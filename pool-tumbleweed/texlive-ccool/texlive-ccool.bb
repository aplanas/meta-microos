SUMMARY = "A key-value document command parser"
DESCRIPTION = "This package provides a key-value interface, \\Ccool, on top of \
xparse's document command parser. Global options control input \
processing and its expansion. By default, they are set to meet \
likely requirements, depending on context: the selected \
language, and which of text and math mode is active. These \
options can be overridden inline. This versality could find its \
use, for example, to encode notational conventions (such as \
\\Real - \\mathbb{R}) at the point where they are introduced in \
the document ('Let R denote real numbers'). Polymorphic \
commands can be generated by parameterizing the keys (for \
instance, one parameter value for style, another for a \
property). User input to \\Ccool can optionally be serialized. \
This can useful for typesetting documents sharing the same \
notation."
LICENSE = "LPPL-1.0"

PV = "2023.209.3.2svn60600"

RPM_NAME = "texlive-ccool-2023.209.3.2svn60600-53.1.noarch.rpm"
RPM_HASH = "35559c02eea8daac12ec2b49d95013691b97244be75a928f7799bd6e3f32c7fb28c58bcf0e181ab65f238652d649373183b6967af2190ef3a7c67bf85ec2905e"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-ccool.sty \
texlive-ccool"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-expl3.sty \
tex-l3keys2e.sty \
tex-lambdax.sty \
tex-xparse.sty \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
