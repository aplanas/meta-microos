SUMMARY = "VDE ecryption module"
DESCRIPTION = "slirpvde is a slirp interface for a VDE network. \
Slirpvde  connects  all  the units (virtual or real machines) to the network \
of the host where slirpvde runs as it were a NAT/Masquerading router. \
The default route is the node 2 (10.0.2.2 in the default  network  configuration) \
and DNS is re-mapped in node 3 (10.0.2.3). \
 \
Slirpvde  runs  using  standard user privileges (no need for root access): \
all the connections are re-generated by slirpvde itself. \
 \
IPv4 only. IPv6 is still unsupported (will be supported when slirpvde \
will be rewritten using the  LWIPv6  network stack)."
LICENSE = "BSD-4-Clause & MIT"

PV = "2.3.2+svn587"

RPM_NAME = "vde2-slirp-2.3.2+svn587-3.23.aarch64.rpm"
RPM_HASH = "24743091c3248ce86db13c1e4d101a5cc2f8fdc77bf488266e1ea4cc5ebe9e33b96ab564177c4e8355de0fdd5be1e28b04d17b9d0401a2e44509b7ef53183d6f"

RPROVIDES:${PN} += "vde2-slirp"

RDEPENDS:${PN} += "ld-linux-aarch64.so.1 \
libc.so.6 \
libvdeplug.so.3"

inherit rpm
