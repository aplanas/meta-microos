SUMMARY = "Extended UTF-8 input encoding support for LaTeX"
DESCRIPTION = "The bundle provides the ucs package, and utf8x.def, together \
with a large number of support files. The utf8x.def definition \
file for use with inputenc covers a wider range of Unicode \
characters than does utf8.def in the LaTeX distribution. The \
package provides facilities for efficient use of its large sets \
of Unicode characters. Glyph production may be controlled by \
various options, which permits use of non-ASCII characters when \
coding mathematical formulae. Note that the bundle previously \
had an alias 'unicode'; that alias has now been withdrawn, and \
no package of that name now exists."
LICENSE = "LPPL-1.0"

PV = "2023.209.2.3svn64114"

RPM_NAME = "texlive-ucs-2023.209.2.3svn64114-54.1.noarch.rpm"
RPM_HASH = "a202a139061ef0ab0d4e4edd126fd16c341586ceb8e8a779b67941f6e89228a243571d237bbd924dc6e37000a8f3b9584440199b374613cc2b0122bf34783d6c"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-autofe.sty \
tex-c00enc.def \
tex-c10enc.def \
tex-c40enc.def \
tex-c42enc.def \
tex-c61enc.def \
tex-cenccmn.tex \
tex-cp1252.enc \
tex-ldvarial.fd \
tex-ldvc2000.fd \
tex-ldvenc.def \
tex-letc2000.fd \
tex-letenc.def \
tex-letgfzem.fd \
tex-letjiret.fd \
tex-lklenc.def \
tex-lklkli.fd \
tex-ltaarial.fd \
tex-ltac2000.fd \
tex-ltaenc.def \
tex-ltgc2000.fd \
tex-ltgenc.def \
tex-ltlcmr.fd \
tex-ltlenc.def \
tex-ltwdsnol.fd \
tex-ltwdsque.fd \
tex-ltwdssin.fd \
tex-ltwenc.def \
tex-lucarial.fd \
tex-lucc2000.fd \
tex-lucenc.def \
tex-mkrenc.def \
tex-mkrezra.fd \
tex-mkrhadas.fd \
tex-mkromega.fd \
tex-mkrrashi.fd \
tex-t2dcmr.fd \
tex-t2denc.def \
tex-tengwarDS.enc \
tex-ucs.sty \
tex-ucsencs.def \
tex-ucshyper.sty \
tex-ucsutils.sty \
tex-uni-0.def \
tex-uni-1.def \
tex-uni-100.def \
tex-uni-101.def \
tex-uni-102.def \
tex-uni-103.def \
tex-uni-104.def \
tex-uni-105.def \
tex-uni-106.def \
tex-uni-107.def \
tex-uni-108.def \
tex-uni-109.def \
tex-uni-110.def \
tex-uni-111.def \
tex-uni-112.def \
tex-uni-113.def \
tex-uni-114.def \
tex-uni-115.def \
tex-uni-116.def \
tex-uni-117.def \
tex-uni-118.def \
tex-uni-119.def \
tex-uni-12.def \
tex-uni-120.def \
tex-uni-121.def \
tex-uni-122.def \
tex-uni-123.def \
tex-uni-124.def \
tex-uni-125.def \
tex-uni-126.def \
tex-uni-127.def \
tex-uni-128.def \
tex-uni-129.def \
tex-uni-130.def \
tex-uni-131.def \
tex-uni-132.def \
tex-uni-133.def \
tex-uni-134.def \
tex-uni-135.def \
tex-uni-136.def \
tex-uni-137.def \
tex-uni-138.def \
tex-uni-139.def \
tex-uni-14.def \
tex-uni-140.def \
tex-uni-141.def \
tex-uni-142.def \
tex-uni-143.def \
tex-uni-144.def \
tex-uni-145.def \
tex-uni-146.def \
tex-uni-147.def \
tex-uni-148.def \
tex-uni-149.def \
tex-uni-150.def \
tex-uni-151.def \
tex-uni-152.def \
tex-uni-153.def \
tex-uni-154.def \
tex-uni-155.def \
tex-uni-156.def \
tex-uni-157.def \
tex-uni-158.def \
tex-uni-159.def \
tex-uni-166.def \
tex-uni-167.def \
tex-uni-171.def \
tex-uni-172.def \
tex-uni-173.def \
tex-uni-174.def \
tex-uni-175.def \
tex-uni-176.def \
tex-uni-177.def \
tex-uni-178.def \
tex-uni-179.def \
tex-uni-18.def \
tex-uni-180.def \
tex-uni-181.def \
tex-uni-182.def \
tex-uni-183.def \
tex-uni-184.def \
tex-uni-185.def \
tex-uni-186.def \
tex-uni-187.def \
tex-uni-188.def \
tex-uni-189.def \
tex-uni-19.def \
tex-uni-190.def \
tex-uni-191.def \
tex-uni-192.def \
tex-uni-193.def \
tex-uni-194.def \
tex-uni-195.def \
tex-uni-196.def \
tex-uni-197.def \
tex-uni-198.def \
tex-uni-199.def \
tex-uni-2.def \
tex-uni-200.def \
tex-uni-201.def \
tex-uni-202.def \
tex-uni-203.def \
tex-uni-204.def \
tex-uni-205.def \
tex-uni-206.def \
tex-uni-207.def \
tex-uni-208.def \
tex-uni-209.def \
tex-uni-210.def \
tex-uni-211.def \
tex-uni-212.def \
tex-uni-213.def \
tex-uni-214.def \
tex-uni-215.def \
tex-uni-24.def \
tex-uni-248.def \
tex-uni-249.def \
tex-uni-250.def \
tex-uni-251.def \
tex-uni-254.def \
tex-uni-255.def \
tex-uni-263.def \
tex-uni-29.def \
tex-uni-3.def \
tex-uni-30.def \
tex-uni-31.def \
tex-uni-32.def \
tex-uni-33.def \
tex-uni-34.def \
tex-uni-35.def \
tex-uni-3584.def \
tex-uni-36.def \
tex-uni-37.def \
tex-uni-38.def \
tex-uni-39.def \
tex-uni-4.def \
tex-uni-40.def \
tex-uni-42.def \
tex-uni-44.def \
tex-uni-46.def \
tex-uni-465.def \
tex-uni-468.def \
tex-uni-469.def \
tex-uni-47.def \
tex-uni-470.def \
tex-uni-471.def \
tex-uni-48.def \
tex-uni-49.def \
tex-uni-497.def \
tex-uni-498.def \
tex-uni-5.def \
tex-uni-50.def \
tex-uni-507.def \
tex-uni-51.def \
tex-uni-760.def \
tex-uni-761.def \
tex-uni-762.def \
tex-uni-78.def \
tex-uni-79.def \
tex-uni-80.def \
tex-uni-81.def \
tex-uni-82.def \
tex-uni-83.def \
tex-uni-84.def \
tex-uni-85.def \
tex-uni-86.def \
tex-uni-87.def \
tex-uni-88.def \
tex-uni-89.def \
tex-uni-9.def \
tex-uni-90.def \
tex-uni-91.def \
tex-uni-92.def \
tex-uni-93.def \
tex-uni-94.def \
tex-uni-95.def \
tex-uni-96.def \
tex-uni-97.def \
tex-uni-98.def \
tex-uni-99.def \
tex-uni-global.def \
tex-uninames.dat \
tex-utf8x.def \
tex-xscmr.fd \
tex-xsenc.def \
texlive-ucs"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-graphicx.sty \
tex-hyperref.sty \
tex-inputenc.sty \
tex-keyval.sty \
tex-utf8.def \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
