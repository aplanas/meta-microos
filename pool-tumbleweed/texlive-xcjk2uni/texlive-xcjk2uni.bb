SUMMARY = "Convert CJK characters to Unicode, in pdfTeX"
DESCRIPTION = "The package provides commands to convert CJK characters to \
Unicode in non-UTF-8 encoding; it provides hooks to support \
hyperref in producing correct bookmarks. The bundle also \
provides /ToUnicode mapping file(s) for a CJK subfont; these \
can be used with the cmap package, allowing searches of, and \
cut-and-paste operations on a PDF file generated by pdfTeX."
LICENSE = "LPPL-1.0"

PV = "2023.209.1.0svn54958"

RPM_NAME = "texlive-xcjk2uni-2023.209.1.0svn54958-53.1.noarch.rpm"
RPM_HASH = "b5b0703b1c2ebbaef3ef4b6a9f8fe3ccd3fc34a0ab4e6dd683d3fb2d593e3b9d96fc7cb459fbf0e164c07f613163120846256ddd39bfd1b2570354d63e145f28"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-xCJK2uni-UBg5plus.def \
tex-xCJK2uni-UBig5.def \
tex-xCJK2uni-UGB.def \
tex-xCJK2uni-UGBK.def \
tex-xCJK2uni-UJIS.def \
tex-xCJK2uni-UKS.def \
tex-xCJK2uni.sty \
texlive-xcjk2uni"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-expl3.sty \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
