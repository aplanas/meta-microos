SUMMARY = "Interface to the Wxwidgets Cross-Platform Gui Toolkit"
DESCRIPTION = "The Wx module is a wrapper for the wxWidgets (formerly known as wxWindows) \
GUI toolkit. \
 \
This module comes with extensive documentation in HTML format; you can \
download it from http://wxperl.sourceforge.net/"
LICENSE = "Artistic-1.0 | GPL-1.0-or-later"

PV = "0.9932"

RPM_NAME = "perl-Wx-0.9932-3.34.aarch64.rpm"
RPM_HASH = "b34aff50b26fb027742090b3703b6b198c15f249d361705d3774dc5e03ab59809161ebed3d87ad7f6275856ab114c1a14c802edcc5addb76939155fcb1daa68a"

RPROVIDES:${PN} += "perl(MY) \
perl(Wx) \
perl(Wx::AUI) \
perl(Wx::App) \
perl(Wx::ArchiveFSHandler) \
perl(Wx::ArrayStringProperty) \
perl(Wx::ArtProvider) \
perl(Wx::AuiManager) \
perl(Wx::AuiManagerEvent) \
perl(Wx::AuiNotebook) \
perl(Wx::AuiNotebookEvent) \
perl(Wx::BesthelpController) \
perl(Wx::BitmapDataObject) \
perl(Wx::BoolProperty) \
perl(Wx::CHMHelpController) \
perl(Wx::Calendar) \
perl(Wx::CalendarCtrl) \
perl(Wx::CalendarEvent) \
perl(Wx::Client) \
perl(Wx::ColourProperty) \
perl(Wx::ColourPropertyValue) \
perl(Wx::Connection) \
perl(Wx::Connectionbase) \
perl(Wx::ContextHelpButton) \
perl(Wx::CursorProperty) \
perl(Wx::DDEClient) \
perl(Wx::DDEConnection) \
perl(Wx::DDEServer) \
perl(Wx::DND) \
perl(Wx::DataObject) \
perl(Wx::DataObjectComposite) \
perl(Wx::DataObjectSimple) \
perl(Wx::DataView) \
perl(Wx::DataViewBitmapRenderer) \
perl(Wx::DataViewCtrl) \
perl(Wx::DataViewCustomRenderer) \
perl(Wx::DataViewDateRenderer) \
perl(Wx::DataViewEvent) \
perl(Wx::DataViewIconTextRenderer) \
perl(Wx::DataViewIndexListModel) \
perl(Wx::DataViewModel) \
perl(Wx::DataViewProgressRenderer) \
perl(Wx::DataViewRenderer) \
perl(Wx::DataViewTextRenderer) \
perl(Wx::DataViewTextRendererAttr) \
perl(Wx::DataViewToggleRenderer) \
perl(Wx::DataViewTreeCtrl) \
perl(Wx::DataViewTreeStore) \
perl(Wx::DatagramSocket) \
perl(Wx::DateEvent) \
perl(Wx::DatePickerCtrl) \
perl(Wx::DateProperty) \
perl(Wx::DateTime) \
perl(Wx::DirProperty) \
perl(Wx::DocChildFrame) \
perl(Wx::DocMDIChildFrame) \
perl(Wx::DocMDIParentFrame) \
perl(Wx::DocManager) \
perl(Wx::DocParentFrame) \
perl(Wx::DocPrintout) \
perl(Wx::DocView) \
perl(Wx::Document) \
perl(Wx::DropFilesEvent) \
perl(Wx::DropSource) \
perl(Wx::DropTarget) \
perl(Wx::EditEnumProperty) \
perl(Wx::EnumProperty) \
perl(Wx::Event) \
perl(Wx::ExtHelpController) \
perl(Wx::FS) \
perl(Wx::FileDataObject) \
perl(Wx::FileDropTarget) \
perl(Wx::FileProperty) \
perl(Wx::FileSystemHandler) \
perl(Wx::FlagsProperty) \
perl(Wx::FloatProperty) \
perl(Wx::Font) \
perl(Wx::FontProperty) \
perl(Wx::GDIObject) \
perl(Wx::GenericMDIChildFrame) \
perl(Wx::GenericMDIClientWindow) \
perl(Wx::GenericMDIParentFrame) \
perl(Wx::GenericPageSetupDialog) \
perl(Wx::GenericPrintDialog) \
perl(Wx::GnomePrintDC) \
perl(Wx::Grid) \
perl(Wx::GridCellAutoWrapStringEditor) \
perl(Wx::GridCellAutoWrapStringRenderer) \
perl(Wx::GridCellBoolEditor) \
perl(Wx::GridCellBoolRenderer) \
perl(Wx::GridCellChoiceEditor) \
perl(Wx::GridCellDateTimeRenderer) \
perl(Wx::GridCellEditor) \
perl(Wx::GridCellEditorEvtHandler) \
perl(Wx::GridCellEnumEditor) \
perl(Wx::GridCellEnumRenderer) \
perl(Wx::GridCellFloatEditor) \
perl(Wx::GridCellFloatRenderer) \
perl(Wx::GridCellNumberEditor) \
perl(Wx::GridCellNumberRenderer) \
perl(Wx::GridCellRenderer) \
perl(Wx::GridCellStringRenderer) \
perl(Wx::GridCellTextEditor) \
perl(Wx::GridEditorCreatedEvent) \
perl(Wx::GridEvent) \
perl(Wx::GridRangeSelectEvent) \
perl(Wx::GridSizeEvent) \
perl(Wx::GridTableBase) \
perl(Wx::GridWindow) \
perl(Wx::Help) \
perl(Wx::HelpController) \
perl(Wx::HelpControllerBase) \
perl(Wx::HelpControllerHelpProvider) \
perl(Wx::HelpControllerHtml) \
perl(Wx::Html) \
perl(Wx::HtmlCell) \
perl(Wx::HtmlCellEvent) \
perl(Wx::HtmlColourCell) \
perl(Wx::HtmlContainerCell) \
perl(Wx::HtmlFontCell) \
perl(Wx::HtmlHelpController) \
perl(Wx::HtmlLinkEvent) \
perl(Wx::HtmlListBox) \
perl(Wx::HtmlParser) \
perl(Wx::HtmlTag) \
perl(Wx::HtmlTagHandler) \
perl(Wx::HtmlWidgetCell) \
perl(Wx::HtmlWinParser) \
perl(Wx::HtmlWinTagHandler) \
perl(Wx::HtmlWindow) \
perl(Wx::HtmlWordCell) \
perl(Wx::IPC) \
perl(Wx::IPV4address) \
perl(Wx::IPV6address) \
perl(Wx::IPaddress) \
perl(Wx::ImageFileProperty) \
perl(Wx::IntProperty) \
perl(Wx::InternetFSHandler) \
perl(Wx::Loader::Standard) \
perl(Wx::Locale) \
perl(Wx::Locale::T) \
perl(Wx::LongStringProperty) \
perl(Wx::MDI) \
perl(Wx::MDIChildFrame) \
perl(Wx::MDIClientWindow) \
perl(Wx::MDIParentFrame) \
perl(Wx::Media) \
perl(Wx::MediaCtrl) \
perl(Wx::MediaEvent) \
perl(Wx::Menu) \
perl(Wx::Mini) \
perl(Wx::MultiChoiceProperty) \
perl(Wx::Object) \
perl(Wx::ObjectRefData) \
perl(Wx::Overload::Driver) \
perl(Wx::Overload::Handle) \
perl(Wx::PGArrayEditorDialog) \
perl(Wx::PGArrayStringEditorDialog) \
perl(Wx::PGCell) \
perl(Wx::PGCellRenderer) \
perl(Wx::PGCheckBoxEditor) \
perl(Wx::PGChoiceAndButtonEditor) \
perl(Wx::PGChoiceEditor) \
perl(Wx::PGChoicesData) \
perl(Wx::PGComboBoxEditor) \
perl(Wx::PGDatePickerCtrlEditor) \
perl(Wx::PGDefaultRenderer) \
perl(Wx::PGEditor) \
perl(Wx::PGFileDialogAdapter) \
perl(Wx::PGInDialogValidator) \
perl(Wx::PGLongStringDialogAdapter) \
perl(Wx::PGMultiButton) \
perl(Wx::PGProperty) \
perl(Wx::PGSpinCtrlEditor) \
perl(Wx::PGTextCtrlAndButtonEditor) \
perl(Wx::PGTextCtrlEditor) \
perl(Wx::PageSetupDialog) \
perl(Wx::Perl::Carp) \
perl(Wx::Perl::SplashFast) \
perl(Wx::Perl::SplashFast::App) \
perl(Wx::Perl::TextValidator) \
perl(Wx::PerlTest) \
perl(Wx::PlArtProvider) \
perl(Wx::PlClient) \
perl(Wx::PlCommand) \
perl(Wx::PlConnection) \
perl(Wx::PlDataObjectSimple) \
perl(Wx::PlDataViewIndexListModel) \
perl(Wx::PlDropTarget) \
perl(Wx::PlFSFile) \
perl(Wx::PlFileSystemHandler) \
perl(Wx::PlGridCellEditor) \
perl(Wx::PlGridCellRenderer) \
perl(Wx::PlGridTable) \
perl(Wx::PlHtmlListBox) \
perl(Wx::PlHtmlTag) \
perl(Wx::PlHtmlTagHandler) \
perl(Wx::PlHtmlWinTagHandler) \
perl(Wx::PlPreviewControlBar) \
perl(Wx::PlPreviewFrame) \
perl(Wx::PlServer) \
perl(Wx::PlThreadEvent) \
perl(Wx::PlXmlResourceHandler) \
perl(Wx::PliXmlSubclassFactory) \
perl(Wx::PostScriptDC) \
perl(Wx::PostScriptPrintPreview) \
perl(Wx::PostScriptPrinter) \
perl(Wx::PreviewCanvas) \
perl(Wx::PreviewControlBar) \
perl(Wx::PreviewFrame) \
perl(Wx::Print) \
perl(Wx::PrintDialog) \
perl(Wx::PrintPaperType) \
perl(Wx::PrintPreview) \
perl(Wx::PrintPreviewBase) \
perl(Wx::PrinterDC) \
perl(Wx::Printout) \
perl(Wx::PropertyCategory) \
perl(Wx::PropertyGrid) \
perl(Wx::PropertyGridIterator) \
perl(Wx::PropertyGridIteratorBase) \
perl(Wx::PropertyGridManager) \
perl(Wx::PropertyGridPage) \
perl(Wx::RadioBox) \
perl(Wx::Ribbon) \
perl(Wx::RibbonAUIArtProvider) \
perl(Wx::RibbonArtProvider) \
perl(Wx::RibbonDefaultArtProvider) \
perl(Wx::RibbonMSWArtProvider) \
perl(Wx::RichText) \
perl(Wx::RichTextBox) \
perl(Wx::RichTextBuffer) \
perl(Wx::RichTextCharacterStyleDefinition) \
perl(Wx::RichTextCompositeObject) \
perl(Wx::RichTextCtrl) \
perl(Wx::RichTextEvent) \
perl(Wx::RichTextFormattingDialog) \
perl(Wx::RichTextHTMLHandler) \
perl(Wx::RichTextHeaderFooterData) \
perl(Wx::RichTextListStyleDefinition) \
perl(Wx::RichTextObject) \
perl(Wx::RichTextParagraphLayoutBox) \
perl(Wx::RichTextParagraphStyleDefinition) \
perl(Wx::RichTextPrinting) \
perl(Wx::RichTextStyleComboCtrl) \
perl(Wx::RichTextStyleDefinition) \
perl(Wx::RichTextStyleListBox) \
perl(Wx::RichTextStyleListCtrl) \
perl(Wx::RichTextStyleOrganiserDialog) \
perl(Wx::RichTextXMLHandler) \
perl(Wx::STC) \
perl(Wx::Server) \
perl(Wx::SimpleApp) \
perl(Wx::SimpleHelpProvider) \
perl(Wx::SimpleHtmlListBox) \
perl(Wx::Socket) \
perl(Wx::Socket::Event) \
perl(Wx::SocketClient) \
perl(Wx::SocketEvent) \
perl(Wx::SocketServer) \
perl(Wx::StringProperty) \
perl(Wx::StyledTextCtrl) \
perl(Wx::StyledTextEvent) \
perl(Wx::SymbolPickerDialog) \
perl(Wx::SystemColourProperty) \
perl(Wx::TCPClient) \
perl(Wx::TCPConnection) \
perl(Wx::TCPServer) \
perl(Wx::TextAttrEx) \
perl(Wx::TextDataObject) \
perl(Wx::TextDropTarget) \
perl(Wx::TimePickerCtrl) \
perl(Wx::Timer) \
perl(Wx::TimerRunner) \
perl(Wx::TreeItemId) \
perl(Wx::UIntProperty) \
perl(Wx::UNIXaddress) \
perl(Wx::URLDataObject) \
perl(Wx::View) \
perl(Wx::WinHelpController) \
perl(Wx::WindowsPrintPreview) \
perl(Wx::WindowsPrinter) \
perl(Wx::Wx_Exp) \
perl(Wx::XRC) \
perl(Wx::XSP::Enum) \
perl(Wx::XSP::Event) \
perl(Wx::XSP::Overload) \
perl(Wx::XSP::Virtual) \
perl(Wx::ZipFSHandler) \
perl(Wx::build::MakeMaker) \
perl(Wx::build::MakeMaker::Any_OS) \
perl(Wx::build::MakeMaker::Any_wx_config) \
perl(Wx::build::MakeMaker::Core) \
perl(Wx::build::MakeMaker::Core::Dummy) \
perl(Wx::build::MakeMaker::Hacks) \
perl(Wx::build::MakeMaker::MacOSX_GCC) \
perl(Wx::build::MakeMaker::Win32) \
perl(Wx::build::MakeMaker::Win32_MSVC) \
perl(Wx::build::MakeMaker::Win32_MinGW) \
perl(Wx::build::Options) \
perl(Wx::build::Utils) \
perl(build::Wx::XSP::Enum) \
perl(build::Wx::XSP::Event) \
perl(build::Wx::XSP::Overload) \
perl(build::Wx::XSP::Virtual) \
perl-Wx \
perl-Wx(aarch-64)"

RDEPENDS:${PN} += "/usr/bin/perl \
ld-linux-aarch64.so.1()(64bit) \
ld-linux-aarch64.so.1(GLIBC_2.17)(64bit) \
libc.so.6(GLIBC_2.34)(64bit) \
libgcc_s.so.1()(64bit) \
libgcc_s.so.1(GCC_3.0)(64bit) \
libgcc_s.so.1(GCC_3.3.1)(64bit) \
libstdc++.so.6()(64bit) \
libstdc++.so.6(CXXABI_1.3)(64bit) \
libstdc++.so.6(CXXABI_1.3.8)(64bit) \
libstdc++.so.6(CXXABI_1.3.9)(64bit) \
libstdc++.so.6(GLIBCXX_3.4)(64bit) \
libstdc++.so.6(GLIBCXX_3.4.21)(64bit) \
libwx_baseu-suse-nostl.so.3.0.5()(64bit) \
libwx_baseu-suse-nostl.so.3.0.5(WXU_3.0)(64bit) \
libwx_baseu_net-suse-nostl.so.3.0.5()(64bit) \
libwx_baseu_net-suse-nostl.so.3.0.5(WXU_3.0)(64bit) \
libwx_baseu_xml-suse-nostl.so.3.0.5()(64bit) \
libwx_baseu_xml-suse-nostl.so.3.0.5(WXU_3.0)(64bit) \
libwx_gtk2u_adv-suse-nostl.so.3.0.5()(64bit) \
libwx_gtk2u_adv-suse-nostl.so.3.0.5(WXU_3.0)(64bit) \
libwx_gtk2u_aui-suse-nostl.so.3.0.5()(64bit) \
libwx_gtk2u_aui-suse-nostl.so.3.0.5(WXU_3.0)(64bit) \
libwx_gtk2u_core-suse-nostl.so.3.0.5()(64bit) \
libwx_gtk2u_core-suse-nostl.so.3.0.5(WXU_3.0)(64bit) \
libwx_gtk2u_html-suse-nostl.so.3.0.5()(64bit) \
libwx_gtk2u_html-suse-nostl.so.3.0.5(WXU_3.0)(64bit) \
libwx_gtk2u_media-suse-nostl.so.3.0.5()(64bit) \
libwx_gtk2u_media-suse-nostl.so.3.0.5(WXU_3.0)(64bit) \
libwx_gtk2u_propgrid-suse-nostl.so.3.0.5()(64bit) \
libwx_gtk2u_propgrid-suse-nostl.so.3.0.5(WXU_3.0)(64bit) \
libwx_gtk2u_ribbon-suse-nostl.so.3.0.5()(64bit) \
libwx_gtk2u_ribbon-suse-nostl.so.3.0.5(WXU_3.0)(64bit) \
libwx_gtk2u_richtext-suse-nostl.so.3.0.5()(64bit) \
libwx_gtk2u_richtext-suse-nostl.so.3.0.5(WXU_3.0)(64bit) \
libwx_gtk2u_stc-suse-nostl.so.3.0.5()(64bit) \
libwx_gtk2u_stc-suse-nostl.so.3.0.5(WXU_3.0)(64bit) \
libwx_gtk2u_xrc-suse-nostl.so.3.0.5()(64bit) \
libwx_gtk2u_xrc-suse-nostl.so.3.0.5(WXU_3.0)(64bit) \
perl(:MODULE_COMPAT_5.36.0) \
perl(Alien::wxWidgets) \
perl(ExtUtils::MakeMaker) \
perl(ExtUtils::ParseXS) \
perl(ExtUtils::XSpp)"

inherit rpm
