SUMMARY = "A graphical frontend for 'xmodmap'"
DESCRIPTION = "'xkeycaps' is a graphical front-end to 'xmodmap'. It opens a window \
that looks like a keyboard. Moving the mouse over a key shows what \
KeySyms and Modifier bits that key generates. Clicking on a key \
simulates KeyPress/KeyRelease events on the window of your choice. It \
is possible to change the KeySyms and Modifiers generated by a key \
through a mouse-based interface. This program can also write an input \
file for xmodmap to recreate your changes in future sessions. \
 \
 \
 \
Authors: \
-------- \
    Jamie Zawinski <jwz@jzw.org>"
LICENSE = "MIT"

PV = "2.46"

RPM_NAME = "xkeycaps-2.46-973.27.aarch64.rpm"
RPM_HASH = "744e3aee56772f03aff04d510a6e80851403a54dd38ea07f05bfb62556c2ab80a2dc1fc1c551fbdf34bf72021280fc61576f39b470f654c1bc77a106848b2b0b"

RPROVIDES:${PN} += "xkeycaps"

RDEPENDS:${PN} += "libX11.so.6 \
libXaw.so.7 \
libXmu.so.6 \
libXt.so.6 \
libc.so.6"

inherit rpm
