SUMMARY = "Languages for package vala-panel-appmenu"
DESCRIPTION = "Provides translations to the packages xfce4-panel-plugin-appmenu, \
mate-applet-appmenu and vala-panel-plugin-appmenu."
LICENSE = "LGPL-3.0-or-later"

PV = "0.7.6"

RPM_NAME = "vala-panel-appmenu-lang-0.7.6-1.6.noarch.rpm"
RPM_HASH = "44d1af6bf0bd10bfad4b4e486e0242956842d73b7077cbb259cc7e227a6cd7cece9220643a164770ff61adc6c5a794f7a950229fd2e0d234690eeedda47144f6"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "locale(vala-panel-appmenu:af) \
locale(vala-panel-appmenu:ar) \
locale(vala-panel-appmenu:as) \
locale(vala-panel-appmenu:ast) \
locale(vala-panel-appmenu:az) \
locale(vala-panel-appmenu:be) \
locale(vala-panel-appmenu:bg) \
locale(vala-panel-appmenu:bn) \
locale(vala-panel-appmenu:br) \
locale(vala-panel-appmenu:bs) \
locale(vala-panel-appmenu:ca) \
locale(vala-panel-appmenu:cs) \
locale(vala-panel-appmenu:cy) \
locale(vala-panel-appmenu:da) \
locale(vala-panel-appmenu:de) \
locale(vala-panel-appmenu:dz) \
locale(vala-panel-appmenu:el) \
locale(vala-panel-appmenu:en_AU) \
locale(vala-panel-appmenu:en_CA) \
locale(vala-panel-appmenu:en_GB) \
locale(vala-panel-appmenu:eo) \
locale(vala-panel-appmenu:es) \
locale(vala-panel-appmenu:et) \
locale(vala-panel-appmenu:eu) \
locale(vala-panel-appmenu:fa) \
locale(vala-panel-appmenu:fi) \
locale(vala-panel-appmenu:fr) \
locale(vala-panel-appmenu:fr_CA) \
locale(vala-panel-appmenu:ga) \
locale(vala-panel-appmenu:gd) \
locale(vala-panel-appmenu:gl) \
locale(vala-panel-appmenu:gu) \
locale(vala-panel-appmenu:he) \
locale(vala-panel-appmenu:hi) \
locale(vala-panel-appmenu:hr) \
locale(vala-panel-appmenu:hu) \
locale(vala-panel-appmenu:ia) \
locale(vala-panel-appmenu:id) \
locale(vala-panel-appmenu:is) \
locale(vala-panel-appmenu:it) \
locale(vala-panel-appmenu:ja) \
locale(vala-panel-appmenu:ka) \
locale(vala-panel-appmenu:kk) \
locale(vala-panel-appmenu:km) \
locale(vala-panel-appmenu:kn) \
locale(vala-panel-appmenu:ko) \
locale(vala-panel-appmenu:lt) \
locale(vala-panel-appmenu:lv) \
locale(vala-panel-appmenu:mk) \
locale(vala-panel-appmenu:ml) \
locale(vala-panel-appmenu:mr) \
locale(vala-panel-appmenu:ms) \
locale(vala-panel-appmenu:nb) \
locale(vala-panel-appmenu:ne) \
locale(vala-panel-appmenu:nl) \
locale(vala-panel-appmenu:nn) \
locale(vala-panel-appmenu:oc) \
locale(vala-panel-appmenu:or) \
locale(vala-panel-appmenu:pa) \
locale(vala-panel-appmenu:pl) \
locale(vala-panel-appmenu:pt) \
locale(vala-panel-appmenu:pt_BR) \
locale(vala-panel-appmenu:ro) \
locale(vala-panel-appmenu:ru) \
locale(vala-panel-appmenu:si) \
locale(vala-panel-appmenu:sk) \
locale(vala-panel-appmenu:sl) \
locale(vala-panel-appmenu:sq) \
locale(vala-panel-appmenu:sr) \
locale(vala-panel-appmenu:sv) \
locale(vala-panel-appmenu:ta) \
locale(vala-panel-appmenu:te) \
locale(vala-panel-appmenu:th) \
locale(vala-panel-appmenu:tr) \
locale(vala-panel-appmenu:ug) \
locale(vala-panel-appmenu:uk) \
locale(vala-panel-appmenu:vi) \
locale(vala-panel-appmenu:wa) \
locale(vala-panel-appmenu:zh) \
locale(vala-panel-appmenu:zh_CN) \
locale(vala-panel-appmenu:zh_HK) \
locale(vala-panel-appmenu:zh_TW) \
mate-applet-appmenu-lang \
mate-applet-appmenu-lang-all \
vala-panel-appmenu-lang \
vala-panel-appmenu-lang-all \
vala-panel-plugin-appmenu-lang \
vala-panel-plugin-appmenu-lang-all \
xfce4-panel-plugin-appmenu-lang \
xfce4-panel-plugin-appmenu-lang-all"

RDEPENDS:${PN} += ""

inherit rpm
