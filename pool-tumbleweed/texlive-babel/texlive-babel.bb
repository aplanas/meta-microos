SUMMARY = "Multilingual support for LaTeX, LuaLaTeX, XeLaTeX, and Plain TeX"
DESCRIPTION = "This package manages culturally-determined typographical (and \
other) rules for a wide range of languages. A document may \
select a single language to be supported, or it may select \
several, in which case the document may switch from one \
language to another in a variety of ways. Babel uses \
contributed configuration files that provide the detail of what \
has to be done for each language. Included is also a set of ini \
files for about 250 languages. Many language styles work with \
pdfLaTeX, as well as with XeLaTeX and LuaLaTeX, out of the box. \
A few even work with plain formats."
LICENSE = "LPPL-1.0"

PV = "2023.201.3.86svn65823"

RPM_NAME = "texlive-babel-2023.201.3.86svn65823-53.1.noarch.rpm"
RPM_HASH = "cb3662bb4a9dde95ac9d6a9017f9f421cb66c50c9e4ff02aa40397617f2c90a2fb577ea3e58f89a43b8db208a9ee26a53c3a44638e993441bf6f8d77e2b81b5a"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-UKenglish.sty \
tex-USenglish.sty \
tex-afrikaans.sty \
tex-albanian.sty \
tex-american.sty \
tex-austrian.sty \
tex-babel-afrikaans.tex \
tex-babel-aghem.tex \
tex-babel-akan.tex \
tex-babel-albanian.tex \
tex-babel-american.tex \
tex-babel-americanenglish.tex \
tex-babel-amharic.tex \
tex-babel-ancientgreek.tex \
tex-babel-arabic-algeria.tex \
tex-babel-arabic-dz.tex \
tex-babel-arabic-eg.tex \
tex-babel-arabic-egypt.tex \
tex-babel-arabic-iq.tex \
tex-babel-arabic-iraq.tex \
tex-babel-arabic-jo.tex \
tex-babel-arabic-jordan.tex \
tex-babel-arabic-lb.tex \
tex-babel-arabic-lebanon.tex \
tex-babel-arabic-ma.tex \
tex-babel-arabic-morocco.tex \
tex-babel-arabic-palestinianterritories.tex \
tex-babel-arabic-ps.tex \
tex-babel-arabic-sa.tex \
tex-babel-arabic-saudiarabia.tex \
tex-babel-arabic-sy.tex \
tex-babel-arabic-syria.tex \
tex-babel-arabic-tn.tex \
tex-babel-arabic-tunisia.tex \
tex-babel-arabic.tex \
tex-babel-armenian.tex \
tex-babel-assamese.tex \
tex-babel-asturian.tex \
tex-babel-asu.tex \
tex-babel-australian.tex \
tex-babel-australianenglish.tex \
tex-babel-austrian.tex \
tex-babel-azerbaijani-cyrillic.tex \
tex-babel-azerbaijani-cyrl.tex \
tex-babel-azerbaijani-latin.tex \
tex-babel-azerbaijani-latn.tex \
tex-babel-azerbaijani.tex \
tex-babel-bafia.tex \
tex-babel-bambara.tex \
tex-babel-bangla.tex \
tex-babel-basaa.tex \
tex-babel-basque.tex \
tex-babel-belarusian.tex \
tex-babel-bemba.tex \
tex-babel-bena.tex \
tex-babel-bengali.tex \
tex-babel-bodo.tex \
tex-babel-bosnian-cyrillic.tex \
tex-babel-bosnian-cyrl.tex \
tex-babel-bosnian-latin.tex \
tex-babel-bosnian-latn.tex \
tex-babel-bosnian.tex \
tex-babel-brazilian.tex \
tex-babel-brazilianportuguese.tex \
tex-babel-breton.tex \
tex-babel-british.tex \
tex-babel-britishenglish.tex \
tex-babel-bulgarian.tex \
tex-babel-burmese.tex \
tex-babel-ca-buddhist.tex \
tex-babel-ca-coptic.tex \
tex-babel-ca-ethiopic.tex \
tex-babel-ca-hebrew.tex \
tex-babel-ca-islamic.tex \
tex-babel-ca-persian.tex \
tex-babel-canadian.tex \
tex-babel-canadianenglish.tex \
tex-babel-cantonese.tex \
tex-babel-catalan.tex \
tex-babel-centralatlastamazight.tex \
tex-babel-centralkurdish-latin.tex \
tex-babel-centralkurdish-latn.tex \
tex-babel-centralkurdish.tex \
tex-babel-chechen.tex \
tex-babel-cherokee.tex \
tex-babel-chiga.tex \
tex-babel-chinese-hans-hk.tex \
tex-babel-chinese-hans-mo.tex \
tex-babel-chinese-hans-sg.tex \
tex-babel-chinese-hans.tex \
tex-babel-chinese-hant-hk.tex \
tex-babel-chinese-hant-mo.tex \
tex-babel-chinese-hant.tex \
tex-babel-chinese-simplified-hongkongsarchina.tex \
tex-babel-chinese-simplified-macausarchina.tex \
tex-babel-chinese-simplified-singapore.tex \
tex-babel-chinese-simplified.tex \
tex-babel-chinese-traditional-hongkongsarchina.tex \
tex-babel-chinese-traditional-macausarchina.tex \
tex-babel-chinese-traditional.tex \
tex-babel-chinese.tex \
tex-babel-churchslavic-cyrs.tex \
tex-babel-churchslavic-glag.tex \
tex-babel-churchslavic-glagolitic.tex \
tex-babel-churchslavic-oldcyrillic.tex \
tex-babel-churchslavic.tex \
tex-babel-churchslavonic.tex \
tex-babel-classiclatin.tex \
tex-babel-colognian.tex \
tex-babel-coptic.tex \
tex-babel-cornish.tex \
tex-babel-croatian.tex \
tex-babel-czech.tex \
tex-babel-danish.tex \
tex-babel-duala.tex \
tex-babel-dutch.tex \
tex-babel-dzongkha.tex \
tex-babel-ecclesiasticlatin.tex \
tex-babel-embu.tex \
tex-babel-english-au.tex \
tex-babel-english-australia.tex \
tex-babel-english-ca.tex \
tex-babel-english-canada.tex \
tex-babel-english-gb.tex \
tex-babel-english-newzealand.tex \
tex-babel-english-nz.tex \
tex-babel-english-unitedkingdom.tex \
tex-babel-english-unitedstates.tex \
tex-babel-english-us.tex \
tex-babel-english.tex \
tex-babel-esperanto.tex \
tex-babel-estonian.tex \
tex-babel-europeanportuguese.tex \
tex-babel-ewe.tex \
tex-babel-ewondo.tex \
tex-babel-faroese.tex \
tex-babel-filipino.tex \
tex-babel-finnish.tex \
tex-babel-french-be.tex \
tex-babel-french-belgium.tex \
tex-babel-french-ca.tex \
tex-babel-french-canada.tex \
tex-babel-french-canadianfrench.tex \
tex-babel-french-ch.tex \
tex-babel-french-lu.tex \
tex-babel-french-luxembourg.tex \
tex-babel-french-swissfrench.tex \
tex-babel-french-switzerland.tex \
tex-babel-french.tex \
tex-babel-friulian.tex \
tex-babel-fulah.tex \
tex-babel-galician.tex \
tex-babel-ganda.tex \
tex-babel-georgian.tex \
tex-babel-german-at.tex \
tex-babel-german-austria-traditional.tex \
tex-babel-german-austria.tex \
tex-babel-german-ch.tex \
tex-babel-german-switzerland-traditional.tex \
tex-babel-german-switzerland.tex \
tex-babel-german-traditional.tex \
tex-babel-german.tex \
tex-babel-greek.tex \
tex-babel-gujarati.tex \
tex-babel-gusii.tex \
tex-babel-hausa-gh.tex \
tex-babel-hausa-ghana.tex \
tex-babel-hausa-ne.tex \
tex-babel-hausa-niger.tex \
tex-babel-hausa.tex \
tex-babel-hawaiian.tex \
tex-babel-hebrew.tex \
tex-babel-hindi.tex \
tex-babel-hungarian.tex \
tex-babel-icelandic.tex \
tex-babel-igbo.tex \
tex-babel-inarisami.tex \
tex-babel-indonesian.tex \
tex-babel-interlingua.tex \
tex-babel-irish.tex \
tex-babel-italian.tex \
tex-babel-japanese.tex \
tex-babel-jolafonyi.tex \
tex-babel-kabuverdianu.tex \
tex-babel-kabyle.tex \
tex-babel-kaingang.tex \
tex-babel-kako.tex \
tex-babel-kalaallisut.tex \
tex-babel-kalenjin.tex \
tex-babel-kamba.tex \
tex-babel-kannada.tex \
tex-babel-kashmiri.tex \
tex-babel-kazakh.tex \
tex-babel-khmer.tex \
tex-babel-kikuyu.tex \
tex-babel-kinyarwanda.tex \
tex-babel-konkani.tex \
tex-babel-korean-han.tex \
tex-babel-korean-hani.tex \
tex-babel-korean.tex \
tex-babel-koyraborosenni.tex \
tex-babel-koyrachiini.tex \
tex-babel-kurmanji.tex \
tex-babel-kwasio.tex \
tex-babel-kyrgyz.tex \
tex-babel-lakota.tex \
tex-babel-langi.tex \
tex-babel-lao.tex \
tex-babel-latin.tex \
tex-babel-latvian.tex \
tex-babel-lingala.tex \
tex-babel-lithuanian.tex \
tex-babel-lowersorbian.tex \
tex-babel-lsorbian.tex \
tex-babel-lubakatanga.tex \
tex-babel-luo.tex \
tex-babel-luxembourgish.tex \
tex-babel-luyia.tex \
tex-babel-macedonian.tex \
tex-babel-machame.tex \
tex-babel-magyar.tex \
tex-babel-makhuwameetto.tex \
tex-babel-makonde.tex \
tex-babel-malagasy.tex \
tex-babel-malay-bn.tex \
tex-babel-malay-brunei.tex \
tex-babel-malay-sg.tex \
tex-babel-malay-singapore.tex \
tex-babel-malay.tex \
tex-babel-malayalam.tex \
tex-babel-maltese.tex \
tex-babel-manx.tex \
tex-babel-marathi.tex \
tex-babel-masai.tex \
tex-babel-mazanderani.tex \
tex-babel-medievallatin.tex \
tex-babel-meru.tex \
tex-babel-meta.tex \
tex-babel-mexican.tex \
tex-babel-mexicanspanish.tex \
tex-babel-moldavian.tex \
tex-babel-mongolian.tex \
tex-babel-monotonicgreek.tex \
tex-babel-morisyen.tex \
tex-babel-mundang.tex \
tex-babel-nama.tex \
tex-babel-naustrian.tex \
tex-babel-nepali.tex \
tex-babel-newzealand.tex \
tex-babel-ngerman.tex \
tex-babel-ngiemboon.tex \
tex-babel-ngomba.tex \
tex-babel-nheengatu.tex \
tex-babel-norsk.tex \
tex-babel-northernkurdish-arab.tex \
tex-babel-northernkurdish-arabic.tex \
tex-babel-northernkurdish.tex \
tex-babel-northernluri.tex \
tex-babel-northernsami.tex \
tex-babel-northndebele.tex \
tex-babel-norwegian.tex \
tex-babel-norwegianbokmal.tex \
tex-babel-norwegiannynorsk.tex \
tex-babel-nswissgerman.tex \
tex-babel-nuer.tex \
tex-babel-nyankole.tex \
tex-babel-nynorsk.tex \
tex-babel-occitan.tex \
tex-babel-odia.tex \
tex-babel-oriya.tex \
tex-babel-oromo.tex \
tex-babel-ossetic.tex \
tex-babel-pashto.tex \
tex-babel-persian.tex \
tex-babel-piedmontese.tex \
tex-babel-polish.tex \
tex-babel-polytonicgreek.tex \
tex-babel-portuguese-br.tex \
tex-babel-portuguese-brazil.tex \
tex-babel-portuguese-portugal.tex \
tex-babel-portuguese-pt.tex \
tex-babel-portuguese.tex \
tex-babel-punjabi-arab.tex \
tex-babel-punjabi-arabic.tex \
tex-babel-punjabi-gurmukhi.tex \
tex-babel-punjabi-guru.tex \
tex-babel-punjabi.tex \
tex-babel-quechua.tex \
tex-babel-romanian-md.tex \
tex-babel-romanian-moldova.tex \
tex-babel-romanian.tex \
tex-babel-romansh.tex \
tex-babel-rombo.tex \
tex-babel-rundi.tex \
tex-babel-russian.tex \
tex-babel-rwa.tex \
tex-babel-sakha.tex \
tex-babel-samburu.tex \
tex-babel-samin.tex \
tex-babel-sango.tex \
tex-babel-sangu.tex \
tex-babel-sanskrit-bangla.tex \
tex-babel-sanskrit-beng.tex \
tex-babel-sanskrit-bengali.tex \
tex-babel-sanskrit-deva.tex \
tex-babel-sanskrit-devanagari.tex \
tex-babel-sanskrit-gujarati.tex \
tex-babel-sanskrit-gujr.tex \
tex-babel-sanskrit-kannada.tex \
tex-babel-sanskrit-knda.tex \
tex-babel-sanskrit-malayalam.tex \
tex-babel-sanskrit-mlym.tex \
tex-babel-sanskrit-telu.tex \
tex-babel-sanskrit-telugu.tex \
tex-babel-sanskrit.tex \
tex-babel-sardinian.tex \
tex-babel-scottishgaelic.tex \
tex-babel-sena.tex \
tex-babel-serbian-cyrillic-bosniaherzegovina.tex \
tex-babel-serbian-cyrillic-kosovo.tex \
tex-babel-serbian-cyrillic-montenegro.tex \
tex-babel-serbian-cyrillic.tex \
tex-babel-serbian-cyrl-ba.tex \
tex-babel-serbian-cyrl-me.tex \
tex-babel-serbian-cyrl-xk.tex \
tex-babel-serbian-cyrl.tex \
tex-babel-serbian-latin-bosniaherzegovina.tex \
tex-babel-serbian-latin-kosovo.tex \
tex-babel-serbian-latin-montenegro.tex \
tex-babel-serbian-latin.tex \
tex-babel-serbian-latn-ba.tex \
tex-babel-serbian-latn-me.tex \
tex-babel-serbian-latn-xk.tex \
tex-babel-serbian-latn.tex \
tex-babel-serbian.tex \
tex-babel-shambala.tex \
tex-babel-shona.tex \
tex-babel-sichuanyi.tex \
tex-babel-sinhala.tex \
tex-babel-slovak.tex \
tex-babel-slovene.tex \
tex-babel-slovenian.tex \
tex-babel-soga.tex \
tex-babel-somali.tex \
tex-babel-sorani.tex \
tex-babel-spanish-mexico.tex \
tex-babel-spanish-mx.tex \
tex-babel-spanish.tex \
tex-babel-standardmoroccantamazight.tex \
tex-babel-swahili.tex \
tex-babel-swedish.tex \
tex-babel-swissgerman.tex \
tex-babel-swisshighgerman.tex \
tex-babel-syriac.tex \
tex-babel-tachelhit-latin.tex \
tex-babel-tachelhit-latn.tex \
tex-babel-tachelhit-tfng.tex \
tex-babel-tachelhit-tifinagh.tex \
tex-babel-tachelhit.tex \
tex-babel-taita.tex \
tex-babel-tamil.tex \
tex-babel-tasawaq.tex \
tex-babel-telugu.tex \
tex-babel-teso.tex \
tex-babel-thai.tex \
tex-babel-tibetan.tex \
tex-babel-tigrinya.tex \
tex-babel-tongan.tex \
tex-babel-turkish.tex \
tex-babel-turkmen.tex \
tex-babel-ukenglish.tex \
tex-babel-ukrainian.tex \
tex-babel-uppersorbian.tex \
tex-babel-urdu.tex \
tex-babel-usenglish.tex \
tex-babel-usorbian.tex \
tex-babel-uyghur.tex \
tex-babel-uzbek-arab.tex \
tex-babel-uzbek-arabic.tex \
tex-babel-uzbek-cyrillic.tex \
tex-babel-uzbek-cyrl.tex \
tex-babel-uzbek-latin.tex \
tex-babel-uzbek-latn.tex \
tex-babel-uzbek.tex \
tex-babel-vai-latin.tex \
tex-babel-vai-latn.tex \
tex-babel-vai-vai.tex \
tex-babel-vai-vaii.tex \
tex-babel-vai.tex \
tex-babel-vietnam.tex \
tex-babel-vietnamese.tex \
tex-babel-vunjo.tex \
tex-babel-walser.tex \
tex-babel-welsh.tex \
tex-babel-westernfrisian.tex \
tex-babel-yangben.tex \
tex-babel-yiddish.tex \
tex-babel-yoruba.tex \
tex-babel-zarma.tex \
tex-babel-zulu.tex \
tex-babel.def \
tex-babel.sty \
tex-bahasa.sty \
tex-bahasam.sty \
tex-basque.sty \
tex-blplain.tex \
tex-bplain.tex \
tex-breton.sty \
tex-british.sty \
tex-bulgarian.sty \
tex-catalan.sty \
tex-croatian.sty \
tex-czech.sty \
tex-danish.sty \
tex-dutch.sty \
tex-english.sty \
tex-esperanto.sty \
tex-estonian.sty \
tex-finnish.sty \
tex-francais.sty \
tex-galician.sty \
tex-germanb.sty \
tex-greek.sty \
tex-hebrew.sty \
tex-hyphen.cfg \
tex-icelandic.sty \
tex-interlingua.sty \
tex-irish.sty \
tex-italian.sty \
tex-latin.sty \
tex-lsorbian.sty \
tex-luababel.def \
tex-magyar.sty \
tex-naustrian.sty \
tex-ngermanb.sty \
tex-nil.ldf \
tex-norsk.sty \
tex-plain.def \
tex-polish.sty \
tex-portuges.sty \
tex-romanian.sty \
tex-russianb.sty \
tex-samin.sty \
tex-scottish.sty \
tex-serbian.sty \
tex-slovak.sty \
tex-slovene.sty \
tex-spanish.sty \
tex-swedish.sty \
tex-switch.def \
tex-turkish.sty \
tex-txtbabel.def \
tex-ukraineb.sty \
tex-usorbian.sty \
tex-welsh.sty \
tex-xebabel.def \
texlive-babel"

RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontspec.sty \
tex-language.def \
tex-luatexbase.sty \
tex-rlbabel.def \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
