SUMMARY = "Support for Vietnamese"
DESCRIPTION = "The vntex bundle provides fonts, Plain TeX, texinfo and LaTeX \
macros for typesetting documents in Vietnamese. Users of the \
fonts (in both Metafont and Adobe Type 1 format) of this bundle \
may alternatively use the lm fonts bundle, for which map files \
are available to provide a Vietnamese version."
LICENSE = "LPPL-1.0"

PV = "2023.201.3.2.2svn62837"

RPM_NAME = "texlive-vntex-2023.201.3.2.2svn62837-53.1.noarch.rpm"
RPM_HASH = "e621d05a5d0a01d6bc07d6998a39510811385df510efa00c037b414fb0a9bfa4565ee21963b774ac9094b7efd79fa2b44e6ac06dcf1ec7956fc7ec0d6613538f"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex(arevvn.map) \
tex(bchb8v.tfm) \
tex(bchbc8v.tfm) \
tex(bchbc8v.vf) \
tex(bchbi8v.tfm) \
tex(bchbo8v.tfm) \
tex(bchr8v.tfm) \
tex(bchrc8v.tfm) \
tex(bchrc8v.vf) \
tex(bchri8v.tfm) \
tex(bchro8v.tfm) \
tex(chartervn.map) \
tex(cmbrightvn.map) \
tex(concretevn.map) \
tex(dblaccnt.sty) \
tex(dblaccnt.tex) \
tex(favb8v.tfm) \
tex(favbi8v.tfm) \
tex(favr8v.tfm) \
tex(favri8v.tfm) \
tex(fplrc8v.tfm) \
tex(grotesqvn.map) \
tex(mcviscii.def) \
tex(pd1supp.def) \
tex(putb8v.tfm) \
tex(putbc8v.tfm) \
tex(putbc8v.vf) \
tex(putbi8v.tfm) \
tex(putbo8v.tfm) \
tex(putr8v.tfm) \
tex(putrc8v.tfm) \
tex(putrc8v.vf) \
tex(putri8v.tfm) \
tex(putro8v.tfm) \
tex(swpvntex.sty) \
tex(t5.enc) \
tex(t5bch.fd) \
tex(t5ccr.fd) \
tex(t5cmbr.fd) \
tex(t5cmdh.fd) \
tex(t5cmfib.fd) \
tex(t5cmfr.fd) \
tex(t5cmr.fd) \
tex(t5cmss.fd) \
tex(t5cmssq.fd) \
tex(t5cmtl.fd) \
tex(t5cmtt.fd) \
tex(t5cmvtt.fd) \
tex(t5code.tex) \
tex(t5d.enc) \
tex(t5enc.def) \
tex(t5fav.fd) \
tex(t5fnc.fd) \
tex(t5fpl.fd) \
tex(t5futs.fd) \
tex(t5mak.fd) \
tex(t5mdbch.fd) \
tex(t5mdput.fd) \
tex(t5mdugm.fd) \
tex(t5pag.fd) \
tex(t5pbk.fd) \
tex(t5pcr.fd) \
tex(t5phv.fd) \
tex(t5pnc.fd) \
tex(t5ppl.fd) \
tex(t5ptm.fd) \
tex(t5ptmom.fd) \
tex(t5put.fd) \
tex(t5pxr.fd) \
tex(t5txr.fd) \
tex(t5txtt.fd) \
tex(t5uag.fd) \
tex(t5ubk.fd) \
tex(t5ucr.fd) \
tex(t5ugq.fd) \
tex(t5uhv.fd) \
tex(t5unc.fd) \
tex(t5uni.enc) \
tex(t5upl.fd) \
tex(t5utm.fd) \
tex(t5uzcm.fd) \
tex(tcvn.def) \
tex(txbtt8v.tfm) \
tex(txbttsc8v.tfm) \
tex(txbttsl8v.tfm) \
tex(txtt8v.tfm) \
tex(txttsc8v.tfm) \
tex(txttsl8v.tfm) \
tex(txttvn.map) \
tex(uagd8v.tfm) \
tex(uagdc8v.tfm) \
tex(uagdc8v.vf) \
tex(uagdo8v.tfm) \
tex(uagk8v.tfm) \
tex(uagkc8v.tfm) \
tex(uagkc8v.vf) \
tex(uagko8v.tfm) \
tex(ubkd8v.tfm) \
tex(ubkdc8v.tfm) \
tex(ubkdc8v.vf) \
tex(ubkdi8v.tfm) \
tex(ubkdo8v.tfm) \
tex(ubkl8v.tfm) \
tex(ubklc8v.tfm) \
tex(ubklc8v.vf) \
tex(ubkli8v.tfm) \
tex(ubklo8v.tfm) \
tex(ucrb8v.tfm) \
tex(ucrbc8v.tfm) \
tex(ucrbc8v.vf) \
tex(ucrbo8v.tfm) \
tex(ucrr8v.tfm) \
tex(ucrrc8v.tfm) \
tex(ucrrc8v.vf) \
tex(ucrro8v.tfm) \
tex(ugqb8v.tfm) \
tex(ugqbo8v.tfm) \
tex(uhvb8v.tfm) \
tex(uhvbc8v.tfm) \
tex(uhvbc8v.vf) \
tex(uhvbo8v.tfm) \
tex(uhvr8v.tfm) \
tex(uhvrc8v.tfm) \
tex(uhvrc8v.vf) \
tex(uhvro8v.tfm) \
tex(uncb8v.tfm) \
tex(uncbc8v.tfm) \
tex(uncbc8v.vf) \
tex(uncbi8v.tfm) \
tex(uncbo8v.tfm) \
tex(uncr8v.tfm) \
tex(uncrc8v.tfm) \
tex(uncrc8v.vf) \
tex(uncri8v.tfm) \
tex(uncro8v.tfm) \
tex(uplb8v.tfm) \
tex(uplbc8v.tfm) \
tex(uplbc8v.vf) \
tex(uplbi8v.tfm) \
tex(uplbo8v.tfm) \
tex(uplr8v.tfm) \
tex(uplrc8v.tfm) \
tex(uplrc8v.vf) \
tex(uplri8v.tfm) \
tex(uplro8v.tfm) \
tex(urwvn.map) \
tex(utmb8v.tfm) \
tex(utmbc8v.tfm) \
tex(utmbc8v.vf) \
tex(utmbi8v.tfm) \
tex(utmbo8v.tfm) \
tex(utmr8v.tfm) \
tex(utmrc8v.tfm) \
tex(utmrc8v.vf) \
tex(utmri8v.tfm) \
tex(utmro8v.tfm) \
tex(uzcmi8v.tfm) \
tex(varioref-vi.sty) \
tex(vietnam.sty) \
tex(viscii.def) \
tex(vnb10.tfm) \
tex(vnbx10.tfm) \
tex(vnbx12.tfm) \
tex(vnbx5.tfm) \
tex(vnbx6.tfm) \
tex(vnbx7.tfm) \
tex(vnbx8.tfm) \
tex(vnbx9.tfm) \
tex(vnbxsl10.tfm) \
tex(vnbxti10.tfm) \
tex(vncaps.tex) \
tex(vncccsc10.tfm) \
tex(vnccr10.tfm) \
tex(vnccsl10.tfm) \
tex(vnccti10.tfm) \
tex(vncmbr10.tfm) \
tex(vncmbr17.tfm) \
tex(vncmbr8.tfm) \
tex(vncmbr9.tfm) \
tex(vncmbrbx10.tfm) \
tex(vncmbrsl10.tfm) \
tex(vncmbrsl17.tfm) \
tex(vncmbrsl8.tfm) \
tex(vncmbrsl9.tfm) \
tex(vncmsltl10.tfm) \
tex(vncmtl10.tfm) \
tex(vncsc10.tfm) \
tex(vndunh10.tfm) \
tex(vnff10.tfm) \
tex(vnfi10.tfm) \
tex(vnfib8.tfm) \
tex(vnitt10.tfm) \
tex(vnr10.tfm) \
tex(vnr12.tfm) \
tex(vnr17.tfm) \
tex(vnr5.tfm) \
tex(vnr6.tfm) \
tex(vnr7.tfm) \
tex(vnr8.tfm) \
tex(vnr9.tfm) \
tex(vnrother.map) \
tex(vnrtext.map) \
tex(vnsl10.tfm) \
tex(vnsl12.tfm) \
tex(vnsl8.tfm) \
tex(vnsl9.tfm) \
tex(vnsltt10.tfm) \
tex(vnss10.tfm) \
tex(vnss12.tfm) \
tex(vnss17.tfm) \
tex(vnss8.tfm) \
tex(vnss9.tfm) \
tex(vnssbx10.tfm) \
tex(vnssdc10.tfm) \
tex(vnssi10.tfm) \
tex(vnssi12.tfm) \
tex(vnssi17.tfm) \
tex(vnssi8.tfm) \
tex(vnssi9.tfm) \
tex(vnssq8.tfm) \
tex(vnssqi8.tfm) \
tex(vntcsc10.tfm) \
tex(vntex.sty) \
tex(vntexinfo.tex) \
tex(vnti10.tfm) \
tex(vnti12.tfm) \
tex(vnti7.tfm) \
tex(vnti8.tfm) \
tex(vnti9.tfm) \
tex(vntopia.map) \
tex(vntt10.tfm) \
tex(vntt12.tfm) \
tex(vntt8.tfm) \
tex(vntt9.tfm) \
tex(vnu10.tfm) \
tex(vnvtt10.tfm) \
tex(vps.def) \
texlive-vntex"

RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex(cmap.sty) \
tex(fontenc.sty) \
tex(ifpdf.sty) \
tex(ifthen.sty) \
tex(inputenc.sty) \
tex(ucs.sty) \
tex(updmap.cfg) \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin \
texlive-vntex-fonts"

inherit rpm
