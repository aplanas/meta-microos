SUMMARY = "The Standard Kernel"
DESCRIPTION = "The standard kernel for both uniprocessor and multiprocessor systems. \
 \
 \
Source Timestamp: 2023-07-25 04:42:30 +0000 \
GIT Revision: 55520bc826c5b1d40857ed0536eb87438cb95192 \
GIT Branch: stable"
LICENSE = "GPL-2.0-only"

PV = "6.4.6"

RPM_NAME = "kernel-default-6.4.6-1.1.aarch64.rpm"
RPM_HASH = "eeb032b9d8125c56758ca90c35e2f3703a961d3b5fdb415a5a1d89f7ed6df6805e3041005ec5389dad4d448f2245b505d04fbc91cdc5e41145df17690e31920e"

RPROVIDES:${PN} += "kernel \
kernel-base \
kernel-default \
kernel-default-6.4.6-1 \
kernel-default-aarch64 \
kernel-default-base-srchash-55520bc826c5b1d40857ed0536eb87438cb95192 \
kernel-default-srchash-55520bc826c5b1d40857ed0536eb87438cb95192 \
kernel-preempt \
kernel-preempt-aarch64 \
kernel-srchash-55520bc826c5b1d40857ed0536eb87438cb95192 \
kernel-uname-r \
kmod-3c59x.ko \
kmod-3w-9xxx.ko \
kmod-3w-sas.ko \
kmod-3w-xxxx.ko \
kmod-6lowpan.ko \
kmod-6pack.ko \
kmod-8021q.ko \
kmod-8139cp.ko \
kmod-8139too.ko \
kmod-8250-base.ko \
kmod-8250-bcm2835aux.ko \
kmod-8250-bcm7271.ko \
kmod-8250-dfl.ko \
kmod-8250-dw.ko \
kmod-8250-em.ko \
kmod-8250-exar.ko \
kmod-8250-mtk.ko \
kmod-8250-of.ko \
kmod-8250-pci.ko \
kmod-8250-pci1xxxx.ko \
kmod-8250-pericom.ko \
kmod-8250-tegra.ko \
kmod-8250.ko \
kmod-8255.ko \
kmod-8390.ko \
kmod-88pg86x.ko \
kmod-9p.ko \
kmod-9pnet-fd.ko \
kmod-9pnet-rdma.ko \
kmod-9pnet-virtio.ko \
kmod-9pnet.ko \
kmod-BusLogic.ko \
kmod-a100u2w.ko \
kmod-a53-pll.ko \
kmod-a7-pll.ko \
kmod-a8293.ko \
kmod-aacraid.ko \
kmod-abp060mg.ko \
kmod-ac.ko \
kmod-ac100.ko \
kmod-ac97-bus.ko \
kmod-acard-ahci.ko \
kmod-acbel-fsg032.ko \
kmod-acecad.ko \
kmod-acenic.ko \
kmod-acp-audio-dma.ko \
kmod-acpi-configfs.ko \
kmod-acpi-ipmi.ko \
kmod-acpi-mdio.ko \
kmod-acpi-tad.ko \
kmod-act-bpf.ko \
kmod-act-connmark.ko \
kmod-act-csum.ko \
kmod-act-ct.ko \
kmod-act-ctinfo.ko \
kmod-act-gact.ko \
kmod-act-gate.ko \
kmod-act-ife.ko \
kmod-act-ipt.ko \
kmod-act-meta-mark.ko \
kmod-act-meta-skbprio.ko \
kmod-act-meta-skbtcindex.ko \
kmod-act-mirred.ko \
kmod-act-mpls.ko \
kmod-act-nat.ko \
kmod-act-pedit.ko \
kmod-act-police.ko \
kmod-act-sample.ko \
kmod-act-simple.ko \
kmod-act-skbedit.ko \
kmod-act-skbmod.ko \
kmod-act-tunnel-key.ko \
kmod-act-vlan.ko \
kmod-ad-sigma-delta.ko \
kmod-ad525x-dpot-i2c.ko \
kmod-ad525x-dpot.ko \
kmod-ad5272.ko \
kmod-ad5592r-base.ko \
kmod-ad5592r.ko \
kmod-ad5686-spi.ko \
kmod-ad5686.ko \
kmod-ad5696-i2c.ko \
kmod-ad5758.ko \
kmod-ad5761.ko \
kmod-ad5766.ko \
kmod-ad5770r.ko \
kmod-ad5820.ko \
kmod-ad7091r-base.ko \
kmod-ad7091r5.ko \
kmod-ad7124.ko \
kmod-ad714x-i2c.ko \
kmod-ad714x.ko \
kmod-ad7292.ko \
kmod-ad7414.ko \
kmod-ad7418.ko \
kmod-ad7606-par.ko \
kmod-ad7606-spi.ko \
kmod-ad7606.ko \
kmod-ad7766.ko \
kmod-ad7768-1.ko \
kmod-ad7879-i2c.ko \
kmod-ad7879.ko \
kmod-ad7949.ko \
kmod-ad8801.ko \
kmod-ad9467.ko \
kmod-ada4250.ko \
kmod-adc-joystick.ko \
kmod-adc128d818.ko \
kmod-adf4371.ko \
kmod-adf7242.ko \
kmod-adfs.ko \
kmod-adi-axi-adc.ko \
kmod-adiantum.ko \
kmod-adin.ko \
kmod-adin1100.ko \
kmod-adin1110.ko \
kmod-adis-lib.ko \
kmod-adis16460.ko \
kmod-adis16475.ko \
kmod-adm1025.ko \
kmod-adm1026.ko \
kmod-adm1029.ko \
kmod-adm1031.ko \
kmod-adm1177.ko \
kmod-adm1266.ko \
kmod-adm1275.ko \
kmod-adm8211.ko \
kmod-adm9240.ko \
kmod-admv1014.ko \
kmod-admv4420.ko \
kmod-adp1653.ko \
kmod-adp5061.ko \
kmod-adp5588-keys.ko \
kmod-adp5589-keys.ko \
kmod-adp8860-bl.ko \
kmod-adp8870-bl.ko \
kmod-adrf6780.ko \
kmod-ads7828.ko \
kmod-ads7846.ko \
kmod-adt7410.ko \
kmod-adt7411.ko \
kmod-adt7462.ko \
kmod-adt7470.ko \
kmod-adt7475.ko \
kmod-adt7x10.ko \
kmod-adummy.ko \
kmod-adutux.ko \
kmod-adux1020.ko \
kmod-adv7170.ko \
kmod-adv7175.ko \
kmod-adv7180.ko \
kmod-adv7183.ko \
kmod-adv7343.ko \
kmod-adv7393.ko \
kmod-adv748x.ko \
kmod-adv7511.ko \
kmod-adv7604.ko \
kmod-adv7842.ko \
kmod-advansys.ko \
kmod-adxl313-core.ko \
kmod-adxl313-i2c.ko \
kmod-adxl313-spi.ko \
kmod-adxl34x-i2c.ko \
kmod-adxl34x-spi.ko \
kmod-adxl34x.ko \
kmod-adxl355-core.ko \
kmod-adxl355-i2c.ko \
kmod-adxl355-spi.ko \
kmod-adxl367-i2c.ko \
kmod-adxl367-spi.ko \
kmod-adxl367.ko \
kmod-adxl372-i2c.ko \
kmod-adxl372-spi.ko \
kmod-adxl372.ko \
kmod-aead.ko \
kmod-aegis128.ko \
kmod-aer-inject.ko \
kmod-aes-arm64.ko \
kmod-aes-ce-blk.ko \
kmod-aes-ce-ccm.ko \
kmod-aes-ce-cipher.ko \
kmod-aes-generic.ko \
kmod-aes-neon-blk.ko \
kmod-aes-neon-bs.ko \
kmod-aes-ti.ko \
kmod-af-alg.ko \
kmod-af-key.ko \
kmod-af-packet-diag.ko \
kmod-af-packet.ko \
kmod-af9013.ko \
kmod-af9033.ko \
kmod-afe4403.ko \
kmod-afe4404.ko \
kmod-affs.ko \
kmod-afs.ko \
kmod-ah4.ko \
kmod-ah6.ko \
kmod-ahci-brcm.ko \
kmod-ahci-ceva.ko \
kmod-ahci-dwc.ko \
kmod-ahci-imx.ko \
kmod-ahci-mtk.ko \
kmod-ahci-mvebu.ko \
kmod-ahci-platform.ko \
kmod-ahci-qoriq.ko \
kmod-ahci-seattle.ko \
kmod-ahci-sunxi.ko \
kmod-ahci-tegra.ko \
kmod-ahci-xgene.ko \
kmod-ahci.ko \
kmod-aht10.ko \
kmod-aic79xx.ko \
kmod-aic7xxx.ko \
kmod-aic94xx.ko \
kmod-aiptek.ko \
kmod-aircable.ko \
kmod-airo.ko \
kmod-airspy.ko \
kmod-ak7375.ko \
kmod-ak881x.ko \
kmod-ak8974.ko \
kmod-akcipher.ko \
kmod-al-mc-edac.ko \
kmod-al3010.ko \
kmod-alcor-pci.ko \
kmod-alcor.ko \
kmod-algif-aead.ko \
kmod-algif-hash.ko \
kmod-algif-rng.ko \
kmod-algif-skcipher.ko \
kmod-alibaba-uncore-drw-pmu.ko \
kmod-alim7101-wdt.ko \
kmod-allegro.ko \
kmod-altera-ci.ko \
kmod-altera-cvp.ko \
kmod-altera-fpga2sdram.ko \
kmod-altera-freeze-bridge.ko \
kmod-altera-hps2fpga.ko \
kmod-altera-msgdma.ko \
kmod-altera-pr-ip-core-plat.ko \
kmod-altera-pr-ip-core.ko \
kmod-altera-ps-spi.ko \
kmod-altera-ps2.ko \
kmod-altera-stapl.ko \
kmod-alx.ko \
kmod-am2315.ko \
kmod-am53c974.ko \
kmod-amba-pl010.ko \
kmod-amba-pl011.ko \
kmod-amc6821.ko \
kmod-amd-xgbe.ko \
kmod-amd.ko \
kmod-amd8111e.ko \
kmod-amdgpu.ko \
kmod-amlogic-gxl-crypto.ko \
kmod-amlogic-thermal.ko \
kmod-amphion-vpu.ko \
kmod-ams-iaq-core.ko \
kmod-amt.ko \
kmod-analogix-anx6345.ko \
kmod-analogix-anx78xx.ko \
kmod-analogix-dp.ko \
kmod-ansi-cprng.ko \
kmod-anx7411.ko \
kmod-anx7625.ko \
kmod-anybuss-core.ko \
kmod-ao-cec-g12a.ko \
kmod-ao-cec.ko \
kmod-aoe.ko \
kmod-apbps2.ko \
kmod-apcs-msm8916.ko \
kmod-apcs-msm8996.ko \
kmod-apcs-sdx55.ko \
kmod-apds990x.ko \
kmod-apds9960.ko \
kmod-apple-admac.ko \
kmod-apple-dart.ko \
kmod-apple-mailbox.ko \
kmod-apple-mfi-fastcharge.ko \
kmod-apple-rtkit.ko \
kmod-apple-sart.ko \
kmod-apple-soc-cpufreq.ko \
kmod-apple-wdt.ko \
kmod-appledisplay.ko \
kmod-appletouch.ko \
kmod-applicom.ko \
kmod-apr.ko \
kmod-apss-ipq-pll.ko \
kmod-apss-ipq6018.ko \
kmod-aptina-pll.ko \
kmod-aqc111.ko \
kmod-aquacomputer-d5next.ko \
kmod-aquantia.ko \
kmod-ar0521.ko \
kmod-ar1021-i2c.ko \
kmod-ar5523.ko \
kmod-ar7part.ko \
kmod-arasan-nand-controller.ko \
kmod-arcmsr.ko \
kmod-arcx-anybus.ko \
kmod-arcxcnn-bl.ko \
kmod-aria-generic.ko \
kmod-arizona-ldo1.ko \
kmod-arizona-micsupp.ko \
kmod-ark3116.ko \
kmod-arm-cci.ko \
kmod-arm-ccn.ko \
kmod-arm-cmn.ko \
kmod-arm-dmc620-pmu.ko \
kmod-arm-dsu-pmu.ko \
kmod-arm-mhuv2.ko \
kmod-arm-scpi.ko \
kmod-arm-smc-wdt.ko \
kmod-arm-smccc-trng.ko \
kmod-arm-smmu-v3.ko \
kmod-arm-smmu.ko \
kmod-arm-smmuv3-pmu.ko \
kmod-arm-spe-pmu.ko \
kmod-arm64-reloc-test.ko \
kmod-armada-37xx-cpufreq.ko \
kmod-armada-37xx-rwtm-mailbox.ko \
kmod-armada-37xx-wdt.ko \
kmod-armada-8k-cpufreq.ko \
kmod-armada-thermal.ko \
kmod-armmmci.ko \
kmod-arp-tables.ko \
kmod-arpt-mangle.ko \
kmod-arptable-filter.ko \
kmod-as102-fe.ko \
kmod-as370-hwmon.ko \
kmod-as5011.ko \
kmod-asc7621.ko \
kmod-ascot2e.ko \
kmod-asix.ko \
kmod-asn1-decoder.ko \
kmod-asn1-encoder.ko \
kmod-ast.ko \
kmod-async-memcpy.ko \
kmod-async-pq.ko \
kmod-async-raid6-recov.ko \
kmod-async-tx.ko \
kmod-async-xor.ko \
kmod-at24.ko \
kmod-at76c50x-usb.ko \
kmod-at803x.ko \
kmod-ata-generic.ko \
kmod-ata-piix.ko \
kmod-atbm8830.ko \
kmod-atc260x-core.ko \
kmod-atc260x-i2c.ko \
kmod-atc260x-onkey.ko \
kmod-atc260x-poweroff.ko \
kmod-atc260x-regulator.ko \
kmod-aten.ko \
kmod-ath.ko \
kmod-ath10k-core.ko \
kmod-ath10k-pci.ko \
kmod-ath10k-sdio.ko \
kmod-ath10k-snoc.ko \
kmod-ath10k-usb.ko \
kmod-ath11k-ahb.ko \
kmod-ath11k-pci.ko \
kmod-ath11k.ko \
kmod-ath12k.ko \
kmod-ath3k.ko \
kmod-ath5k.ko \
kmod-ath6kl-core.ko \
kmod-ath6kl-sdio.ko \
kmod-ath6kl-usb.ko \
kmod-ath9k-common.ko \
kmod-ath9k-htc.ko \
kmod-ath9k-hw.ko \
kmod-ath9k-pci-owl-loader.ko \
kmod-ath9k.ko \
kmod-ati-remote.ko \
kmod-ati-remote2.ko \
kmod-atkbd.ko \
kmod-atl1.ko \
kmod-atl1c.ko \
kmod-atl1e.ko \
kmod-atl2.ko \
kmod-atlantic.ko \
kmod-atlas-ezo-sensor.ko \
kmod-atlas-sensor.ko \
kmod-atm.ko \
kmod-atmel-captouch.ko \
kmod-atmel-ecc.ko \
kmod-atmel-hlcdc.ko \
kmod-atmel-i2c.ko \
kmod-atmel-mxt-ts.ko \
kmod-atmel-pci.ko \
kmod-atmel-sha204a.ko \
kmod-atmel.ko \
kmod-atmtcp.ko \
kmod-atp870u.ko \
kmod-atxp1.ko \
kmod-au0828.ko \
kmod-au8522-common.ko \
kmod-au8522-decoder.ko \
kmod-au8522-dig.ko \
kmod-auo-pixcir-ts.ko \
kmod-auth-rpcgss.ko \
kmod-authenc.ko \
kmod-authencesn.ko \
kmod-autofs4.ko \
kmod-auxadc-thermal.ko \
kmod-ax25.ko \
kmod-ax88179-178a.ko \
kmod-ax88796b.ko \
kmod-ax88796c.ko \
kmod-axg-aoclk.ko \
kmod-axg-audio.ko \
kmod-axg.ko \
kmod-axi-fan-control.ko \
kmod-axis-fifo.ko \
kmod-axp20x-ac-power.ko \
kmod-axp20x-adc.ko \
kmod-axp20x-battery.ko \
kmod-axp20x-i2c.ko \
kmod-axp20x-pek.ko \
kmod-axp20x-regulator.ko \
kmod-axp20x-rsb.ko \
kmod-axp20x-usb-power.ko \
kmod-axp20x.ko \
kmod-axp288-adc.ko \
kmod-b2c2-flexcop-pci.ko \
kmod-b2c2-flexcop-usb.ko \
kmod-b2c2-flexcop.ko \
kmod-b43.ko \
kmod-b43legacy.ko \
kmod-b44.ko \
kmod-b53-common.ko \
kmod-b53-mdio.ko \
kmod-b53-mmap.ko \
kmod-b53-serdes.ko \
kmod-b53-spi.ko \
kmod-b53-srab.ko \
kmod-ba431-rng.ko \
kmod-backlight.ko \
kmod-bam-dma.ko \
kmod-bareudp.ko \
kmod-batman-adv.ko \
kmod-battery.ko \
kmod-baycom-par.ko \
kmod-baycom-ser-fdx.ko \
kmod-baycom-ser-hdx.ko \
kmod-bcache.ko \
kmod-bch.ko \
kmod-bcm-crypto-spu.ko \
kmod-bcm-flexrm-mailbox.ko \
kmod-bcm-iproc-adc.ko \
kmod-bcm-iproc-tsc.ko \
kmod-bcm-pdc-mailbox.ko \
kmod-bcm-phy-lib.ko \
kmod-bcm-sba-raid.ko \
kmod-bcm-sf2.ko \
kmod-bcm-vk.ko \
kmod-bcm203x.ko \
kmod-bcm2711-thermal.ko \
kmod-bcm2835-dma.ko \
kmod-bcm2835-mailbox.ko \
kmod-bcm2835-mmal-vchiq.ko \
kmod-bcm2835-rng.ko \
kmod-bcm2835-thermal.ko \
kmod-bcm2835-v4l2.ko \
kmod-bcm2835-wdt.ko \
kmod-bcm2835.ko \
kmod-bcm3510.ko \
kmod-bcm4908-enet.ko \
kmod-bcm54140.ko \
kmod-bcm5974.ko \
kmod-bcm63xx-uart.ko \
kmod-bcm7038-wdt.ko \
kmod-bcm7xxx.ko \
kmod-bcm84881.ko \
kmod-bcm87xx.ko \
kmod-bcma-hcd.ko \
kmod-bcma.ko \
kmod-bcmsysport.ko \
kmod-bd6107.ko \
kmod-bd71815-regulator.ko \
kmod-bd71828-regulator.ko \
kmod-bd718x7-regulator.ko \
kmod-bd9571mwv-regulator.ko \
kmod-bd9571mwv.ko \
kmod-bd9576-regulator.ko \
kmod-bd9576-wdt.ko \
kmod-bd99954-charger.ko \
kmod-bdc.ko \
kmod-be2iscsi.ko \
kmod-be2net.ko \
kmod-befs.ko \
kmod-bel-pfe.ko \
kmod-belkin-sa.ko \
kmod-bfa.ko \
kmod-bfq.ko \
kmod-bfs.ko \
kmod-bfusb.ko \
kmod-bgmac-platform.ko \
kmod-bgmac.ko \
kmod-bh1770glc.ko \
kmod-binfmt-misc.ko \
kmod-binfmt-script.ko \
kmod-blake2b-generic.ko \
kmod-block2mtd.ko \
kmod-blocklayoutdriver.ko \
kmod-blowfish-common.ko \
kmod-blowfish-generic.ko \
kmod-bluefield-edac.ko \
kmod-bluetooth-6lowpan.ko \
kmod-bluetooth.ko \
kmod-bma150.ko \
kmod-bma220-spi.ko \
kmod-bma400-core.ko \
kmod-bma400-i2c.ko \
kmod-bma400-spi.ko \
kmod-bmc150-accel-core.ko \
kmod-bmc150-accel-i2c.ko \
kmod-bmc150-accel-spi.ko \
kmod-bme680-core.ko \
kmod-bme680-i2c.ko \
kmod-bme680-spi.ko \
kmod-bmi088-accel-core.ko \
kmod-bmi088-accel-spi.ko \
kmod-bmi160-core.ko \
kmod-bmi160-i2c.ko \
kmod-bmi160-spi.ko \
kmod-bmp280-i2c.ko \
kmod-bmp280-spi.ko \
kmod-bmp280.ko \
kmod-bna.ko \
kmod-bnep.ko \
kmod-bnx2.ko \
kmod-bnx2fc.ko \
kmod-bnx2i.ko \
kmod-bnx2x.ko \
kmod-bnxt-en.ko \
kmod-bnxt-re.ko \
kmod-bochs.ko \
kmod-bonding.ko \
kmod-bpa-rs600.ko \
kmod-bpa10x.ko \
kmod-bpck.ko \
kmod-bpck6.ko \
kmod-bpfilter.ko \
kmod-bpqether.ko \
kmod-bq24190-charger.ko \
kmod-bq24257-charger.ko \
kmod-bq24735-charger.ko \
kmod-bq2515x-charger.ko \
kmod-bq256xx-charger.ko \
kmod-bq25890-charger.ko \
kmod-bq25980-charger.ko \
kmod-bq27xxx-battery-hdq.ko \
kmod-bq27xxx-battery-i2c.ko \
kmod-bq27xxx-battery.ko \
kmod-br-netfilter.ko \
kmod-br2684.ko \
kmod-brcmfmac-bca.ko \
kmod-brcmfmac-cyw.ko \
kmod-brcmfmac-wcc.ko \
kmod-brcmfmac.ko \
kmod-brcmsmac.ko \
kmod-brcmstb-avs-cpufreq.ko \
kmod-brcmstb-dpfe.ko \
kmod-brcmstb-gisb.ko \
kmod-brcmstb-memc.ko \
kmod-brcmstb-thermal.ko \
kmod-brcmstb-usb-pinmap.ko \
kmod-brcmutil.ko \
kmod-brd.ko \
kmod-bridge.ko \
kmod-broadcom.ko \
kmod-bsd-comp.ko \
kmod-bsg.ko \
kmod-bt819.ko \
kmod-bt856.ko \
kmod-bt866.ko \
kmod-bt878.ko \
kmod-btbcm.ko \
kmod-btcoexist.ko \
kmod-btintel.ko \
kmod-btmrvl-sdio.ko \
kmod-btmrvl.ko \
kmod-btmtk.ko \
kmod-btmtksdio.ko \
kmod-btmtkuart.ko \
kmod-btnxpuart.ko \
kmod-btqca.ko \
kmod-btqcomsmd.ko \
kmod-btrfs.ko \
kmod-btrsi.ko \
kmod-btrtl.ko \
kmod-btsdio.ko \
kmod-bttv.ko \
kmod-btusb.ko \
kmod-bu21013-ts.ko \
kmod-bu21029-ts.ko \
kmod-budget-ci.ko \
kmod-budget-core.ko \
kmod-budget.ko \
kmod-button.ko \
kmod-c-can-pci.ko \
kmod-c-can.ko \
kmod-c67x00.ko \
kmod-ca8210.ko \
kmod-caam-jr.ko \
kmod-caam.ko \
kmod-caamalg-desc.ko \
kmod-caamhash-desc.ko \
kmod-cachefiles.ko \
kmod-cadence-nand-controller.ko \
kmod-cadence-wdt.ko \
kmod-cafe-ccic.ko \
kmod-cafe-nand.ko \
kmod-caif-socket.ko \
kmod-caif-usb.ko \
kmod-caif.ko \
kmod-camcc-sc7180.ko \
kmod-camcc-sc7280.ko \
kmod-camcc-sdm845.ko \
kmod-camcc-sm6350.ko \
kmod-camcc-sm8250.ko \
kmod-camcc-sm8450.ko \
kmod-camellia-generic.ko \
kmod-can-bcm.ko \
kmod-can-dev.ko \
kmod-can-gw.ko \
kmod-can-isotp.ko \
kmod-can-j1939.ko \
kmod-can-raw.ko \
kmod-can.ko \
kmod-can327.ko \
kmod-cap11xx.ko \
kmod-capsule-loader.ko \
kmod-carl9170.ko \
kmod-cassini.ko \
kmod-cast-common.ko \
kmod-cast5-generic.ko \
kmod-cast6-generic.ko \
kmod-catc.ko \
kmod-cavium-ptp.ko \
kmod-cavium-rng-vf.ko \
kmod-cavium-rng.ko \
kmod-cb710-mmc.ko \
kmod-cb710.ko \
kmod-cbc.ko \
kmod-ccm.ko \
kmod-ccp-crypto.ko \
kmod-ccp.ko \
kmod-ccree.ko \
kmod-ccs-pll.ko \
kmod-ccs.ko \
kmod-ccs811.ko \
kmod-cctrng.ko \
kmod-cdc-acm.ko \
kmod-cdc-eem.ko \
kmod-cdc-ether.ko \
kmod-cdc-mbim.ko \
kmod-cdc-ncm.ko \
kmod-cdc-phonet.ko \
kmod-cdc-subset.ko \
kmod-cdc-wdm.ko \
kmod-cdns-csi2rx.ko \
kmod-cdns-csi2tx.ko \
kmod-cdns-dphy-rx.ko \
kmod-cdns-dphy.ko \
kmod-cdns-dsi.ko \
kmod-cdns-mhdp8546.ko \
kmod-cdns-pltfrm.ko \
kmod-cdns-usb-common.ko \
kmod-cdns3-imx.ko \
kmod-cdns3-pci-wrap.ko \
kmod-cdns3.ko \
kmod-cdnsp-udc-pci.ko \
kmod-cdrom.ko \
kmod-cdx-controller.ko \
kmod-cec-gpio.ko \
kmod-cec.ko \
kmod-ceph.ko \
kmod-cfb.ko \
kmod-cfbcopyarea.ko \
kmod-cfbfillrect.ko \
kmod-cfbimgblt.ko \
kmod-cfg80211.ko \
kmod-cfi-cmdset-0001.ko \
kmod-cfi-cmdset-0002.ko \
kmod-cfi-cmdset-0020.ko \
kmod-cfi-probe.ko \
kmod-cfi-util.ko \
kmod-ch-ipsec.ko \
kmod-ch-ktls.ko \
kmod-ch.ko \
kmod-ch341.ko \
kmod-ch7006.ko \
kmod-ch7322.ko \
kmod-ch9200.ko \
kmod-chacha-generic.ko \
kmod-chacha-neon.ko \
kmod-chacha20poly1305.ko \
kmod-chaoskey.ko \
kmod-charlcd.ko \
kmod-chcr.ko \
kmod-chipone-icn6211.ko \
kmod-chipone-icn8318.ko \
kmod-chipone-icn8505.ko \
kmod-chipreg.ko \
kmod-chnl-net.ko \
kmod-chromeos-acpi.ko \
kmod-chromeos-privacy-screen.ko \
kmod-chromeos-tbmc.ko \
kmod-chrontel-ch7033.ko \
kmod-ci-hdrc-imx.ko \
kmod-ci-hdrc-msm.ko \
kmod-ci-hdrc-pci.ko \
kmod-ci-hdrc-tegra.ko \
kmod-ci-hdrc-usb2.ko \
kmod-ci-hdrc.ko \
kmod-cicada.ko \
kmod-cifs-arc4.ko \
kmod-cifs-md4.ko \
kmod-cifs.ko \
kmod-cirrus.ko \
kmod-clip.ko \
kmod-clk-apmixed.ko \
kmod-clk-apple-nco.ko \
kmod-clk-axi-clkgen.ko \
kmod-clk-bcm2711-dvp.ko \
kmod-clk-bd718x7.ko \
kmod-clk-cbf-8996.ko \
kmod-clk-cdce706.ko \
kmod-clk-cdce925.ko \
kmod-clk-cpu-8996.ko \
kmod-clk-cpu-dyndiv.ko \
kmod-clk-cpumux.ko \
kmod-clk-cs2000-cp.ko \
kmod-clk-dualdiv.ko \
kmod-clk-exynos-audss.ko \
kmod-clk-exynos-clkout.ko \
kmod-clk-fsl-flexspi.ko \
kmod-clk-gate.ko \
kmod-clk-hi3519.ko \
kmod-clk-hi655x.ko \
kmod-clk-imx-lpcg-scu.ko \
kmod-clk-imx-scu.ko \
kmod-clk-imx8mm.ko \
kmod-clk-imx8mn.ko \
kmod-clk-imx8mp-audiomix.ko \
kmod-clk-imx8mp.ko \
kmod-clk-imx8mq.ko \
kmod-clk-imx8ulp.ko \
kmod-clk-imx93.ko \
kmod-clk-lmk04832.ko \
kmod-clk-lochnagar.ko \
kmod-clk-max77686.ko \
kmod-clk-max9485.ko \
kmod-clk-mpll.ko \
kmod-clk-mt2712-apmixedsys.ko \
kmod-clk-mt2712-bdp.ko \
kmod-clk-mt2712-img.ko \
kmod-clk-mt2712-jpgdec.ko \
kmod-clk-mt2712-mfg.ko \
kmod-clk-mt2712-mm.ko \
kmod-clk-mt2712-vdec.ko \
kmod-clk-mt2712-venc.ko \
kmod-clk-mt2712.ko \
kmod-clk-mt6765-audio.ko \
kmod-clk-mt6765-cam.ko \
kmod-clk-mt6765-img.ko \
kmod-clk-mt6765-mipi0a.ko \
kmod-clk-mt6765-mm.ko \
kmod-clk-mt6765-vcodec.ko \
kmod-clk-mt6765.ko \
kmod-clk-mt6779-aud.ko \
kmod-clk-mt6779-cam.ko \
kmod-clk-mt6779-img.ko \
kmod-clk-mt6779-ipe.ko \
kmod-clk-mt6779-mfg.ko \
kmod-clk-mt6779-mm.ko \
kmod-clk-mt6779-vdec.ko \
kmod-clk-mt6779-venc.ko \
kmod-clk-mt6779.ko \
kmod-clk-mt6795-apmixedsys.ko \
kmod-clk-mt6795-infracfg.ko \
kmod-clk-mt6795-mfg.ko \
kmod-clk-mt6795-mm.ko \
kmod-clk-mt6795-pericfg.ko \
kmod-clk-mt6795-topckgen.ko \
kmod-clk-mt6795-vdecsys.ko \
kmod-clk-mt6795-vencsys.ko \
kmod-clk-mt6797-img.ko \
kmod-clk-mt6797-mm.ko \
kmod-clk-mt6797-vdec.ko \
kmod-clk-mt6797-venc.ko \
kmod-clk-mt6797.ko \
kmod-clk-mt7622-apmixedsys.ko \
kmod-clk-mt7622-aud.ko \
kmod-clk-mt7622-eth.ko \
kmod-clk-mt7622-hif.ko \
kmod-clk-mt7622-infracfg.ko \
kmod-clk-mt7622.ko \
kmod-clk-mt7981-apmixed.ko \
kmod-clk-mt7981-eth.ko \
kmod-clk-mt7981-infracfg.ko \
kmod-clk-mt7981-topckgen.ko \
kmod-clk-mt7986-apmixed.ko \
kmod-clk-mt7986-eth.ko \
kmod-clk-mt7986-infracfg.ko \
kmod-clk-mt7986-topckgen.ko \
kmod-clk-mt8167-apmixedsys.ko \
kmod-clk-mt8167-aud.ko \
kmod-clk-mt8167-img.ko \
kmod-clk-mt8167-mfgcfg.ko \
kmod-clk-mt8167-mm.ko \
kmod-clk-mt8167-vdec.ko \
kmod-clk-mt8167.ko \
kmod-clk-mt8173-apmixedsys.ko \
kmod-clk-mt8173-img.ko \
kmod-clk-mt8173-infracfg.ko \
kmod-clk-mt8173-mm.ko \
kmod-clk-mt8173-pericfg.ko \
kmod-clk-mt8173-topckgen.ko \
kmod-clk-mt8173-vdecsys.ko \
kmod-clk-mt8173-vencsys.ko \
kmod-clk-mt8183-apmixedsys.ko \
kmod-clk-mt8183-audio.ko \
kmod-clk-mt8183-cam.ko \
kmod-clk-mt8183-img.ko \
kmod-clk-mt8183-ipu-adl.ko \
kmod-clk-mt8183-ipu-conn.ko \
kmod-clk-mt8183-ipu0.ko \
kmod-clk-mt8183-ipu1.ko \
kmod-clk-mt8183-mfgcfg.ko \
kmod-clk-mt8183-mm.ko \
kmod-clk-mt8183-vdec.ko \
kmod-clk-mt8183-venc.ko \
kmod-clk-mt8183.ko \
kmod-clk-mt8186-apmixedsys.ko \
kmod-clk-mt8186-cam.ko \
kmod-clk-mt8186-img.ko \
kmod-clk-mt8186-imp-iic-wrap.ko \
kmod-clk-mt8186-infra-ao.ko \
kmod-clk-mt8186-ipe.ko \
kmod-clk-mt8186-mcu.ko \
kmod-clk-mt8186-mdp.ko \
kmod-clk-mt8186-mfg.ko \
kmod-clk-mt8186-mm.ko \
kmod-clk-mt8186-topckgen.ko \
kmod-clk-mt8186-vdec.ko \
kmod-clk-mt8186-venc.ko \
kmod-clk-mt8186-wpe.ko \
kmod-clk-mt8188-adsp-audio26m.ko \
kmod-clk-mt8188-apmixedsys.ko \
kmod-clk-mt8188-cam.ko \
kmod-clk-mt8188-ccu.ko \
kmod-clk-mt8188-img.ko \
kmod-clk-mt8188-imp-iic-wrap.ko \
kmod-clk-mt8188-infra-ao.ko \
kmod-clk-mt8188-ipe.ko \
kmod-clk-mt8188-mfg.ko \
kmod-clk-mt8188-peri-ao.ko \
kmod-clk-mt8188-topckgen.ko \
kmod-clk-mt8188-vdec.ko \
kmod-clk-mt8188-vdo0.ko \
kmod-clk-mt8188-vdo1.ko \
kmod-clk-mt8188-venc.ko \
kmod-clk-mt8188-vpp0.ko \
kmod-clk-mt8188-vpp1.ko \
kmod-clk-mt8188-wpe.ko \
kmod-clk-mt8192-apmixedsys.ko \
kmod-clk-mt8192-aud.ko \
kmod-clk-mt8192-cam.ko \
kmod-clk-mt8192-img.ko \
kmod-clk-mt8192-imp-iic-wrap.ko \
kmod-clk-mt8192-ipe.ko \
kmod-clk-mt8192-mdp.ko \
kmod-clk-mt8192-mfg.ko \
kmod-clk-mt8192-mm.ko \
kmod-clk-mt8192-msdc.ko \
kmod-clk-mt8192-scp-adsp.ko \
kmod-clk-mt8192-vdec.ko \
kmod-clk-mt8192-venc.ko \
kmod-clk-mt8192.ko \
kmod-clk-mt8195-apmixedsys.ko \
kmod-clk-mt8195-apusys-pll.ko \
kmod-clk-mt8195-cam.ko \
kmod-clk-mt8195-ccu.ko \
kmod-clk-mt8195-img.ko \
kmod-clk-mt8195-imp-iic-wrap.ko \
kmod-clk-mt8195-infra-ao.ko \
kmod-clk-mt8195-ipe.ko \
kmod-clk-mt8195-mfg.ko \
kmod-clk-mt8195-peri-ao.ko \
kmod-clk-mt8195-scp-adsp.ko \
kmod-clk-mt8195-topckgen.ko \
kmod-clk-mt8195-vdec.ko \
kmod-clk-mt8195-vdo0.ko \
kmod-clk-mt8195-vdo1.ko \
kmod-clk-mt8195-venc.ko \
kmod-clk-mt8195-vpp0.ko \
kmod-clk-mt8195-vpp1.ko \
kmod-clk-mt8195-wpe.ko \
kmod-clk-mt8365-apmixedsys.ko \
kmod-clk-mt8365-apu.ko \
kmod-clk-mt8365-cam.ko \
kmod-clk-mt8365-mfg.ko \
kmod-clk-mt8365-mm.ko \
kmod-clk-mt8365-vdec.ko \
kmod-clk-mt8365-venc.ko \
kmod-clk-mt8365.ko \
kmod-clk-mt8516-apmixedsys.ko \
kmod-clk-mt8516-aud.ko \
kmod-clk-mt8516.ko \
kmod-clk-mtk.ko \
kmod-clk-mux.ko \
kmod-clk-phase.ko \
kmod-clk-pll.ko \
kmod-clk-plldig.ko \
kmod-clk-pwm.ko \
kmod-clk-qcom.ko \
kmod-clk-raspberrypi.ko \
kmod-clk-regmap.ko \
kmod-clk-renesas-pcie.ko \
kmod-clk-rk808.ko \
kmod-clk-rpm.ko \
kmod-clk-rpmh.ko \
kmod-clk-scmi.ko \
kmod-clk-scpi.ko \
kmod-clk-si514.ko \
kmod-clk-si521xx.ko \
kmod-clk-si5341.ko \
kmod-clk-si544.ko \
kmod-clk-smd-rpm.ko \
kmod-clk-spmi-pmic-div.ko \
kmod-clk-sprd.ko \
kmod-clk-versaclock5.ko \
kmod-clk-versaclock7.ko \
kmod-clk-vexpress-osc.ko \
kmod-clk-xlnx-clock-wizard.ko \
kmod-cls-basic.ko \
kmod-cls-bpf.ko \
kmod-cls-cgroup.ko \
kmod-cls-flow.ko \
kmod-cls-flower.ko \
kmod-cls-fw.ko \
kmod-cls-matchall.ko \
kmod-cls-route.ko \
kmod-cls-u32.ko \
kmod-cm109.ko \
kmod-cm3232.ko \
kmod-cm3323.ko \
kmod-cm3605.ko \
kmod-cma3000-d0x-i2c.ko \
kmod-cma3000-d0x.ko \
kmod-cmac.ko \
kmod-cmd-db.ko \
kmod-cmdlinepart.ko \
kmod-cn.ko \
kmod-cn10k-rng.ko \
kmod-cnic.ko \
kmod-coda-vpu.ko \
kmod-coda.ko \
kmod-colibri-vf50-ts.ko \
kmod-comedi-8255.ko \
kmod-comedi-usb.ko \
kmod-comedi.ko \
kmod-comm.ko \
kmod-configfs.ko \
kmod-configs.ko \
kmod-cordic.ko \
kmod-core.ko \
kmod-coresight-catu.ko \
kmod-coresight-cpu-debug.ko \
kmod-coresight-cti.ko \
kmod-coresight-etb10.ko \
kmod-coresight-etm4x.ko \
kmod-coresight-funnel.ko \
kmod-coresight-replicator.ko \
kmod-coresight-stm.ko \
kmod-coresight-tmc.ko \
kmod-coresight-tpda.ko \
kmod-coresight-tpdm.ko \
kmod-coresight-tpiu.ko \
kmod-coresight-trbe.ko \
kmod-coresight.ko \
kmod-corsair-cpro.ko \
kmod-corsair-psu.ko \
kmod-cortina.ko \
kmod-cp210x.ko \
kmod-cpcap-adc.ko \
kmod-cpcap-battery.ko \
kmod-cpcap-pwrbutton.ko \
kmod-cpcap-regulator.ko \
kmod-cppc-cpufreq.ko \
kmod-cpr.ko \
kmod-cptpf.ko \
kmod-cptvf.ko \
kmod-cpufreq-conservative.ko \
kmod-cpufreq-dt.ko \
kmod-cpufreq-ondemand.ko \
kmod-cpufreq-performance.ko \
kmod-cpufreq-powersave.ko \
kmod-cpufreq-userspace.ko \
kmod-cqhci.ko \
kmod-cramfs.ko \
kmod-crasher.ko \
kmod-crc-ccitt.ko \
kmod-crc-itu-t.ko \
kmod-crc-t10dif.ko \
kmod-crc16.ko \
kmod-crc32-generic.ko \
kmod-crc32.ko \
kmod-crc32c-generic.ko \
kmod-crc4.ko \
kmod-crc64-rocksoft-generic.ko \
kmod-crc64-rocksoft.ko \
kmod-crc64.ko \
kmod-crc7.ko \
kmod-crc8.ko \
kmod-crct10dif-ce.ko \
kmod-crct10dif-common.ko \
kmod-crct10dif-generic.ko \
kmod-crg-hi3798cv200.ko \
kmod-cros-ec-accel-legacy.ko \
kmod-cros-ec-anx7688.ko \
kmod-cros-ec-baro.ko \
kmod-cros-ec-cec.ko \
kmod-cros-ec-chardev.ko \
kmod-cros-ec-dev.ko \
kmod-cros-ec-i2c.ko \
kmod-cros-ec-keyb.ko \
kmod-cros-ec-lid-angle.ko \
kmod-cros-ec-light-prox.ko \
kmod-cros-ec-lightbar.ko \
kmod-cros-ec-mkbp-proximity.ko \
kmod-cros-ec-regulator.ko \
kmod-cros-ec-rpmsg.ko \
kmod-cros-ec-sensorhub.ko \
kmod-cros-ec-sensors-core.ko \
kmod-cros-ec-sensors.ko \
kmod-cros-ec-spi.ko \
kmod-cros-ec-sysfs.ko \
kmod-cros-ec-typec.ko \
kmod-cros-ec-uart.ko \
kmod-cros-ec-vbc.ko \
kmod-cros-ec.ko \
kmod-cros-hps-i2c.ko \
kmod-cros-kbd-led-backlight.ko \
kmod-cros-peripheral-charger.ko \
kmod-cros-typec-switch.ko \
kmod-cros-usbpd-charger.ko \
kmod-cros-usbpd-logger.ko \
kmod-cros-usbpd-notify.ko \
kmod-cryptd.ko \
kmod-crypto-acompress.ko \
kmod-crypto-algapi.ko \
kmod-crypto-engine.ko \
kmod-crypto-hash.ko \
kmod-crypto-null.ko \
kmod-crypto-safexcel.ko \
kmod-crypto-user.ko \
kmod-crypto.ko \
kmod-cryptomgr.ko \
kmod-cs-dsp.ko \
kmod-cs3308.ko \
kmod-cs5345.ko \
kmod-cs53l32a.ko \
kmod-csiostor.ko \
kmod-ctr.ko \
kmod-cts.ko \
kmod-ctucanfd-pci.ko \
kmod-ctucanfd-platform.ko \
kmod-ctucanfd.ko \
kmod-curve25519-generic.ko \
kmod-cuse.ko \
kmod-custom-method.ko \
kmod-cw1200-core.ko \
kmod-cw1200-wlan-sdio.ko \
kmod-cw2015-battery.ko \
kmod-cx18-alsa.ko \
kmod-cx18.ko \
kmod-cx22700.ko \
kmod-cx22702.ko \
kmod-cx231xx-alsa.ko \
kmod-cx231xx-dvb.ko \
kmod-cx231xx.ko \
kmod-cx2341x.ko \
kmod-cx23885.ko \
kmod-cx24110.ko \
kmod-cx24113.ko \
kmod-cx24116.ko \
kmod-cx24117.ko \
kmod-cx24120.ko \
kmod-cx24123.ko \
kmod-cx25821-alsa.ko \
kmod-cx25821.ko \
kmod-cx25840.ko \
kmod-cx82310-eth.ko \
kmod-cx88-alsa.ko \
kmod-cx88-blackbird.ko \
kmod-cx88-dvb.ko \
kmod-cx88-vp3054-i2c.ko \
kmod-cx8800.ko \
kmod-cx8802.ko \
kmod-cx88xx.ko \
kmod-cxacru.ko \
kmod-cxd2099.ko \
kmod-cxd2820r.ko \
kmod-cxd2841er.ko \
kmod-cxd2880-spi.ko \
kmod-cxd2880.ko \
kmod-cxgb.ko \
kmod-cxgb3.ko \
kmod-cxgb3i.ko \
kmod-cxgb4.ko \
kmod-cxgb4i.ko \
kmod-cxgb4vf.ko \
kmod-cxgbit.ko \
kmod-cxl-acpi.ko \
kmod-cxl-core.ko \
kmod-cxl-mem.ko \
kmod-cxl-pci.ko \
kmod-cxl-pmem.ko \
kmod-cxl-port.ko \
kmod-cy8ctma140.ko \
kmod-cy8ctmg110-ts.ko \
kmod-cyapatp.ko \
kmod-cyberjack.ko \
kmod-cypress-cy7c63.ko \
kmod-cypress-firmware.ko \
kmod-cypress-m8.ko \
kmod-cypress-sf.ko \
kmod-cytherm.ko \
kmod-cyttsp-core.ko \
kmod-cyttsp-i2c-common.ko \
kmod-cyttsp-i2c.ko \
kmod-cyttsp4-core.ko \
kmod-cyttsp4-i2c.ko \
kmod-cyttsp5.ko \
kmod-da280.ko \
kmod-da311.ko \
kmod-da7280.ko \
kmod-da9121-regulator.ko \
kmod-davicom.ko \
kmod-dax-cxl.ko \
kmod-dax-hmem.ko \
kmod-dax-pmem.ko \
kmod-dax.ko \
kmod-db9.ko \
kmod-dc395x.ko \
kmod-dccp-diag.ko \
kmod-dccp-ipv4.ko \
kmod-dccp-ipv6.ko \
kmod-dccp.ko \
kmod-ddbridge-dummy-fe.ko \
kmod-ddbridge.ko \
kmod-de2104x.ko \
kmod-deflate.ko \
kmod-defxx.ko \
kmod-delta-ahe50dc-fan.ko \
kmod-denali-dt.ko \
kmod-denali.ko \
kmod-des-generic.ko \
kmod-designware-i2s.ko \
kmod-device-dax.ko \
kmod-dfl-afu.ko \
kmod-dfl-emif.ko \
kmod-dfl-fme-br.ko \
kmod-dfl-fme-mgr.ko \
kmod-dfl-fme-region.ko \
kmod-dfl-fme.ko \
kmod-dfl-n3000-nios.ko \
kmod-dfl-pci.ko \
kmod-dfl.ko \
kmod-dh-generic.ko \
kmod-diag.ko \
kmod-dib0070.ko \
kmod-dib0090.ko \
kmod-dib3000mb.ko \
kmod-dib3000mc.ko \
kmod-dib7000m.ko \
kmod-dib7000p.ko \
kmod-dib8000.ko \
kmod-dib9000.ko \
kmod-dibx000-common.ko \
kmod-digi-acceleport.ko \
kmod-digsig.ko \
kmod-diskonchip.ko \
kmod-dispcc-qcm2290.ko \
kmod-dispcc-sc7180.ko \
kmod-dispcc-sc7280.ko \
kmod-dispcc-sc8280xp.ko \
kmod-dispcc-sdm845.ko \
kmod-dispcc-sm6115.ko \
kmod-dispcc-sm6125.ko \
kmod-dispcc-sm6350.ko \
kmod-dispcc-sm6375.ko \
kmod-dispcc-sm8250.ko \
kmod-dispcc-sm8450.ko \
kmod-dispcc-sm8550.ko \
kmod-display-connector.ko \
kmod-dl2k.ko \
kmod-dlhl60d.ko \
kmod-dlink-dir685-touchkeys.ko \
kmod-dlm.ko \
kmod-dln2-adc.ko \
kmod-dln2.ko \
kmod-dm-bio-prison.ko \
kmod-dm-bufio.ko \
kmod-dm-cache-smq.ko \
kmod-dm-cache.ko \
kmod-dm-clone.ko \
kmod-dm-crypt.ko \
kmod-dm-delay.ko \
kmod-dm-dust.ko \
kmod-dm-ebs.ko \
kmod-dm-era.ko \
kmod-dm-flakey.ko \
kmod-dm-historical-service-time.ko \
kmod-dm-integrity.ko \
kmod-dm-io-affinity.ko \
kmod-dm-log-userspace.ko \
kmod-dm-log-writes.ko \
kmod-dm-log.ko \
kmod-dm-mirror.ko \
kmod-dm-mod.ko \
kmod-dm-multipath.ko \
kmod-dm-persistent-data.ko \
kmod-dm-queue-length.ko \
kmod-dm-raid.ko \
kmod-dm-region-hash.ko \
kmod-dm-round-robin.ko \
kmod-dm-service-time.ko \
kmod-dm-snapshot.ko \
kmod-dm-switch.ko \
kmod-dm-thin-pool.ko \
kmod-dm-unstripe.ko \
kmod-dm-verity.ko \
kmod-dm-writecache.ko \
kmod-dm-zero.ko \
kmod-dm-zoned.ko \
kmod-dm1105.ko \
kmod-dm9601.ko \
kmod-dma-axi-dmac.ko \
kmod-dmard06.ko \
kmod-dmard09.ko \
kmod-dmard10.ko \
kmod-dmc520-edac.ko \
kmod-dme1737.ko \
kmod-dmfe.ko \
kmod-dmi-sysfs.ko \
kmod-dmx3191d.ko \
kmod-dnet.ko \
kmod-dns-resolver.ko \
kmod-dp83822.ko \
kmod-dp83848.ko \
kmod-dp83867.ko \
kmod-dp83869.ko \
kmod-dp83tc811.ko \
kmod-dp83td510.ko \
kmod-dpaa2-caam.ko \
kmod-dpaa2-console.ko \
kmod-dpaa2-qdma.ko \
kmod-dpdmai.ko \
kmod-dpot-dac.ko \
kmod-dps310.ko \
kmod-dps920ab.ko \
kmod-drbd.ko \
kmod-drbg.ko \
kmod-drivetemp.ko \
kmod-drm-buddy.ko \
kmod-drm-display-helper.ko \
kmod-drm-dma-helper.ko \
kmod-drm-dp-aux-bus.ko \
kmod-drm-kms-helper.ko \
kmod-drm-mipi-dbi.ko \
kmod-drm-mipi-dsi.ko \
kmod-drm-panel-orientation-quirks.ko \
kmod-drm-shmem-helper.ko \
kmod-drm-suballoc-helper.ko \
kmod-drm-ttm-helper.ko \
kmod-drm-vram-helper.ko \
kmod-drm.ko \
kmod-drop-monitor.ko \
kmod-drv260x.ko \
kmod-drv2665.ko \
kmod-drv2667.ko \
kmod-drx39xyj.ko \
kmod-drxd.ko \
kmod-drxk.ko \
kmod-ds1621.ko \
kmod-ds1682.ko \
kmod-ds2482.ko \
kmod-ds2490.ko \
kmod-ds2760-battery.ko \
kmod-ds2780-battery.ko \
kmod-ds2781-battery.ko \
kmod-ds2782-battery.ko \
kmod-ds3000.ko \
kmod-ds4424.ko \
kmod-ds620.ko \
kmod-dsa-core.ko \
kmod-dsa-loop.ko \
kmod-dsbr100.ko \
kmod-dst-ca.ko \
kmod-dst.ko \
kmod-dstr.ko \
kmod-dt3155.ko \
kmod-dt9812.ko \
kmod-dummy-irq.ko \
kmod-dummy.ko \
kmod-dvb-as102.ko \
kmod-dvb-bt8xx.ko \
kmod-dvb-core.ko \
kmod-dvb-pll.ko \
kmod-dvb-ttpci.ko \
kmod-dvb-ttusb-budget.ko \
kmod-dvb-usb-a800.ko \
kmod-dvb-usb-af9005-remote.ko \
kmod-dvb-usb-af9005.ko \
kmod-dvb-usb-af9015.ko \
kmod-dvb-usb-af9035.ko \
kmod-dvb-usb-anysee.ko \
kmod-dvb-usb-au6610.ko \
kmod-dvb-usb-az6007.ko \
kmod-dvb-usb-az6027.ko \
kmod-dvb-usb-ce6230.ko \
kmod-dvb-usb-cinergyT2.ko \
kmod-dvb-usb-cxusb.ko \
kmod-dvb-usb-dib0700.ko \
kmod-dvb-usb-dibusb-common.ko \
kmod-dvb-usb-dibusb-mb.ko \
kmod-dvb-usb-dibusb-mc-common.ko \
kmod-dvb-usb-dibusb-mc.ko \
kmod-dvb-usb-digitv.ko \
kmod-dvb-usb-dtt200u.ko \
kmod-dvb-usb-dtv5100.ko \
kmod-dvb-usb-dvbsky.ko \
kmod-dvb-usb-dw2102.ko \
kmod-dvb-usb-ec168.ko \
kmod-dvb-usb-gl861.ko \
kmod-dvb-usb-gp8psk.ko \
kmod-dvb-usb-lmedm04.ko \
kmod-dvb-usb-m920x.ko \
kmod-dvb-usb-mxl111sf.ko \
kmod-dvb-usb-nova-t-usb2.ko \
kmod-dvb-usb-opera.ko \
kmod-dvb-usb-pctv452e.ko \
kmod-dvb-usb-rtl28xxu.ko \
kmod-dvb-usb-technisat-usb2.ko \
kmod-dvb-usb-ttusb2.ko \
kmod-dvb-usb-umt-010.ko \
kmod-dvb-usb-v2.ko \
kmod-dvb-usb-vp702x.ko \
kmod-dvb-usb-vp7045.ko \
kmod-dvb-usb.ko \
kmod-dw-axi-dmac-platform.ko \
kmod-dw-dmac-core.ko \
kmod-dw-dmac-pci.ko \
kmod-dw-drm-dsi.ko \
kmod-dw-edma-pcie.ko \
kmod-dw-edma.ko \
kmod-dw-hdmi-ahb-audio.ko \
kmod-dw-hdmi-cec.ko \
kmod-dw-hdmi-gp-audio.ko \
kmod-dw-hdmi-i2s-audio.ko \
kmod-dw-hdmi.ko \
kmod-dw-i3c-master.ko \
kmod-dw-mipi-dsi.ko \
kmod-dw-mmc-bluefield.ko \
kmod-dw-mmc-exynos.ko \
kmod-dw-mmc-hi3798cv200.ko \
kmod-dw-mmc-k3.ko \
kmod-dw-mmc-pci.ko \
kmod-dw-mmc-pltfm.ko \
kmod-dw-mmc-rockchip.ko \
kmod-dw-mmc.ko \
kmod-dw-wdt.ko \
kmod-dw-xdata-pcie.ko \
kmod-dw100.ko \
kmod-dw9714.ko \
kmod-dw9768.ko \
kmod-dw9807-vcm.ko \
kmod-dwc-xlgmac.ko \
kmod-dwc2-pci.ko \
kmod-dwc2.ko \
kmod-dwc3-exynos.ko \
kmod-dwc3-haps.ko \
kmod-dwc3-imx8mp.ko \
kmod-dwc3-meson-g12a.ko \
kmod-dwc3-of-simple.ko \
kmod-dwc3-pci.ko \
kmod-dwc3-qcom.ko \
kmod-dwc3-xilinx.ko \
kmod-dwc3.ko \
kmod-dwmac-altr-socfpga.ko \
kmod-dwmac-dwc-qos-eth.ko \
kmod-dwmac-generic.ko \
kmod-dwmac-imx.ko \
kmod-dwmac-ipq806x.ko \
kmod-dwmac-mediatek.ko \
kmod-dwmac-meson.ko \
kmod-dwmac-meson8b.ko \
kmod-dwmac-qcom-ethqos.ko \
kmod-dwmac-rk.ko \
kmod-dwmac-sun8i.ko \
kmod-dwmac-sunxi.ko \
kmod-dwmac-visconti.ko \
kmod-dynapro.ko \
kmod-e100.ko \
kmod-e1000.ko \
kmod-e1000e.ko \
kmod-e4000.ko \
kmod-earth-pt1.ko \
kmod-earth-pt3.ko \
kmod-ebt-802-3.ko \
kmod-ebt-among.ko \
kmod-ebt-arp.ko \
kmod-ebt-arpreply.ko \
kmod-ebt-dnat.ko \
kmod-ebt-ip.ko \
kmod-ebt-ip6.ko \
kmod-ebt-limit.ko \
kmod-ebt-log.ko \
kmod-ebt-mark-m.ko \
kmod-ebt-mark.ko \
kmod-ebt-nflog.ko \
kmod-ebt-pkttype.ko \
kmod-ebt-redirect.ko \
kmod-ebt-snat.ko \
kmod-ebt-stp.ko \
kmod-ebt-vlan.ko \
kmod-ebtable-broute.ko \
kmod-ebtable-filter.ko \
kmod-ebtable-nat.ko \
kmod-ebtables.ko \
kmod-ec100.ko \
kmod-ecb.ko \
kmod-ecc-mtk.ko \
kmod-ecc.ko \
kmod-ecdh-generic.ko \
kmod-ecdsa-generic.ko \
kmod-echainiv.ko \
kmod-echo.ko \
kmod-ecrdsa-generic.ko \
kmod-ecryptfs.ko \
kmod-edac-core.ko \
kmod-edt-ft5x06.ko \
kmod-ee1004.ko \
kmod-eeprom-93cx6.ko \
kmod-eeprom.ko \
kmod-eeti-ts.ko \
kmod-efa.ko \
kmod-efct.ko \
kmod-efi-pstore.ko \
kmod-efibc.ko \
kmod-efivarfs.ko \
kmod-efs.ko \
kmod-egalax-ts-serial.ko \
kmod-ehci-exynos.ko \
kmod-ehci-fsl.ko \
kmod-ehci-hcd.ko \
kmod-ehci-npcm7xx.ko \
kmod-ehci-orion.ko \
kmod-ehci-pci.ko \
kmod-ehci-platform.ko \
kmod-ehset.ko \
kmod-ektf2127.ko \
kmod-elan-i2c.ko \
kmod-elants-i2c.ko \
kmod-elo.ko \
kmod-em-canid.ko \
kmod-em-cmp.ko \
kmod-em-ipset.ko \
kmod-em-ipt.ko \
kmod-em-meta.ko \
kmod-em-nbyte.ko \
kmod-em-text.ko \
kmod-em-u32.ko \
kmod-em28xx-alsa.ko \
kmod-em28xx-dvb.ko \
kmod-em28xx-rc.ko \
kmod-em28xx-v4l.ko \
kmod-em28xx.ko \
kmod-emc1403.ko \
kmod-emc2103.ko \
kmod-emc2305.ko \
kmod-emc6w201.ko \
kmod-emi26.ko \
kmod-emi62.ko \
kmod-empeg.ko \
kmod-ems-pci.ko \
kmod-ems-usb.ko \
kmod-emxx-udc.ko \
kmod-ena.ko \
kmod-enc28j60.ko \
kmod-enclosure.ko \
kmod-encrypted-keys.ko \
kmod-encx24j600-regmap.ko \
kmod-encx24j600.ko \
kmod-eni.ko \
kmod-enic.ko \
kmod-epat.ko \
kmod-epia.ko \
kmod-epic100.ko \
kmod-eql.ko \
kmod-erdma.ko \
kmod-erofs.ko \
kmod-error.ko \
kmod-erst-dbg.ko \
kmod-esas2r.ko \
kmod-esd-usb.ko \
kmod-esp-scsi.ko \
kmod-esp4-offload.ko \
kmod-esp4.ko \
kmod-esp6-offload.ko \
kmod-esp6.ko \
kmod-essiv.ko \
kmod-et1011c.ko \
kmod-et131x.ko \
kmod-et8ek8.ko \
kmod-etas-es58x.ko \
kmod-ethoc.ko \
kmod-etnaviv.ko \
kmod-evdev.ko \
kmod-exc3000.ko \
kmod-exfat.ko \
kmod-exportfs.ko \
kmod-ext4.ko \
kmod-extcon-core.ko \
kmod-extcon-fsa9480.ko \
kmod-extcon-gpio.ko \
kmod-extcon-max3355.ko \
kmod-extcon-ptn5150.ko \
kmod-extcon-qcom-spmi-misc.ko \
kmod-extcon-sm5502.ko \
kmod-extcon-usbc-cros-ec.ko \
kmod-extcon-usbc-tusb320.ko \
kmod-exynos-bus.ko \
kmod-exynos-chipid.ko \
kmod-exynos-gsc.ko \
kmod-exynos-interconnect.ko \
kmod-exynos-lpass.ko \
kmod-exynos-nocp.ko \
kmod-exynos-ppmu.ko \
kmod-exynos-rng.ko \
kmod-exynos-thermal.ko \
kmod-exynos-trng.ko \
kmod-exynos-usi.ko \
kmod-ezusb.ko \
kmod-f2fs.ko \
kmod-f71805f.ko \
kmod-f71882fg.ko \
kmod-f75375s.ko \
kmod-f81232.ko \
kmod-f81534.ko \
kmod-f81601.ko \
kmod-failover.ko \
kmod-fakelb.ko \
kmod-fan.ko \
kmod-fan53555.ko \
kmod-fan53880.ko \
kmod-farsync.ko \
kmod-fastrpc.ko \
kmod-fat.ko \
kmod-faulty.ko \
kmod-fb-agm1264k-fl.ko \
kmod-fb-bd663474.ko \
kmod-fb-hx8340bn.ko \
kmod-fb-hx8347d.ko \
kmod-fb-hx8353d.ko \
kmod-fb-hx8357d.ko \
kmod-fb-ili9163.ko \
kmod-fb-ili9320.ko \
kmod-fb-ili9325.ko \
kmod-fb-ili9340.ko \
kmod-fb-ili9341.ko \
kmod-fb-ili9481.ko \
kmod-fb-ili9486.ko \
kmod-fb-pcd8544.ko \
kmod-fb-ra8875.ko \
kmod-fb-s6d02a1.ko \
kmod-fb-s6d1121.ko \
kmod-fb-seps525.ko \
kmod-fb-sh1106.ko \
kmod-fb-ssd1289.ko \
kmod-fb-ssd1305.ko \
kmod-fb-ssd1306.ko \
kmod-fb-ssd1325.ko \
kmod-fb-ssd1331.ko \
kmod-fb-ssd1351.ko \
kmod-fb-st7735r.ko \
kmod-fb-st7789v.ko \
kmod-fb-sys-fops.ko \
kmod-fb-tinylcd.ko \
kmod-fb-tls8204.ko \
kmod-fb-uc1611.ko \
kmod-fb-uc1701.ko \
kmod-fb-upd161704.ko \
kmod-fb.ko \
kmod-fbtft.ko \
kmod-fc0011.ko \
kmod-fc0012.ko \
kmod-fc0013.ko \
kmod-fc2580.ko \
kmod-fcoe.ko \
kmod-fcrypt.ko \
kmod-fddi.ko \
kmod-fdomain-pci.ko \
kmod-fdomain.ko \
kmod-fealnx.ko \
kmod-fec.ko \
kmod-ff-memless.ko \
kmod-ffa-module.ko \
kmod-fieldbus-dev.ko \
kmod-firedtv.ko \
kmod-firewire-core.ko \
kmod-firewire-net.ko \
kmod-firewire-ohci.ko \
kmod-firewire-sbp2.ko \
kmod-firmware-class.ko \
kmod-fit2.ko \
kmod-fit3.ko \
kmod-fixed-phy.ko \
kmod-fixed.ko \
kmod-flexcan.ko \
kmod-fm-drv.ko \
kmod-fm10k.ko \
kmod-font.ko \
kmod-forcedeth.ko \
kmod-fore-200e.ko \
kmod-fou.ko \
kmod-fou6.ko \
kmod-fpga-bridge.ko \
kmod-fpga-mgr.ko \
kmod-fpga-region.ko \
kmod-freevxfs.ko \
kmod-friq.ko \
kmod-frpw.ko \
kmod-fsa4480.ko \
kmod-fscache.ko \
kmod-fsia6b.ko \
kmod-fsl-dpa.ko \
kmod-fsl-dpaa-fman-port.ko \
kmod-fsl-dpaa-fman.ko \
kmod-fsl-dpaa-mac.ko \
kmod-fsl-dpaa2-eth.ko \
kmod-fsl-dpaa2-ptp.ko \
kmod-fsl-dpaa2-switch.ko \
kmod-fsl-edma-common.ko \
kmod-fsl-edma.ko \
kmod-fsl-enetc-core.ko \
kmod-fsl-enetc-ierb.ko \
kmod-fsl-enetc-mdio.ko \
kmod-fsl-enetc-ptp.ko \
kmod-fsl-enetc-vf.ko \
kmod-fsl-enetc.ko \
kmod-fsl-ifc-nand.ko \
kmod-fsl-imx8-ddr-perf.ko \
kmod-fsl-ldb.ko \
kmod-fsl-linflexuart.ko \
kmod-fsl-lpuart.ko \
kmod-fsl-mc-dpio.ko \
kmod-fsl-mph-dr-of.ko \
kmod-fsl-pq-mdio.ko \
kmod-fsl-qdma.ko \
kmod-fsl-ucc-hdlc.ko \
kmod-fsp-3y.ko \
kmod-ftdi-sio.ko \
kmod-ftl.ko \
kmod-ftsteutates.ko \
kmod-fujitsu-ts.ko \
kmod-funcore.ko \
kmod-funeth.ko \
kmod-fusb302.ko \
kmod-fuse.ko \
kmod-fwnode-mdio.ko \
kmod-fxas21002c-core.ko \
kmod-fxas21002c-i2c.ko \
kmod-fxas21002c-spi.ko \
kmod-fxls8962af-core.ko \
kmod-fxls8962af-i2c.ko \
kmod-fxls8962af-spi.ko \
kmod-fxos8700-core.ko \
kmod-fxos8700-i2c.ko \
kmod-fxos8700-spi.ko \
kmod-g-acm-ms.ko \
kmod-g-audio.ko \
kmod-g-cdc.ko \
kmod-g-dbgp.ko \
kmod-g-ether.ko \
kmod-g-ffs.ko \
kmod-g-hid.ko \
kmod-g-mass-storage.ko \
kmod-g-midi.ko \
kmod-g-multi.ko \
kmod-g-ncm.ko \
kmod-g-nokia.ko \
kmod-g-printer.ko \
kmod-g-serial.ko \
kmod-g-webcam.ko \
kmod-g12a-aoclk.ko \
kmod-g12a.ko \
kmod-g760a.ko \
kmod-g762.ko \
kmod-gadgetfs.ko \
kmod-gamecon.ko \
kmod-garmin-gps.ko \
kmod-garp.ko \
kmod-gateworks-gsc.ko \
kmod-gcc-ipq6018.ko \
kmod-gcc-mdm9607.ko \
kmod-gcc-msm8909.ko \
kmod-gcc-msm8916.ko \
kmod-gcc-msm8939.ko \
kmod-gcc-msm8953.ko \
kmod-gcc-msm8976.ko \
kmod-gcc-msm8994.ko \
kmod-gcc-msm8998.ko \
kmod-gcc-qcm2290.ko \
kmod-gcc-qcs404.ko \
kmod-gcc-qdu1000.ko \
kmod-gcc-sa8775p.ko \
kmod-gcc-sc7180.ko \
kmod-gcc-sc7280.ko \
kmod-gcc-sc8180x.ko \
kmod-gcc-sc8280xp.ko \
kmod-gcc-sdm660.ko \
kmod-gcc-sdm845.ko \
kmod-gcc-sdx55.ko \
kmod-gcc-sdx65.ko \
kmod-gcc-sm6115.ko \
kmod-gcc-sm6125.ko \
kmod-gcc-sm6350.ko \
kmod-gcc-sm6375.ko \
kmod-gcc-sm7150.ko \
kmod-gcc-sm8150.ko \
kmod-gcc-sm8250.ko \
kmod-gcc-sm8350.ko \
kmod-gcc-sm8450.ko \
kmod-gcc-sm8550.ko \
kmod-gcm.ko \
kmod-gdmtty.ko \
kmod-gdmulte.ko \
kmod-ge2d.ko \
kmod-gemini.ko \
kmod-gen-probe.ko \
kmod-generic.ko \
kmod-genet.ko \
kmod-geneve.ko \
kmod-geniv.ko \
kmod-genwqe-card.ko \
kmod-gf128mul.ko \
kmod-gfs2.ko \
kmod-ghash-ce.ko \
kmod-ghash-generic.ko \
kmod-ghes-edac.ko \
kmod-gianfar-driver.ko \
kmod-gl518sm.ko \
kmod-gl520sm.ko \
kmod-gl620a.ko \
kmod-glob.ko \
kmod-gluebi.ko \
kmod-gm12u320.ko \
kmod-gnss-mtk.ko \
kmod-gnss-serial.ko \
kmod-gnss-sirf.ko \
kmod-gnss-ubx.ko \
kmod-gnss-usb.ko \
kmod-gnss.ko \
kmod-go7007-loader.ko \
kmod-go7007-usb.ko \
kmod-go7007.ko \
kmod-goodix-ts.ko \
kmod-governor-passive.ko \
kmod-governor-performance.ko \
kmod-governor-powersave.ko \
kmod-governor-simpleondemand.ko \
kmod-governor-userspace.ko \
kmod-gp2ap002.ko \
kmod-gp8psk-fe.ko \
kmod-gpi.ko \
kmod-gpio-74xx-mmio.ko \
kmod-gpio-aggregator.ko \
kmod-gpio-altera-a10sr.ko \
kmod-gpio-backlight.ko \
kmod-gpio-bd71815.ko \
kmod-gpio-bd71828.ko \
kmod-gpio-bd9571mwv.ko \
kmod-gpio-brcmstb.ko \
kmod-gpio-cadence.ko \
kmod-gpio-charger.ko \
kmod-gpio-decoder.ko \
kmod-gpio-dln2.ko \
kmod-gpio-dwapb.ko \
kmod-gpio-eic-sprd.ko \
kmod-gpio-fan.ko \
kmod-gpio-fxl6408.ko \
kmod-gpio-generic.ko \
kmod-gpio-grgpio.ko \
kmod-gpio-gw-pld.ko \
kmod-gpio-hisi.ko \
kmod-gpio-idio-16.ko \
kmod-gpio-ir-recv.ko \
kmod-gpio-ir-tx.ko \
kmod-gpio-kempld.ko \
kmod-gpio-keys-polled.ko \
kmod-gpio-keys.ko \
kmod-gpio-latch.ko \
kmod-gpio-lp3943.ko \
kmod-gpio-lp873x.ko \
kmod-gpio-lp87565.ko \
kmod-gpio-madera.ko \
kmod-gpio-max3191x.ko \
kmod-gpio-max7300.ko \
kmod-gpio-max730x.ko \
kmod-gpio-max732x.ko \
kmod-gpio-max77620.ko \
kmod-gpio-max77650.ko \
kmod-gpio-mb86s7x.ko \
kmod-gpio-mlxbf.ko \
kmod-gpio-mlxbf2.ko \
kmod-gpio-mockup.ko \
kmod-gpio-mouse.ko \
kmod-gpio-moxtet.ko \
kmod-gpio-mxc.ko \
kmod-gpio-pca953x.ko \
kmod-gpio-pca9570.ko \
kmod-gpio-pcf857x.ko \
kmod-gpio-pci-idio-16.ko \
kmod-gpio-pcie-idio-24.ko \
kmod-gpio-pisosr.ko \
kmod-gpio-pl061.ko \
kmod-gpio-pmic-eic-sprd.ko \
kmod-gpio-raspberrypi-exp.ko \
kmod-gpio-rcar.ko \
kmod-gpio-regmap.ko \
kmod-gpio-regulator.ko \
kmod-gpio-rockchip.ko \
kmod-gpio-sbu-mux.ko \
kmod-gpio-sim.ko \
kmod-gpio-sprd.ko \
kmod-gpio-syscon.ko \
kmod-gpio-tegra.ko \
kmod-gpio-tegra186.ko \
kmod-gpio-thunderx.ko \
kmod-gpio-tpic2810.ko \
kmod-gpio-tqmx86.ko \
kmod-gpio-vibra.ko \
kmod-gpio-viperboard.ko \
kmod-gpio-virtio.ko \
kmod-gpio-visconti.ko \
kmod-gpio-wcd934x.ko \
kmod-gpio-xgene-sb.ko \
kmod-gpio-xgs-iproc.ko \
kmod-gpio-xilinx.ko \
kmod-gpio-xlp.ko \
kmod-gpio-xra1403.ko \
kmod-gpio-zynq.ko \
kmod-gpio-zynqmp-modepin.ko \
kmod-gpio.ko \
kmod-gpmi-nand.ko \
kmod-gpu-sched.ko \
kmod-gpucc-msm8998.ko \
kmod-gpucc-sc7180.ko \
kmod-gpucc-sc7280.ko \
kmod-gpucc-sc8280xp.ko \
kmod-gpucc-sdm660.ko \
kmod-gpucc-sdm845.ko \
kmod-gpucc-sm6115.ko \
kmod-gpucc-sm6125.ko \
kmod-gpucc-sm6350.ko \
kmod-gpucc-sm6375.ko \
kmod-gpucc-sm8150.ko \
kmod-gpucc-sm8250.ko \
kmod-gpucc-sm8350.ko \
kmod-grace.ko \
kmod-gre.ko \
kmod-gs-usb.ko \
kmod-gs1662.ko \
kmod-gsc-hwmon.ko \
kmod-gspca-benq.ko \
kmod-gspca-conex.ko \
kmod-gspca-cpia1.ko \
kmod-gspca-dtcs033.ko \
kmod-gspca-etoms.ko \
kmod-gspca-finepix.ko \
kmod-gspca-gl860.ko \
kmod-gspca-jeilinj.ko \
kmod-gspca-jl2005bcd.ko \
kmod-gspca-kinect.ko \
kmod-gspca-konica.ko \
kmod-gspca-m5602.ko \
kmod-gspca-main.ko \
kmod-gspca-mars.ko \
kmod-gspca-mr97310a.ko \
kmod-gspca-nw80x.ko \
kmod-gspca-ov519.ko \
kmod-gspca-ov534-9.ko \
kmod-gspca-ov534.ko \
kmod-gspca-pac207.ko \
kmod-gspca-pac7302.ko \
kmod-gspca-pac7311.ko \
kmod-gspca-se401.ko \
kmod-gspca-sn9c2028.ko \
kmod-gspca-sn9c20x.ko \
kmod-gspca-sonixb.ko \
kmod-gspca-sonixj.ko \
kmod-gspca-spca1528.ko \
kmod-gspca-spca500.ko \
kmod-gspca-spca501.ko \
kmod-gspca-spca505.ko \
kmod-gspca-spca506.ko \
kmod-gspca-spca508.ko \
kmod-gspca-spca561.ko \
kmod-gspca-sq905.ko \
kmod-gspca-sq905c.ko \
kmod-gspca-sq930x.ko \
kmod-gspca-stk014.ko \
kmod-gspca-stk1135.ko \
kmod-gspca-stv0680.ko \
kmod-gspca-stv06xx.ko \
kmod-gspca-sunplus.ko \
kmod-gspca-t613.ko \
kmod-gspca-topro.ko \
kmod-gspca-touptek.ko \
kmod-gspca-tv8532.ko \
kmod-gspca-vc032x.ko \
kmod-gspca-vicam.ko \
kmod-gspca-xirlink-cit.ko \
kmod-gspca-zc3xx.ko \
kmod-gtp.ko \
kmod-gud.ko \
kmod-gunze.ko \
kmod-gve.ko \
kmod-gxbb-aoclk.ko \
kmod-gxbb.ko \
kmod-hackrf.ko \
kmod-hamachi.ko \
kmod-hampshire.ko \
kmod-hantro-vpu.ko \
kmod-hanwang.ko \
kmod-hci-bcm4377.ko \
kmod-hci-nokia.ko \
kmod-hci-uart.ko \
kmod-hci-vhci.ko \
kmod-hci.ko \
kmod-hclge.ko \
kmod-hclgevf.ko \
kmod-hctr2.ko \
kmod-hd3ss3220.ko \
kmod-hd44780-common.ko \
kmod-hd44780.ko \
kmod-hdc100x.ko \
kmod-hdlc-cisco.ko \
kmod-hdlc-fr.ko \
kmod-hdlc-ppp.ko \
kmod-hdlc-raw-eth.ko \
kmod-hdlc-raw.ko \
kmod-hdlc-x25.ko \
kmod-hdlc.ko \
kmod-hdlcd.ko \
kmod-hdlcdrv.ko \
kmod-hdma-mgmt.ko \
kmod-hdma.ko \
kmod-hdpvr.ko \
kmod-he.ko \
kmod-hed.ko \
kmod-helene.ko \
kmod-hellcreek-sw.ko \
kmod-hfpll.ko \
kmod-hfsplus.ko \
kmod-hi311x.ko \
kmod-hi3660-mailbox.ko \
kmod-hi556.ko \
kmod-hi6210-i2s.ko \
kmod-hi6220-mailbox.ko \
kmod-hi6220-reset.ko \
kmod-hi6421-pmic-core.ko \
kmod-hi6421-regulator.ko \
kmod-hi6421-spmi-pmic.ko \
kmod-hi6421v530-regulator.ko \
kmod-hi6421v600-irq.ko \
kmod-hi6421v600-regulator.ko \
kmod-hi655x-pmic.ko \
kmod-hi655x-regulator.ko \
kmod-hi8435.ko \
kmod-hi846.ko \
kmod-hi847.ko \
kmod-hibmc-drm.ko \
kmod-hid-a4tech.ko \
kmod-hid-accutouch.ko \
kmod-hid-alps.ko \
kmod-hid-apple.ko \
kmod-hid-appleir.ko \
kmod-hid-asus.ko \
kmod-hid-aureal.ko \
kmod-hid-axff.ko \
kmod-hid-belkin.ko \
kmod-hid-betopff.ko \
kmod-hid-bigbenff.ko \
kmod-hid-bpf.ko \
kmod-hid-cherry.ko \
kmod-hid-chicony.ko \
kmod-hid-corsair.ko \
kmod-hid-cougar.ko \
kmod-hid-cp2112.ko \
kmod-hid-creative-sb0540.ko \
kmod-hid-cypress.ko \
kmod-hid-dr.ko \
kmod-hid-elan.ko \
kmod-hid-elecom.ko \
kmod-hid-elo.ko \
kmod-hid-emsff.ko \
kmod-hid-evision.ko \
kmod-hid-ezkey.ko \
kmod-hid-ft260.ko \
kmod-hid-gaff.ko \
kmod-hid-gembird.ko \
kmod-hid-generic.ko \
kmod-hid-gfrm.ko \
kmod-hid-glorious.ko \
kmod-hid-google-hammer.ko \
kmod-hid-gt683r.ko \
kmod-hid-gyration.ko \
kmod-hid-holtek-kbd.ko \
kmod-hid-holtek-mouse.ko \
kmod-hid-holtekff.ko \
kmod-hid-hyperv.ko \
kmod-hid-icade.ko \
kmod-hid-ite.ko \
kmod-hid-jabra.ko \
kmod-hid-kensington.ko \
kmod-hid-keytouch.ko \
kmod-hid-kye.ko \
kmod-hid-lcpower.ko \
kmod-hid-led.ko \
kmod-hid-lenovo.ko \
kmod-hid-letsketch.ko \
kmod-hid-lg-g15.ko \
kmod-hid-logitech-dj.ko \
kmod-hid-logitech-hidpp.ko \
kmod-hid-logitech.ko \
kmod-hid-macally.ko \
kmod-hid-magicmouse.ko \
kmod-hid-maltron.ko \
kmod-hid-mcp2221.ko \
kmod-hid-megaworld.ko \
kmod-hid-mf.ko \
kmod-hid-microsoft.ko \
kmod-hid-monterey.ko \
kmod-hid-multitouch.ko \
kmod-hid-nintendo.ko \
kmod-hid-nti.ko \
kmod-hid-ntrig.ko \
kmod-hid-ortek.ko \
kmod-hid-penmount.ko \
kmod-hid-petalynx.ko \
kmod-hid-picolcd.ko \
kmod-hid-pl.ko \
kmod-hid-plantronics.ko \
kmod-hid-playstation.ko \
kmod-hid-primax.ko \
kmod-hid-prodikeys.ko \
kmod-hid-pxrc.ko \
kmod-hid-razer.ko \
kmod-hid-redragon.ko \
kmod-hid-retrode.ko \
kmod-hid-rmi.ko \
kmod-hid-roccat-arvo.ko \
kmod-hid-roccat-common.ko \
kmod-hid-roccat-isku.ko \
kmod-hid-roccat-kone.ko \
kmod-hid-roccat-koneplus.ko \
kmod-hid-roccat-konepure.ko \
kmod-hid-roccat-kovaplus.ko \
kmod-hid-roccat-lua.ko \
kmod-hid-roccat-pyra.ko \
kmod-hid-roccat-ryos.ko \
kmod-hid-roccat-savu.ko \
kmod-hid-roccat.ko \
kmod-hid-saitek.ko \
kmod-hid-samsung.ko \
kmod-hid-semitek.ko \
kmod-hid-sensor-accel-3d.ko \
kmod-hid-sensor-als.ko \
kmod-hid-sensor-custom-intel-hinge.ko \
kmod-hid-sensor-custom.ko \
kmod-hid-sensor-gyro-3d.ko \
kmod-hid-sensor-hub.ko \
kmod-hid-sensor-humidity.ko \
kmod-hid-sensor-iio-common.ko \
kmod-hid-sensor-incl-3d.ko \
kmod-hid-sensor-magn-3d.ko \
kmod-hid-sensor-press.ko \
kmod-hid-sensor-prox.ko \
kmod-hid-sensor-rotation.ko \
kmod-hid-sensor-temperature.ko \
kmod-hid-sensor-trigger.ko \
kmod-hid-sigmamicro.ko \
kmod-hid-sjoy.ko \
kmod-hid-sony.ko \
kmod-hid-speedlink.ko \
kmod-hid-steam.ko \
kmod-hid-steelseries.ko \
kmod-hid-sunplus.ko \
kmod-hid-thrustmaster.ko \
kmod-hid-tivo.ko \
kmod-hid-tmff.ko \
kmod-hid-topre.ko \
kmod-hid-topseed.ko \
kmod-hid-twinhan.ko \
kmod-hid-u2fzero.ko \
kmod-hid-uclogic.ko \
kmod-hid-udraw-ps3.ko \
kmod-hid-viewsonic.ko \
kmod-hid-vivaldi-common.ko \
kmod-hid-vivaldi.ko \
kmod-hid-vrc2.ko \
kmod-hid-waltop.ko \
kmod-hid-wiimote.ko \
kmod-hid-xiaomi.ko \
kmod-hid-xinmo.ko \
kmod-hid-zpff.ko \
kmod-hid-zydacron.ko \
kmod-hid.ko \
kmod-hideep.ko \
kmod-hidp.ko \
kmod-hih6130.ko \
kmod-himax-hx83112b.ko \
kmod-hinic.ko \
kmod-hip04-eth.ko \
kmod-hisi-acc-vfio-pci.ko \
kmod-hisi-dma.ko \
kmod-hisi-femac.ko \
kmod-hisi-hikey-usb.ko \
kmod-hisi-hpre.ko \
kmod-hisi-pcie-pmu.ko \
kmod-hisi-powerkey.ko \
kmod-hisi-ptt.ko \
kmod-hisi-qm.ko \
kmod-hisi-rng.ko \
kmod-hisi-sas-main.ko \
kmod-hisi-sas-v1-hw.ko \
kmod-hisi-sas-v2-hw.ko \
kmod-hisi-sas-v3-hw.ko \
kmod-hisi-sec.ko \
kmod-hisi-sec2.ko \
kmod-hisi-sfc.ko \
kmod-hisi-thermal.ko \
kmod-hisi-trng-v2.ko \
kmod-hisi-uncore-cpa-pmu.ko \
kmod-hisi-uncore-ddrc-pmu.ko \
kmod-hisi-uncore-hha-pmu.ko \
kmod-hisi-uncore-l3c-pmu.ko \
kmod-hisi-uncore-pa-pmu.ko \
kmod-hisi-uncore-pmu.ko \
kmod-hisi-uncore-sllc-pmu.ko \
kmod-hisi-zip.ko \
kmod-hisi504-nand.ko \
kmod-histb-trng.ko \
kmod-hix5hd2-gmac.ko \
kmod-hmac.ko \
kmod-hmc425a.ko \
kmod-hmc6352.ko \
kmod-hms-profinet.ko \
kmod-hnae.ko \
kmod-hnae3.ko \
kmod-hns-dsaf.ko \
kmod-hns-enet-drv.ko \
kmod-hns-mdio.ko \
kmod-hns-roce-hw-v2.ko \
kmod-hns3-pmu.ko \
kmod-hns3.ko \
kmod-hopper.ko \
kmod-horus3a.ko \
kmod-host1x.ko \
kmod-hostap-pci.ko \
kmod-hostap-plx.ko \
kmod-hostap.ko \
kmod-hpfs.ko \
kmod-hpilo.ko \
kmod-hpsa.ko \
kmod-hptiop.ko \
kmod-hpwdt.ko \
kmod-hsi-char.ko \
kmod-hsi.ko \
kmod-hso.ko \
kmod-hsr.ko \
kmod-ht16k33.ko \
kmod-hte-tegra194.ko \
kmod-hts221-i2c.ko \
kmod-hts221-spi.ko \
kmod-hts221.ko \
kmod-htu21.ko \
kmod-huawei-cdc-ncm.ko \
kmod-hv-balloon.ko \
kmod-hv-netvsc.ko \
kmod-hv-sock.ko \
kmod-hv-storvsc.ko \
kmod-hv-utils.ko \
kmod-hv-vmbus.ko \
kmod-hwmon-vid.ko \
kmod-hwmon.ko \
kmod-hwpoison-inject.ko \
kmod-hx711.ko \
kmod-hx8357d.ko \
kmod-hycon-hy46xx.ko \
kmod-hynitron-cstxxx.ko \
kmod-hyperbus-core.ko \
kmod-hyperv-drm.ko \
kmod-hyperv-keyboard.ko \
kmod-i2c-algo-bit.ko \
kmod-i2c-algo-pca.ko \
kmod-i2c-ali1535.ko \
kmod-i2c-ali1563.ko \
kmod-i2c-ali15x3.ko \
kmod-i2c-altera.ko \
kmod-i2c-amd756.ko \
kmod-i2c-amd8111.ko \
kmod-i2c-apple.ko \
kmod-i2c-bcm-iproc.ko \
kmod-i2c-bcm2835.ko \
kmod-i2c-brcmstb.ko \
kmod-i2c-cadence.ko \
kmod-i2c-cbus-gpio.ko \
kmod-i2c-ccgx-ucsi.ko \
kmod-i2c-core.ko \
kmod-i2c-cp2615.ko \
kmod-i2c-cros-ec-tunnel.ko \
kmod-i2c-demux-pinctrl.ko \
kmod-i2c-designware-core.ko \
kmod-i2c-designware-pci.ko \
kmod-i2c-designware-platform.ko \
kmod-i2c-dev.ko \
kmod-i2c-diolan-u2c.ko \
kmod-i2c-dln2.ko \
kmod-i2c-gpio.ko \
kmod-i2c-hid-acpi.ko \
kmod-i2c-hid-of-elan.ko \
kmod-i2c-hid-of-goodix.ko \
kmod-i2c-hid-of.ko \
kmod-i2c-hid.ko \
kmod-i2c-hisi.ko \
kmod-i2c-hix5hd2.ko \
kmod-i2c-i801.ko \
kmod-i2c-imx-lpi2c.ko \
kmod-i2c-imx.ko \
kmod-i2c-isch.ko \
kmod-i2c-kempld.ko \
kmod-i2c-mchp-pci1xxxx.ko \
kmod-i2c-meson.ko \
kmod-i2c-mlxbf.ko \
kmod-i2c-mt65xx.ko \
kmod-i2c-mux-gpio.ko \
kmod-i2c-mux-gpmux.ko \
kmod-i2c-mux-ltc4306.ko \
kmod-i2c-mux-mlxcpld.ko \
kmod-i2c-mux-pca9541.ko \
kmod-i2c-mux-pca954x.ko \
kmod-i2c-mux-pinctrl.ko \
kmod-i2c-mux-reg.ko \
kmod-i2c-mux.ko \
kmod-i2c-mv64xxx.ko \
kmod-i2c-nforce2.ko \
kmod-i2c-npcm7xx.ko \
kmod-i2c-nvidia-gpu.ko \
kmod-i2c-ocores.ko \
kmod-i2c-owl.ko \
kmod-i2c-parport.ko \
kmod-i2c-pca-platform.ko \
kmod-i2c-piix4.ko \
kmod-i2c-pxa.ko \
kmod-i2c-qcom-cci.ko \
kmod-i2c-qcom-geni.ko \
kmod-i2c-qup.ko \
kmod-i2c-rcar.ko \
kmod-i2c-riic.ko \
kmod-i2c-rk3x.ko \
kmod-i2c-robotfuzz-osif.ko \
kmod-i2c-rzv2m.ko \
kmod-i2c-s3c2410.ko \
kmod-i2c-sh-mobile.ko \
kmod-i2c-sis5595.ko \
kmod-i2c-sis630.ko \
kmod-i2c-sis96x.ko \
kmod-i2c-slave-eeprom.ko \
kmod-i2c-smbus.ko \
kmod-i2c-sprd.ko \
kmod-i2c-stub.ko \
kmod-i2c-synquacer.ko \
kmod-i2c-taos-evm.ko \
kmod-i2c-tegra-bpmp.ko \
kmod-i2c-tegra.ko \
kmod-i2c-thunderx.ko \
kmod-i2c-tiny-usb.ko \
kmod-i2c-viapro.ko \
kmod-i2c-viperboard.ko \
kmod-i2c-virtio.ko \
kmod-i2c-xgene-slimpro.ko \
kmod-i2c-xiic.ko \
kmod-i2c-xlp9xx.ko \
kmod-i3c-master-cdns.ko \
kmod-i3c.ko \
kmod-i40e.ko \
kmod-i5k-amb.ko \
kmod-i6300esb.ko \
kmod-iavf.ko \
kmod-ib-cm.ko \
kmod-ib-core.ko \
kmod-ib-ipoib.ko \
kmod-ib-iser.ko \
kmod-ib-isert.ko \
kmod-ib-mthca.ko \
kmod-ib-srp.ko \
kmod-ib-srpt.ko \
kmod-ib-umad.ko \
kmod-ib-uverbs.ko \
kmod-ibm-panel.ko \
kmod-ibmaem.ko \
kmod-ibmpex.ko \
kmod-icc-bcm-voter.ko \
kmod-icc-bwmon.ko \
kmod-icc-osm-l3.ko \
kmod-icc-rpmh.ko \
kmod-icc-smd-rpm.ko \
kmod-ice.ko \
kmod-ice40-spi.ko \
kmod-icp10100.ko \
kmod-icplus.ko \
kmod-ics932s401.ko \
kmod-idmouse.ko \
kmod-idt-89hpesx.ko \
kmod-idt-gen2.ko \
kmod-idt-gen3.ko \
kmod-idt77105.ko \
kmod-idt77252.ko \
kmod-idtcps.ko \
kmod-ieee802154-6lowpan.ko \
kmod-ieee802154-socket.ko \
kmod-ieee802154.ko \
kmod-ifb.ko \
kmod-ifcvf.ko \
kmod-ife.ko \
kmod-ifi-canfd.ko \
kmod-iforce-serio.ko \
kmod-iforce-usb.ko \
kmod-iforce.ko \
kmod-igb.ko \
kmod-igbvf.ko \
kmod-igc.ko \
kmod-igorplugusb.ko \
kmod-iguanair.ko \
kmod-iio-mux.ko \
kmod-iio-rescale.ko \
kmod-iio-trig-hrtimer.ko \
kmod-iio-trig-loop.ko \
kmod-ila.ko \
kmod-ili210x.ko \
kmod-ili9225.ko \
kmod-ili9341.ko \
kmod-ili9486.ko \
kmod-ilitek-ts-i2c.ko \
kmod-imagis.ko \
kmod-imm.ko \
kmod-imon-raw.ko \
kmod-imon.ko \
kmod-ims-pcu.ko \
kmod-imx-audio-rpmsg.ko \
kmod-imx-bus.ko \
kmod-imx-common.ko \
kmod-imx-cpufreq-dt.ko \
kmod-imx-dcss.ko \
kmod-imx-dma.ko \
kmod-imx-dsp-rproc.ko \
kmod-imx-dsp.ko \
kmod-imx-earlycon.ko \
kmod-imx-interconnect.ko \
kmod-imx-keypad.ko \
kmod-imx-lcdc.ko \
kmod-imx-lcdif.ko \
kmod-imx-mailbox.ko \
kmod-imx-media-common.ko \
kmod-imx-mipi-csis.ko \
kmod-imx-pcm-dma.ko \
kmod-imx-pcm-rpmsg.ko \
kmod-imx-pxp.ko \
kmod-imx-rproc.ko \
kmod-imx-sc-key.ko \
kmod-imx-sc-thermal.ko \
kmod-imx-sc-wdt.ko \
kmod-imx-scu.ko \
kmod-imx-sdma.ko \
kmod-imx-thermal.ko \
kmod-imx-weim.ko \
kmod-imx.ko \
kmod-imx2-wdt.ko \
kmod-imx208.ko \
kmod-imx214.ko \
kmod-imx219.ko \
kmod-imx258.ko \
kmod-imx274.ko \
kmod-imx290.ko \
kmod-imx296.ko \
kmod-imx319.ko \
kmod-imx334.ko \
kmod-imx335.ko \
kmod-imx355.ko \
kmod-imx412.ko \
kmod-imx415.ko \
kmod-imx7-media-csi.ko \
kmod-imx7ulp-wdt.ko \
kmod-imx8-isi.ko \
kmod-imx8m-blk-ctrl.ko \
kmod-imx8m-ddrc.ko \
kmod-imx8mm-interconnect.ko \
kmod-imx8mm-thermal.ko \
kmod-imx8mn-interconnect.ko \
kmod-imx8mp-blk-ctrl.ko \
kmod-imx8mp-interconnect.ko \
kmod-imx8mq-interconnect.ko \
kmod-imx8qm-ldb.ko \
kmod-imx8qxp-adc.ko \
kmod-imx8qxp-ldb.ko \
kmod-imx8qxp-pixel-combiner.ko \
kmod-imx8qxp-pixel-link.ko \
kmod-imx8qxp-pxl2dpi.ko \
kmod-imx93-adc.ko \
kmod-imx93-blk-ctrl.ko \
kmod-imx93-pd.ko \
kmod-imx93-src.ko \
kmod-imxfb.ko \
kmod-ina209.ko \
kmod-ina238.ko \
kmod-ina2xx-adc.ko \
kmod-ina2xx.ko \
kmod-ina3221.ko \
kmod-industrialio-buffer-cb.ko \
kmod-industrialio-buffer-dma.ko \
kmod-industrialio-buffer-dmaengine.ko \
kmod-industrialio-configfs.ko \
kmod-industrialio-hw-consumer.ko \
kmod-industrialio-sw-device.ko \
kmod-industrialio-sw-trigger.ko \
kmod-industrialio-triggered-buffer.ko \
kmod-industrialio-triggered-event.ko \
kmod-industrialio.ko \
kmod-inet-diag.ko \
kmod-inexio.ko \
kmod-inftl.ko \
kmod-initio.ko \
kmod-input-core.ko \
kmod-input-leds.ko \
kmod-inspur-ipsps.ko \
kmod-int51x1.ko \
kmod-intel-qat.ko \
kmod-intel-vr-nor.ko \
kmod-intel-xway.ko \
kmod-interconnect-qcom.ko \
kmod-interval-tree-test.ko \
kmod-inv-icm42600-i2c.ko \
kmod-inv-icm42600-spi.ko \
kmod-inv-icm42600.ko \
kmod-inv-mpu6050-i2c.ko \
kmod-inv-mpu6050-spi.ko \
kmod-inv-mpu6050.ko \
kmod-io-domain.ko \
kmod-io-edgeport.ko \
kmod-io-ti.ko \
kmod-ionic.ko \
kmod-iova.ko \
kmod-iowarrior.ko \
kmod-ip-gre.ko \
kmod-ip-set-bitmap-ip.ko \
kmod-ip-set-bitmap-ipmac.ko \
kmod-ip-set-bitmap-port.ko \
kmod-ip-set-hash-ip.ko \
kmod-ip-set-hash-ipmac.ko \
kmod-ip-set-hash-ipmark.ko \
kmod-ip-set-hash-ipport.ko \
kmod-ip-set-hash-ipportip.ko \
kmod-ip-set-hash-ipportnet.ko \
kmod-ip-set-hash-mac.ko \
kmod-ip-set-hash-net.ko \
kmod-ip-set-hash-netiface.ko \
kmod-ip-set-hash-netnet.ko \
kmod-ip-set-hash-netport.ko \
kmod-ip-set-hash-netportnet.ko \
kmod-ip-set-list-set.ko \
kmod-ip-set.ko \
kmod-ip-tables.ko \
kmod-ip-tunnel.ko \
kmod-ip-vs-dh.ko \
kmod-ip-vs-fo.ko \
kmod-ip-vs-ftp.ko \
kmod-ip-vs-lblc.ko \
kmod-ip-vs-lblcr.ko \
kmod-ip-vs-lc.ko \
kmod-ip-vs-mh.ko \
kmod-ip-vs-nq.ko \
kmod-ip-vs-ovf.ko \
kmod-ip-vs-pe-sip.ko \
kmod-ip-vs-rr.ko \
kmod-ip-vs-sed.ko \
kmod-ip-vs-sh.ko \
kmod-ip-vs-twos.ko \
kmod-ip-vs-wlc.ko \
kmod-ip-vs-wrr.ko \
kmod-ip-vs.ko \
kmod-ip-vti.ko \
kmod-ip5xxx-power.ko \
kmod-ip6-gre.ko \
kmod-ip6-tables.ko \
kmod-ip6-tunnel.ko \
kmod-ip6-udp-tunnel.ko \
kmod-ip6-vti.ko \
kmod-ip6t-NPT.ko \
kmod-ip6t-REJECT.ko \
kmod-ip6t-SYNPROXY.ko \
kmod-ip6t-ah.ko \
kmod-ip6t-eui64.ko \
kmod-ip6t-frag.ko \
kmod-ip6t-hbh.ko \
kmod-ip6t-ipv6header.ko \
kmod-ip6t-mh.ko \
kmod-ip6t-rpfilter.ko \
kmod-ip6t-rt.ko \
kmod-ip6t-srh.ko \
kmod-ip6table-filter.ko \
kmod-ip6table-mangle.ko \
kmod-ip6table-nat.ko \
kmod-ip6table-raw.ko \
kmod-ip6table-security.ko \
kmod-ipa.ko \
kmod-ipack.ko \
kmod-ipaq.ko \
kmod-ipcomp.ko \
kmod-ipcomp6.ko \
kmod-iphase.ko \
kmod-ipheth.ko \
kmod-ipip.ko \
kmod-ipmb-dev-int.ko \
kmod-ipmi-devintf.ko \
kmod-ipmi-ipmb.ko \
kmod-ipmi-msghandler.ko \
kmod-ipmi-poweroff.ko \
kmod-ipmi-si.ko \
kmod-ipmi-ssif.ko \
kmod-ipmi-watchdog.ko \
kmod-ipoctal.ko \
kmod-ipr.ko \
kmod-iproc-rng200.ko \
kmod-ips.ko \
kmod-ipt-ECN.ko \
kmod-ipt-REJECT.ko \
kmod-ipt-SYNPROXY.ko \
kmod-ipt-ah.ko \
kmod-ipt-rpfilter.ko \
kmod-iptable-filter.ko \
kmod-iptable-mangle.ko \
kmod-iptable-nat.ko \
kmod-iptable-raw.ko \
kmod-iptable-security.ko \
kmod-ipv6.ko \
kmod-ipvlan.ko \
kmod-ipvtap.ko \
kmod-ipw.ko \
kmod-ipw2100.ko \
kmod-ipw2200.ko \
kmod-iqs269a.ko \
kmod-iqs5xx.ko \
kmod-iqs620at-temp.ko \
kmod-iqs621-als.ko \
kmod-iqs624-pos.ko \
kmod-iqs626a.ko \
kmod-iqs62x-keys.ko \
kmod-iqs62x.ko \
kmod-iqs7222.ko \
kmod-ir-hix5hd2.ko \
kmod-ir-imon-decoder.ko \
kmod-ir-jvc-decoder.ko \
kmod-ir-kbd-i2c.ko \
kmod-ir-mce-kbd-decoder.ko \
kmod-ir-nec-decoder.ko \
kmod-ir-rc5-decoder.ko \
kmod-ir-rc6-decoder.ko \
kmod-ir-rcmm-decoder.ko \
kmod-ir-sanyo-decoder.ko \
kmod-ir-sharp-decoder.ko \
kmod-ir-sony-decoder.ko \
kmod-ir-spi.ko \
kmod-ir-toy.ko \
kmod-ir-usb.ko \
kmod-ir-xmp-decoder.ko \
kmod-ir35221.ko \
kmod-ir36021.ko \
kmod-ir38064.ko \
kmod-irdma.ko \
kmod-irps5401.ko \
kmod-irq-bcm7038-l1.ko \
kmod-irq-bcm7120-l2.ko \
kmod-irq-brcmstb-l2.ko \
kmod-irq-imx-mu-msi.ko \
kmod-irq-madera.ko \
kmod-irq-meson-gpio.ko \
kmod-irq-mvebu-pic.ko \
kmod-irq-qcom-mpm.ko \
kmod-irqbypass.ko \
kmod-iscsi-boot-sysfs.ko \
kmod-iscsi-ibft.ko \
kmod-iscsi-target-mod.ko \
kmod-iscsi-tcp.ko \
kmod-isight-firmware.ko \
kmod-isl29020.ko \
kmod-isl29501.ko \
kmod-isl6405.ko \
kmod-isl6421.ko \
kmod-isl6423.ko \
kmod-isl68137.ko \
kmod-isl7998x.ko \
kmod-isl9305.ko \
kmod-isofs.ko \
kmod-isp116x-hcd.ko \
kmod-isp1704-charger.ko \
kmod-isp1760.ko \
kmod-it87.ko \
kmod-it913x.ko \
kmod-itd1000.ko \
kmod-ite-it6505.ko \
kmod-ite-it66121.ko \
kmod-iuu-phoenix.ko \
kmod-ivtv-alsa.ko \
kmod-ivtv.ko \
kmod-ivtvfb.ko \
kmod-iw-cm.ko \
kmod-iw-cxgb4.ko \
kmod-iwl3945.ko \
kmod-iwl4965.ko \
kmod-iwldvm.ko \
kmod-iwlegacy.ko \
kmod-iwlmvm.ko \
kmod-iwlwifi.ko \
kmod-ix2505v.ko \
kmod-ixgbe.ko \
kmod-ixgbevf.ko \
kmod-jbd2.ko \
kmod-jc42.ko \
kmod-jedec-probe.ko \
kmod-jffs2.ko \
kmod-jfs.ko \
kmod-jitterentropy-rng.ko \
kmod-jmb38x-ms.ko \
kmod-jme.ko \
kmod-joydev.ko \
kmod-jsa1212.ko \
kmod-jsm.ko \
kmod-k3dma.ko \
kmod-kafs.ko \
kmod-kalmia.ko \
kmod-kaweth.ko \
kmod-kbic.ko \
kmod-kbtab.ko \
kmod-kcm.ko \
kmod-kcomedilib.ko \
kmod-kcs-bmc-cdev-ipmi.ko \
kmod-kcs-bmc-npcm7xx.ko \
kmod-kcs-bmc-serio.ko \
kmod-kcs-bmc.ko \
kmod-kdf-sp800108.ko \
kmod-keembay-ocs-aes.ko \
kmod-keembay-ocs-ecc.ko \
kmod-keembay-ocs-hcu.ko \
kmod-keembay-wdt.ko \
kmod-kempld-core.ko \
kmod-kempld-wdt.ko \
kmod-keyspan-pda.ko \
kmod-keyspan-remote.ko \
kmod-keyspan.ko \
kmod-keywrap.ko \
kmod-kfifo-buf.ko \
kmod-kgdboc.ko \
kmod-khadas-mcu-fan.ko \
kmod-khadas-mcu.ko \
kmod-kirin-drm.ko \
kmod-kl5kusb105.ko \
kmod-kmem.ko \
kmod-kmx61.ko \
kmod-kobil-sct.ko \
kmod-komeda.ko \
kmod-kpp.ko \
kmod-ks0108.ko \
kmod-ks0127.ko \
kmod-ks7010.ko \
kmod-ks8842.ko \
kmod-ks8851-common.ko \
kmod-ks8851-par.ko \
kmod-ks8851-spi.ko \
kmod-ksmbd.ko \
kmod-ksz-spi.ko \
kmod-ksz-switch.ko \
kmod-ksz884x.ko \
kmod-ksz8863-smi.ko \
kmod-ksz9477-i2c.ko \
kmod-ktd253-backlight.ko \
kmod-ktti.ko \
kmod-ktz8866.ko \
kmod-kvaser-pci.ko \
kmod-kvaser-pciefd.ko \
kmod-kvaser-usb.ko \
kmod-kvm.ko \
kmod-kxtj9.ko \
kmod-kyber-iosched.ko \
kmod-l2tp-core.ko \
kmod-l2tp-eth.ko \
kmod-l2tp-ip.ko \
kmod-l2tp-ip6.ko \
kmod-l2tp-netlink.ko \
kmod-l2tp-ppp.ko \
kmod-l64781.ko \
kmod-lan743x.ko \
kmod-lan78xx.ko \
kmod-lan9303-core.ko \
kmod-lan9303-i2c.ko \
kmod-lan9303-mdio.ko \
kmod-lan966x-serdes.ko \
kmod-lan966x-switch.ko \
kmod-lanai.ko \
kmod-lantiq-gswip.ko \
kmod-lapb.ko \
kmod-lapbether.ko \
kmod-lattice-sysconfig-spi.ko \
kmod-lattice-sysconfig.ko \
kmod-layerscape-edac-mod.ko \
kmod-lcd.ko \
kmod-ldusb.ko \
kmod-lec.ko \
kmod-led-bl.ko \
kmod-led-class-flash.ko \
kmod-led-class-multicolor.ko \
kmod-led-class.ko \
kmod-leds-an30259a.ko \
kmod-leds-as3645a.ko \
kmod-leds-aw2013.ko \
kmod-leds-bd2606mvv.ko \
kmod-leds-bd2802.ko \
kmod-leds-blinkm.ko \
kmod-leds-cpcap.ko \
kmod-leds-cr0014114.ko \
kmod-leds-el15203000.ko \
kmod-leds-gpio.ko \
kmod-leds-is31fl319x.ko \
kmod-leds-is31fl32xx.ko \
kmod-leds-lm3530.ko \
kmod-leds-lm3532.ko \
kmod-leds-lm3533.ko \
kmod-leds-lm355x.ko \
kmod-leds-lm3601x.ko \
kmod-leds-lm36274.ko \
kmod-leds-lm3642.ko \
kmod-leds-lm3692x.ko \
kmod-leds-lm3697.ko \
kmod-leds-lp3944.ko \
kmod-leds-lp3952.ko \
kmod-leds-lp50xx.ko \
kmod-leds-lp5521.ko \
kmod-leds-lp5523.ko \
kmod-leds-lp5562.ko \
kmod-leds-lp55xx-common.ko \
kmod-leds-lp8501.ko \
kmod-leds-lp8860.ko \
kmod-leds-lt3593.ko \
kmod-leds-max77650.ko \
kmod-leds-menf21bmc.ko \
kmod-leds-mlxreg.ko \
kmod-leds-mt6360.ko \
kmod-leds-pca9532.ko \
kmod-leds-pca955x.ko \
kmod-leds-pca963x.ko \
kmod-leds-pwm-multicolor.ko \
kmod-leds-pwm.ko \
kmod-leds-qcom-flash.ko \
kmod-leds-qcom-lpg.ko \
kmod-leds-rt4505.ko \
kmod-leds-rt8515.ko \
kmod-leds-sc27xx-bltc.ko \
kmod-leds-sgm3140.ko \
kmod-leds-spi-byte.ko \
kmod-leds-tca6507.ko \
kmod-leds-ti-lmu-common.ko \
kmod-ledtrig-activity.ko \
kmod-ledtrig-audio.ko \
kmod-ledtrig-backlight.ko \
kmod-ledtrig-camera.ko \
kmod-ledtrig-default-on.ko \
kmod-ledtrig-heartbeat.ko \
kmod-ledtrig-netdev.ko \
kmod-ledtrig-oneshot.ko \
kmod-ledtrig-pattern.ko \
kmod-ledtrig-timer.ko \
kmod-ledtrig-transient.ko \
kmod-ledtrig-tty.ko \
kmod-ledtrig-usbport.ko \
kmod-legousbtower.ko \
kmod-lg-vl600.ko \
kmod-lg2160.ko \
kmod-lgdt3305.ko \
kmod-lgdt3306a.ko \
kmod-lgdt330x.ko \
kmod-lgs8gl5.ko \
kmod-lgs8gxx.ko \
kmod-lib80211-crypt-ccmp.ko \
kmod-lib80211-crypt-tkip.ko \
kmod-lib80211-crypt-wep.ko \
kmod-lib80211.ko \
kmod-libaes.ko \
kmod-libahci-platform.ko \
kmod-libahci.ko \
kmod-libarc4.ko \
kmod-libata.ko \
kmod-libceph.ko \
kmod-libchacha.ko \
kmod-libchacha20poly1305.ko \
kmod-libcomposite.ko \
kmod-libcrc32c.ko \
kmod-libcryptoutils.ko \
kmod-libcurve25519-generic.ko \
kmod-libcurve25519.ko \
kmod-libcxgb.ko \
kmod-libcxgbi.ko \
kmod-libdes.ko \
kmod-libertas-sdio.ko \
kmod-libertas-tf-usb.ko \
kmod-libertas-tf.ko \
kmod-libertas.ko \
kmod-libfc.ko \
kmod-libfcoe.ko \
kmod-libipw.ko \
kmod-libiscsi-tcp.ko \
kmod-libiscsi.ko \
kmod-libnvdimm.ko \
kmod-libphy.ko \
kmod-libpoly1305.ko \
kmod-libps2.ko \
kmod-libsas.ko \
kmod-libsha1.ko \
kmod-libsha256.ko \
kmod-libwx.ko \
kmod-lima.ko \
kmod-line-display.ko \
kmod-lineage-pem.ko \
kmod-linear-ranges.ko \
kmod-linear.ko \
kmod-linkstation-poweroff.ko \
kmod-liquidio-vf.ko \
kmod-liquidio.ko \
kmod-lis3lv02d-i2c.ko \
kmod-lis3lv02d.ko \
kmod-litex-liteeth.ko \
kmod-lkdtm.ko \
kmod-ll-temac.ko \
kmod-llc.ko \
kmod-llc2.ko \
kmod-llcc-qcom.ko \
kmod-lm25066.ko \
kmod-lm3533-bl.ko \
kmod-lm3533-core.ko \
kmod-lm3533-ctrlbank.ko \
kmod-lm3560.ko \
kmod-lm3630a-bl.ko \
kmod-lm3639-bl.ko \
kmod-lm363x-regulator.ko \
kmod-lm3646.ko \
kmod-lm63.ko \
kmod-lm73.ko \
kmod-lm75.ko \
kmod-lm77.ko \
kmod-lm78.ko \
kmod-lm80.ko \
kmod-lm83.ko \
kmod-lm8323.ko \
kmod-lm8333.ko \
kmod-lm85.ko \
kmod-lm87.ko \
kmod-lm90.ko \
kmod-lm92.ko \
kmod-lm93.ko \
kmod-lm95234.ko \
kmod-lm95241.ko \
kmod-lm95245.ko \
kmod-lmh.ko \
kmod-lmp91000.ko \
kmod-lnbh25.ko \
kmod-lnbh29.ko \
kmod-lnbp21.ko \
kmod-lnbp22.ko \
kmod-lochnagar-hwmon.ko \
kmod-lochnagar-regulator.ko \
kmod-lockd.ko \
kmod-logicvc-drm.ko \
kmod-lontium-lt8912b.ko \
kmod-lontium-lt9211.ko \
kmod-lontium-lt9611.ko \
kmod-lontium-lt9611uxc.ko \
kmod-loop.ko \
kmod-lp.ko \
kmod-lp3943.ko \
kmod-lp855x-bl.ko \
kmod-lp8727-charger.ko \
kmod-lp873x-regulator.ko \
kmod-lp873x.ko \
kmod-lp87565-regulator.ko \
kmod-lp87565.ko \
kmod-lpass-gfm-sm8250.ko \
kmod-lpassaudiocc-sc7280.ko \
kmod-lpasscc-sc7280.ko \
kmod-lpasscc-sdm845.ko \
kmod-lpasscorecc-sc7180.ko \
kmod-lpasscorecc-sc7280.ko \
kmod-lpc-ich.ko \
kmod-lpc-sch.ko \
kmod-lpddr-cmds.ko \
kmod-lpfc.ko \
kmod-lru-cache.ko \
kmod-lrw.ko \
kmod-lt3651-charger.ko \
kmod-lt7182s.ko \
kmod-ltc1660.ko \
kmod-ltc2471.ko \
kmod-ltc2485.ko \
kmod-ltc2496.ko \
kmod-ltc2497-core.ko \
kmod-ltc2497.ko \
kmod-ltc2632.ko \
kmod-ltc2688.ko \
kmod-ltc2945.ko \
kmod-ltc2947-core.ko \
kmod-ltc2947-i2c.ko \
kmod-ltc2947-spi.ko \
kmod-ltc2978.ko \
kmod-ltc2983.ko \
kmod-ltc2990.ko \
kmod-ltc2992.ko \
kmod-ltc3589.ko \
kmod-ltc3676.ko \
kmod-ltc3815.ko \
kmod-ltc4151.ko \
kmod-ltc4162-l-charger.ko \
kmod-ltc4215.ko \
kmod-ltc4222.ko \
kmod-ltc4245.ko \
kmod-ltc4260.ko \
kmod-ltc4261.ko \
kmod-lv0104cs.ko \
kmod-lv5207lp.ko \
kmod-lvds-codec.ko \
kmod-lvstest.ko \
kmod-lvts-thermal.ko \
kmod-lxt.ko \
kmod-lz4-compress.ko \
kmod-lz4-decompress.ko \
kmod-lz4.ko \
kmod-lz4hc-compress.ko \
kmod-lz4hc.ko \
kmod-lzo-compress.ko \
kmod-lzo-decompress.ko \
kmod-lzo-rle.ko \
kmod-lzo.ko \
kmod-m-can-pci.ko \
kmod-m-can-platform.ko \
kmod-m-can.ko \
kmod-m2m-deinterlace.ko \
kmod-m52790.ko \
kmod-m62332.ko \
kmod-m88ds3103.ko \
kmod-m88rs2000.ko \
kmod-m88rs6000t.ko \
kmod-mac-celtic.ko \
kmod-mac-centeuro.ko \
kmod-mac-croatian.ko \
kmod-mac-cyrillic.ko \
kmod-mac-gaelic.ko \
kmod-mac-greek.ko \
kmod-mac-iceland.ko \
kmod-mac-inuit.ko \
kmod-mac-roman.ko \
kmod-mac-romanian.ko \
kmod-mac-turkish.ko \
kmod-mac80211-hwsim.ko \
kmod-mac80211.ko \
kmod-mac802154-hwsim.ko \
kmod-mac802154.ko \
kmod-macb-pci.ko \
kmod-macb.ko \
kmod-machxo2-spi.ko \
kmod-macsec.ko \
kmod-macvlan.ko \
kmod-macvtap.ko \
kmod-madera-i2c.ko \
kmod-madera-spi.ko \
kmod-madera.ko \
kmod-magellan.ko \
kmod-mailbox-xgene-slimpro.ko \
kmod-mali-dp.ko \
kmod-mantis-core.ko \
kmod-mantis.ko \
kmod-map-absent.ko \
kmod-map-funcs.ko \
kmod-map-ram.ko \
kmod-map-rom.ko \
kmod-marvell-88x2222.ko \
kmod-marvell-cesa.ko \
kmod-marvell-cn10k-ddr-pmu.ko \
kmod-marvell-cn10k-tad-pmu.ko \
kmod-marvell-nand.ko \
kmod-marvell.ko \
kmod-marvell10g.ko \
kmod-matrix-keymap.ko \
kmod-matrix-keypad.ko \
kmod-matrox-w1.ko \
kmod-max11100.ko \
kmod-max1118.ko \
kmod-max11801-ts.ko \
kmod-max1241.ko \
kmod-max127.ko \
kmod-max14656-charger-detector.ko \
kmod-max15301.ko \
kmod-max16064.ko \
kmod-max16065.ko \
kmod-max1619.ko \
kmod-max16601.ko \
kmod-max1668.ko \
kmod-max17040-battery.ko \
kmod-max17042-battery.ko \
kmod-max1721x-battery.ko \
kmod-max20086-regulator.ko \
kmod-max20411-regulator.ko \
kmod-max20730.ko \
kmod-max20751.ko \
kmod-max2165.ko \
kmod-max2175.ko \
kmod-max30100.ko \
kmod-max30102.ko \
kmod-max30208.ko \
kmod-max31722.ko \
kmod-max31730.ko \
kmod-max31760.ko \
kmod-max31785.ko \
kmod-max31790.ko \
kmod-max31856.ko \
kmod-max31865.ko \
kmod-max3420-udc.ko \
kmod-max3421-hcd.ko \
kmod-max34440.ko \
kmod-max44009.ko \
kmod-max5432.ko \
kmod-max5481.ko \
kmod-max5487.ko \
kmod-max597x-regulator.ko \
kmod-max6620.ko \
kmod-max6621.ko \
kmod-max6639.ko \
kmod-max6650.ko \
kmod-max6697.ko \
kmod-max6875.ko \
kmod-max7359-keypad.ko \
kmod-max77620-regulator.ko \
kmod-max77620-thermal.ko \
kmod-max77620-wdt.ko \
kmod-max77650-charger.ko \
kmod-max77650-onkey.ko \
kmod-max77650-regulator.ko \
kmod-max77650.ko \
kmod-max77714.ko \
kmod-max77826-regulator.ko \
kmod-max77976-charger.ko \
kmod-max8688.ko \
kmod-max8893.ko \
kmod-max8903-charger.ko \
kmod-max9271.ko \
kmod-max9286.ko \
kmod-max9611.ko \
kmod-max96712.ko \
kmod-maxim-thermocouple.ko \
kmod-mb1232.ko \
kmod-mb86a16.ko \
kmod-mb86a20s.ko \
kmod-mbcache.ko \
kmod-mc.ko \
kmod-mc3230.ko \
kmod-mc34vr500.ko \
kmod-mc44s803.ko \
kmod-mcam-core.ko \
kmod-mcba-usb.ko \
kmod-mceusb.ko \
kmod-mchp-pci1xxxx-gp.ko \
kmod-mchp-pci1xxxx-gpio.ko \
kmod-mchp23k256.ko \
kmod-mchp48l640.ko \
kmod-mcp16502.ko \
kmod-mcp251xfd.ko \
kmod-mcp3021.ko \
kmod-mcp3911.ko \
kmod-mcp4018.ko \
kmod-mcp41010.ko \
kmod-mcp4531.ko \
kmod-mcr20a.ko \
kmod-mcs-touchkey.ko \
kmod-mcs5000-ts.ko \
kmod-mcs7830.ko \
kmod-mct-u232.ko \
kmod-mctp-i2c.ko \
kmod-mctp-serial.ko \
kmod-md-cluster.ko \
kmod-md-mod.ko \
kmod-md4.ko \
kmod-md5.ko \
kmod-mdc800.ko \
kmod-mdio-bcm-unimac.ko \
kmod-mdio-bitbang.ko \
kmod-mdio-cavium.ko \
kmod-mdio-devres.ko \
kmod-mdio-gpio.ko \
kmod-mdio-hisi-femac.ko \
kmod-mdio-i2c.ko \
kmod-mdio-ipq4019.ko \
kmod-mdio-ipq8064.ko \
kmod-mdio-mscc-miim.ko \
kmod-mdio-mux-bcm-iproc.ko \
kmod-mdio-mux-gpio.ko \
kmod-mdio-mux-meson-g12a.ko \
kmod-mdio-mux-meson-gxl.ko \
kmod-mdio-mux-mmioreg.ko \
kmod-mdio-mux-multiplexer.ko \
kmod-mdio-mux.ko \
kmod-mdio-mvusb.ko \
kmod-mdio-octeon.ko \
kmod-mdio-sun4i.ko \
kmod-mdio-thunder.ko \
kmod-mdio-xgene.ko \
kmod-mdio.ko \
kmod-mdt-loader.ko \
kmod-mediatek-cpufreq-hw.ko \
kmod-mediatek-cpufreq.ko \
kmod-mediatek-drm-hdmi.ko \
kmod-mediatek-drm.ko \
kmod-mediatek-ge.ko \
kmod-mediatek.ko \
kmod-megachips-stdpxxxx-ge-b850v3-fw.ko \
kmod-megaraid-mbox.ko \
kmod-megaraid-mm.ko \
kmod-megaraid-sas.ko \
kmod-megaraid.ko \
kmod-melfas-mip4.ko \
kmod-memory-notifier-error-inject.ko \
kmod-memstick.ko \
kmod-mena21-wdt.ko \
kmod-menf21bmc.ko \
kmod-meson-aoclk.ko \
kmod-meson-canvas.ko \
kmod-meson-clk-measure.ko \
kmod-meson-drm.ko \
kmod-meson-dw-hdmi.ko \
kmod-meson-ee-pwrc.ko \
kmod-meson-eeclk.ko \
kmod-meson-gx-mmc.ko \
kmod-meson-gx-pwrc-vpu.ko \
kmod-meson-gxbb-wdt.ko \
kmod-meson-gxl.ko \
kmod-meson-ir-tx.ko \
kmod-meson-ir.ko \
kmod-meson-nand.ko \
kmod-meson-rng.ko \
kmod-meson-saradc.ko \
kmod-meson-secure-pwrc.ko \
kmod-meson-sm.ko \
kmod-meson-uart.ko \
kmod-meson-vdec.ko \
kmod-meson-wdt.ko \
kmod-metro-usb.ko \
kmod-mfd-core.ko \
kmod-mgag200.ko \
kmod-mhi-ep.ko \
kmod-mhi-net.ko \
kmod-mhi-pci-generic.ko \
kmod-mhi-wwan-ctrl.ko \
kmod-mhi-wwan-mbim.ko \
kmod-mhi.ko \
kmod-mi0283qt.ko \
kmod-michael-mic.ko \
kmod-micrel.ko \
kmod-microchip-spi.ko \
kmod-microchip-t1.ko \
kmod-microchip-t1s.ko \
kmod-microchip.ko \
kmod-microread-i2c.ko \
kmod-microread.ko \
kmod-microtek.ko \
kmod-mii.ko \
kmod-minix.ko \
kmod-mip6.ko \
kmod-mipi-i3c-hci.ko \
kmod-mk712.ko \
kmod-mkiss.ko \
kmod-ml86v7667.ko \
kmod-mlx-wdt.ko \
kmod-mlx4-core.ko \
kmod-mlx4-en.ko \
kmod-mlx4-ib.ko \
kmod-mlx5-core.ko \
kmod-mlx5-ib.ko \
kmod-mlx5-vdpa.ko \
kmod-mlx5-vfio-pci.ko \
kmod-mlx90614.ko \
kmod-mlx90632.ko \
kmod-mlxbf-bootctl.ko \
kmod-mlxbf-gige.ko \
kmod-mlxbf-pmc.ko \
kmod-mlxbf-tmfifo.ko \
kmod-mlxfw.ko \
kmod-mlxreg-fan.ko \
kmod-mlxreg-hotplug.ko \
kmod-mlxreg-io.ko \
kmod-mlxreg-lc.ko \
kmod-mlxsw-core.ko \
kmod-mlxsw-i2c.ko \
kmod-mlxsw-minimal.ko \
kmod-mlxsw-pci.ko \
kmod-mlxsw-spectrum.ko \
kmod-mma7455-core.ko \
kmod-mma7455-i2c.ko \
kmod-mma7455-spi.ko \
kmod-mma7660.ko \
kmod-mma8450.ko \
kmod-mma9551-core.ko \
kmod-mma9551.ko \
kmod-mma9553.ko \
kmod-mmc-block.ko \
kmod-mmc-core.ko \
kmod-mmc-hsq.ko \
kmod-mmcc-msm8994.ko \
kmod-mmcc-msm8998.ko \
kmod-mmcc-sdm660.ko \
kmod-mms114.ko \
kmod-mn88443x.ko \
kmod-mn88472.ko \
kmod-mn88473.ko \
kmod-mos7720.ko \
kmod-mos7840.ko \
kmod-motorcomm.ko \
kmod-motorola-cpcap.ko \
kmod-mousedev.ko \
kmod-moxtet.ko \
kmod-mp2629-adc.ko \
kmod-mp2629-charger.ko \
kmod-mp2629.ko \
kmod-mp2888.ko \
kmod-mp2975.ko \
kmod-mp5023.ko \
kmod-mp5416.ko \
kmod-mp8859.ko \
kmod-mp886x.ko \
kmod-mpi.ko \
kmod-mpi3mr.ko \
kmod-mpl115-i2c.ko \
kmod-mpl115-spi.ko \
kmod-mpl115.ko \
kmod-mpls-gso.ko \
kmod-mpls-iptunnel.ko \
kmod-mpls-router.ko \
kmod-mpoa.ko \
kmod-mpq7920.ko \
kmod-mpq7932.ko \
kmod-mpr121-touchkey.ko \
kmod-mpt3sas.ko \
kmod-mptbase.ko \
kmod-mptcp-diag.ko \
kmod-mptctl.ko \
kmod-mptfc.ko \
kmod-mptlan.ko \
kmod-mptsas.ko \
kmod-mptscsih.ko \
kmod-mptspi.ko \
kmod-mpu3050.ko \
kmod-mq-deadline.ko \
kmod-mr75203.ko \
kmod-mrp.ko \
kmod-ms-block.ko \
kmod-ms-sensors-i2c.ko \
kmod-ms5637.ko \
kmod-mscc-felix-dsa-lib.ko \
kmod-mscc-felix.ko \
kmod-mscc-ocelot-ext.ko \
kmod-mscc-ocelot-switch-lib.ko \
kmod-mscc-ocelot.ko \
kmod-mscc-seville.ko \
kmod-mscc.ko \
kmod-msdos.ko \
kmod-mse102x.ko \
kmod-msg2638.ko \
kmod-msi001.ko \
kmod-msi2500.ko \
kmod-msm-serial.ko \
kmod-msm.ko \
kmod-msp3400.ko \
kmod-mspro-block.ko \
kmod-mss-sc7180.ko \
kmod-mt2060.ko \
kmod-mt2063.ko \
kmod-mt20xx.ko \
kmod-mt2131.ko \
kmod-mt2266.ko \
kmod-mt312.ko \
kmod-mt352.ko \
kmod-mt6315-regulator.ko \
kmod-mt6359-accdet.ko \
kmod-mt6360-adc.ko \
kmod-mt6360-charger.ko \
kmod-mt6360-core.ko \
kmod-mt6360-regulator.ko \
kmod-mt6380-regulator.ko \
kmod-mt6577-auxadc.ko \
kmod-mt6779-keypad.ko \
kmod-mt6797-mt6351.ko \
kmod-mt7530-mdio.ko \
kmod-mt7530-mmio.ko \
kmod-mt7530.ko \
kmod-mt76-connac-lib.ko \
kmod-mt76-sdio.ko \
kmod-mt76-usb.ko \
kmod-mt76.ko \
kmod-mt7601u.ko \
kmod-mt7603e.ko \
kmod-mt7615-common.ko \
kmod-mt7615e.ko \
kmod-mt7663-usb-sdio-common.ko \
kmod-mt7663s.ko \
kmod-mt7663u.ko \
kmod-mt76x0-common.ko \
kmod-mt76x02-lib.ko \
kmod-mt76x02-usb.ko \
kmod-mt76x0e.ko \
kmod-mt76x0u.ko \
kmod-mt76x2-common.ko \
kmod-mt76x2e.ko \
kmod-mt76x2u.ko \
kmod-mt7915e.ko \
kmod-mt7921-common.ko \
kmod-mt7921e.ko \
kmod-mt7921s.ko \
kmod-mt7921u.ko \
kmod-mt7996e.ko \
kmod-mt8183-da7219-max98357.ko \
kmod-mt8183-mt6358-ts3a227-max98357.ko \
kmod-mt8186-mt6366-da7219-max98357.ko \
kmod-mt8186-mt6366-rt1019-rt5682s.ko \
kmod-mt8188-mt6359.ko \
kmod-mt8192-mt6359-rt1015-rt5682.ko \
kmod-mt8195-mt6359.ko \
kmod-mt9m001.ko \
kmod-mt9m111.ko \
kmod-mt9p031.ko \
kmod-mt9t112.ko \
kmod-mt9v011.ko \
kmod-mt9v032.ko \
kmod-mt9v111.ko \
kmod-mtd-blkdevs.ko \
kmod-mtd-nandbiterrs.ko \
kmod-mtd-nandecctest.ko \
kmod-mtd-oobtest.ko \
kmod-mtd-pagetest.ko \
kmod-mtd-readtest.ko \
kmod-mtd-speedtest.ko \
kmod-mtd-stresstest.ko \
kmod-mtd-subpagetest.ko \
kmod-mtd-torturetest.ko \
kmod-mtd.ko \
kmod-mtdblock-ro.ko \
kmod-mtdblock.ko \
kmod-mtdoops.ko \
kmod-mtdpstore.ko \
kmod-mtdram.ko \
kmod-mtdswap.ko \
kmod-mtip32xx.ko \
kmod-mtk-adsp-common.ko \
kmod-mtk-adsp-ipc.ko \
kmod-mtk-adsp-mailbox.ko \
kmod-mtk-btcvsd.ko \
kmod-mtk-cci-devfreq.ko \
kmod-mtk-cir.ko \
kmod-mtk-cmdq-helper.ko \
kmod-mtk-cmdq-mailbox.ko \
kmod-mtk-cqdma.ko \
kmod-mtk-devapc.ko \
kmod-mtk-dp.ko \
kmod-mtk-eint.ko \
kmod-mtk-eth.ko \
kmod-mtk-hsdma.ko \
kmod-mtk-iommu.ko \
kmod-mtk-jpeg-dec-hw.ko \
kmod-mtk-jpeg-enc-hw.ko \
kmod-mtk-jpeg.ko \
kmod-mtk-mdp.ko \
kmod-mtk-mdp3.ko \
kmod-mtk-mmsys.ko \
kmod-mtk-mutex.ko \
kmod-mtk-nand.ko \
kmod-mtk-pmic-wrap.ko \
kmod-mtk-regulator-coupler.ko \
kmod-mtk-rng.ko \
kmod-mtk-rpmsg.ko \
kmod-mtk-scp-ipi.ko \
kmod-mtk-scp.ko \
kmod-mtk-sd.ko \
kmod-mtk-smi.ko \
kmod-mtk-star-emac.ko \
kmod-mtk-svs.ko \
kmod-mtk-t7xx.ko \
kmod-mtk-uart-apdma.ko \
kmod-mtk-vcodec-common.ko \
kmod-mtk-vcodec-dec-hw.ko \
kmod-mtk-vcodec-dec.ko \
kmod-mtk-vcodec-enc.ko \
kmod-mtk-vpu.ko \
kmod-mtk-wdt.ko \
kmod-mtouch.ko \
kmod-mtu3.ko \
kmod-multipath.ko \
kmod-musb-hdrc.ko \
kmod-mux-adg792a.ko \
kmod-mux-adgs1408.ko \
kmod-mux-core.ko \
kmod-mux-gpio.ko \
kmod-mux-mmio.ko \
kmod-mv88e6060.ko \
kmod-mv88e6xxx.ko \
kmod-mvmdio.ko \
kmod-mvneta.ko \
kmod-mvpp2.ko \
kmod-mvsas.ko \
kmod-mvumi.ko \
kmod-mwifiex-pcie.ko \
kmod-mwifiex-sdio.ko \
kmod-mwifiex-usb.ko \
kmod-mwifiex.ko \
kmod-mwl8k.ko \
kmod-mx3fb.ko \
kmod-mxc-clk.ko \
kmod-mxc-jpeg-encdec.ko \
kmod-mxc-nand.ko \
kmod-mxc-w1.ko \
kmod-mxc4005.ko \
kmod-mxc6255.ko \
kmod-mxic-nand.ko \
kmod-mxl-gpy.ko \
kmod-mxl111sf-demod.ko \
kmod-mxl111sf-tuner.ko \
kmod-mxl301rf.ko \
kmod-mxl5005s.ko \
kmod-mxl5007t.ko \
kmod-mxl5xx.ko \
kmod-mxl692.ko \
kmod-mxs-dcp.ko \
kmod-mxser.ko \
kmod-mxuport.ko \
kmod-myrb.ko \
kmod-myri10ge.ko \
kmod-myrs.ko \
kmod-n-gsm.ko \
kmod-n-hdlc.ko \
kmod-n-null.ko \
kmod-n5pf.ko \
kmod-nand.ko \
kmod-nandcore.ko \
kmod-nandsim.ko \
kmod-national.ko \
kmod-natsemi.ko \
kmod-navman.ko \
kmod-nbd.ko \
kmod-nci-uart.ko \
kmod-nci.ko \
kmod-ncn26000.ko \
kmod-nct6683.ko \
kmod-nct6775-core.ko \
kmod-nct6775-i2c.ko \
kmod-nct6775.ko \
kmod-nct7802.ko \
kmod-nct7904.ko \
kmod-nd-btt.ko \
kmod-nd-pmem.ko \
kmod-nd-virtio.ko \
kmod-ne2k-pci.ko \
kmod-net-failover.ko \
kmod-net1080.ko \
kmod-netconsole.ko \
kmod-netdev-notifier-error-inject.ko \
kmod-netdevsim.ko \
kmod-netfs.ko \
kmod-netlink-diag.ko \
kmod-netrom.ko \
kmod-netsec.ko \
kmod-netup-unidvb.ko \
kmod-netxen-nic.ko \
kmod-newtonkbd.ko \
kmod-nf-conncount.ko \
kmod-nf-conntrack-amanda.ko \
kmod-nf-conntrack-bridge.ko \
kmod-nf-conntrack-broadcast.ko \
kmod-nf-conntrack-ftp.ko \
kmod-nf-conntrack-h323.ko \
kmod-nf-conntrack-irc.ko \
kmod-nf-conntrack-netbios-ns.ko \
kmod-nf-conntrack-netlink.ko \
kmod-nf-conntrack-pptp.ko \
kmod-nf-conntrack-sane.ko \
kmod-nf-conntrack-sip.ko \
kmod-nf-conntrack-snmp.ko \
kmod-nf-conntrack-tftp.ko \
kmod-nf-conntrack.ko \
kmod-nf-defrag-ipv4.ko \
kmod-nf-defrag-ipv6.ko \
kmod-nf-dup-ipv4.ko \
kmod-nf-dup-ipv6.ko \
kmod-nf-dup-netdev.ko \
kmod-nf-flow-table-inet.ko \
kmod-nf-flow-table.ko \
kmod-nf-log-syslog.ko \
kmod-nf-nat-amanda.ko \
kmod-nf-nat-ftp.ko \
kmod-nf-nat-h323.ko \
kmod-nf-nat-irc.ko \
kmod-nf-nat-pptp.ko \
kmod-nf-nat-sip.ko \
kmod-nf-nat-snmp-basic.ko \
kmod-nf-nat-tftp.ko \
kmod-nf-nat.ko \
kmod-nf-reject-ipv4.ko \
kmod-nf-reject-ipv6.ko \
kmod-nf-socket-ipv4.ko \
kmod-nf-socket-ipv6.ko \
kmod-nf-synproxy-core.ko \
kmod-nf-tables.ko \
kmod-nf-tproxy-ipv4.ko \
kmod-nf-tproxy-ipv6.ko \
kmod-nfc-digital.ko \
kmod-nfc.ko \
kmod-nfcmrvl-i2c.ko \
kmod-nfcmrvl-uart.ko \
kmod-nfcmrvl-usb.ko \
kmod-nfcmrvl.ko \
kmod-nfcsim.ko \
kmod-nfit.ko \
kmod-nfnetlink-acct.ko \
kmod-nfnetlink-cthelper.ko \
kmod-nfnetlink-cttimeout.ko \
kmod-nfnetlink-hook.ko \
kmod-nfnetlink-log.ko \
kmod-nfnetlink-osf.ko \
kmod-nfnetlink-queue.ko \
kmod-nfnetlink.ko \
kmod-nfp.ko \
kmod-nfs-acl.ko \
kmod-nfs-layout-flexfiles.ko \
kmod-nfs-layout-nfsv41-files.ko \
kmod-nfs.ko \
kmod-nfsd.ko \
kmod-nfsv2.ko \
kmod-nfsv3.ko \
kmod-nfsv4.ko \
kmod-nft-chain-nat.ko \
kmod-nft-compat.ko \
kmod-nft-connlimit.ko \
kmod-nft-ct.ko \
kmod-nft-dup-ipv4.ko \
kmod-nft-dup-ipv6.ko \
kmod-nft-dup-netdev.ko \
kmod-nft-fib-inet.ko \
kmod-nft-fib-ipv4.ko \
kmod-nft-fib-ipv6.ko \
kmod-nft-fib-netdev.ko \
kmod-nft-fib.ko \
kmod-nft-flow-offload.ko \
kmod-nft-fwd-netdev.ko \
kmod-nft-hash.ko \
kmod-nft-limit.ko \
kmod-nft-log.ko \
kmod-nft-masq.ko \
kmod-nft-meta-bridge.ko \
kmod-nft-nat.ko \
kmod-nft-numgen.ko \
kmod-nft-osf.ko \
kmod-nft-queue.ko \
kmod-nft-quota.ko \
kmod-nft-redir.ko \
kmod-nft-reject-bridge.ko \
kmod-nft-reject-inet.ko \
kmod-nft-reject-ipv4.ko \
kmod-nft-reject-ipv6.ko \
kmod-nft-reject-netdev.ko \
kmod-nft-reject.ko \
kmod-nft-socket.ko \
kmod-nft-synproxy.ko \
kmod-nft-tproxy.ko \
kmod-nft-tunnel.ko \
kmod-nft-xfrm.ko \
kmod-nftl.ko \
kmod-ngbe.ko \
kmod-ngene.ko \
kmod-nhc-dest.ko \
kmod-nhc-fragment.ko \
kmod-nhc-ghc-ext-dest.ko \
kmod-nhc-ghc-ext-frag.ko \
kmod-nhc-ghc-ext-hop.ko \
kmod-nhc-ghc-ext-route.ko \
kmod-nhc-ghc-icmpv6.ko \
kmod-nhc-ghc-udp.ko \
kmod-nhc-hop.ko \
kmod-nhc-ipv6.ko \
kmod-nhc-mobility.ko \
kmod-nhc-routing.ko \
kmod-nhc-udp.ko \
kmod-nhpoly1305-neon.ko \
kmod-nhpoly1305.ko \
kmod-ni-usb6501.ko \
kmod-nicpf.ko \
kmod-nicstar.ko \
kmod-nicvf.ko \
kmod-nilfs2.ko \
kmod-nitro-enclaves.ko \
kmod-niu.ko \
kmod-nixge.ko \
kmod-nlmon.ko \
kmod-nls-ascii.ko \
kmod-nls-base.ko \
kmod-nls-cp1250.ko \
kmod-nls-cp1251.ko \
kmod-nls-cp1255.ko \
kmod-nls-cp437.ko \
kmod-nls-cp737.ko \
kmod-nls-cp775.ko \
kmod-nls-cp850.ko \
kmod-nls-cp852.ko \
kmod-nls-cp855.ko \
kmod-nls-cp857.ko \
kmod-nls-cp860.ko \
kmod-nls-cp861.ko \
kmod-nls-cp862.ko \
kmod-nls-cp863.ko \
kmod-nls-cp864.ko \
kmod-nls-cp865.ko \
kmod-nls-cp866.ko \
kmod-nls-cp869.ko \
kmod-nls-cp874.ko \
kmod-nls-cp932.ko \
kmod-nls-cp936.ko \
kmod-nls-cp949.ko \
kmod-nls-cp950.ko \
kmod-nls-euc-jp.ko \
kmod-nls-iso8859-1.ko \
kmod-nls-iso8859-13.ko \
kmod-nls-iso8859-14.ko \
kmod-nls-iso8859-15.ko \
kmod-nls-iso8859-2.ko \
kmod-nls-iso8859-3.ko \
kmod-nls-iso8859-4.ko \
kmod-nls-iso8859-5.ko \
kmod-nls-iso8859-6.ko \
kmod-nls-iso8859-7.ko \
kmod-nls-iso8859-9.ko \
kmod-nls-koi8-r.ko \
kmod-nls-koi8-ru.ko \
kmod-nls-koi8-u.ko \
kmod-nls-utf8.ko \
kmod-noa1305.ko \
kmod-nosy.ko \
kmod-notifier-error-inject.ko \
kmod-nouveau.ko \
kmod-novatek-nvt-ts.ko \
kmod-nozomi.ko \
kmod-npcm-adc.ko \
kmod-npcm-rng.ko \
kmod-npcm-wdt.ko \
kmod-npcm750-pwm-fan.ko \
kmod-nps-enet.ko \
kmod-ns-thermal.ko \
kmod-ns83820.ko \
kmod-nsh.ko \
kmod-ntb-hw-epf.ko \
kmod-ntb-hw-idt.ko \
kmod-ntb-hw-switchtec.ko \
kmod-ntb-netdev.ko \
kmod-ntb-perf.ko \
kmod-ntb-transport.ko \
kmod-ntb.ko \
kmod-ntfs3.ko \
kmod-null-blk.ko \
kmod-nvec-kbd.ko \
kmod-nvec-paz00.ko \
kmod-nvec-power.ko \
kmod-nvec-ps2.ko \
kmod-nvec.ko \
kmod-nvme-apple.ko \
kmod-nvme-core.ko \
kmod-nvme-fabrics.ko \
kmod-nvme-fc.ko \
kmod-nvme-fcloop.ko \
kmod-nvme-loop.ko \
kmod-nvme-rdma.ko \
kmod-nvme-tcp.ko \
kmod-nvme.ko \
kmod-nvmem-apple-efuses.ko \
kmod-nvmem-bcm-ocotp.ko \
kmod-nvmem-imx-iim.ko \
kmod-nvmem-imx-ocotp-scu.ko \
kmod-nvmem-imx-ocotp.ko \
kmod-nvmem-layerscape-sfp.ko \
kmod-nvmem-meson-efuse.ko \
kmod-nvmem-meson-mx-efuse.ko \
kmod-nvmem-mtk-efuse.ko \
kmod-nvmem-qcom-spmi-sdam.ko \
kmod-nvmem-qfprom.ko \
kmod-nvmem-reboot-mode.ko \
kmod-nvmem-rmem.ko \
kmod-nvmem-rockchip-efuse.ko \
kmod-nvmem-rockchip-otp.ko \
kmod-nvmem-sc27xx-efuse.ko \
kmod-nvmem-snvs-lpgpr.ko \
kmod-nvmem-sprd-efuse.ko \
kmod-nvmem-sunxi-sid.ko \
kmod-nvmem-u-boot-env.ko \
kmod-nvmem-zynqmp-nvmem.ko \
kmod-nvmet-fc.ko \
kmod-nvmet-rdma.ko \
kmod-nvmet-tcp.ko \
kmod-nvmet.ko \
kmod-nvsw-sn2201.ko \
kmod-nwl-dsi.ko \
kmod-nxp-bbnsm-pwrkey.ko \
kmod-nxp-c45-tja11xx.ko \
kmod-nxp-cbtx.ko \
kmod-nxp-nci-i2c.ko \
kmod-nxp-nci.ko \
kmod-nxp-ptn3460.ko \
kmod-nxp-tja11xx.ko \
kmod-nxt200x.ko \
kmod-nxt6000.ko \
kmod-nzxt-kraken2.ko \
kmod-nzxt-smart2.ko \
kmod-objagg.ko \
kmod-ocelot-soc.ko \
kmod-ocfs2-dlm.ko \
kmod-ocfs2-dlmfs.ko \
kmod-ocfs2-nodemanager.ko \
kmod-ocfs2-stack-o2cb.ko \
kmod-ocfs2-stack-user.ko \
kmod-ocfs2-stackglue.ko \
kmod-ocfs2.ko \
kmod-ocmem.ko \
kmod-ocrdma.ko \
kmod-octeon-ep.ko \
kmod-octeontx-cpt.ko \
kmod-octeontx-cptvf.ko \
kmod-odroid-go-ultra-poweroff.ko \
kmod-of-fpga-region.ko \
kmod-of-mdio.ko \
kmod-of-pmem.ko \
kmod-of-reconfig-notifier-error-inject.ko \
kmod-of-xilinx-wdt.ko \
kmod-ofb.ko \
kmod-ofpart.ko \
kmod-og01a1b.ko \
kmod-ohci-exynos.ko \
kmod-ohci-hcd.ko \
kmod-ohci-pci.ko \
kmod-ohci-platform.ko \
kmod-oid-registry.ko \
kmod-omap-rng.ko \
kmod-omfs.ko \
kmod-omninet.ko \
kmod-on20.ko \
kmod-on26.ko \
kmod-onboard-usb-hub.ko \
kmod-onenand.ko \
kmod-onie-tlv.ko \
kmod-open-dice.ko \
kmod-opencores-kbd.ko \
kmod-openvswitch.ko \
kmod-opt3001.ko \
kmod-optee-rng.ko \
kmod-optee.ko \
kmod-opticon.ko \
kmod-option.ko \
kmod-or51132.ko \
kmod-or51211.ko \
kmod-orangefs.ko \
kmod-orinoco-nortel.ko \
kmod-orinoco-pci.ko \
kmod-orinoco-plx.ko \
kmod-orinoco-tmd.ko \
kmod-orinoco-usb.ko \
kmod-orinoco.ko \
kmod-oti6858.ko \
kmod-otm3225a.ko \
kmod-otx2-ptp.ko \
kmod-ov02a10.ko \
kmod-ov08d10.ko \
kmod-ov08x40.ko \
kmod-ov13858.ko \
kmod-ov13b10.ko \
kmod-ov2640.ko \
kmod-ov2659.ko \
kmod-ov2680.ko \
kmod-ov2685.ko \
kmod-ov2740.ko \
kmod-ov4689.ko \
kmod-ov5640.ko \
kmod-ov5645.ko \
kmod-ov5647.ko \
kmod-ov5648.ko \
kmod-ov5670.ko \
kmod-ov5675.ko \
kmod-ov5693.ko \
kmod-ov5695.ko \
kmod-ov6650.ko \
kmod-ov7251.ko \
kmod-ov7640.ko \
kmod-ov7670.ko \
kmod-ov772x.ko \
kmod-ov7740.ko \
kmod-ov8856.ko \
kmod-ov8858.ko \
kmod-ov8865.ko \
kmod-ov9282.ko \
kmod-ov9640.ko \
kmod-ov9650.ko \
kmod-ov9734.ko \
kmod-overlay.ko \
kmod-owl-dma.ko \
kmod-owl-emac.ko \
kmod-owl-mmc.ko \
kmod-owl-uart.ko \
kmod-oxu210hp-hcd.ko \
kmod-p54common.ko \
kmod-p54pci.ko \
kmod-p54usb.ko \
kmod-p8022.ko \
kmod-pa12203001.ko \
kmod-panel-abt-y030xx067a.ko \
kmod-panel-arm-versatile.ko \
kmod-panel-asus-z00t-tm5p5-n35596.ko \
kmod-panel-boe-bf060y8m-aj0.ko \
kmod-panel-boe-himax8279d.ko \
kmod-panel-boe-tv101wum-nl6.ko \
kmod-panel-dsi-cm.ko \
kmod-panel-ebbg-ft8719.ko \
kmod-panel-edp.ko \
kmod-panel-elida-kd35t133.ko \
kmod-panel-feixin-k101-im2ba02.ko \
kmod-panel-feiyang-fy07024di26a30d.ko \
kmod-panel-ilitek-ili9322.ko \
kmod-panel-ilitek-ili9881c.ko \
kmod-panel-innolux-p079zca.ko \
kmod-panel-jdi-fhd-r63452.ko \
kmod-panel-jdi-lt070me05000.ko \
kmod-panel-khadas-ts050.ko \
kmod-panel-kingdisplay-kd097d04.ko \
kmod-panel-leadtek-ltk050h3146w.ko \
kmod-panel-leadtek-ltk500hd1829.ko \
kmod-panel-lg-lb035q02.ko \
kmod-panel-lg-lg4573.ko \
kmod-panel-lvds.ko \
kmod-panel-magnachip-d53e6ea8966.ko \
kmod-panel-mantix-mlaf057we51.ko \
kmod-panel-mipi-dbi.ko \
kmod-panel-nec-nl8048hl11.ko \
kmod-panel-newvision-nv3052c.ko \
kmod-panel-novatek-nt35510.ko \
kmod-panel-novatek-nt35560.ko \
kmod-panel-novatek-nt35950.ko \
kmod-panel-novatek-nt36523.ko \
kmod-panel-novatek-nt36672a.ko \
kmod-panel-novatek-nt39016.ko \
kmod-panel-olimex-lcd-olinuxino.ko \
kmod-panel-orisetech-otm8009a.ko \
kmod-panel-osd-osd101t2587-53ts.ko \
kmod-panel-panasonic-vvx10f034n00.ko \
kmod-panel-raspberrypi-touchscreen.ko \
kmod-panel-raydium-rm67191.ko \
kmod-panel-raydium-rm68200.ko \
kmod-panel-ronbo-rb070d30.ko \
kmod-panel-samsung-ld9040.ko \
kmod-panel-samsung-s6d16d0.ko \
kmod-panel-samsung-s6d27a1.ko \
kmod-panel-samsung-s6e3ha2.ko \
kmod-panel-samsung-s6e63j0x03.ko \
kmod-panel-samsung-s6e63m0-spi.ko \
kmod-panel-samsung-s6e63m0.ko \
kmod-panel-samsung-s6e88a0-ams452ef01.ko \
kmod-panel-samsung-s6e8aa0.ko \
kmod-panel-samsung-sofef00.ko \
kmod-panel-seiko-43wvf1g.ko \
kmod-panel-sharp-lq101r1sx01.ko \
kmod-panel-sharp-ls037v7dw01.ko \
kmod-panel-sharp-ls043t1le01.ko \
kmod-panel-sharp-ls060t1sx01.ko \
kmod-panel-simple.ko \
kmod-panel-sitronix-st7701.ko \
kmod-panel-sitronix-st7703.ko \
kmod-panel-sitronix-st7789v.ko \
kmod-panel-sony-acx565akm.ko \
kmod-panel-sony-td4353-jdi.ko \
kmod-panel-sony-tulip-truly-nt35521.ko \
kmod-panel-tdo-tl070wsh30.ko \
kmod-panel-tpo-td028ttec1.ko \
kmod-panel-tpo-td043mtea1.ko \
kmod-panel-tpo-tpg110.ko \
kmod-panel-truly-nt35597.ko \
kmod-panel-visionox-rm69299.ko \
kmod-panel-xinpeng-xpp055c272.ko \
kmod-panel.ko \
kmod-panfrost.ko \
kmod-parade-ps8622.ko \
kmod-parade-ps8640.ko \
kmod-parkbd.ko \
kmod-parman.ko \
kmod-parport-pc.ko \
kmod-parport-serial.ko \
kmod-parport.ko \
kmod-parser-trx.ko \
kmod-pata-ali.ko \
kmod-pata-amd.ko \
kmod-pata-artop.ko \
kmod-pata-atiixp.ko \
kmod-pata-atp867x.ko \
kmod-pata-cmd640.ko \
kmod-pata-cmd64x.ko \
kmod-pata-cypress.ko \
kmod-pata-efar.ko \
kmod-pata-hpt366.ko \
kmod-pata-hpt37x.ko \
kmod-pata-hpt3x2n.ko \
kmod-pata-hpt3x3.ko \
kmod-pata-imx.ko \
kmod-pata-it8213.ko \
kmod-pata-it821x.ko \
kmod-pata-jmicron.ko \
kmod-pata-marvell.ko \
kmod-pata-mpiix.ko \
kmod-pata-netcell.ko \
kmod-pata-ninja32.ko \
kmod-pata-ns87410.ko \
kmod-pata-ns87415.ko \
kmod-pata-oldpiix.ko \
kmod-pata-opti.ko \
kmod-pata-optidma.ko \
kmod-pata-parport.ko \
kmod-pata-pdc2027x.ko \
kmod-pata-pdc202xx-old.ko \
kmod-pata-piccolo.ko \
kmod-pata-radisys.ko \
kmod-pata-rdc.ko \
kmod-pata-rz1000.ko \
kmod-pata-sch.ko \
kmod-pata-serverworks.ko \
kmod-pata-sil680.ko \
kmod-pata-sis.ko \
kmod-pata-sl82c105.ko \
kmod-pata-triflex.ko \
kmod-pata-via.ko \
kmod-pc300too.ko \
kmod-pc87360.ko \
kmod-pc87427.ko \
kmod-pca9450-regulator.ko \
kmod-pcbc.ko \
kmod-pcf8574-keypad.ko \
kmod-pcf8591.ko \
kmod-pci-aardvark.ko \
kmod-pci-endpoint-test.ko \
kmod-pci-epf-ntb.ko \
kmod-pci-epf-test.ko \
kmod-pci-epf-vntb.ko \
kmod-pci-exynos.ko \
kmod-pci-host-common.ko \
kmod-pci-host-generic.ko \
kmod-pci-hyperv-intf.ko \
kmod-pci-hyperv.ko \
kmod-pci-meson.ko \
kmod-pci-pf-stub.ko \
kmod-pci-stub.ko \
kmod-pci.ko \
kmod-pci200syn.ko \
kmod-pcie-altera-msi.ko \
kmod-pcie-altera.ko \
kmod-pcie-apple.ko \
kmod-pcie-brcmstb.ko \
kmod-pcie-iproc-platform.ko \
kmod-pcie-iproc.ko \
kmod-pcie-kirin.ko \
kmod-pcie-mediatek-gen3.ko \
kmod-pcie-mediatek.ko \
kmod-pcie-qcom-ep.ko \
kmod-pcie-rockchip-host.ko \
kmod-pcie-tegra194.ko \
kmod-pcips2.ko \
kmod-pcnet32.ko \
kmod-pcrypt.ko \
kmod-pcs-lynx.ko \
kmod-pcs-mtk-lynxi.ko \
kmod-pcs-xpcs.ko \
kmod-pcwd-pci.ko \
kmod-pcwd-usb.ko \
kmod-pdc-adma.ko \
kmod-pdr-interface.ko \
kmod-pds-core.ko \
kmod-peak-pci.ko \
kmod-peak-pciefd.ko \
kmod-peak-usb.ko \
kmod-pegasus-notetaker.ko \
kmod-pegasus.ko \
kmod-penmount.ko \
kmod-pf8x00-regulator.ko \
kmod-pfr-telemetry.ko \
kmod-pfr-update.ko \
kmod-pfuze100-regulator.ko \
kmod-phantom.ko \
kmod-phonet.ko \
kmod-phram.ko \
kmod-phy-armada38x-comphy.ko \
kmod-phy-bcm-kona-usb2.ko \
kmod-phy-bcm-ns-usb2.ko \
kmod-phy-bcm-ns-usb3.ko \
kmod-phy-bcm-ns2-pcie.ko \
kmod-phy-bcm-ns2-usbdrd.ko \
kmod-phy-bcm-sr-pcie.ko \
kmod-phy-bcm-sr-usb.ko \
kmod-phy-berlin-sata.ko \
kmod-phy-berlin-usb.ko \
kmod-phy-brcm-sata.ko \
kmod-phy-brcm-usb-dvr.ko \
kmod-phy-cadence-salvo.ko \
kmod-phy-cadence-sierra.ko \
kmod-phy-cadence-torrent.ko \
kmod-phy-can-transceiver.ko \
kmod-phy-cpcap-usb.ko \
kmod-phy-exynos-dp-video.ko \
kmod-phy-exynos-mipi-video.ko \
kmod-phy-exynos-ufs.ko \
kmod-phy-fsl-imx8-mipi-dphy.ko \
kmod-phy-fsl-imx8m-pcie.ko \
kmod-phy-fsl-imx8mq-usb.ko \
kmod-phy-fsl-imx8qm-lvds-phy.ko \
kmod-phy-fsl-lynx-28g.ko \
kmod-phy-generic.ko \
kmod-phy-hi3660-usb3.ko \
kmod-phy-hi3670-pcie.ko \
kmod-phy-hi3670-usb3.ko \
kmod-phy-hi6220-usb.ko \
kmod-phy-hisi-inno-usb2.ko \
kmod-phy-histb-combphy.ko \
kmod-phy-intel-keembay-emmc.ko \
kmod-phy-intel-keembay-usb.ko \
kmod-phy-isp1301.ko \
kmod-phy-mapphone-mdm6600.ko \
kmod-phy-meson-axg-mipi-dphy.ko \
kmod-phy-meson-axg-mipi-pcie-analog.ko \
kmod-phy-meson-axg-pcie.ko \
kmod-phy-meson-g12a-mipi-dphy-analog.ko \
kmod-phy-meson-g12a-usb2.ko \
kmod-phy-meson-g12a-usb3-pcie.ko \
kmod-phy-meson-gxl-usb2.ko \
kmod-phy-meson8b-usb2.ko \
kmod-phy-mtk-dp.ko \
kmod-phy-mtk-hdmi-drv.ko \
kmod-phy-mtk-mipi-dsi-drv.ko \
kmod-phy-mtk-pcie.ko \
kmod-phy-mtk-tphy.ko \
kmod-phy-mtk-ufs.ko \
kmod-phy-mtk-xsphy.ko \
kmod-phy-mvebu-a3700-comphy.ko \
kmod-phy-mvebu-a3700-utmi.ko \
kmod-phy-mvebu-cp110-comphy.ko \
kmod-phy-mvebu-cp110-utmi.ko \
kmod-phy-mxs-usb.ko \
kmod-phy-ocelot-serdes.ko \
kmod-phy-pxa-28nm-hsic.ko \
kmod-phy-pxa-28nm-usb2.ko \
kmod-phy-qcom-apq8064-sata.ko \
kmod-phy-qcom-edp.ko \
kmod-phy-qcom-eusb2-repeater.ko \
kmod-phy-qcom-ipq806x-sata.ko \
kmod-phy-qcom-ipq806x-usb.ko \
kmod-phy-qcom-pcie2.ko \
kmod-phy-qcom-qmp-combo.ko \
kmod-phy-qcom-qmp-pcie-msm8996.ko \
kmod-phy-qcom-qmp-pcie.ko \
kmod-phy-qcom-qmp-ufs.ko \
kmod-phy-qcom-qmp-usb.ko \
kmod-phy-qcom-qusb2.ko \
kmod-phy-qcom-snps-eusb2.ko \
kmod-phy-qcom-snps-femto-v2.ko \
kmod-phy-qcom-usb-hs-28nm.ko \
kmod-phy-qcom-usb-hs.ko \
kmod-phy-qcom-usb-hsic.ko \
kmod-phy-qcom-usb-ss.ko \
kmod-phy-rcar-gen2.ko \
kmod-phy-rcar-gen3-pcie.ko \
kmod-phy-rcar-gen3-usb2.ko \
kmod-phy-rcar-gen3-usb3.ko \
kmod-phy-rockchip-dp.ko \
kmod-phy-rockchip-dphy-rx0.ko \
kmod-phy-rockchip-emmc.ko \
kmod-phy-rockchip-inno-csidphy.ko \
kmod-phy-rockchip-inno-dsidphy.ko \
kmod-phy-rockchip-inno-hdmi.ko \
kmod-phy-rockchip-inno-usb2.ko \
kmod-phy-rockchip-naneng-combphy.ko \
kmod-phy-rockchip-pcie.ko \
kmod-phy-rockchip-snps-pcie3.ko \
kmod-phy-rockchip-typec.ko \
kmod-phy-rockchip-usb.ko \
kmod-phy-sun4i-usb.ko \
kmod-phy-sun50i-usb3.ko \
kmod-phy-sun6i-mipi-dphy.ko \
kmod-phy-sun9i-usb.ko \
kmod-phy-tegra-usb.ko \
kmod-phy-tegra-xusb.ko \
kmod-phy-tegra194-p2u.ko \
kmod-phy-xgene.ko \
kmod-phy-zynqmp.ko \
kmod-phylink.ko \
kmod-physmap.ko \
kmod-pi3usb30532.ko \
kmod-pi433.ko \
kmod-pim4328.ko \
kmod-pinctrl-apple-gpio.ko \
kmod-pinctrl-axp209.ko \
kmod-pinctrl-bcm2835.ko \
kmod-pinctrl-bcm4908.ko \
kmod-pinctrl-cy8c95x0.ko \
kmod-pinctrl-imx.ko \
kmod-pinctrl-imx8dxl.ko \
kmod-pinctrl-imx8mm.ko \
kmod-pinctrl-imx8mn.ko \
kmod-pinctrl-imx8mp.ko \
kmod-pinctrl-imx8mq.ko \
kmod-pinctrl-imx8qm.ko \
kmod-pinctrl-imx8qxp.ko \
kmod-pinctrl-imx8ulp.ko \
kmod-pinctrl-imx93.ko \
kmod-pinctrl-ipq5332.ko \
kmod-pinctrl-ipq6018.ko \
kmod-pinctrl-ipq9574.ko \
kmod-pinctrl-keembay.ko \
kmod-pinctrl-lochnagar.ko \
kmod-pinctrl-lpass-lpi.ko \
kmod-pinctrl-madera.ko \
kmod-pinctrl-max77620.ko \
kmod-pinctrl-mcp23s08-i2c.ko \
kmod-pinctrl-mcp23s08-spi.ko \
kmod-pinctrl-mcp23s08.ko \
kmod-pinctrl-meson-a1.ko \
kmod-pinctrl-meson-axg-pmx.ko \
kmod-pinctrl-meson-axg.ko \
kmod-pinctrl-meson-g12a.ko \
kmod-pinctrl-meson-gxbb.ko \
kmod-pinctrl-meson-gxl.ko \
kmod-pinctrl-meson-s4.ko \
kmod-pinctrl-meson.ko \
kmod-pinctrl-meson8-pmx.ko \
kmod-pinctrl-mlxbf3.ko \
kmod-pinctrl-msm.ko \
kmod-pinctrl-msm8916.ko \
kmod-pinctrl-msm8953.ko \
kmod-pinctrl-msm8976.ko \
kmod-pinctrl-msm8998.ko \
kmod-pinctrl-mt6765.ko \
kmod-pinctrl-mt6779.ko \
kmod-pinctrl-mtk-common-v2.ko \
kmod-pinctrl-paris.ko \
kmod-pinctrl-qcm2290.ko \
kmod-pinctrl-qdf2xxx.ko \
kmod-pinctrl-qdu1000.ko \
kmod-pinctrl-rk805.ko \
kmod-pinctrl-rockchip.ko \
kmod-pinctrl-s32g2.ko \
kmod-pinctrl-sa8775p.ko \
kmod-pinctrl-sc7180.ko \
kmod-pinctrl-sc7280-lpass-lpi.ko \
kmod-pinctrl-sc7280.ko \
kmod-pinctrl-sc8180x.ko \
kmod-pinctrl-sc8280xp-lpass-lpi.ko \
kmod-pinctrl-sc8280xp.ko \
kmod-pinctrl-scu.ko \
kmod-pinctrl-sdm845.ko \
kmod-pinctrl-single.ko \
kmod-pinctrl-sm6115.ko \
kmod-pinctrl-sm6125.ko \
kmod-pinctrl-sm6350.ko \
kmod-pinctrl-sm7150.ko \
kmod-pinctrl-sm8150.ko \
kmod-pinctrl-sm8250-lpass-lpi.ko \
kmod-pinctrl-sm8250.ko \
kmod-pinctrl-sm8350.ko \
kmod-pinctrl-sm8450-lpass-lpi.ko \
kmod-pinctrl-sm8450.ko \
kmod-pinctrl-sm8550-lpass-lpi.ko \
kmod-pinctrl-sm8550.ko \
kmod-pinctrl-spmi-gpio.ko \
kmod-pinctrl-spmi-mpp.ko \
kmod-pinctrl-sprd-sc9860.ko \
kmod-pinctrl-sprd.ko \
kmod-pinctrl-ssbi-gpio.ko \
kmod-pinctrl-ssbi-mpp.ko \
kmod-pinctrl-stmfx.ko \
kmod-pinctrl-zynqmp.ko \
kmod-pinephone-keyboard.ko \
kmod-ping.ko \
kmod-pixcir-i2c-ts.ko \
kmod-pkcs7-message.ko \
kmod-pkcs8-key-parser.ko \
kmod-pktcdvd.ko \
kmod-pktgen.ko \
kmod-pl111-drm.ko \
kmod-pl172.ko \
kmod-pl2303.ko \
kmod-pl330.ko \
kmod-plat-nand.ko \
kmod-plat-ram.ko \
kmod-platform-lcd.ko \
kmod-platform-mhu.ko \
kmod-platform-profile.ko \
kmod-plfxlc.ko \
kmod-pli1209bc.ko \
kmod-plip.ko \
kmod-plusb.ko \
kmod-pluto2.ko \
kmod-plx-dma.ko \
kmod-plx-pci.ko \
kmod-pm-notifier-error-inject.ko \
kmod-pm6764tr.ko \
kmod-pm80xx.ko \
kmod-pm8916-wdt.ko \
kmod-pm8941-pwrkey.ko \
kmod-pm8xxx-vibrator.ko \
kmod-pmbus-core.ko \
kmod-pmbus.ko \
kmod-pmc551.ko \
kmod-pmcraid.ko \
kmod-pmic-glink-altmode.ko \
kmod-pmic-glink.ko \
kmod-pms7003.ko \
kmod-pn-pep.ko \
kmod-pn532-uart.ko \
kmod-pn533-i2c.ko \
kmod-pn533-usb.ko \
kmod-pn533.ko \
kmod-pn544-i2c.ko \
kmod-pn544.ko \
kmod-poly1305-generic.ko \
kmod-poly1305-neon.ko \
kmod-polynomial.ko \
kmod-polyval-ce.ko \
kmod-polyval-generic.ko \
kmod-port100.ko \
kmod-powermate.ko \
kmod-powr1220.ko \
kmod-ppa.ko \
kmod-ppdev.ko \
kmod-ppp-async.ko \
kmod-ppp-deflate.ko \
kmod-ppp-generic.ko \
kmod-ppp-mppe.ko \
kmod-ppp-synctty.ko \
kmod-pppoatm.ko \
kmod-pppoe.ko \
kmod-pppox.ko \
kmod-pps-core.ko \
kmod-pps-gpio.ko \
kmod-pps-ldisc.ko \
kmod-pps-parport.ko \
kmod-pptp.ko \
kmod-prestera-pci.ko \
kmod-prestera.ko \
kmod-pretimeout-noop.ko \
kmod-pretimeout-panic.ko \
kmod-prism2-usb.ko \
kmod-processor.ko \
kmod-ps2-gpio.ko \
kmod-ps2mult.ko \
kmod-psample.ko \
kmod-pse-regulator.ko \
kmod-psmouse.ko \
kmod-psnap.ko \
kmod-pstore-blk.ko \
kmod-pstore-zone.ko \
kmod-pstore.ko \
kmod-psxpad-spi.ko \
kmod-ptp-clockmatrix.ko \
kmod-ptp-dfl-tod.ko \
kmod-ptp-dte.ko \
kmod-ptp-idt82p33.ko \
kmod-ptp-kvm.ko \
kmod-ptp-ocp.ko \
kmod-ptp-qoriq.ko \
kmod-ptp.ko \
kmod-public-key.ko \
kmod-pulse8-cec.ko \
kmod-pulsedlight-lidar-lite-v2.ko \
kmod-pvpanic-mmio.ko \
kmod-pvpanic-pci.ko \
kmod-pvpanic.ko \
kmod-pvrusb2.ko \
kmod-pwc-rzv2m.ko \
kmod-pwc.ko \
kmod-pwm-apple.ko \
kmod-pwm-atmel-hlcdc.ko \
kmod-pwm-atmel-tcb.ko \
kmod-pwm-bcm-iproc.ko \
kmod-pwm-bcm2835.ko \
kmod-pwm-beeper.ko \
kmod-pwm-berlin.ko \
kmod-pwm-bl.ko \
kmod-pwm-brcmstb.ko \
kmod-pwm-clk.ko \
kmod-pwm-cros-ec.ko \
kmod-pwm-dwc.ko \
kmod-pwm-fan.ko \
kmod-pwm-hibvt.ko \
kmod-pwm-imx-tpm.ko \
kmod-pwm-iqs620a.ko \
kmod-pwm-ir-tx.ko \
kmod-pwm-keembay.ko \
kmod-pwm-lp3943.ko \
kmod-pwm-mediatek.ko \
kmod-pwm-meson.ko \
kmod-pwm-mtk-disp.ko \
kmod-pwm-raspberrypi-poe.ko \
kmod-pwm-rcar.ko \
kmod-pwm-regulator.ko \
kmod-pwm-renesas-tpu.ko \
kmod-pwm-rockchip.ko \
kmod-pwm-samsung.ko \
kmod-pwm-sprd.ko \
kmod-pwm-sun4i.ko \
kmod-pwm-tegra.ko \
kmod-pwm-vibra.ko \
kmod-pwm-visconti.ko \
kmod-pwm-xilinx.ko \
kmod-pwr-mlxbf.ko \
kmod-pwrseq-emmc.ko \
kmod-pwrseq-sd8787.ko \
kmod-pwrseq-simple.ko \
kmod-pxe1610.ko \
kmod-pxrc.ko \
kmod-q54sj108a2.ko \
kmod-q6adm.ko \
kmod-q6afe-clocks.ko \
kmod-q6afe-dai.ko \
kmod-q6afe.ko \
kmod-q6apm-dai.ko \
kmod-q6apm-lpass-dais.ko \
kmod-q6asm-dai.ko \
kmod-q6asm.ko \
kmod-q6core.ko \
kmod-q6prm-clocks.ko \
kmod-q6prm.ko \
kmod-q6routing.ko \
kmod-q6sstop-qcs404.ko \
kmod-qaic.ko \
kmod-qat-4xxx.ko \
kmod-qat-c3xxx.ko \
kmod-qat-c3xxxvf.ko \
kmod-qat-c62x.ko \
kmod-qat-c62xvf.ko \
kmod-qat-dh895xcc.ko \
kmod-qat-dh895xccvf.ko \
kmod-qca-7k-common.ko \
kmod-qca8k.ko \
kmod-qcaspi.ko \
kmod-qcauart.ko \
kmod-qcaux.ko \
kmod-qcom-aoss.ko \
kmod-qcom-apcs-ipc-mailbox.ko \
kmod-qcom-bam-dmux.ko \
kmod-qcom-battmgr.ko \
kmod-qcom-camss.ko \
kmod-qcom-common.ko \
kmod-qcom-cpufreq-hw.ko \
kmod-qcom-cpufreq-nvmem.ko \
kmod-qcom-edac.ko \
kmod-qcom-emac.ko \
kmod-qcom-eud.ko \
kmod-qcom-geni-se.ko \
kmod-qcom-geni-serial.ko \
kmod-qcom-glink-rpm.ko \
kmod-qcom-glink-smem.ko \
kmod-qcom-glink.ko \
kmod-qcom-gsbi.ko \
kmod-qcom-hwspinlock.ko \
kmod-qcom-ipcc.ko \
kmod-qcom-labibb-regulator.ko \
kmod-qcom-nandc.ko \
kmod-qcom-pdc.ko \
kmod-qcom-pil-info.ko \
kmod-qcom-pm8008.ko \
kmod-qcom-pmic-typec.ko \
kmod-qcom-pon.ko \
kmod-qcom-q6v5-adsp.ko \
kmod-qcom-q6v5-mss.ko \
kmod-qcom-q6v5-pas.ko \
kmod-qcom-q6v5-wcss.ko \
kmod-qcom-q6v5.ko \
kmod-qcom-rng.ko \
kmod-qcom-rpm-regulator.ko \
kmod-qcom-rpm.ko \
kmod-qcom-rpmh-regulator.ko \
kmod-qcom-rpmh.ko \
kmod-qcom-scm.ko \
kmod-qcom-smbb.ko \
kmod-qcom-smd-regulator.ko \
kmod-qcom-smd.ko \
kmod-qcom-spmi-adc-tm5.ko \
kmod-qcom-spmi-adc5.ko \
kmod-qcom-spmi-pmic.ko \
kmod-qcom-spmi-regulator.ko \
kmod-qcom-spmi-rradc.ko \
kmod-qcom-stats.ko \
kmod-qcom-sysmon.ko \
kmod-qcom-tsens.ko \
kmod-qcom-usb-vbus-regulator.ko \
kmod-qcom-vadc-common.ko \
kmod-qcom-wled.ko \
kmod-qcomsmempart.ko \
kmod-qcrypto.ko \
kmod-qcserial.ko \
kmod-qed.ko \
kmod-qede.ko \
kmod-qedf.ko \
kmod-qedi.ko \
kmod-qedr.ko \
kmod-qemu-fw-cfg.ko \
kmod-qinfo-probe.ko \
kmod-qla1280.ko \
kmod-qla2xxx.ko \
kmod-qla3xxx.ko \
kmod-qla4xxx.ko \
kmod-qlcnic.ko \
kmod-qlge.ko \
kmod-qm1d1b0004.ko \
kmod-qm1d1c0042.ko \
kmod-qmi-helpers.ko \
kmod-qmi-wwan.ko \
kmod-qnoc-msm8916.ko \
kmod-qnoc-msm8939.ko \
kmod-qnoc-msm8974.ko \
kmod-qnoc-msm8996.ko \
kmod-qnoc-qcm2290.ko \
kmod-qnoc-qcs404.ko \
kmod-qnoc-qdu1000.ko \
kmod-qnoc-sa8775p.ko \
kmod-qnoc-sc7180.ko \
kmod-qnoc-sc7280.ko \
kmod-qnoc-sc8180x.ko \
kmod-qnoc-sc8280xp.ko \
kmod-qnoc-sdm660.ko \
kmod-qnoc-sdm670.ko \
kmod-qnoc-sdm845.ko \
kmod-qnoc-sdx55.ko \
kmod-qnoc-sdx65.ko \
kmod-qnoc-sm6350.ko \
kmod-qnoc-sm8150.ko \
kmod-qnoc-sm8250.ko \
kmod-qnoc-sm8350.ko \
kmod-qnoc-sm8450.ko \
kmod-qnoc-sm8550.ko \
kmod-qnx4.ko \
kmod-qnx6.ko \
kmod-qoriq-cpufreq.ko \
kmod-qoriq-thermal.ko \
kmod-qrtr-mhi.ko \
kmod-qrtr-smd.ko \
kmod-qrtr-tun.ko \
kmod-qrtr.ko \
kmod-qsemi.ko \
kmod-qt1010.ko \
kmod-qt1050.ko \
kmod-qt1070.ko \
kmod-qt2160.ko \
kmod-qtnfmac-pcie.ko \
kmod-qtnfmac.ko \
kmod-quatech2.ko \
kmod-quota-tree.ko \
kmod-quota-v1.ko \
kmod-quota-v2.ko \
kmod-qwiic-joystick.ko \
kmod-qxl.ko \
kmod-r592.ko \
kmod-r6040.ko \
kmod-r8152.ko \
kmod-r8153-ecm.ko \
kmod-r8169.ko \
kmod-r8192e-pci.ko \
kmod-r8192u-usb.ko \
kmod-r820t.ko \
kmod-r852.ko \
kmod-r8712u.ko \
kmod-r8723bs.ko \
kmod-r8a66597-hcd.ko \
kmod-r8a779f0-ether-serdes.ko \
kmod-radeon.ko \
kmod-radio-keene.ko \
kmod-radio-ma901.ko \
kmod-radio-maxiradio.ko \
kmod-radio-mr800.ko \
kmod-radio-platform-si4713.ko \
kmod-radio-raremono.ko \
kmod-radio-shark.ko \
kmod-radio-si470x-common.ko \
kmod-radio-si470x-usb.ko \
kmod-radio-tea5764.ko \
kmod-radio-usb-si4713.ko \
kmod-radio-wl1273.ko \
kmod-raid-class.ko \
kmod-raid0.ko \
kmod-raid1.ko \
kmod-raid10.ko \
kmod-raid456.ko \
kmod-raid6-pq.ko \
kmod-raid6test.ko \
kmod-rainshadow-cec.ko \
kmod-ramoops.ko \
kmod-ramp-controller.ko \
kmod-rapidio.ko \
kmod-raspberrypi-cpufreq.ko \
kmod-raspberrypi-hwmon.ko \
kmod-raspberrypi-ts.ko \
kmod-raspberrypi.ko \
kmod-rational.ko \
kmod-ravb.ko \
kmod-raw-diag.ko \
kmod-raw-gadget.ko \
kmod-raydium-i2c-ts.ko \
kmod-rbd.ko \
kmod-rbtree-test.ko \
kmod-rc-adstech-dvb-t-pci.ko \
kmod-rc-alink-dtu-m.ko \
kmod-rc-anysee.ko \
kmod-rc-apac-viewcomp.ko \
kmod-rc-astrometa-t2hybrid.ko \
kmod-rc-asus-pc39.ko \
kmod-rc-asus-ps3-100.ko \
kmod-rc-ati-tv-wonder-hd-600.ko \
kmod-rc-ati-x10.ko \
kmod-rc-avermedia-a16d.ko \
kmod-rc-avermedia-cardbus.ko \
kmod-rc-avermedia-dvbt.ko \
kmod-rc-avermedia-m135a.ko \
kmod-rc-avermedia-m733a-rm-k6.ko \
kmod-rc-avermedia-rm-ks.ko \
kmod-rc-avermedia.ko \
kmod-rc-avertv-303.ko \
kmod-rc-azurewave-ad-tu700.ko \
kmod-rc-beelink-gs1.ko \
kmod-rc-beelink-mxiii.ko \
kmod-rc-behold-columbus.ko \
kmod-rc-behold.ko \
kmod-rc-budget-ci-old.ko \
kmod-rc-cinergy-1400.ko \
kmod-rc-cinergy.ko \
kmod-rc-core.ko \
kmod-rc-ct-90405.ko \
kmod-rc-d680-dmb.ko \
kmod-rc-delock-61959.ko \
kmod-rc-dib0700-nec.ko \
kmod-rc-dib0700-rc5.ko \
kmod-rc-digitalnow-tinytwin.ko \
kmod-rc-digittrade.ko \
kmod-rc-dm1105-nec.ko \
kmod-rc-dntv-live-dvb-t.ko \
kmod-rc-dntv-live-dvbt-pro.ko \
kmod-rc-dreambox.ko \
kmod-rc-dtt200u.ko \
kmod-rc-dvbsky.ko \
kmod-rc-dvico-mce.ko \
kmod-rc-dvico-portable.ko \
kmod-rc-em-terratec.ko \
kmod-rc-encore-enltv-fm53.ko \
kmod-rc-encore-enltv.ko \
kmod-rc-encore-enltv2.ko \
kmod-rc-evga-indtube.ko \
kmod-rc-eztv.ko \
kmod-rc-flydvb.ko \
kmod-rc-flyvideo.ko \
kmod-rc-fusionhdtv-mce.ko \
kmod-rc-gadmei-rm008z.ko \
kmod-rc-geekbox.ko \
kmod-rc-genius-tvgo-a11mce.ko \
kmod-rc-gotview7135.ko \
kmod-rc-hauppauge.ko \
kmod-rc-hisi-poplar.ko \
kmod-rc-hisi-tv-demo.ko \
kmod-rc-imon-mce.ko \
kmod-rc-imon-pad.ko \
kmod-rc-imon-rsc.ko \
kmod-rc-iodata-bctv7e.ko \
kmod-rc-it913x-v1.ko \
kmod-rc-it913x-v2.ko \
kmod-rc-kaiomy.ko \
kmod-rc-khadas.ko \
kmod-rc-khamsin.ko \
kmod-rc-kworld-315u.ko \
kmod-rc-kworld-pc150u.ko \
kmod-rc-kworld-plus-tv-analog.ko \
kmod-rc-leadtek-y04g0051.ko \
kmod-rc-lme2510.ko \
kmod-rc-loopback.ko \
kmod-rc-manli.ko \
kmod-rc-mecool-kii-pro.ko \
kmod-rc-mecool-kiii-pro.ko \
kmod-rc-medion-x10-digitainer.ko \
kmod-rc-medion-x10-or2x.ko \
kmod-rc-medion-x10.ko \
kmod-rc-minix-neo.ko \
kmod-rc-msi-digivox-ii.ko \
kmod-rc-msi-digivox-iii.ko \
kmod-rc-msi-tvanywhere-plus.ko \
kmod-rc-msi-tvanywhere.ko \
kmod-rc-nebula.ko \
kmod-rc-nec-terratec-cinergy-xs.ko \
kmod-rc-norwood.ko \
kmod-rc-npgtech.ko \
kmod-rc-odroid.ko \
kmod-rc-pctv-sedna.ko \
kmod-rc-pine64.ko \
kmod-rc-pinnacle-color.ko \
kmod-rc-pinnacle-grey.ko \
kmod-rc-pinnacle-pctv-hd.ko \
kmod-rc-pixelview-002t.ko \
kmod-rc-pixelview-mk12.ko \
kmod-rc-pixelview-new.ko \
kmod-rc-pixelview.ko \
kmod-rc-powercolor-real-angel.ko \
kmod-rc-proteus-2309.ko \
kmod-rc-purpletv.ko \
kmod-rc-pv951.ko \
kmod-rc-rc6-mce.ko \
kmod-rc-real-audio-220-32-keys.ko \
kmod-rc-reddo.ko \
kmod-rc-snapstream-firefly.ko \
kmod-rc-streamzap.ko \
kmod-rc-su3000.ko \
kmod-rc-tanix-tx3mini.ko \
kmod-rc-tanix-tx5max.ko \
kmod-rc-tbs-nec.ko \
kmod-rc-technisat-ts35.ko \
kmod-rc-technisat-usb2.ko \
kmod-rc-terratec-cinergy-c-pci.ko \
kmod-rc-terratec-cinergy-s2-hd.ko \
kmod-rc-terratec-cinergy-xs.ko \
kmod-rc-terratec-slim-2.ko \
kmod-rc-terratec-slim.ko \
kmod-rc-tevii-nec.ko \
kmod-rc-tivo.ko \
kmod-rc-total-media-in-hand-02.ko \
kmod-rc-total-media-in-hand.ko \
kmod-rc-trekstor.ko \
kmod-rc-tt-1500.ko \
kmod-rc-twinhan-dtv-cab-ci.ko \
kmod-rc-twinhan1027.ko \
kmod-rc-vega-s9x.ko \
kmod-rc-videomate-m1f.ko \
kmod-rc-videomate-s350.ko \
kmod-rc-videomate-tv-pvr.ko \
kmod-rc-videostrong-kii-pro.ko \
kmod-rc-wetek-hub.ko \
kmod-rc-wetek-play2.ko \
kmod-rc-winfast-usbii-deluxe.ko \
kmod-rc-winfast.ko \
kmod-rc-x96max.ko \
kmod-rc-xbox-360.ko \
kmod-rc-xbox-dvd.ko \
kmod-rc-zx-irdec.ko \
kmod-rcar-can.ko \
kmod-rcar-canfd.ko \
kmod-rcar-cmm.ko \
kmod-rcar-csi2.ko \
kmod-rcar-dmac.ko \
kmod-rcar-drif.ko \
kmod-rcar-du-drm.ko \
kmod-rcar-dw-hdmi.ko \
kmod-rcar-fcp.ko \
kmod-rcar-fdp1.ko \
kmod-rcar-gen3-thermal.ko \
kmod-rcar-isp.ko \
kmod-rcar-jpu.ko \
kmod-rcar-lvds.ko \
kmod-rcar-mipi-dsi.ko \
kmod-rcar-rproc.ko \
kmod-rcar-thermal.ko \
kmod-rcar-vin.ko \
kmod-rcuscale.ko \
kmod-rcutorture.ko \
kmod-rdacm20.ko \
kmod-rdacm21.ko \
kmod-rdma-cm.ko \
kmod-rdma-rxe.ko \
kmod-rdma-ucm.ko \
kmod-rds-rdma.ko \
kmod-rds-tcp.ko \
kmod-rds.ko \
kmod-realtek-mdio.ko \
kmod-realtek-smi.ko \
kmod-realtek.ko \
kmod-reboot-mode.ko \
kmod-redboot.ko \
kmod-redrat3.ko \
kmod-reed-solomon.ko \
kmod-regmap-i2c.ko \
kmod-regmap-i3c.ko \
kmod-regmap-mmio.ko \
kmod-regmap-sccb.ko \
kmod-regmap-sdw-mbq.ko \
kmod-regmap-sdw.ko \
kmod-regmap-slimbus.ko \
kmod-regmap-spi.ko \
kmod-regmap-spmi.ko \
kmod-regmap-w1.ko \
kmod-regulator-haptic.ko \
kmod-renesas-nand-controller.ko \
kmod-renesas-rpc-if.ko \
kmod-renesas-sdhi-core.ko \
kmod-renesas-sdhi-internal-dmac.ko \
kmod-renesas-usb3.ko \
kmod-renesas-usbf.ko \
kmod-renesas-usbhs.ko \
kmod-renesas-wdt.ko \
kmod-repaper.ko \
kmod-reset-a10sr.ko \
kmod-reset-berlin.ko \
kmod-reset-brcmstb-rescal.ko \
kmod-reset-brcmstb.ko \
kmod-reset-hi3660.ko \
kmod-reset-imx7.ko \
kmod-reset-meson-audio-arb.ko \
kmod-reset-meson.ko \
kmod-reset-qcom-aoss.ko \
kmod-reset-qcom-pdc.ko \
kmod-reset-raspberrypi.ko \
kmod-reset-rzg2l-usbphy-ctrl.ko \
kmod-reset-scmi.ko \
kmod-reset-ti-syscon.ko \
kmod-reset.ko \
kmod-resistive-adc-touch.ko \
kmod-rfcomm.ko \
kmod-rfd-ftl.ko \
kmod-rfd77402.ko \
kmod-rfkill-gpio.ko \
kmod-rfkill.ko \
kmod-ring-buffer-benchmark.ko \
kmod-rio-cm.ko \
kmod-rio-mport-cdev.ko \
kmod-rio-scan.ko \
kmod-rionet.ko \
kmod-rj54n1cb0c.ko \
kmod-rk-crypto.ko \
kmod-rk3399-dmc.ko \
kmod-rk805-pwrkey.ko \
kmod-rk808-regulator.ko \
kmod-rk808.ko \
kmod-rk817-charger.ko \
kmod-rm3100-core.ko \
kmod-rm3100-i2c.ko \
kmod-rm3100-spi.ko \
kmod-rmd160.ko \
kmod-rmi-core.ko \
kmod-rmi-i2c.ko \
kmod-rmi-smbus.ko \
kmod-rmi-spi.ko \
kmod-rmnet.ko \
kmod-rmtfs-mem.ko \
kmod-rnbd-client.ko \
kmod-rnbd-server.ko \
kmod-rndis-host.ko \
kmod-rndis-wlan.ko \
kmod-rng-core.ko \
kmod-rng.ko \
kmod-rockchip-dfi.ko \
kmod-rockchip-isp1.ko \
kmod-rockchip-nand-controller.ko \
kmod-rockchip-rga.ko \
kmod-rockchip-thermal.ko \
kmod-rockchip-vdec.ko \
kmod-rockchip.ko \
kmod-rockchipdrm.ko \
kmod-rocker.ko \
kmod-rohm-bd71828.ko \
kmod-rohm-bd718x7.ko \
kmod-rohm-bd9576.ko \
kmod-rohm-bu21023.ko \
kmod-rohm-regulator.ko \
kmod-roles.ko \
kmod-romfs.ko \
kmod-rose.ko \
kmod-rotary-encoder.ko \
kmod-rp2.ko \
kmod-rpcrdma.ko \
kmod-rpcsec-gss-krb5.ko \
kmod-rpi-panel-attiny-regulator.ko \
kmod-rpmhpd.ko \
kmod-rpmpd.ko \
kmod-rpmsg-char.ko \
kmod-rpmsg-core.ko \
kmod-rpmsg-ctrl.ko \
kmod-rpmsg-ns.ko \
kmod-rpmsg-tty.ko \
kmod-rpmsg-wwan-ctrl.ko \
kmod-rpr0521.ko \
kmod-rrunner.ko \
kmod-rsa-generic.ko \
kmod-rsi-91x.ko \
kmod-rsi-sdio.ko \
kmod-rsi-usb.ko \
kmod-rswitch-drv.ko \
kmod-rt1719.ko \
kmod-rt2400pci.ko \
kmod-rt2500pci.ko \
kmod-rt2500usb.ko \
kmod-rt2800lib.ko \
kmod-rt2800mmio.ko \
kmod-rt2800pci.ko \
kmod-rt2800usb.ko \
kmod-rt2x00lib.ko \
kmod-rt2x00mmio.ko \
kmod-rt2x00pci.ko \
kmod-rt2x00usb.ko \
kmod-rt4801-regulator.ko \
kmod-rt4803.ko \
kmod-rt4831-backlight.ko \
kmod-rt4831-regulator.ko \
kmod-rt4831.ko \
kmod-rt5033-battery.ko \
kmod-rt5190a-regulator.ko \
kmod-rt5739.ko \
kmod-rt5759-regulator.ko \
kmod-rt6160-regulator.ko \
kmod-rt6190-regulator.ko \
kmod-rt61pci.ko \
kmod-rt6245-regulator.ko \
kmod-rt73usb.ko \
kmod-rt9455-charger.ko \
kmod-rt9467-charger.ko \
kmod-rt9471.ko \
kmod-rtc-ab-b5ze-s3.ko \
kmod-rtc-ab-eoz9.ko \
kmod-rtc-abx80x.ko \
kmod-rtc-ac100.ko \
kmod-rtc-armada38x.ko \
kmod-rtc-bd70528.ko \
kmod-rtc-brcmstb-waketimer.ko \
kmod-rtc-cadence.ko \
kmod-rtc-cpcap.ko \
kmod-rtc-cros-ec.ko \
kmod-rtc-ds1307.ko \
kmod-rtc-ds1374.ko \
kmod-rtc-ds1672.ko \
kmod-rtc-ds1685.ko \
kmod-rtc-ds3232.ko \
kmod-rtc-efi.ko \
kmod-rtc-fm3130.ko \
kmod-rtc-fsl-ftm-alarm.ko \
kmod-rtc-ftrtc010.ko \
kmod-rtc-goldfish.ko \
kmod-rtc-hid-sensor-time.ko \
kmod-rtc-imx-sc.ko \
kmod-rtc-imxdi.ko \
kmod-rtc-isl12026.ko \
kmod-rtc-isl1208.ko \
kmod-rtc-m41t80.ko \
kmod-rtc-max6900.ko \
kmod-rtc-max6916.ko \
kmod-rtc-max77686.ko \
kmod-rtc-meson-vrtc.ko \
kmod-rtc-mt2712.ko \
kmod-rtc-mt7622.ko \
kmod-rtc-mv.ko \
kmod-rtc-mxc-v2.ko \
kmod-rtc-mxc.ko \
kmod-rtc-nct3018y.ko \
kmod-rtc-nxp-bbnsm.ko \
kmod-rtc-optee.ko \
kmod-rtc-pcf2127.ko \
kmod-rtc-pcf85063.ko \
kmod-rtc-pcf8523.ko \
kmod-rtc-pcf85363.ko \
kmod-rtc-pcf8563.ko \
kmod-rtc-pcf8583.ko \
kmod-rtc-pl030.ko \
kmod-rtc-pl031.ko \
kmod-rtc-pm8xxx.ko \
kmod-rtc-r7301.ko \
kmod-rtc-rk808.ko \
kmod-rtc-rs5c372.ko \
kmod-rtc-rv3028.ko \
kmod-rtc-rv3032.ko \
kmod-rtc-rv8803.ko \
kmod-rtc-rx8010.ko \
kmod-rtc-rx8025.ko \
kmod-rtc-s35390a.ko \
kmod-rtc-s3c.ko \
kmod-rtc-sc27xx.ko \
kmod-rtc-sd3078.ko \
kmod-rtc-sh.ko \
kmod-rtc-tegra.ko \
kmod-rtc-x1205.ko \
kmod-rtc-xgene.ko \
kmod-rtc-zynqmp.ko \
kmod-rtl-pci.ko \
kmod-rtl-usb.ko \
kmod-rtl2830.ko \
kmod-rtl2832-sdr.ko \
kmod-rtl2832.ko \
kmod-rtl8150.ko \
kmod-rtl8187.ko \
kmod-rtl8188ee.ko \
kmod-rtl818x-pci.ko \
kmod-rtl8192c-common.ko \
kmod-rtl8192ce.ko \
kmod-rtl8192cu.ko \
kmod-rtl8192de.ko \
kmod-rtl8192ee.ko \
kmod-rtl8192se.ko \
kmod-rtl8365mb.ko \
kmod-rtl8366.ko \
kmod-rtl8723-common.ko \
kmod-rtl8723ae.ko \
kmod-rtl8723be.ko \
kmod-rtl8821ae.ko \
kmod-rtl8xxxu.ko \
kmod-rtllib-crypt-ccmp.ko \
kmod-rtllib-crypt-tkip.ko \
kmod-rtllib-crypt-wep.ko \
kmod-rtllib.ko \
kmod-rtlwifi.ko \
kmod-rtmv20-regulator.ko \
kmod-rtq2134-regulator.ko \
kmod-rtq6752-regulator.ko \
kmod-rtrs-client.ko \
kmod-rtrs-core.ko \
kmod-rtrs-server.ko \
kmod-rts5208.ko \
kmod-rtsx-pci-ms.ko \
kmod-rtsx-pci-sdmmc.ko \
kmod-rtsx-pci.ko \
kmod-rtsx-usb-ms.ko \
kmod-rtsx-usb-sdmmc.ko \
kmod-rtsx-usb.ko \
kmod-rtw88-8723d.ko \
kmod-rtw88-8723de.ko \
kmod-rtw88-8723du.ko \
kmod-rtw88-8821c.ko \
kmod-rtw88-8821ce.ko \
kmod-rtw88-8821cs.ko \
kmod-rtw88-8821cu.ko \
kmod-rtw88-8822b.ko \
kmod-rtw88-8822be.ko \
kmod-rtw88-8822bs.ko \
kmod-rtw88-8822bu.ko \
kmod-rtw88-8822c.ko \
kmod-rtw88-8822ce.ko \
kmod-rtw88-8822cs.ko \
kmod-rtw88-8822cu.ko \
kmod-rtw88-core.ko \
kmod-rtw88-pci.ko \
kmod-rtw88-sdio.ko \
kmod-rtw88-usb.ko \
kmod-rtw89-8852a.ko \
kmod-rtw89-8852ae.ko \
kmod-rtw89-8852b.ko \
kmod-rtw89-8852be.ko \
kmod-rtw89-8852c.ko \
kmod-rtw89-8852ce.ko \
kmod-rtw89-core.ko \
kmod-rtw89-pci.ko \
kmod-rvu-af.ko \
kmod-rvu-cptcommon.ko \
kmod-rvu-cptpf.ko \
kmod-rvu-cptvf.ko \
kmod-rvu-mbox.ko \
kmod-rvu-nicpf.ko \
kmod-rvu-nicvf.ko \
kmod-rxperf.ko \
kmod-rxrpc.ko \
kmod-rz-dmac.ko \
kmod-rza-wdt.ko \
kmod-rzg2l-adc.ko \
kmod-rzg2l-thermal.ko \
kmod-rzg2l-wdt.ko \
kmod-rzn1-wdt.ko \
kmod-rzv2m-usb3drd.ko \
kmod-s2250.ko \
kmod-s2255drv.ko \
kmod-s2io.ko \
kmod-s3c2410-wdt.ko \
kmod-s3fwrn5-i2c.ko \
kmod-s3fwrn5.ko \
kmod-s3fwrn82-uart.ko \
kmod-s5c73m3.ko \
kmod-s5h1409.ko \
kmod-s5h1411.ko \
kmod-s5h1420.ko \
kmod-s5h1432.ko \
kmod-s5k5baf.ko \
kmod-s5k6a3.ko \
kmod-s5p-cec.ko \
kmod-s5p-g2d.ko \
kmod-s5p-jpeg.ko \
kmod-s5p-mfc.ko \
kmod-s5p-sss.ko \
kmod-s6sy761.ko \
kmod-s921.ko \
kmod-saa6588.ko \
kmod-saa6752hs.ko \
kmod-saa7110.ko \
kmod-saa7115.ko \
kmod-saa7127.ko \
kmod-saa7134-alsa.ko \
kmod-saa7134-dvb.ko \
kmod-saa7134-empress.ko \
kmod-saa7134-go7007.ko \
kmod-saa7134.ko \
kmod-saa7146-vv.ko \
kmod-saa7146.ko \
kmod-saa7164.ko \
kmod-saa717x.ko \
kmod-saa7185.ko \
kmod-saa7706h.ko \
kmod-safe-serial.ko \
kmod-sahara.ko \
kmod-samsung-sxgbe.ko \
kmod-samsung-tty.ko \
kmod-sata-dwc-460ex.ko \
kmod-sata-inic162x.ko \
kmod-sata-mv.ko \
kmod-sata-nv.ko \
kmod-sata-promise.ko \
kmod-sata-qstor.ko \
kmod-sata-rcar.ko \
kmod-sata-sil.ko \
kmod-sata-sil24.ko \
kmod-sata-sis.ko \
kmod-sata-svw.ko \
kmod-sata-sx4.ko \
kmod-sata-uli.ko \
kmod-sata-via.ko \
kmod-sata-vsc.ko \
kmod-sbp-target.ko \
kmod-sbrmi.ko \
kmod-sbs-battery.ko \
kmod-sbs-charger.ko \
kmod-sbs-manager.ko \
kmod-sbsa-gwdt.ko \
kmod-sbtsi-temp.ko \
kmod-sc16is7xx.ko \
kmod-sc2731-charger.ko \
kmod-sc2731-regulator.ko \
kmod-sc27xx-adc.ko \
kmod-sc27xx-fuel-gauge.ko \
kmod-sc27xx-poweroff.ko \
kmod-sc27xx-vibra.ko \
kmod-sc92031.ko \
kmod-sc9860-clk.ko \
kmod-sc9863a-clk.ko \
kmod-sca3300.ko \
kmod-scd30-core.ko \
kmod-scd30-i2c.ko \
kmod-scd30-serial.ko \
kmod-scd4x.ko \
kmod-sch-cake.ko \
kmod-sch-cbs.ko \
kmod-sch-choke.ko \
kmod-sch-codel.ko \
kmod-sch-drr.ko \
kmod-sch-etf.ko \
kmod-sch-ets.ko \
kmod-sch-fq-codel.ko \
kmod-sch-fq-pie.ko \
kmod-sch-fq.ko \
kmod-sch-gred.ko \
kmod-sch-hfsc.ko \
kmod-sch-hhf.ko \
kmod-sch-htb.ko \
kmod-sch-ingress.ko \
kmod-sch-mqprio-lib.ko \
kmod-sch-mqprio.ko \
kmod-sch-multiq.ko \
kmod-sch-netem.ko \
kmod-sch-pie.ko \
kmod-sch-plug.ko \
kmod-sch-prio.ko \
kmod-sch-qfq.ko \
kmod-sch-red.ko \
kmod-sch-sfb.ko \
kmod-sch-sfq.ko \
kmod-sch-skbprio.ko \
kmod-sch-taprio.ko \
kmod-sch-tbf.ko \
kmod-sch-teql.ko \
kmod-sch5627.ko \
kmod-sch5636.ko \
kmod-sch56xx-common.ko \
kmod-sclk-div.ko \
kmod-scmi-core.ko \
kmod-scmi-cpufreq.ko \
kmod-scmi-hwmon.ko \
kmod-scmi-iio.ko \
kmod-scmi-module.ko \
kmod-scmi-pm-domain.ko \
kmod-scmi-power-control.ko \
kmod-scmi-regulator.ko \
kmod-scpi-cpufreq.ko \
kmod-scpi-hwmon.ko \
kmod-scpi-pm-domain.ko \
kmod-scsi-common.ko \
kmod-scsi-debug.ko \
kmod-scsi-dh-alua.ko \
kmod-scsi-dh-emc.ko \
kmod-scsi-dh-hp-sw.ko \
kmod-scsi-dh-rdac.ko \
kmod-scsi-mod.ko \
kmod-scsi-transport-fc.ko \
kmod-scsi-transport-iscsi.ko \
kmod-scsi-transport-sas.ko \
kmod-scsi-transport-spi.ko \
kmod-scsi-transport-srp.ko \
kmod-sctp-diag.ko \
kmod-sctp.ko \
kmod-scu-pd.ko \
kmod-sd-mod.ko \
kmod-sdhci-acpi.ko \
kmod-sdhci-am654.ko \
kmod-sdhci-brcmstb.ko \
kmod-sdhci-cadence.ko \
kmod-sdhci-esdhc-imx.ko \
kmod-sdhci-f-sdh30.ko \
kmod-sdhci-iproc.ko \
kmod-sdhci-msm.ko \
kmod-sdhci-of-arasan.ko \
kmod-sdhci-of-dwcmshc.ko \
kmod-sdhci-of-esdhc.ko \
kmod-sdhci-of-sparx5.ko \
kmod-sdhci-pci.ko \
kmod-sdhci-pltfm.ko \
kmod-sdhci-pxav3.ko \
kmod-sdhci-s3c.ko \
kmod-sdhci-sprd.ko \
kmod-sdhci-tegra.ko \
kmod-sdhci-xenon-driver.ko \
kmod-sdhci.ko \
kmod-sdio-uart.ko \
kmod-selftests.ko \
kmod-sensehat-joystick.ko \
kmod-seqiv.ko \
kmod-serdev.ko \
kmod-serial-core.ko \
kmod-serial-ir.ko \
kmod-serial-mctrl-gpio.ko \
kmod-serial-tegra.ko \
kmod-serio-raw.ko \
kmod-serio.ko \
kmod-sermouse.ko \
kmod-serpent-generic.ko \
kmod-serport.ko \
kmod-ses.ko \
kmod-sfc-falcon.ko \
kmod-sfc-siena.ko \
kmod-sfc.ko \
kmod-sfp.ko \
kmod-sg.ko \
kmod-sh-eth.ko \
kmod-sh-mmcif.ko \
kmod-sh-mobile-lcdcfb.ko \
kmod-sh-sci.ko \
kmod-sha1-ce.ko \
kmod-sha1-generic.ko \
kmod-sha2-ce.ko \
kmod-sha256-arm64.ko \
kmod-sha256-generic.ko \
kmod-sha3-ce.ko \
kmod-sha3-generic.ko \
kmod-sha512-arm64.ko \
kmod-sha512-ce.ko \
kmod-sha512-generic.ko \
kmod-shark2.ko \
kmod-sht15.ko \
kmod-sht21.ko \
kmod-sht3x.ko \
kmod-sht4x.ko \
kmod-shtc1.ko \
kmod-si1133.ko \
kmod-si1145.ko \
kmod-si2157.ko \
kmod-si2165.ko \
kmod-si2168.ko \
kmod-si21xx.ko \
kmod-si4713.ko \
kmod-sierra-net.ko \
kmod-sierra.ko \
kmod-sii902x.ko \
kmod-sii9234.ko \
kmod-sil-sii8620.ko \
kmod-sil164.ko \
kmod-silead.ko \
kmod-simple-bridge.ko \
kmod-simple-mfd-i2c.ko \
kmod-simpledrm.ko \
kmod-sis-i2c.ko \
kmod-sis190.ko \
kmod-sis5595.ko \
kmod-sis900.ko \
kmod-sisusbvga.ko \
kmod-sit.ko \
kmod-siw.ko \
kmod-sja1000.ko \
kmod-sja1105.ko \
kmod-skcipher.ko \
kmod-skfp.ko \
kmod-skge.ko \
kmod-sky2.ko \
kmod-sky81452-backlight.ko \
kmod-sky81452-regulator.ko \
kmod-sky81452.ko \
kmod-sl28vpd.ko \
kmod-sl811-hcd.ko \
kmod-slcan.ko \
kmod-slg51000-regulator.ko \
kmod-slhc.ko \
kmod-slic-ds26522.ko \
kmod-slicoss.ko \
kmod-slim-qcom-ctrl.ko \
kmod-slim-qcom-ngd-ctrl.ko \
kmod-slimbus.ko \
kmod-slip.ko \
kmod-slram.ko \
kmod-sm-common.ko \
kmod-sm2-generic.ko \
kmod-sm3-ce.ko \
kmod-sm3-generic.ko \
kmod-sm3-neon.ko \
kmod-sm3.ko \
kmod-sm4-ce-ccm.ko \
kmod-sm4-ce-cipher.ko \
kmod-sm4-ce-gcm.ko \
kmod-sm4-ce.ko \
kmod-sm4-generic.ko \
kmod-sm4-neon.ko \
kmod-sm4.ko \
kmod-sm750fb.ko \
kmod-smartpqi.ko \
kmod-smb347-charger.ko \
kmod-smc-diag.ko \
kmod-smc.ko \
kmod-smc91x.ko \
kmod-smd-rpm.ko \
kmod-smem.ko \
kmod-smipcie.ko \
kmod-smm665.ko \
kmod-smp2p.ko \
kmod-smpro-core.ko \
kmod-smpro-errmon.ko \
kmod-smpro-hwmon.ko \
kmod-smpro-misc.ko \
kmod-smsc.ko \
kmod-smsc47b397.ko \
kmod-smsc47m1.ko \
kmod-smsc47m192.ko \
kmod-smsc75xx.ko \
kmod-smsc911x.ko \
kmod-smsc9420.ko \
kmod-smsc95xx.ko \
kmod-smsdvb.ko \
kmod-smsm.ko \
kmod-smsmdtv.ko \
kmod-smssdio.ko \
kmod-smsusb.ko \
kmod-snd-ac97-codec.ko \
kmod-snd-acp-config.ko \
kmod-snd-ad1889.ko \
kmod-snd-ak4113.ko \
kmod-snd-ak4114.ko \
kmod-snd-ak4xxx-adda.ko \
kmod-snd-aloop.ko \
kmod-snd-atiixp-modem.ko \
kmod-snd-atiixp.ko \
kmod-snd-au8810.ko \
kmod-snd-au8820.ko \
kmod-snd-au8830.ko \
kmod-snd-aw2.ko \
kmod-snd-bcd2000.ko \
kmod-snd-bcm2835.ko \
kmod-snd-bebob.ko \
kmod-snd-bt87x.ko \
kmod-snd-ca0106.ko \
kmod-snd-cmipci.ko \
kmod-snd-compress.ko \
kmod-snd-cs4281.ko \
kmod-snd-cs46xx.ko \
kmod-snd-ctl-led.ko \
kmod-snd-ctxfi.ko \
kmod-snd-darla20.ko \
kmod-snd-darla24.ko \
kmod-snd-dice.ko \
kmod-snd-dummy.ko \
kmod-snd-echo3g.ko \
kmod-snd-ens1370.ko \
kmod-snd-ens1371.ko \
kmod-snd-fireface.ko \
kmod-snd-firewire-digi00x.ko \
kmod-snd-firewire-lib.ko \
kmod-snd-firewire-motu.ko \
kmod-snd-firewire-tascam.ko \
kmod-snd-fireworks.ko \
kmod-snd-fm801.ko \
kmod-snd-gina20.ko \
kmod-snd-gina24.ko \
kmod-snd-hda-codec-analog.ko \
kmod-snd-hda-codec-ca0110.ko \
kmod-snd-hda-codec-ca0132.ko \
kmod-snd-hda-codec-cirrus.ko \
kmod-snd-hda-codec-cmedia.ko \
kmod-snd-hda-codec-conexant.ko \
kmod-snd-hda-codec-cs8409.ko \
kmod-snd-hda-codec-generic.ko \
kmod-snd-hda-codec-hdmi.ko \
kmod-snd-hda-codec-idt.ko \
kmod-snd-hda-codec-realtek.ko \
kmod-snd-hda-codec-si3054.ko \
kmod-snd-hda-codec-via.ko \
kmod-snd-hda-codec.ko \
kmod-snd-hda-core.ko \
kmod-snd-hda-cs-dsp-ctls.ko \
kmod-snd-hda-ext-core.ko \
kmod-snd-hda-intel.ko \
kmod-snd-hda-scodec-cs35l41-i2c.ko \
kmod-snd-hda-scodec-cs35l41-spi.ko \
kmod-snd-hda-scodec-cs35l41.ko \
kmod-snd-hda-tegra.ko \
kmod-snd-hdsp.ko \
kmod-snd-hdspm.ko \
kmod-snd-hrtimer.ko \
kmod-snd-hwdep.ko \
kmod-snd-i2c.ko \
kmod-snd-ice1724.ko \
kmod-snd-ice17xx-ak4xxx.ko \
kmod-snd-indigo.ko \
kmod-snd-indigodj.ko \
kmod-snd-indigodjx.ko \
kmod-snd-indigoio.ko \
kmod-snd-indigoiox.ko \
kmod-snd-intel-dspcfg.ko \
kmod-snd-intel-sdw-acpi.ko \
kmod-snd-intel8x0.ko \
kmod-snd-intel8x0m.ko \
kmod-snd-isight.ko \
kmod-snd-korg1212.ko \
kmod-snd-layla20.ko \
kmod-snd-layla24.ko \
kmod-snd-lola.ko \
kmod-snd-lx6464es.ko \
kmod-snd-mia.ko \
kmod-snd-mixart.ko \
kmod-snd-mixer-oss.ko \
kmod-snd-mona.ko \
kmod-snd-mpu401-uart.ko \
kmod-snd-mpu401.ko \
kmod-snd-mtpav.ko \
kmod-snd-mts64.ko \
kmod-snd-nm256.ko \
kmod-snd-opl3-lib.ko \
kmod-snd-opl3-synth.ko \
kmod-snd-oxfw.ko \
kmod-snd-oxygen-lib.ko \
kmod-snd-oxygen.ko \
kmod-snd-pcm-dmaengine.ko \
kmod-snd-pcm-oss.ko \
kmod-snd-pcm.ko \
kmod-snd-pcxhr.ko \
kmod-snd-portman2x4.ko \
kmod-snd-pt2258.ko \
kmod-snd-q6apm.ko \
kmod-snd-q6dsp-common.ko \
kmod-snd-rawmidi.ko \
kmod-snd-riptide.ko \
kmod-snd-rme32.ko \
kmod-snd-rme96.ko \
kmod-snd-rme9652.ko \
kmod-snd-seq-device.ko \
kmod-snd-seq-dummy.ko \
kmod-snd-seq-midi-emul.ko \
kmod-snd-seq-midi-event.ko \
kmod-snd-seq-midi.ko \
kmod-snd-seq-oss.ko \
kmod-snd-seq-virmidi.ko \
kmod-snd-seq.ko \
kmod-snd-serial-generic.ko \
kmod-snd-serial-u16550.ko \
kmod-snd-soc-63xx.ko \
kmod-snd-soc-ac97.ko \
kmod-snd-soc-acp-da7219mx98357-mach.ko \
kmod-snd-soc-acp-es8336-mach.ko \
kmod-snd-soc-acp-rt5645-mach.ko \
kmod-snd-soc-acpi.ko \
kmod-snd-soc-adau-utils.ko \
kmod-snd-soc-adau1701.ko \
kmod-snd-soc-adau1761-i2c.ko \
kmod-snd-soc-adau1761-spi.ko \
kmod-snd-soc-adau1761.ko \
kmod-snd-soc-adau17x1.ko \
kmod-snd-soc-adau7002.ko \
kmod-snd-soc-adau7118-hw.ko \
kmod-snd-soc-adau7118-i2c.ko \
kmod-snd-soc-adau7118.ko \
kmod-snd-soc-adi-axi-i2s.ko \
kmod-snd-soc-adi-axi-spdif.ko \
kmod-snd-soc-ak4104.ko \
kmod-snd-soc-ak4118.ko \
kmod-snd-soc-ak4375.ko \
kmod-snd-soc-ak4458.ko \
kmod-snd-soc-ak4554.ko \
kmod-snd-soc-ak4613.ko \
kmod-snd-soc-ak4642.ko \
kmod-snd-soc-ak5386.ko \
kmod-snd-soc-ak5558.ko \
kmod-snd-soc-alc5623.ko \
kmod-snd-soc-apple-mca.ko \
kmod-snd-soc-apq8016-sbc.ko \
kmod-snd-soc-apq8096.ko \
kmod-snd-soc-aries-wm8994.ko \
kmod-snd-soc-armada-370-db.ko \
kmod-snd-soc-audio-graph-card.ko \
kmod-snd-soc-audio-graph-card2-custom-sample.ko \
kmod-snd-soc-audio-graph-card2.ko \
kmod-snd-soc-aw8738.ko \
kmod-snd-soc-bcm2835-i2s.ko \
kmod-snd-soc-bd28623.ko \
kmod-snd-soc-bt-sco.ko \
kmod-snd-soc-core.ko \
kmod-snd-soc-cpcap.ko \
kmod-snd-soc-cros-ec-codec.ko \
kmod-snd-soc-cs35l32.ko \
kmod-snd-soc-cs35l33.ko \
kmod-snd-soc-cs35l34.ko \
kmod-snd-soc-cs35l35.ko \
kmod-snd-soc-cs35l36.ko \
kmod-snd-soc-cs35l41-i2c.ko \
kmod-snd-soc-cs35l41-lib.ko \
kmod-snd-soc-cs35l41-spi.ko \
kmod-snd-soc-cs35l41.ko \
kmod-snd-soc-cs35l45-i2c.ko \
kmod-snd-soc-cs35l45-spi.ko \
kmod-snd-soc-cs35l45.ko \
kmod-snd-soc-cs35l56-i2c.ko \
kmod-snd-soc-cs35l56-sdw.ko \
kmod-snd-soc-cs35l56-shared.ko \
kmod-snd-soc-cs35l56-spi.ko \
kmod-snd-soc-cs35l56.ko \
kmod-snd-soc-cs4265.ko \
kmod-snd-soc-cs4270.ko \
kmod-snd-soc-cs4271-i2c.ko \
kmod-snd-soc-cs4271-spi.ko \
kmod-snd-soc-cs4271.ko \
kmod-snd-soc-cs42l42-i2c.ko \
kmod-snd-soc-cs42l42-sdw.ko \
kmod-snd-soc-cs42l42.ko \
kmod-snd-soc-cs42l51-i2c.ko \
kmod-snd-soc-cs42l51.ko \
kmod-snd-soc-cs42l52.ko \
kmod-snd-soc-cs42l56.ko \
kmod-snd-soc-cs42l73.ko \
kmod-snd-soc-cs42xx8-i2c.ko \
kmod-snd-soc-cs42xx8.ko \
kmod-snd-soc-cs43130.ko \
kmod-snd-soc-cs4341.ko \
kmod-snd-soc-cs4349.ko \
kmod-snd-soc-cs53l30.ko \
kmod-snd-soc-cx2072x.ko \
kmod-snd-soc-da7213.ko \
kmod-snd-soc-da7219.ko \
kmod-snd-soc-dmic.ko \
kmod-snd-soc-es7134.ko \
kmod-snd-soc-es7241.ko \
kmod-snd-soc-es8316.ko \
kmod-snd-soc-es8326.ko \
kmod-snd-soc-es8328-i2c.ko \
kmod-snd-soc-es8328-spi.ko \
kmod-snd-soc-es8328.ko \
kmod-snd-soc-fsi.ko \
kmod-snd-soc-fsl-asoc-card.ko \
kmod-snd-soc-fsl-asrc.ko \
kmod-snd-soc-fsl-aud2htx.ko \
kmod-snd-soc-fsl-audmix.ko \
kmod-snd-soc-fsl-easrc.ko \
kmod-snd-soc-fsl-esai.ko \
kmod-snd-soc-fsl-micfil.ko \
kmod-snd-soc-fsl-mqs.ko \
kmod-snd-soc-fsl-rpmsg.ko \
kmod-snd-soc-fsl-sai.ko \
kmod-snd-soc-fsl-spdif.ko \
kmod-snd-soc-fsl-ssi.ko \
kmod-snd-soc-fsl-utils.ko \
kmod-snd-soc-gtm601.ko \
kmod-snd-soc-hda-codec.ko \
kmod-snd-soc-hdmi-codec.ko \
kmod-snd-soc-i2s.ko \
kmod-snd-soc-idma.ko \
kmod-snd-soc-imx-audmix.ko \
kmod-snd-soc-imx-audmux.ko \
kmod-snd-soc-imx-card.ko \
kmod-snd-soc-imx-es8328.ko \
kmod-snd-soc-imx-hdmi.ko \
kmod-snd-soc-imx-rpmsg.ko \
kmod-snd-soc-imx-sgtl5000.ko \
kmod-snd-soc-imx-spdif.ko \
kmod-snd-soc-kirkwood.ko \
kmod-snd-soc-kmb-platform.ko \
kmod-snd-soc-lochnagar-sc.ko \
kmod-snd-soc-lpass-apq8016.ko \
kmod-snd-soc-lpass-cdc-dma.ko \
kmod-snd-soc-lpass-cpu.ko \
kmod-snd-soc-lpass-hdmi.ko \
kmod-snd-soc-lpass-ipq806x.ko \
kmod-snd-soc-lpass-macro-common.ko \
kmod-snd-soc-lpass-platform.ko \
kmod-snd-soc-lpass-sc7180.ko \
kmod-snd-soc-lpass-sc7280.ko \
kmod-snd-soc-max9759.ko \
kmod-snd-soc-max98088.ko \
kmod-snd-soc-max98090.ko \
kmod-snd-soc-max98095.ko \
kmod-snd-soc-max98357a.ko \
kmod-snd-soc-max98363.ko \
kmod-snd-soc-max98373-i2c.ko \
kmod-snd-soc-max98373-sdw.ko \
kmod-snd-soc-max98373.ko \
kmod-snd-soc-max98390.ko \
kmod-snd-soc-max98396.ko \
kmod-snd-soc-max98504.ko \
kmod-snd-soc-max98520.ko \
kmod-snd-soc-max9860.ko \
kmod-snd-soc-max9867.ko \
kmod-snd-soc-max98927.ko \
kmod-snd-soc-meson-aiu.ko \
kmod-snd-soc-meson-axg-fifo.ko \
kmod-snd-soc-meson-axg-frddr.ko \
kmod-snd-soc-meson-axg-pdm.ko \
kmod-snd-soc-meson-axg-sound-card.ko \
kmod-snd-soc-meson-axg-spdifin.ko \
kmod-snd-soc-meson-axg-spdifout.ko \
kmod-snd-soc-meson-axg-tdm-formatter.ko \
kmod-snd-soc-meson-axg-tdm-interface.ko \
kmod-snd-soc-meson-axg-tdmin.ko \
kmod-snd-soc-meson-axg-tdmout.ko \
kmod-snd-soc-meson-axg-toddr.ko \
kmod-snd-soc-meson-card-utils.ko \
kmod-snd-soc-meson-codec-glue.ko \
kmod-snd-soc-meson-g12a-toacodec.ko \
kmod-snd-soc-meson-g12a-tohdmitx.ko \
kmod-snd-soc-meson-gx-sound-card.ko \
kmod-snd-soc-meson-t9015.ko \
kmod-snd-soc-midas-wm1811.ko \
kmod-snd-soc-mt6351.ko \
kmod-snd-soc-mt6358.ko \
kmod-snd-soc-mt6359.ko \
kmod-snd-soc-mt6660.ko \
kmod-snd-soc-mt6797-afe.ko \
kmod-snd-soc-mt8183-afe.ko \
kmod-snd-soc-mt8186-afe.ko \
kmod-snd-soc-mt8188-afe.ko \
kmod-snd-soc-mt8192-afe.ko \
kmod-snd-soc-mt8195-afe.ko \
kmod-snd-soc-mtk-common.ko \
kmod-snd-soc-nau8540.ko \
kmod-snd-soc-nau8810.ko \
kmod-snd-soc-nau8821.ko \
kmod-snd-soc-nau8822.ko \
kmod-snd-soc-nau8824.ko \
kmod-snd-soc-pcm.ko \
kmod-snd-soc-pcm1681.ko \
kmod-snd-soc-pcm1789-codec.ko \
kmod-snd-soc-pcm1789-i2c.ko \
kmod-snd-soc-pcm179x-codec.ko \
kmod-snd-soc-pcm179x-i2c.ko \
kmod-snd-soc-pcm179x-spi.ko \
kmod-snd-soc-pcm186x-i2c.ko \
kmod-snd-soc-pcm186x-spi.ko \
kmod-snd-soc-pcm186x.ko \
kmod-snd-soc-pcm3060-i2c.ko \
kmod-snd-soc-pcm3060-spi.ko \
kmod-snd-soc-pcm3060.ko \
kmod-snd-soc-pcm512x-i2c.ko \
kmod-snd-soc-pcm512x-spi.ko \
kmod-snd-soc-pcm512x.ko \
kmod-snd-soc-qcom-common.ko \
kmod-snd-soc-qcom-sdw.ko \
kmod-snd-soc-rcar.ko \
kmod-snd-soc-rk3288-hdmi-analog.ko \
kmod-snd-soc-rk3328.ko \
kmod-snd-soc-rk3399-gru-sound.ko \
kmod-snd-soc-rk817.ko \
kmod-snd-soc-rl6231.ko \
kmod-snd-soc-rockchip-i2s-tdm.ko \
kmod-snd-soc-rockchip-i2s.ko \
kmod-snd-soc-rockchip-max98090.ko \
kmod-snd-soc-rockchip-pdm.ko \
kmod-snd-soc-rockchip-rt5645.ko \
kmod-snd-soc-rockchip-spdif.ko \
kmod-snd-soc-rt1011.ko \
kmod-snd-soc-rt1015.ko \
kmod-snd-soc-rt1015p.ko \
kmod-snd-soc-rt1308-sdw.ko \
kmod-snd-soc-rt1316-sdw.ko \
kmod-snd-soc-rt5514-spi.ko \
kmod-snd-soc-rt5514.ko \
kmod-snd-soc-rt5616.ko \
kmod-snd-soc-rt5631.ko \
kmod-snd-soc-rt5640.ko \
kmod-snd-soc-rt5645.ko \
kmod-snd-soc-rt5659.ko \
kmod-snd-soc-rt5663.ko \
kmod-snd-soc-rt5682-i2c.ko \
kmod-snd-soc-rt5682-sdw.ko \
kmod-snd-soc-rt5682.ko \
kmod-snd-soc-rt5682s.ko \
kmod-snd-soc-rt700.ko \
kmod-snd-soc-rt711-sdca.ko \
kmod-snd-soc-rt711.ko \
kmod-snd-soc-rt712-sdca-dmic.ko \
kmod-snd-soc-rt712-sdca.ko \
kmod-snd-soc-rt715-sdca.ko \
kmod-snd-soc-rt715.ko \
kmod-snd-soc-rt9120.ko \
kmod-snd-soc-rz-ssi.ko \
kmod-snd-soc-s3c-dma.ko \
kmod-snd-soc-samsung-spdif.ko \
kmod-snd-soc-sc7180.ko \
kmod-snd-soc-sc7280.ko \
kmod-snd-soc-sc8280xp.ko \
kmod-snd-soc-sdm845.ko \
kmod-snd-soc-sdw-mockup.ko \
kmod-snd-soc-sgtl5000.ko \
kmod-snd-soc-sigmadsp-i2c.ko \
kmod-snd-soc-sigmadsp-regmap.ko \
kmod-snd-soc-sigmadsp.ko \
kmod-snd-soc-simple-amplifier.ko \
kmod-snd-soc-simple-card-utils.ko \
kmod-snd-soc-simple-card.ko \
kmod-snd-soc-sm8250.ko \
kmod-snd-soc-smdk-spdif.ko \
kmod-snd-soc-smdk-wm8994.ko \
kmod-snd-soc-smdk-wm8994pcm.ko \
kmod-snd-soc-snow.ko \
kmod-snd-soc-spdif-rx.ko \
kmod-snd-soc-spdif-tx.ko \
kmod-snd-soc-sprd-platform.ko \
kmod-snd-soc-ssm2305.ko \
kmod-snd-soc-ssm2518.ko \
kmod-snd-soc-ssm2602-i2c.ko \
kmod-snd-soc-ssm2602-spi.ko \
kmod-snd-soc-ssm2602.ko \
kmod-snd-soc-ssm4567.ko \
kmod-snd-soc-sta32x.ko \
kmod-snd-soc-sta350.ko \
kmod-snd-soc-sti-sas.ko \
kmod-snd-soc-storm.ko \
kmod-snd-soc-tas2552.ko \
kmod-snd-soc-tas2562.ko \
kmod-snd-soc-tas2770.ko \
kmod-snd-soc-tas5086.ko \
kmod-snd-soc-tas571x.ko \
kmod-snd-soc-tas5720.ko \
kmod-snd-soc-tas5805m.ko \
kmod-snd-soc-tas6424.ko \
kmod-snd-soc-tda7419.ko \
kmod-snd-soc-tegra-audio-graph-card.ko \
kmod-snd-soc-tegra-machine.ko \
kmod-snd-soc-tegra-pcm.ko \
kmod-snd-soc-tegra186-asrc.ko \
kmod-snd-soc-tegra186-dspk.ko \
kmod-snd-soc-tegra210-admaif.ko \
kmod-snd-soc-tegra210-adx.ko \
kmod-snd-soc-tegra210-ahub.ko \
kmod-snd-soc-tegra210-amx.ko \
kmod-snd-soc-tegra210-dmic.ko \
kmod-snd-soc-tegra210-i2s.ko \
kmod-snd-soc-tegra210-mixer.ko \
kmod-snd-soc-tegra210-mvc.ko \
kmod-snd-soc-tegra210-ope.ko \
kmod-snd-soc-tegra210-sfc.ko \
kmod-snd-soc-test-component.ko \
kmod-snd-soc-tfa9879.ko \
kmod-snd-soc-tfa989x.ko \
kmod-snd-soc-tlv320adcx140.ko \
kmod-snd-soc-tlv320aic23-i2c.ko \
kmod-snd-soc-tlv320aic23-spi.ko \
kmod-snd-soc-tlv320aic23.ko \
kmod-snd-soc-tlv320aic31xx.ko \
kmod-snd-soc-tlv320aic32x4-i2c.ko \
kmod-snd-soc-tlv320aic32x4-spi.ko \
kmod-snd-soc-tlv320aic32x4.ko \
kmod-snd-soc-tlv320aic3x-i2c.ko \
kmod-snd-soc-tlv320aic3x-spi.ko \
kmod-snd-soc-tlv320aic3x.ko \
kmod-snd-soc-tpa6130a2.ko \
kmod-snd-soc-ts3a227e.ko \
kmod-snd-soc-tscs42xx.ko \
kmod-snd-soc-tscs454.ko \
kmod-snd-soc-uda1334.ko \
kmod-snd-soc-wcd-mbhc.ko \
kmod-snd-soc-wcd9335.ko \
kmod-snd-soc-wcd934x.ko \
kmod-snd-soc-wcd938x-sdw.ko \
kmod-snd-soc-wcd938x.ko \
kmod-snd-soc-wm-adsp.ko \
kmod-snd-soc-wm-hubs.ko \
kmod-snd-soc-wm8510.ko \
kmod-snd-soc-wm8523.ko \
kmod-snd-soc-wm8524.ko \
kmod-snd-soc-wm8580.ko \
kmod-snd-soc-wm8711.ko \
kmod-snd-soc-wm8728.ko \
kmod-snd-soc-wm8737.ko \
kmod-snd-soc-wm8741.ko \
kmod-snd-soc-wm8750.ko \
kmod-snd-soc-wm8753.ko \
kmod-snd-soc-wm8770.ko \
kmod-snd-soc-wm8776.ko \
kmod-snd-soc-wm8782.ko \
kmod-snd-soc-wm8804-i2c.ko \
kmod-snd-soc-wm8804-spi.ko \
kmod-snd-soc-wm8804.ko \
kmod-snd-soc-wm8903.ko \
kmod-snd-soc-wm8904.ko \
kmod-snd-soc-wm8960.ko \
kmod-snd-soc-wm8962.ko \
kmod-snd-soc-wm8974.ko \
kmod-snd-soc-wm8978.ko \
kmod-snd-soc-wm8985.ko \
kmod-snd-soc-wm8994.ko \
kmod-snd-soc-wsa881x.ko \
kmod-snd-soc-xlnx-formatter-pcm.ko \
kmod-snd-soc-xlnx-i2s.ko \
kmod-snd-soc-xlnx-spdif.ko \
kmod-snd-soc-xtfpga-i2s.ko \
kmod-snd-soc-zl38060.ko \
kmod-snd-sof-imx8.ko \
kmod-snd-sof-imx8m.ko \
kmod-snd-sof-imx8ulp.ko \
kmod-snd-sof-mt8186.ko \
kmod-snd-sof-mt8195.ko \
kmod-snd-sof-of.ko \
kmod-snd-sof-utils.ko \
kmod-snd-sof-xtensa-dsp.ko \
kmod-snd-sof.ko \
kmod-snd-timer.ko \
kmod-snd-ua101.ko \
kmod-snd-usb-6fire.ko \
kmod-snd-usb-audio.ko \
kmod-snd-usb-caiaq.ko \
kmod-snd-usb-hiface.ko \
kmod-snd-usb-line6.ko \
kmod-snd-usb-pod.ko \
kmod-snd-usb-podhd.ko \
kmod-snd-usb-toneport.ko \
kmod-snd-usb-variax.ko \
kmod-snd-usbmidi-lib.ko \
kmod-snd-via82xx-modem.ko \
kmod-snd-via82xx.ko \
kmod-snd-virmidi.ko \
kmod-snd-virtuoso.ko \
kmod-snd-vx-lib.ko \
kmod-snd-vx222.ko \
kmod-snd-ymfpci.ko \
kmod-snd.ko \
kmod-snet-vdpa.ko \
kmod-snic.ko \
kmod-snps-udc-core.ko \
kmod-snps-udc-plat.ko \
kmod-snvs-pwrkey.ko \
kmod-soc-button-array.ko \
kmod-soc-imx8m.ko \
kmod-socfpga-a10.ko \
kmod-socfpga.ko \
kmod-socinfo.ko \
kmod-softdog.ko \
kmod-softing.ko \
kmod-solo6x10.ko \
kmod-solos-pci.ko \
kmod-sony-btf-mpx.ko \
kmod-soundcore.ko \
kmod-soundwire-amd.ko \
kmod-soundwire-bus.ko \
kmod-soundwire-generic-allocation.ko \
kmod-soundwire-qcom.ko \
kmod-sp2.ko \
kmod-sp805-wdt.ko \
kmod-sp8870.ko \
kmod-sp887x.ko \
kmod-spaceball.ko \
kmod-spaceorb.ko \
kmod-sparse-keymap.ko \
kmod-sparx5-switch.ko \
kmod-sparx5-temp.ko \
kmod-spcp8x5.ko \
kmod-speedtch.ko \
kmod-spi-altera-core.ko \
kmod-spi-altera-dfl.ko \
kmod-spi-amd.ko \
kmod-spi-amlogic-spifc-a1.ko \
kmod-spi-armada-3700.ko \
kmod-spi-bcm-qspi.ko \
kmod-spi-bcm2835.ko \
kmod-spi-bcm2835aux.ko \
kmod-spi-bcm63xx-hsspi.ko \
kmod-spi-bcmbca-hsspi.ko \
kmod-spi-bitbang.ko \
kmod-spi-brcmstb-qspi.ko \
kmod-spi-cadence-quadspi.ko \
kmod-spi-cadence-xspi.ko \
kmod-spi-cadence.ko \
kmod-spi-dln2.ko \
kmod-spi-dw-mmio.ko \
kmod-spi-dw-pci.ko \
kmod-spi-dw.ko \
kmod-spi-fsl-dspi.ko \
kmod-spi-fsl-lib.ko \
kmod-spi-fsl-lpspi.ko \
kmod-spi-fsl-qspi.ko \
kmod-spi-fsl-spi.ko \
kmod-spi-geni-qcom.ko \
kmod-spi-gpio.ko \
kmod-spi-hisi-kunpeng.ko \
kmod-spi-hisi-sfc-v3xx.ko \
kmod-spi-imx.ko \
kmod-spi-iproc-qspi.ko \
kmod-spi-ks8995.ko \
kmod-spi-loopback-test.ko \
kmod-spi-meson-spicc.ko \
kmod-spi-microchip-core-qspi.ko \
kmod-spi-microchip-core.ko \
kmod-spi-mt65xx.ko \
kmod-spi-mtk-nor.ko \
kmod-spi-mtk-snfi.ko \
kmod-spi-mux.ko \
kmod-spi-mxic.ko \
kmod-spi-nor.ko \
kmod-spi-npcm-fiu.ko \
kmod-spi-npcm-pspi.ko \
kmod-spi-nxp-fspi.ko \
kmod-spi-oc-tiny.ko \
kmod-spi-orion.ko \
kmod-spi-pl022.ko \
kmod-spi-qcom-qspi.ko \
kmod-spi-qup.ko \
kmod-spi-rockchip-sfc.ko \
kmod-spi-rockchip.ko \
kmod-spi-rpc-if.ko \
kmod-spi-rspi.ko \
kmod-spi-s3c64xx.ko \
kmod-spi-sc18is602.ko \
kmod-spi-sh-hspi.ko \
kmod-spi-sh-msiof.ko \
kmod-spi-sifive.ko \
kmod-spi-slave-mt27xx.ko \
kmod-spi-slave-system-control.ko \
kmod-spi-slave-time.ko \
kmod-spi-sprd-adi.ko \
kmod-spi-sprd.ko \
kmod-spi-sun4i.ko \
kmod-spi-sun6i.ko \
kmod-spi-synquacer.ko \
kmod-spi-tegra114.ko \
kmod-spi-tegra20-sflash.ko \
kmod-spi-tegra20-slink.ko \
kmod-spi-tegra210-quad.ko \
kmod-spi-thunderx.ko \
kmod-spi-wpcm-fiu.ko \
kmod-spi-xcomm.ko \
kmod-spi-xilinx.ko \
kmod-spi-xlp.ko \
kmod-spi-zynqmp-gqspi.ko \
kmod-spidev.ko \
kmod-spinand.ko \
kmod-spm.ko \
kmod-spmi-mtk-pmif.ko \
kmod-spmi-pmic-arb.ko \
kmod-spmi.ko \
kmod-sprd-dma.ko \
kmod-sprd-drm.ko \
kmod-sprd-hwspinlock.ko \
kmod-sprd-iommu.ko \
kmod-sprd-mailbox.ko \
kmod-sprd-mcdt.ko \
kmod-sprd-sc27xx-spi.ko \
kmod-sprd-serial.ko \
kmod-sprd-thermal.ko \
kmod-sprd-wdt.ko \
kmod-sps30-i2c.ko \
kmod-sps30-serial.ko \
kmod-sps30.ko \
kmod-squashfs.ko \
kmod-sr-mod.ko \
kmod-sr-thermal.ko \
kmod-sr9700.ko \
kmod-sr9800.ko \
kmod-srf04.ko \
kmod-srf08.ko \
kmod-ssb-hcd.ko \
kmod-ssb.ko \
kmod-ssd130x-i2c.ko \
kmod-ssd130x-spi.ko \
kmod-ssd130x.ko \
kmod-ssfdc.ko \
kmod-ssif-bmc.ko \
kmod-ssu100.ko \
kmod-st-accel-i2c.ko \
kmod-st-accel-spi.ko \
kmod-st-accel.ko \
kmod-st-drv.ko \
kmod-st-lsm6dsx-i2c.ko \
kmod-st-lsm6dsx-i3c.ko \
kmod-st-lsm6dsx-spi.ko \
kmod-st-lsm6dsx.ko \
kmod-st-lsm9ds0-i2c.ko \
kmod-st-lsm9ds0-spi.ko \
kmod-st-lsm9ds0.ko \
kmod-st-magn-i2c.ko \
kmod-st-magn-spi.ko \
kmod-st-magn.ko \
kmod-st-nci-i2c.ko \
kmod-st-nci-spi.ko \
kmod-st-nci.ko \
kmod-st-pressure-i2c.ko \
kmod-st-pressure-spi.ko \
kmod-st-pressure.ko \
kmod-st-sensors-i2c.ko \
kmod-st-sensors-spi.ko \
kmod-st-sensors.ko \
kmod-st-uvis25-core.ko \
kmod-st-uvis25-i2c.ko \
kmod-st-uvis25-spi.ko \
kmod-st-vgxy61.ko \
kmod-st.ko \
kmod-st1232.ko \
kmod-st21nfca-hci.ko \
kmod-st21nfca-i2c.ko \
kmod-st7586.ko \
kmod-st7735r.ko \
kmod-st95hf.ko \
kmod-starfire.ko \
kmod-stb0899.ko \
kmod-stb6000.ko \
kmod-stb6100.ko \
kmod-ste10Xp.ko \
kmod-stex.ko \
kmod-stinger.ko \
kmod-stk1160.ko \
kmod-stk8312.ko \
kmod-stk8ba50.ko \
kmod-stm-console.ko \
kmod-stm-core.ko \
kmod-stm-ftrace.ko \
kmod-stm-p-basic.ko \
kmod-stm-p-sys-t.ko \
kmod-stmfts.ko \
kmod-stmfx.ko \
kmod-stmmac-pci.ko \
kmod-stmmac-platform.ko \
kmod-stmmac.ko \
kmod-stp.ko \
kmod-stpddc60.ko \
kmod-stpmic1-onkey.ko \
kmod-stpmic1-regulator.ko \
kmod-stpmic1-wdt.ko \
kmod-stpmic1.ko \
kmod-stratix10-rsu.ko \
kmod-stratix10-soc.ko \
kmod-stratix10-svc.ko \
kmod-streamzap.ko \
kmod-streebog-generic.ko \
kmod-stts751.ko \
kmod-stusb160x.ko \
kmod-stv0288.ko \
kmod-stv0297.ko \
kmod-stv0299.ko \
kmod-stv0367.ko \
kmod-stv0900.ko \
kmod-stv090x.ko \
kmod-stv0910.ko \
kmod-stv6110.ko \
kmod-stv6110x.ko \
kmod-stv6111.ko \
kmod-sun4i-codec.ko \
kmod-sun4i-csi.ko \
kmod-sun4i-drm.ko \
kmod-sun4i-gpadc-iio.ko \
kmod-sun4i-gpadc.ko \
kmod-sun4i-i2s.ko \
kmod-sun4i-lradc-keys.ko \
kmod-sun4i-spdif.ko \
kmod-sun4i-ss.ko \
kmod-sun4i-tcon.ko \
kmod-sun4i-ts.ko \
kmod-sun4i-tv.ko \
kmod-sun50i-a100-ccu.ko \
kmod-sun50i-a100-r-ccu.ko \
kmod-sun50i-a64-ccu.ko \
kmod-sun50i-codec-analog.ko \
kmod-sun50i-cpufreq-nvmem.ko \
kmod-sun50i-dmic.ko \
kmod-sun50i-h6-ccu.ko \
kmod-sun50i-h6-r-ccu.ko \
kmod-sun50i-h616-ccu.ko \
kmod-sun6i-dma.ko \
kmod-sun6i-drc.ko \
kmod-sun6i-hwspinlock.ko \
kmod-sun6i-mipi-csi2.ko \
kmod-sun6i-mipi-dsi.ko \
kmod-sun6i-msgbox.ko \
kmod-sun6i-rtc-ccu.ko \
kmod-sun8i-a33-mbus.ko \
kmod-sun8i-a83t-mipi-csi2.ko \
kmod-sun8i-adda-pr-regmap.ko \
kmod-sun8i-ce.ko \
kmod-sun8i-codec-analog.ko \
kmod-sun8i-codec.ko \
kmod-sun8i-de2-ccu.ko \
kmod-sun8i-di.ko \
kmod-sun8i-drm-hdmi.ko \
kmod-sun8i-h3-ccu.ko \
kmod-sun8i-mixer.ko \
kmod-sun8i-r-ccu.ko \
kmod-sun8i-rotate.ko \
kmod-sun8i-ss.ko \
kmod-sun8i-tcon-top.ko \
kmod-sun8i-thermal.ko \
kmod-sundance.ko \
kmod-sungem-phy.ko \
kmod-sungem.ko \
kmod-sunhme.ko \
kmod-suni.ko \
kmod-sunkbd.ko \
kmod-sunrise-co2.ko \
kmod-sunrpc.ko \
kmod-sunxi-ccu.ko \
kmod-sunxi-cedrus.ko \
kmod-sunxi-cir.ko \
kmod-sunxi-mmc.ko \
kmod-sunxi-nand.ko \
kmod-sunxi-rsb.ko \
kmod-sunxi-wdt.ko \
kmod-sunxi.ko \
kmod-sur40.ko \
kmod-surface-acpi-notify.ko \
kmod-surface-aggregator-cdev.ko \
kmod-surface-aggregator-hub.ko \
kmod-surface-aggregator-registry.ko \
kmod-surface-aggregator-tabletsw.ko \
kmod-surface-aggregator.ko \
kmod-surface-battery.ko \
kmod-surface-charger.ko \
kmod-surface-dtx.ko \
kmod-surface-gpe.ko \
kmod-surface-hid-core.ko \
kmod-surface-hid.ko \
kmod-surface-hotplug.ko \
kmod-surface-kbd.ko \
kmod-surface-platform-profile.ko \
kmod-surface3-power.ko \
kmod-surfacepro3-button.ko \
kmod-svc-i3c-master.ko \
kmod-switchtec.ko \
kmod-sx-common.ko \
kmod-sx8654.ko \
kmod-sx9310.ko \
kmod-sx9324.ko \
kmod-sx9360.ko \
kmod-sx9500.ko \
kmod-sy8106a-regulator.ko \
kmod-sy8824x.ko \
kmod-sy8827n.ko \
kmod-sym53c8xx.ko \
kmod-symbolserial.ko \
kmod-synaptics-i2c.ko \
kmod-synaptics-usb.ko \
kmod-synopsys-edac.ko \
kmod-syscon-reboot-mode.ko \
kmod-syscopyarea.ko \
kmod-sysfillrect.ko \
kmod-sysimgblt.ko \
kmod-sysv.ko \
kmod-t10-pi.ko \
kmod-tag-brcm.ko \
kmod-tag-dsa.ko \
kmod-tag-gswip.ko \
kmod-tag-hellcreek.ko \
kmod-tag-ksz.ko \
kmod-tag-lan9303.ko \
kmod-tag-mtk.ko \
kmod-tag-none.ko \
kmod-tag-ocelot-8021q.ko \
kmod-tag-ocelot.ko \
kmod-tag-qca.ko \
kmod-tag-rtl4-a.ko \
kmod-tag-rtl8-4.ko \
kmod-tag-rzn1-a5psw.ko \
kmod-tag-sja1105.ko \
kmod-tag-trailer.ko \
kmod-tag-xrs700x.ko \
kmod-tap.ko \
kmod-target-core-file.ko \
kmod-target-core-iblock.ko \
kmod-target-core-mod.ko \
kmod-target-core-pscsi.ko \
kmod-target-core-user.ko \
kmod-tc358743.ko \
kmod-tc358746.ko \
kmod-tc358762.ko \
kmod-tc358764.ko \
kmod-tc358767.ko \
kmod-tc358768.ko \
kmod-tc358775.ko \
kmod-tc654.ko \
kmod-tc74.ko \
kmod-tc90522.ko \
kmod-tca6416-keypad.ko \
kmod-tca8418-keypad.ko \
kmod-tcan4x5x.ko \
kmod-tcm-fc.ko \
kmod-tcm-loop.ko \
kmod-tcm-qla2xxx.ko \
kmod-tcm-remote.ko \
kmod-tcm-usb-gadget.ko \
kmod-tcp-bbr.ko \
kmod-tcp-bic.ko \
kmod-tcp-cdg.ko \
kmod-tcp-cubic.ko \
kmod-tcp-dctcp.ko \
kmod-tcp-diag.ko \
kmod-tcp-highspeed.ko \
kmod-tcp-htcp.ko \
kmod-tcp-hybla.ko \
kmod-tcp-illinois.ko \
kmod-tcp-lp.ko \
kmod-tcp-nv.ko \
kmod-tcp-scalable.ko \
kmod-tcp-vegas.ko \
kmod-tcp-veno.ko \
kmod-tcp-westwood.ko \
kmod-tcp-yeah.ko \
kmod-tcpci-maxim.ko \
kmod-tcpci-mt6360.ko \
kmod-tcpci-rt1711h.ko \
kmod-tcpci.ko \
kmod-tcpm.ko \
kmod-tcrypt.ko \
kmod-tcsrcc-sm8550.ko \
kmod-tda10021.ko \
kmod-tda10023.ko \
kmod-tda10048.ko \
kmod-tda1004x.ko \
kmod-tda10071.ko \
kmod-tda10086.ko \
kmod-tda18212.ko \
kmod-tda18218.ko \
kmod-tda18250.ko \
kmod-tda18271.ko \
kmod-tda18271c2dd.ko \
kmod-tda1997x.ko \
kmod-tda38640.ko \
kmod-tda665x.ko \
kmod-tda7432.ko \
kmod-tda8083.ko \
kmod-tda8261.ko \
kmod-tda826x.ko \
kmod-tda827x.ko \
kmod-tda8290.ko \
kmod-tda9840.ko \
kmod-tda9887.ko \
kmod-tda9950.ko \
kmod-tda998x.ko \
kmod-tea575x.ko \
kmod-tea5761.ko \
kmod-tea5767.ko \
kmod-tea6415c.ko \
kmod-tea6420.ko \
kmod-team-mode-activebackup.ko \
kmod-team-mode-broadcast.ko \
kmod-team-mode-loadbalance.ko \
kmod-team-mode-random.ko \
kmod-team-mode-roundrobin.ko \
kmod-team.ko \
kmod-tee-bnxt-fw.ko \
kmod-tee.ko \
kmod-tef6862.ko \
kmod-tegra-aconnect.ko \
kmod-tegra-bpmp-thermal.ko \
kmod-tegra-cec.ko \
kmod-tegra-drm.ko \
kmod-tegra-gmi.ko \
kmod-tegra-kbc.ko \
kmod-tegra-nand.ko \
kmod-tegra-soctherm.ko \
kmod-tegra-tcu.ko \
kmod-tegra-vde.ko \
kmod-tegra-video.ko \
kmod-tegra-wdt.ko \
kmod-tegra-xudc.ko \
kmod-tegra186-cpufreq.ko \
kmod-tegra186-gpc-dma.ko \
kmod-tegra194-cpufreq.ko \
kmod-tegra20-apb-dma.ko \
kmod-tegra210-adma.ko \
kmod-tegra210-emc.ko \
kmod-tegra30-devfreq.ko \
kmod-tehuti.ko \
kmod-teranetics.ko \
kmod-test-firmware.ko \
kmod-test-module.ko \
kmod-test-sysctl.ko \
kmod-tg3.ko \
kmod-thc63lvd1024.ko \
kmod-thermal-generic-adc.ko \
kmod-thermal-mmio.ko \
kmod-thermal.ko \
kmod-thmc50.ko \
kmod-ths7303.ko \
kmod-ths8200.ko \
kmod-thunder-bgx.ko \
kmod-thunder-xcv.ko \
kmod-thunderbolt-net.ko \
kmod-thunderbolt.ko \
kmod-thunderx-edac.ko \
kmod-thunderx-mmc.ko \
kmod-thunderx-zip.ko \
kmod-thunderx2-pmu.ko \
kmod-ti-adc0832.ko \
kmod-ti-adc084s021.ko \
kmod-ti-adc108s102.ko \
kmod-ti-adc12138.ko \
kmod-ti-adc161s626.ko \
kmod-ti-ads1015.ko \
kmod-ti-ads124s08.ko \
kmod-ti-ads131e08.ko \
kmod-ti-ads7950.ko \
kmod-ti-ads8344.ko \
kmod-ti-am335x-tscadc.ko \
kmod-ti-dac082s085.ko \
kmod-ti-dac5571.ko \
kmod-ti-dac7311.ko \
kmod-ti-dac7612.ko \
kmod-ti-dlpc3433.ko \
kmod-ti-lmu.ko \
kmod-ti-sn65dsi83.ko \
kmod-ti-sn65dsi86.ko \
kmod-ti-tfp410.ko \
kmod-ti-tlc4541.ko \
kmod-ti-tpd12s015.ko \
kmod-ti-tsc2046.ko \
kmod-ti-usb-3410-5052.ko \
kmod-tidss.ko \
kmod-tifm-7xx1.ko \
kmod-tifm-core.ko \
kmod-tifm-ms.ko \
kmod-tifm-sd.ko \
kmod-timeriomem-rng.ko \
kmod-tiny-power-button.ko \
kmod-tipc.ko \
kmod-tlan.ko \
kmod-tls.ko \
kmod-tlv320aic23b.ko \
kmod-tm2-touchkey.ko \
kmod-tmio-mmc-core.ko \
kmod-tmp007.ko \
kmod-tmp102.ko \
kmod-tmp103.ko \
kmod-tmp108.ko \
kmod-tmp117.ko \
kmod-tmp401.ko \
kmod-tmp421.ko \
kmod-tmp464.ko \
kmod-tmp513.ko \
kmod-torture.ko \
kmod-toshsd.ko \
kmod-touchit213.ko \
kmod-touchright.ko \
kmod-touchwin.ko \
kmod-tpci200.ko \
kmod-tpl0102.ko \
kmod-tpm-atmel.ko \
kmod-tpm-crb.ko \
kmod-tpm-ftpm-tee.ko \
kmod-tpm-i2c-atmel.ko \
kmod-tpm-i2c-infineon.ko \
kmod-tpm-i2c-nuvoton.ko \
kmod-tpm-infineon.ko \
kmod-tpm-st33zp24-i2c.ko \
kmod-tpm-st33zp24-spi.ko \
kmod-tpm-st33zp24.ko \
kmod-tpm-tis-core.ko \
kmod-tpm-tis-i2c-cr50.ko \
kmod-tpm-tis-i2c.ko \
kmod-tpm-tis-spi.ko \
kmod-tpm-tis-synquacer.ko \
kmod-tpm-tis.ko \
kmod-tpm-vtpm-proxy.ko \
kmod-tpm.ko \
kmod-tps23861.ko \
kmod-tps40422.ko \
kmod-tps53679.ko \
kmod-tps546d24.ko \
kmod-tps6286x-regulator.ko \
kmod-tps65010.ko \
kmod-tps6507x-ts.ko \
kmod-tps6507x.ko \
kmod-tps65132-regulator.ko \
kmod-tps6598x.ko \
kmod-tqmx86.ko \
kmod-trancevibrator.ko \
kmod-trusted.ko \
kmod-ts-bm.ko \
kmod-ts-fsm.ko \
kmod-ts-kmp.ko \
kmod-ts2020.ko \
kmod-tsc2004.ko \
kmod-tsc2007.ko \
kmod-tsc200x-core.ko \
kmod-tsc40.ko \
kmod-tsi721-mport.ko \
kmod-tsl2550.ko \
kmod-tsl2591.ko \
kmod-tsl2772.ko \
kmod-tsnep.ko \
kmod-tsys01.ko \
kmod-tsys02d.ko \
kmod-ttm.ko \
kmod-ttpci-eeprom.ko \
kmod-ttusb-dec.ko \
kmod-ttusbdecfe.ko \
kmod-ttusbir.ko \
kmod-ttynull.ko \
kmod-tua6100.ko \
kmod-tua9001.ko \
kmod-tulip.ko \
kmod-tun.ko \
kmod-tuner-simple.ko \
kmod-tuner-types.ko \
kmod-tuner.ko \
kmod-tunnel4.ko \
kmod-tunnel6.ko \
kmod-turbografx.ko \
kmod-turingcc-qcs404.ko \
kmod-turris-mox-rwtm.ko \
kmod-tvaudio.ko \
kmod-tveeprom.ko \
kmod-tvp514x.ko \
kmod-tvp5150.ko \
kmod-tvp7002.ko \
kmod-tw2804.ko \
kmod-tw5864.ko \
kmod-tw68.ko \
kmod-tw686x.ko \
kmod-tw9903.ko \
kmod-tw9906.ko \
kmod-tw9910.ko \
kmod-twidjoy.ko \
kmod-twofish-common.ko \
kmod-twofish-generic.ko \
kmod-txgbe.ko \
kmod-typec-displayport.ko \
kmod-typec-nvidia.ko \
kmod-typec-ucsi.ko \
kmod-typec.ko \
kmod-typhoon.ko \
kmod-u-audio.ko \
kmod-u-ether.ko \
kmod-u-serial.ko \
kmod-uPD60620.ko \
kmod-uacce.ko \
kmod-uas.ko \
kmod-ubi.ko \
kmod-ubifs.ko \
kmod-ublk-drv.ko \
kmod-ucan.ko \
kmod-ucd9000.ko \
kmod-ucd9200.ko \
kmod-ucs1002-power.ko \
kmod-ucs2-string.ko \
kmod-ucsi-acpi.ko \
kmod-ucsi-ccg.ko \
kmod-ucsi-glink.ko \
kmod-ucsi-stm32g0.ko \
kmod-uda1342.ko \
kmod-udc-core.ko \
kmod-udc-xilinx.ko \
kmod-udf.ko \
kmod-udl.ko \
kmod-udp-diag.ko \
kmod-udp-tunnel.ko \
kmod-ueagle-atm.ko \
kmod-ufs-exynos.ko \
kmod-ufs-hisi.ko \
kmod-ufs-mediatek.ko \
kmod-ufs-renesas.ko \
kmod-ufs-sprd.ko \
kmod-ufs.ko \
kmod-ufshcd-core.ko \
kmod-ufshcd-pci.ko \
kmod-ufshcd-pltfrm.ko \
kmod-ug3105-battery.ko \
kmod-uhci-hcd.ko \
kmod-uhid.ko \
kmod-uinput.ko \
kmod-uio-aec.ko \
kmod-uio-cif.ko \
kmod-uio-dfl.ko \
kmod-uio-dmem-genirq.ko \
kmod-uio-hv-generic.ko \
kmod-uio-mf624.ko \
kmod-uio-netx.ko \
kmod-uio-pci-generic.ko \
kmod-uio-pdrv-genirq.ko \
kmod-uio-sercos3.ko \
kmod-uio.ko \
kmod-uleds.ko \
kmod-uli526x.ko \
kmod-ulpi.ko \
kmod-ultrasoc-smb.ko \
kmod-ums-alauda.ko \
kmod-ums-cypress.ko \
kmod-ums-datafab.ko \
kmod-ums-eneub6250.ko \
kmod-ums-freecom.ko \
kmod-ums-isd200.ko \
kmod-ums-jumpshot.ko \
kmod-ums-karma.ko \
kmod-ums-onetouch.ko \
kmod-ums-realtek.ko \
kmod-ums-sddr09.ko \
kmod-ums-sddr55.ko \
kmod-ums-usbat.ko \
kmod-ums512-clk.ko \
kmod-unix-diag.ko \
kmod-unix.ko \
kmod-upd64031a.ko \
kmod-upd64083.ko \
kmod-upd78f0730.ko \
kmod-us5182d.ko \
kmod-usb-8dev.ko \
kmod-usb-common.ko \
kmod-usb-conn-gpio.ko \
kmod-usb-debug.ko \
kmod-usb-dmac.ko \
kmod-usb-f-acm.ko \
kmod-usb-f-ecm-subset.ko \
kmod-usb-f-ecm.ko \
kmod-usb-f-eem.ko \
kmod-usb-f-fs.ko \
kmod-usb-f-hid.ko \
kmod-usb-f-mass-storage.ko \
kmod-usb-f-midi.ko \
kmod-usb-f-ncm.ko \
kmod-usb-f-obex.ko \
kmod-usb-f-phonet.ko \
kmod-usb-f-printer.ko \
kmod-usb-f-rndis.ko \
kmod-usb-f-serial.ko \
kmod-usb-f-ss-lb.ko \
kmod-usb-f-tcm.ko \
kmod-usb-f-uac1.ko \
kmod-usb-f-uac2.ko \
kmod-usb-f-uvc.ko \
kmod-usb-otg-fsm.ko \
kmod-usb-serial-simple.ko \
kmod-usb-storage.ko \
kmod-usb-wwan.ko \
kmod-usb251xb.ko \
kmod-usb3503.ko \
kmod-usb4604.ko \
kmod-usb8xxx.ko \
kmod-usbatm.ko \
kmod-usbcore.ko \
kmod-usbdux.ko \
kmod-usbduxfast.ko \
kmod-usbduxsigma.ko \
kmod-usbhid.ko \
kmod-usbip-core.ko \
kmod-usbip-host.ko \
kmod-usbip-vudc.ko \
kmod-usblcd.ko \
kmod-usblp.ko \
kmod-usbmisc-imx.ko \
kmod-usbmon.ko \
kmod-usbnet.ko \
kmod-usbserial.ko \
kmod-usbsevseg.ko \
kmod-usbtmc.ko \
kmod-usbtouchscreen.ko \
kmod-usbtv.ko \
kmod-usdhi6rol0.ko \
kmod-userio.ko \
kmod-ushc.ko \
kmod-uss720.ko \
kmod-utf8data.ko \
kmod-uvc.ko \
kmod-uvcvideo.ko \
kmod-v3d.ko \
kmod-v4l2-async.ko \
kmod-v4l2-dv-timings.ko \
kmod-v4l2-fwnode.ko \
kmod-v4l2-h264.ko \
kmod-v4l2-jpeg.ko \
kmod-v4l2-mem2mem.ko \
kmod-v4l2-vp9.ko \
kmod-vc4.ko \
kmod-vcan.ko \
kmod-vchiq.ko \
kmod-vcnl3020.ko \
kmod-vcnl4035.ko \
kmod-vcpu-stall-detector.ko \
kmod-vctrl-regulator.ko \
kmod-vdpa-sim-blk.ko \
kmod-vdpa-sim-net.ko \
kmod-vdpa-sim.ko \
kmod-vdpa.ko \
kmod-vduse.ko \
kmod-veml6030.ko \
kmod-venus-core.ko \
kmod-venus-dec.ko \
kmod-venus-enc.ko \
kmod-versal-fpga.ko \
kmod-ves1820.ko \
kmod-ves1x93.ko \
kmod-veth.ko \
kmod-vexpress-config.ko \
kmod-vexpress-hwmon.ko \
kmod-vexpress-regulator.ko \
kmod-vexpress-sysreg.ko \
kmod-vfat.ko \
kmod-vfio-fsl-mc.ko \
kmod-vfio-iommu-type1.ko \
kmod-vfio-pci-core.ko \
kmod-vfio-pci.ko \
kmod-vfio.ko \
kmod-vhci-hcd.ko \
kmod-vhost-iotlb.ko \
kmod-vhost-net.ko \
kmod-vhost-scsi.ko \
kmod-vhost-vdpa.ko \
kmod-vhost-vsock.ko \
kmod-vhost.ko \
kmod-via-rhine.ko \
kmod-via-sdmmc.ko \
kmod-via-velocity.ko \
kmod-via686a.ko \
kmod-vid-pll-div.ko \
kmod-video-i2c.ko \
kmod-video-mux.ko \
kmod-video.ko \
kmod-videobuf-core.ko \
kmod-videobuf-dma-sg.ko \
kmod-videobuf2-common.ko \
kmod-videobuf2-dma-contig.ko \
kmod-videobuf2-dma-sg.ko \
kmod-videobuf2-dvb.ko \
kmod-videobuf2-memops.ko \
kmod-videobuf2-v4l2.ko \
kmod-videobuf2-vmalloc.ko \
kmod-videocc-sc7180.ko \
kmod-videocc-sc7280.ko \
kmod-videocc-sdm845.ko \
kmod-videocc-sm8150.ko \
kmod-videocc-sm8250.ko \
kmod-videodev.ko \
kmod-viperboard.ko \
kmod-virt-dma.ko \
kmod-virt-wifi.ko \
kmod-virtio-balloon.ko \
kmod-virtio-blk.ko \
kmod-virtio-bt.ko \
kmod-virtio-console.ko \
kmod-virtio-crypto.ko \
kmod-virtio-dma-buf.ko \
kmod-virtio-gpu.ko \
kmod-virtio-input.ko \
kmod-virtio-iommu.ko \
kmod-virtio-mem.ko \
kmod-virtio-mmio.ko \
kmod-virtio-net.ko \
kmod-virtio-pci-legacy-dev.ko \
kmod-virtio-pci-modern-dev.ko \
kmod-virtio-pci.ko \
kmod-virtio-pmem.ko \
kmod-virtio-ring.ko \
kmod-virtio-rng.ko \
kmod-virtio-rpmsg-bus.ko \
kmod-virtio-scsi.ko \
kmod-virtio-snd.ko \
kmod-virtio-vdpa.ko \
kmod-virtio.ko \
kmod-virtiofs.ko \
kmod-virtual-ncidev.ko \
kmod-visconti-wdt.ko \
kmod-visor.ko \
kmod-vitesse-vsc73xx-core.ko \
kmod-vitesse-vsc73xx-platform.ko \
kmod-vitesse-vsc73xx-spi.ko \
kmod-vitesse.ko \
kmod-vivaldi-fmap.ko \
kmod-vkms.ko \
kmod-vl53l0x-i2c.ko \
kmod-vl6180.ko \
kmod-vmac.ko \
kmod-vmgenid.ko \
kmod-vmk80xx.ko \
kmod-vmw-vmci.ko \
kmod-vmw-vsock-virtio-transport-common.ko \
kmod-vmw-vsock-virtio-transport.ko \
kmod-vmw-vsock-vmci-transport.ko \
kmod-vmwgfx.ko \
kmod-vmxnet3.ko \
kmod-vp-vdpa.ko \
kmod-vp27smpx.ko \
kmod-vport-geneve.ko \
kmod-vport-gre.ko \
kmod-vport-vxlan.ko \
kmod-vpx3220.ko \
kmod-vqmmc-ipq4019-regulator.ko \
kmod-vrf.ko \
kmod-vringh.ko \
kmod-vsock-diag.ko \
kmod-vsock-loopback.ko \
kmod-vsock.ko \
kmod-vsockmon.ko \
kmod-vsp1.ko \
kmod-vsxxxaa.ko \
kmod-vt1211.ko \
kmod-vt6655-stage.ko \
kmod-vt6656-stage.ko \
kmod-vt8231.ko \
kmod-vub300.ko \
kmod-vx855.ko \
kmod-vxcan.ko \
kmod-vxlan.ko \
kmod-vz89x.ko \
kmod-w1-ds2405.ko \
kmod-w1-ds2406.ko \
kmod-w1-ds2408.ko \
kmod-w1-ds2413.ko \
kmod-w1-ds2423.ko \
kmod-w1-ds2430.ko \
kmod-w1-ds2431.ko \
kmod-w1-ds2433.ko \
kmod-w1-ds2438.ko \
kmod-w1-ds250x.ko \
kmod-w1-ds2780.ko \
kmod-w1-ds2781.ko \
kmod-w1-ds2805.ko \
kmod-w1-ds28e04.ko \
kmod-w1-ds28e17.ko \
kmod-w1-gpio.ko \
kmod-w1-smem.ko \
kmod-w1-therm.ko \
kmod-w5100-spi.ko \
kmod-w5100.ko \
kmod-w5300.ko \
kmod-w83627ehf.ko \
kmod-w83627hf.ko \
kmod-w83773g.ko \
kmod-w83781d.ko \
kmod-w83791d.ko \
kmod-w83792d.ko \
kmod-w83793.ko \
kmod-w83795.ko \
kmod-w83l785ts.ko \
kmod-w83l786ng.ko \
kmod-wacom-i2c.ko \
kmod-wacom-serial4.ko \
kmod-wacom-w8001.ko \
kmod-wacom.ko \
kmod-walkera0701.ko \
kmod-wanxl.ko \
kmod-warrior.ko \
kmod-watchdog.ko \
kmod-wcd934x.ko \
kmod-wcn36xx.ko \
kmod-wcnss-ctrl.ko \
kmod-wd719x.ko \
kmod-wdat-wdt.ko \
kmod-wdt-pci.ko \
kmod-wdt87xx-i2c.ko \
kmod-wfx.ko \
kmod-whiteheat.ko \
kmod-wil6210.ko \
kmod-winbond-840.ko \
kmod-wire.ko \
kmod-wireguard.ko \
kmod-wishbone-serial.ko \
kmod-wl1251-sdio.ko \
kmod-wl1251.ko \
kmod-wl1273-core.ko \
kmod-wl12xx.ko \
kmod-wl18xx.ko \
kmod-wlcore-sdio.ko \
kmod-wlcore.ko \
kmod-wm8739.ko \
kmod-wm8775.ko \
kmod-wm8994-regulator.ko \
kmod-wm8994.ko \
kmod-wm97xx-ts.ko \
kmod-wp512.ko \
kmod-wpcm450-soc.ko \
kmod-wusb3801.ko \
kmod-wwan-hwsim.ko \
kmod-wwan.ko \
kmod-x-tables.ko \
kmod-x25.ko \
kmod-x509-key-parser.ko \
kmod-xbox-remote.ko \
kmod-xc2028.ko \
kmod-xc4000.ko \
kmod-xc5000.ko \
kmod-xcbc.ko \
kmod-xctr.ko \
kmod-xdma.ko \
kmod-xdpe12284.ko \
kmod-xdpe152c4.ko \
kmod-xfrm-algo.ko \
kmod-xfrm-interface.ko \
kmod-xfrm-ipcomp.ko \
kmod-xfrm-user.ko \
kmod-xfrm4-tunnel.ko \
kmod-xfrm6-tunnel.ko \
kmod-xfs.ko \
kmod-xgene-dma.ko \
kmod-xgene-edac.ko \
kmod-xgene-enet-v2.ko \
kmod-xgene-enet.ko \
kmod-xgene-hwmon.ko \
kmod-xgene-rng.ko \
kmod-xgmac-mdio.ko \
kmod-xhci-hcd.ko \
kmod-xhci-histb.ko \
kmod-xhci-mtk-hcd.ko \
kmod-xhci-pci-renesas.ko \
kmod-xhci-pci.ko \
kmod-xhci-plat-hcd.ko \
kmod-xhci-rcar-hcd.ko \
kmod-xhci-tegra.ko \
kmod-xilinx-ams.ko \
kmod-xilinx-can.ko \
kmod-xilinx-csi2rxss.ko \
kmod-xilinx-dma.ko \
kmod-xilinx-dpdma.ko \
kmod-xilinx-emac.ko \
kmod-xilinx-emaclite.ko \
kmod-xilinx-gmii2rgmii.ko \
kmod-xilinx-pr-decoupler.ko \
kmod-xilinx-sdfec.ko \
kmod-xilinx-spi.ko \
kmod-xilinx-uartps.ko \
kmod-xilinx-video.ko \
kmod-xilinx-vtc.ko \
kmod-xilinx-xadc.ko \
kmod-xilinxfb.ko \
kmod-xillybus-class.ko \
kmod-xillybus-core.ko \
kmod-xillybus-of.ko \
kmod-xillybus-pcie.ko \
kmod-xillyusb.ko \
kmod-xiphera-trng.ko \
kmod-xlnx-vcu.ko \
kmod-xor-neon.ko \
kmod-xor.ko \
kmod-xpad.ko \
kmod-xr-serial.ko \
kmod-xrs700x-i2c.ko \
kmod-xrs700x-mdio.ko \
kmod-xrs700x.ko \
kmod-xsens-mt.ko \
kmod-xsk-diag.ko \
kmod-xt-AUDIT.ko \
kmod-xt-CHECKSUM.ko \
kmod-xt-CLASSIFY.ko \
kmod-xt-CONNSECMARK.ko \
kmod-xt-CT.ko \
kmod-xt-DSCP.ko \
kmod-xt-HL.ko \
kmod-xt-HMARK.ko \
kmod-xt-IDLETIMER.ko \
kmod-xt-LED.ko \
kmod-xt-LOG.ko \
kmod-xt-MASQUERADE.ko \
kmod-xt-NETMAP.ko \
kmod-xt-NFLOG.ko \
kmod-xt-NFQUEUE.ko \
kmod-xt-RATEEST.ko \
kmod-xt-REDIRECT.ko \
kmod-xt-SECMARK.ko \
kmod-xt-TCPMSS.ko \
kmod-xt-TCPOPTSTRIP.ko \
kmod-xt-TEE.ko \
kmod-xt-TPROXY.ko \
kmod-xt-TRACE.ko \
kmod-xt-addrtype.ko \
kmod-xt-bpf.ko \
kmod-xt-cgroup.ko \
kmod-xt-cluster.ko \
kmod-xt-comment.ko \
kmod-xt-connbytes.ko \
kmod-xt-connlabel.ko \
kmod-xt-connlimit.ko \
kmod-xt-connmark.ko \
kmod-xt-conntrack.ko \
kmod-xt-cpu.ko \
kmod-xt-dccp.ko \
kmod-xt-devgroup.ko \
kmod-xt-dscp.ko \
kmod-xt-ecn.ko \
kmod-xt-esp.ko \
kmod-xt-hashlimit.ko \
kmod-xt-helper.ko \
kmod-xt-hl.ko \
kmod-xt-ipcomp.ko \
kmod-xt-iprange.ko \
kmod-xt-ipvs.ko \
kmod-xt-l2tp.ko \
kmod-xt-length.ko \
kmod-xt-limit.ko \
kmod-xt-mac.ko \
kmod-xt-mark.ko \
kmod-xt-multiport.ko \
kmod-xt-nat.ko \
kmod-xt-nfacct.ko \
kmod-xt-osf.ko \
kmod-xt-owner.ko \
kmod-xt-physdev.ko \
kmod-xt-pkttype.ko \
kmod-xt-policy.ko \
kmod-xt-quota.ko \
kmod-xt-rateest.ko \
kmod-xt-realm.ko \
kmod-xt-recent.ko \
kmod-xt-sctp.ko \
kmod-xt-set.ko \
kmod-xt-socket.ko \
kmod-xt-state.ko \
kmod-xt-statistic.ko \
kmod-xt-string.ko \
kmod-xt-tcpmss.ko \
kmod-xt-tcpudp.ko \
kmod-xt-time.ko \
kmod-xt-u32.ko \
kmod-xtkbd.ko \
kmod-xts.ko \
kmod-xusbatm.ko \
kmod-xxhash-generic.ko \
kmod-xxhash.ko \
kmod-xz-dec.ko \
kmod-yam.ko \
kmod-yamaha-yas530.ko \
kmod-yealink.ko \
kmod-yellowfin.ko \
kmod-yurex.ko \
kmod-z3fold.ko \
kmod-zaurus.ko \
kmod-zbud.ko \
kmod-zd1201.ko \
kmod-zd1211rw.ko \
kmod-zd1301-demod.ko \
kmod-zd1301.ko \
kmod-zet6223.ko \
kmod-zforce-ts.ko \
kmod-zhenhua.ko \
kmod-ziirave-wdt.ko \
kmod-zinitix.ko \
kmod-zl10036.ko \
kmod-zl10039.ko \
kmod-zl10353.ko \
kmod-zl6100.ko \
kmod-zlib-deflate.ko \
kmod-zlib-inflate.ko \
kmod-zonefs.ko \
kmod-zopt2201.ko \
kmod-zpa2326-i2c.ko \
kmod-zpa2326-spi.ko \
kmod-zpa2326.ko \
kmod-zr36067.ko \
kmod-zram.ko \
kmod-zsmalloc.ko \
kmod-zstd-common.ko \
kmod-zstd-compress.ko \
kmod-zstd-decompress.ko \
kmod-zstd.ko \
kmod-zynqmp-aes-gcm.ko \
kmod-zynqmp-dma.ko \
kmod-zynqmp-dpsub.ko \
kmod-zynqmp-edac.ko \
kmod-zynqmp-fpga.ko \
kmod-zynqmp-ipi-mailbox.ko \
kmod-zynqmp-sha.ko \
multiversion-kernel"

RDEPENDS:${PN} += "/usr/bin/sh \
awk \
coreutils \
distribution-release \
dracut \
kmod-zstd \
modutils \
perl-Bootloader \
suse-kernel-rpm-scriptlets \
suse-module-tools"

inherit rpm
