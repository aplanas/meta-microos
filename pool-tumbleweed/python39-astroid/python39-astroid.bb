SUMMARY = "Representation of Python source as an AST for pylint"
DESCRIPTION = "This module provides a common base representation of Python source code for \
projects such as pychecker, pyreverse, pylint. The development of this library \
is governed by pylint's needs. \
 \
It provides a compatible representation which comes from the _ast \
module. It rebuilds the tree generated by the builtin _ast module by \
recursively walking down the AST and building an extended ast. The new \
node classes have additional methods and attributes for different \
usages. They include some support for static inference and local name \
scopes. Furthermore, astroid builds partial trees by inspecting living \
objects."
LICENSE = "LGPL-2.1-or-later"

PV = "2.15.5"

RPM_NAME = "python39-astroid-2.15.5-1.3.noarch.rpm"
RPM_HASH = "4ac1928300bafec93c9ff532dfd6af7e812b06b8ed3139e6408656dfec5b50679c0f3e6432c78707ff9e4bfbb70caa0f495e27d7135ea721f5c56f3f206c21fa"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "python3.9dist-astroid \
python39-astroid \
python3dist-astroid"

RDEPENDS:${PN} += "python-abi \
python39-lazy-object-proxy \
python39-typing-extensions \
python39-wrapt"

inherit rpm
