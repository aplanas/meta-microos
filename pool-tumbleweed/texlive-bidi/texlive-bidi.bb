SUMMARY = "Bidirectional typesetting in plain TeX and LaTeX, using XeTeX"
DESCRIPTION = "A convenient interface for typesetting bidirectional texts with \
plain TeX and LaTeX. The package includes adaptations for use \
with many other commonly-used packages."
LICENSE = "LPPL-1.0"

PV = "2023.201.39.7svn65572"

RPM_NAME = "texlive-bidi-2023.201.39.7svn65572-53.1.noarch.rpm"
RPM_HASH = "c9c51c14d0a2237b144b99800edcad705af414d41264cac59767b9d9eb28534afd21168853a58dd8d77bf0ea78f2598883df2d9fc9d749774aac44b2975f50fb"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex(adjmulticol-xetex-bidi.def) \
tex(algorithm2e-xetex-bidi.def) \
tex(amsart-xetex-bidi.def) \
tex(amsbook-xetex-bidi.def) \
tex(amsmath-xetex-bidi.def) \
tex(amstext-xetex-bidi.def) \
tex(amsthm-xetex-bidi.def) \
tex(array-xetex-bidi.def) \
tex(article-xetex-bidi.def) \
tex(artikel1-xetex-bidi.def) \
tex(artikel2-xetex-bidi.def) \
tex(artikel3-xetex-bidi.def) \
tex(arydshln-xetex-bidi.def) \
tex(beamer-xetex-bidi.def) \
tex(beamerbaseauxtemplates-xetex-bidi.def) \
tex(beamerbaseboxes-xetex-bidi.def) \
tex(beamerbasecolor-xetex-bidi.def) \
tex(beamerbasecompatibility-xetex-bidi.def) \
tex(beamerbaseframecomponents-xetex-bidi.def) \
tex(beamerbaseframesize-xetex-bidi.def) \
tex(beamerbaselocalstructure-xetex-bidi.def) \
tex(beamerbasemisc-xetex-bidi.def) \
tex(beamerbasenavigation-xetex-bidi.def) \
tex(beamerbaseoverlay-xetex-bidi.def) \
tex(beamerinnerthemecircles-xetex-bidi.def) \
tex(beamerinnerthemedefault-xetex-bidi.def) \
tex(beamerinnerthemefocus-xetex-bidi.def) \
tex(beamerinnerthemeinmargin-xetex-bidi.def) \
tex(beamerinnerthememetropolis-xetex-bidi.def) \
tex(beamerinnerthemerectangles-xetex-bidi.def) \
tex(beamerinnerthemerounded-xetex-bidi.def) \
tex(beamerouterthemedefault-xetex-bidi.def) \
tex(beamerouterthemefocus-xetex-bidi.def) \
tex(beamerouterthemeinfolines-xetex-bidi.def) \
tex(beamerouterthememetropolis-xetex-bidi.def) \
tex(beamerouterthememiniframes-xetex-bidi.def) \
tex(beamerouterthemeshadow-xetex-bidi.def) \
tex(beamerouterthemesidebar-xetex-bidi.def) \
tex(beamerouterthemesmoothbars-xetex-bidi.def) \
tex(beamerouterthemesmoothtree-xetex-bidi.def) \
tex(beamerouterthemesplit-xetex-bidi.def) \
tex(beamerouterthemetree-xetex-bidi.def) \
tex(beamerthemeHannover-xetex-bidi.def) \
tex(beamerthemeSingapore-xetex-bidi.def) \
tex(bidi-media9.sty) \
tex(bidi-perpage.sty) \
tex(bidi.sty) \
tex(bidi.tex) \
tex(bidi2in1.sty) \
tex(bidicode.sty) \
tex(bidiftnxtra.sty) \
tex(bidimoderncv.cls) \
tex(bidipoem.sty) \
tex(biditools.sty) \
tex(biditufte-book.cls) \
tex(biditufte-handout.cls) \
tex(bidituftefloat.sty) \
tex(bidituftegeneralstructure.sty) \
tex(bidituftehyperref.sty) \
tex(bidituftesidenote.sty) \
tex(bidituftetitle.sty) \
tex(bidituftetoc.sty) \
tex(boek-xetex-bidi.def) \
tex(boek3-xetex-bidi.def) \
tex(book-xetex-bidi.def) \
tex(bookest-xetex-bidi.def) \
tex(breqn-xetex-bidi.def) \
tex(cals-xetex-bidi.def) \
tex(caption-xetex-bidi.def) \
tex(caption3-xetex-bidi.def) \
tex(color-xetex-bidi.def) \
tex(colortbl-xetex-bidi.def) \
tex(combine-xetex-bidi.def) \
tex(crop-xetex-bidi.def) \
tex(cuted-xetex-bidi.def) \
tex(cutwin-xetex-bidi.def) \
tex(cvthemebidicasual.sty) \
tex(cvthemebidiclassic.sty) \
tex(dblfnote-xetex-bidi.def) \
tex(diagbox-xetex-bidi.def) \
tex(draftwatermark-xetex-bidi.def) \
tex(empheq-xetex-bidi.def) \
tex(eso-pic-xetex-bidi.def) \
tex(extarticle-xetex-bidi.def) \
tex(extbook-xetex-bidi.def) \
tex(extletter-xetex-bidi.def) \
tex(extrafootnotefeatures-xetex-bidi.def) \
tex(extreport-xetex-bidi.def) \
tex(fancybox-xetex-bidi.def) \
tex(fancyhdr-xetex-bidi.def) \
tex(fix2col-xetex-bidi.def) \
tex(fleqn-xetex-bidi.def) \
tex(float-xetex-bidi.def) \
tex(floatrow-xetex-bidi.def) \
tex(flowfram-xetex-bidi.def) \
tex(footnote-xetex-bidi.def) \
tex(footnotebackref-xetex-bidi.def) \
tex(framed-xetex-bidi.def) \
tex(ftnright-xetex-bidi.def) \
tex(geometry-xetex-bidi.def) \
tex(graphicx-xetex-bidi.def) \
tex(hvfloat-xetex-bidi.def) \
tex(hyperref-xetex-bidi.def) \
tex(imsproc-xetex-bidi.def) \
tex(latex-xetex-bidi.def) \
tex(leqno-xetex-bidi.def) \
tex(letter-xetex-bidi.def) \
tex(lettrine-xetex-bidi.def) \
tex(lineno-xetex-bidi.def) \
tex(listings-xetex-bidi.def) \
tex(loadingorder-xetex-bidi.def) \
tex(longtable-xetex-bidi.def) \
tex(lscape-xetex-bidi.def) \
tex(mathtools-xetex-bidi.def) \
tex(mdframed-xetex-bidi.def) \
tex(memoir-xetex-bidi.def) \
tex(midfloat-xetex-bidi.def) \
tex(minitoc-xetex-bidi.def) \
tex(multicol-xetex-bidi.def) \
tex(multienum-xetex-bidi.def) \
tex(natbib-xetex-bidi.def) \
tex(newfloat-xetex-bidi.def) \
tex(nicematrix-xetex-bidi.def) \
tex(ntheorem-hyper-xetex-bidi.def) \
tex(ntheorem-xetex-bidi.def) \
tex(overpic-xetex-bidi.def) \
tex(pdfbase-xetex-bidi.def) \
tex(pdflscape-xetex-bidi.def) \
tex(pdfpages-xetex-bidi.def) \
tex(pgfcorescopes.code-xetex-bidi.def) \
tex(pgfsys.code-xetex-bidi.def) \
tex(picinpar-xetex-bidi.def) \
tex(plain-xetex-bidi.def) \
tex(pstricks-xetex-bidi.def) \
tex(quotchap-xetex-bidi.def) \
tex(ragged2e-xetex-bidi.def) \
tex(rapport1-xetex-bidi.def) \
tex(rapport3-xetex-bidi.def) \
tex(refrep-xetex-bidi.def) \
tex(report-xetex-bidi.def) \
tex(rotating-xetex-bidi.def) \
tex(scrartcl-xetex-bidi.def) \
tex(scrbook-xetex-bidi.def) \
tex(scrreprt-xetex-bidi.def) \
tex(sidecap-xetex-bidi.def) \
tex(soul-xetex-bidi.def) \
tex(stabular-xetex-bidi.def) \
tex(subfigure-xetex-bidi.def) \
tex(tabls-xetex-bidi.def) \
tex(tabularx-xetex-bidi.def) \
tex(tabulary-xetex-bidi.def) \
tex(tc-xetex-bidi.def) \
tex(tcolorbox-xetex-bidi.def) \
tex(titlesec-xetex-bidi.def) \
tex(titletoc-xetex-bidi.def) \
tex(tocbasic-xetex-bidi.def) \
tex(tocbibind-xetex-bidi.def) \
tex(tocloft-xetex-bidi.def) \
tex(tocstyle-xetex-bidi.def) \
tex(todonotes-xetex-bidi.def) \
tex(wrapfig-xetex-bidi.def) \
tex(xcolor-xetex-bidi.def) \
tex(xltxtra-xetex-bidi.def) \
texlive-bidi"
RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex(article.cls) \
tex(auxhook.sty) \
tex(bibentry.sty) \
tex(book.cls) \
tex(changepage.sty) \
tex(chngpage.sty) \
tex(color.sty) \
tex(crop.sty) \
tex(fancyhdr.sty) \
tex(floatrow.sty) \
tex(geometry.sty) \
tex(graphicx.sty) \
tex(hyperref.sty) \
tex(iftex.sty) \
tex(ifthen.sty) \
tex(lscape.sty) \
tex(ltxcmds.sty) \
tex(marvosym.sty) \
tex(media9.sty) \
tex(multicol.sty) \
tex(natbib.sty) \
tex(optparams.sty) \
tex(paralist.sty) \
tex(placeins.sty) \
tex(ragged2e.sty) \
tex(setspace.sty) \
tex(showexpl.sty) \
tex(sidecap.sty) \
tex(titlesec.sty) \
tex(titletoc.sty) \
tex(url.sty) \
tex(xcolor.sty) \
tex(xifthen.sty) \
tex(xkeyval.sty) \
tex(zref-abspage.sty) \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
