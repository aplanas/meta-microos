SUMMARY = "Drop-in replacement for Palatino"
DESCRIPTION = "The Domitian fonts are a free and open-source OpenType font \
family, based on the Palatino design by Hermann Zapf \
(1918-2015), as implemented in Palladio, the version \
distributed as part of URW's free Core 35 PostScript fonts \
(2.0). Domitian is meant as a drop-in replacement for Adobe's \
version of Palatino. It extends Palladio with small capitals, \
old-style figures and scientific inferiors. The metrics have \
been adjusted to more closely match Adobe Palatino, and hinting \
has been improved."
LICENSE = "LPPL-1.0"

PV = "2023.201.1.0.1svn55286"

RPM_NAME = "texlive-domitian-2023.201.1.0.1svn55286-52.1.noarch.rpm"
RPM_HASH = "3b820eb4b9a29ea71b2bca0977cda8a0a6cbbfab78ff8e131b8374c8e072050af82a339490b14890ba5fc9c23606ac51c759705532cb4ffbb929b2d74349689d"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-Domitian-Bold-inf-lgr--base.tfm \
tex-Domitian-Bold-inf-lgr.tfm \
tex-Domitian-Bold-inf-lgr.vf \
tex-Domitian-Bold-inf-ly1--base.tfm \
tex-Domitian-Bold-inf-ly1--lcdfj.tfm \
tex-Domitian-Bold-inf-ly1.tfm \
tex-Domitian-Bold-inf-ly1.vf \
tex-Domitian-Bold-inf-ot1--base.tfm \
tex-Domitian-Bold-inf-ot1--lcdfj.tfm \
tex-Domitian-Bold-inf-ot1.tfm \
tex-Domitian-Bold-inf-ot1.vf \
tex-Domitian-Bold-inf-t1--base.tfm \
tex-Domitian-Bold-inf-t1--lcdfj.tfm \
tex-Domitian-Bold-inf-t1.tfm \
tex-Domitian-Bold-inf-t1.vf \
tex-Domitian-Bold-inf-t2a--base.tfm \
tex-Domitian-Bold-inf-t2a--lcdfj.tfm \
tex-Domitian-Bold-inf-t2a.tfm \
tex-Domitian-Bold-inf-t2a.vf \
tex-Domitian-Bold-inf-t2b--base.tfm \
tex-Domitian-Bold-inf-t2b--lcdfj.tfm \
tex-Domitian-Bold-inf-t2b.tfm \
tex-Domitian-Bold-inf-t2b.vf \
tex-Domitian-Bold-inf-t2c--base.tfm \
tex-Domitian-Bold-inf-t2c--lcdfj.tfm \
tex-Domitian-Bold-inf-t2c.tfm \
tex-Domitian-Bold-inf-t2c.vf \
tex-Domitian-Bold-inf-t3--base.tfm \
tex-Domitian-Bold-inf-t3--lcdfj.tfm \
tex-Domitian-Bold-inf-t3.tfm \
tex-Domitian-Bold-inf-t3.vf \
tex-Domitian-Bold-inf-ts3.tfm \
tex-Domitian-Bold-sup-lgr--base.tfm \
tex-Domitian-Bold-sup-lgr.tfm \
tex-Domitian-Bold-sup-lgr.vf \
tex-Domitian-Bold-sup-ly1--base.tfm \
tex-Domitian-Bold-sup-ly1--lcdfj.tfm \
tex-Domitian-Bold-sup-ly1.tfm \
tex-Domitian-Bold-sup-ly1.vf \
tex-Domitian-Bold-sup-ot1--base.tfm \
tex-Domitian-Bold-sup-ot1--lcdfj.tfm \
tex-Domitian-Bold-sup-ot1.tfm \
tex-Domitian-Bold-sup-ot1.vf \
tex-Domitian-Bold-sup-t1--base.tfm \
tex-Domitian-Bold-sup-t1--lcdfj.tfm \
tex-Domitian-Bold-sup-t1.tfm \
tex-Domitian-Bold-sup-t1.vf \
tex-Domitian-Bold-sup-t2a--base.tfm \
tex-Domitian-Bold-sup-t2a--lcdfj.tfm \
tex-Domitian-Bold-sup-t2a.tfm \
tex-Domitian-Bold-sup-t2a.vf \
tex-Domitian-Bold-sup-t2b--base.tfm \
tex-Domitian-Bold-sup-t2b--lcdfj.tfm \
tex-Domitian-Bold-sup-t2b.tfm \
tex-Domitian-Bold-sup-t2b.vf \
tex-Domitian-Bold-sup-t2c--base.tfm \
tex-Domitian-Bold-sup-t2c--lcdfj.tfm \
tex-Domitian-Bold-sup-t2c.tfm \
tex-Domitian-Bold-sup-t2c.vf \
tex-Domitian-Bold-sup-t3--base.tfm \
tex-Domitian-Bold-sup-t3--lcdfj.tfm \
tex-Domitian-Bold-sup-t3.tfm \
tex-Domitian-Bold-sup-t3.vf \
tex-Domitian-Bold-sup-ts3.tfm \
tex-Domitian-Bold-tlf-lgr--base.tfm \
tex-Domitian-Bold-tlf-lgr.tfm \
tex-Domitian-Bold-tlf-lgr.vf \
tex-Domitian-Bold-tlf-ly1--base.tfm \
tex-Domitian-Bold-tlf-ly1--lcdfj.tfm \
tex-Domitian-Bold-tlf-ly1.tfm \
tex-Domitian-Bold-tlf-ly1.vf \
tex-Domitian-Bold-tlf-ot1--base.tfm \
tex-Domitian-Bold-tlf-ot1--lcdfj.tfm \
tex-Domitian-Bold-tlf-ot1.tfm \
tex-Domitian-Bold-tlf-ot1.vf \
tex-Domitian-Bold-tlf-t1--base.tfm \
tex-Domitian-Bold-tlf-t1--lcdfj.tfm \
tex-Domitian-Bold-tlf-t1.tfm \
tex-Domitian-Bold-tlf-t1.vf \
tex-Domitian-Bold-tlf-t2a--base.tfm \
tex-Domitian-Bold-tlf-t2a--lcdfj.tfm \
tex-Domitian-Bold-tlf-t2a.tfm \
tex-Domitian-Bold-tlf-t2a.vf \
tex-Domitian-Bold-tlf-t2b--base.tfm \
tex-Domitian-Bold-tlf-t2b--lcdfj.tfm \
tex-Domitian-Bold-tlf-t2b.tfm \
tex-Domitian-Bold-tlf-t2b.vf \
tex-Domitian-Bold-tlf-t2c--base.tfm \
tex-Domitian-Bold-tlf-t2c--lcdfj.tfm \
tex-Domitian-Bold-tlf-t2c.tfm \
tex-Domitian-Bold-tlf-t2c.vf \
tex-Domitian-Bold-tlf-t3--base.tfm \
tex-Domitian-Bold-tlf-t3--lcdfj.tfm \
tex-Domitian-Bold-tlf-t3.tfm \
tex-Domitian-Bold-tlf-t3.vf \
tex-Domitian-Bold-tlf-ts1--base.tfm \
tex-Domitian-Bold-tlf-ts1.tfm \
tex-Domitian-Bold-tlf-ts1.vf \
tex-Domitian-Bold-tlf-ts3.tfm \
tex-Domitian-Bold-tosf-lgr--base.tfm \
tex-Domitian-Bold-tosf-lgr.tfm \
tex-Domitian-Bold-tosf-lgr.vf \
tex-Domitian-Bold-tosf-ly1--base.tfm \
tex-Domitian-Bold-tosf-ly1--lcdfj.tfm \
tex-Domitian-Bold-tosf-ly1.tfm \
tex-Domitian-Bold-tosf-ly1.vf \
tex-Domitian-Bold-tosf-ot1--base.tfm \
tex-Domitian-Bold-tosf-ot1--lcdfj.tfm \
tex-Domitian-Bold-tosf-ot1.tfm \
tex-Domitian-Bold-tosf-ot1.vf \
tex-Domitian-Bold-tosf-t1--base.tfm \
tex-Domitian-Bold-tosf-t1--lcdfj.tfm \
tex-Domitian-Bold-tosf-t1.tfm \
tex-Domitian-Bold-tosf-t1.vf \
tex-Domitian-Bold-tosf-t2a--base.tfm \
tex-Domitian-Bold-tosf-t2a--lcdfj.tfm \
tex-Domitian-Bold-tosf-t2a.tfm \
tex-Domitian-Bold-tosf-t2a.vf \
tex-Domitian-Bold-tosf-t2b--base.tfm \
tex-Domitian-Bold-tosf-t2b--lcdfj.tfm \
tex-Domitian-Bold-tosf-t2b.tfm \
tex-Domitian-Bold-tosf-t2b.vf \
tex-Domitian-Bold-tosf-t2c--base.tfm \
tex-Domitian-Bold-tosf-t2c--lcdfj.tfm \
tex-Domitian-Bold-tosf-t2c.tfm \
tex-Domitian-Bold-tosf-t2c.vf \
tex-Domitian-Bold-tosf-t3--base.tfm \
tex-Domitian-Bold-tosf-t3--lcdfj.tfm \
tex-Domitian-Bold-tosf-t3.tfm \
tex-Domitian-Bold-tosf-t3.vf \
tex-Domitian-Bold-tosf-ts1--base.tfm \
tex-Domitian-Bold-tosf-ts1.tfm \
tex-Domitian-Bold-tosf-ts1.vf \
tex-Domitian-Bold-tosf-ts3.tfm \
tex-Domitian-BoldItalic-inf-lgr--base.tfm \
tex-Domitian-BoldItalic-inf-lgr.tfm \
tex-Domitian-BoldItalic-inf-lgr.vf \
tex-Domitian-BoldItalic-inf-ly1--base.tfm \
tex-Domitian-BoldItalic-inf-ly1--lcdfj.tfm \
tex-Domitian-BoldItalic-inf-ly1.tfm \
tex-Domitian-BoldItalic-inf-ly1.vf \
tex-Domitian-BoldItalic-inf-ot1--base.tfm \
tex-Domitian-BoldItalic-inf-ot1--lcdfj.tfm \
tex-Domitian-BoldItalic-inf-ot1.tfm \
tex-Domitian-BoldItalic-inf-ot1.vf \
tex-Domitian-BoldItalic-inf-t1--base.tfm \
tex-Domitian-BoldItalic-inf-t1--lcdfj.tfm \
tex-Domitian-BoldItalic-inf-t1.tfm \
tex-Domitian-BoldItalic-inf-t1.vf \
tex-Domitian-BoldItalic-inf-t2a--base.tfm \
tex-Domitian-BoldItalic-inf-t2a--lcdfj.tfm \
tex-Domitian-BoldItalic-inf-t2a.tfm \
tex-Domitian-BoldItalic-inf-t2a.vf \
tex-Domitian-BoldItalic-inf-t2b--base.tfm \
tex-Domitian-BoldItalic-inf-t2b--lcdfj.tfm \
tex-Domitian-BoldItalic-inf-t2b.tfm \
tex-Domitian-BoldItalic-inf-t2b.vf \
tex-Domitian-BoldItalic-inf-t2c--base.tfm \
tex-Domitian-BoldItalic-inf-t2c--lcdfj.tfm \
tex-Domitian-BoldItalic-inf-t2c.tfm \
tex-Domitian-BoldItalic-inf-t2c.vf \
tex-Domitian-BoldItalic-inf-t3--base.tfm \
tex-Domitian-BoldItalic-inf-t3--lcdfj.tfm \
tex-Domitian-BoldItalic-inf-t3.tfm \
tex-Domitian-BoldItalic-inf-t3.vf \
tex-Domitian-BoldItalic-inf-ts3.tfm \
tex-Domitian-BoldItalic-sup-lgr--base.tfm \
tex-Domitian-BoldItalic-sup-lgr.tfm \
tex-Domitian-BoldItalic-sup-lgr.vf \
tex-Domitian-BoldItalic-sup-ly1--base.tfm \
tex-Domitian-BoldItalic-sup-ly1--lcdfj.tfm \
tex-Domitian-BoldItalic-sup-ly1.tfm \
tex-Domitian-BoldItalic-sup-ly1.vf \
tex-Domitian-BoldItalic-sup-ot1--base.tfm \
tex-Domitian-BoldItalic-sup-ot1--lcdfj.tfm \
tex-Domitian-BoldItalic-sup-ot1.tfm \
tex-Domitian-BoldItalic-sup-ot1.vf \
tex-Domitian-BoldItalic-sup-t1--base.tfm \
tex-Domitian-BoldItalic-sup-t1--lcdfj.tfm \
tex-Domitian-BoldItalic-sup-t1.tfm \
tex-Domitian-BoldItalic-sup-t1.vf \
tex-Domitian-BoldItalic-sup-t2a--base.tfm \
tex-Domitian-BoldItalic-sup-t2a--lcdfj.tfm \
tex-Domitian-BoldItalic-sup-t2a.tfm \
tex-Domitian-BoldItalic-sup-t2a.vf \
tex-Domitian-BoldItalic-sup-t2b--base.tfm \
tex-Domitian-BoldItalic-sup-t2b--lcdfj.tfm \
tex-Domitian-BoldItalic-sup-t2b.tfm \
tex-Domitian-BoldItalic-sup-t2b.vf \
tex-Domitian-BoldItalic-sup-t2c--base.tfm \
tex-Domitian-BoldItalic-sup-t2c--lcdfj.tfm \
tex-Domitian-BoldItalic-sup-t2c.tfm \
tex-Domitian-BoldItalic-sup-t2c.vf \
tex-Domitian-BoldItalic-sup-t3--base.tfm \
tex-Domitian-BoldItalic-sup-t3--lcdfj.tfm \
tex-Domitian-BoldItalic-sup-t3.tfm \
tex-Domitian-BoldItalic-sup-t3.vf \
tex-Domitian-BoldItalic-sup-ts3.tfm \
tex-Domitian-BoldItalic-tlf-lgr--base.tfm \
tex-Domitian-BoldItalic-tlf-lgr.tfm \
tex-Domitian-BoldItalic-tlf-lgr.vf \
tex-Domitian-BoldItalic-tlf-ly1--base.tfm \
tex-Domitian-BoldItalic-tlf-ly1--lcdfj.tfm \
tex-Domitian-BoldItalic-tlf-ly1.tfm \
tex-Domitian-BoldItalic-tlf-ly1.vf \
tex-Domitian-BoldItalic-tlf-ot1--base.tfm \
tex-Domitian-BoldItalic-tlf-ot1--lcdfj.tfm \
tex-Domitian-BoldItalic-tlf-ot1.tfm \
tex-Domitian-BoldItalic-tlf-ot1.vf \
tex-Domitian-BoldItalic-tlf-t1--base.tfm \
tex-Domitian-BoldItalic-tlf-t1--lcdfj.tfm \
tex-Domitian-BoldItalic-tlf-t1.tfm \
tex-Domitian-BoldItalic-tlf-t1.vf \
tex-Domitian-BoldItalic-tlf-t2a--base.tfm \
tex-Domitian-BoldItalic-tlf-t2a--lcdfj.tfm \
tex-Domitian-BoldItalic-tlf-t2a.tfm \
tex-Domitian-BoldItalic-tlf-t2a.vf \
tex-Domitian-BoldItalic-tlf-t2b--base.tfm \
tex-Domitian-BoldItalic-tlf-t2b--lcdfj.tfm \
tex-Domitian-BoldItalic-tlf-t2b.tfm \
tex-Domitian-BoldItalic-tlf-t2b.vf \
tex-Domitian-BoldItalic-tlf-t2c--base.tfm \
tex-Domitian-BoldItalic-tlf-t2c--lcdfj.tfm \
tex-Domitian-BoldItalic-tlf-t2c.tfm \
tex-Domitian-BoldItalic-tlf-t2c.vf \
tex-Domitian-BoldItalic-tlf-t3--base.tfm \
tex-Domitian-BoldItalic-tlf-t3--lcdfj.tfm \
tex-Domitian-BoldItalic-tlf-t3.tfm \
tex-Domitian-BoldItalic-tlf-t3.vf \
tex-Domitian-BoldItalic-tlf-ts1--base.tfm \
tex-Domitian-BoldItalic-tlf-ts1.tfm \
tex-Domitian-BoldItalic-tlf-ts1.vf \
tex-Domitian-BoldItalic-tlf-ts3.tfm \
tex-Domitian-BoldItalic-tosf-lgr--base.tfm \
tex-Domitian-BoldItalic-tosf-lgr.tfm \
tex-Domitian-BoldItalic-tosf-lgr.vf \
tex-Domitian-BoldItalic-tosf-ly1--base.tfm \
tex-Domitian-BoldItalic-tosf-ly1--lcdfj.tfm \
tex-Domitian-BoldItalic-tosf-ly1.tfm \
tex-Domitian-BoldItalic-tosf-ly1.vf \
tex-Domitian-BoldItalic-tosf-ot1--base.tfm \
tex-Domitian-BoldItalic-tosf-ot1--lcdfj.tfm \
tex-Domitian-BoldItalic-tosf-ot1.tfm \
tex-Domitian-BoldItalic-tosf-ot1.vf \
tex-Domitian-BoldItalic-tosf-t1--base.tfm \
tex-Domitian-BoldItalic-tosf-t1--lcdfj.tfm \
tex-Domitian-BoldItalic-tosf-t1.tfm \
tex-Domitian-BoldItalic-tosf-t1.vf \
tex-Domitian-BoldItalic-tosf-t2a--base.tfm \
tex-Domitian-BoldItalic-tosf-t2a--lcdfj.tfm \
tex-Domitian-BoldItalic-tosf-t2a.tfm \
tex-Domitian-BoldItalic-tosf-t2a.vf \
tex-Domitian-BoldItalic-tosf-t2b--base.tfm \
tex-Domitian-BoldItalic-tosf-t2b--lcdfj.tfm \
tex-Domitian-BoldItalic-tosf-t2b.tfm \
tex-Domitian-BoldItalic-tosf-t2b.vf \
tex-Domitian-BoldItalic-tosf-t2c--base.tfm \
tex-Domitian-BoldItalic-tosf-t2c--lcdfj.tfm \
tex-Domitian-BoldItalic-tosf-t2c.tfm \
tex-Domitian-BoldItalic-tosf-t2c.vf \
tex-Domitian-BoldItalic-tosf-t3--base.tfm \
tex-Domitian-BoldItalic-tosf-t3--lcdfj.tfm \
tex-Domitian-BoldItalic-tosf-t3.tfm \
tex-Domitian-BoldItalic-tosf-t3.vf \
tex-Domitian-BoldItalic-tosf-ts1--base.tfm \
tex-Domitian-BoldItalic-tosf-ts1.tfm \
tex-Domitian-BoldItalic-tosf-ts1.vf \
tex-Domitian-BoldItalic-tosf-ts3.tfm \
tex-Domitian-Italic-inf-lgr--base.tfm \
tex-Domitian-Italic-inf-lgr.tfm \
tex-Domitian-Italic-inf-lgr.vf \
tex-Domitian-Italic-inf-ly1--base.tfm \
tex-Domitian-Italic-inf-ly1--lcdfj.tfm \
tex-Domitian-Italic-inf-ly1.tfm \
tex-Domitian-Italic-inf-ly1.vf \
tex-Domitian-Italic-inf-ot1--base.tfm \
tex-Domitian-Italic-inf-ot1--lcdfj.tfm \
tex-Domitian-Italic-inf-ot1.tfm \
tex-Domitian-Italic-inf-ot1.vf \
tex-Domitian-Italic-inf-t1--base.tfm \
tex-Domitian-Italic-inf-t1--lcdfj.tfm \
tex-Domitian-Italic-inf-t1.tfm \
tex-Domitian-Italic-inf-t1.vf \
tex-Domitian-Italic-inf-t2a--base.tfm \
tex-Domitian-Italic-inf-t2a--lcdfj.tfm \
tex-Domitian-Italic-inf-t2a.tfm \
tex-Domitian-Italic-inf-t2a.vf \
tex-Domitian-Italic-inf-t2b--base.tfm \
tex-Domitian-Italic-inf-t2b--lcdfj.tfm \
tex-Domitian-Italic-inf-t2b.tfm \
tex-Domitian-Italic-inf-t2b.vf \
tex-Domitian-Italic-inf-t2c--base.tfm \
tex-Domitian-Italic-inf-t2c--lcdfj.tfm \
tex-Domitian-Italic-inf-t2c.tfm \
tex-Domitian-Italic-inf-t2c.vf \
tex-Domitian-Italic-inf-t3--base.tfm \
tex-Domitian-Italic-inf-t3--lcdfj.tfm \
tex-Domitian-Italic-inf-t3.tfm \
tex-Domitian-Italic-inf-t3.vf \
tex-Domitian-Italic-inf-ts3.tfm \
tex-Domitian-Italic-sup-lgr--base.tfm \
tex-Domitian-Italic-sup-lgr.tfm \
tex-Domitian-Italic-sup-lgr.vf \
tex-Domitian-Italic-sup-ly1--base.tfm \
tex-Domitian-Italic-sup-ly1--lcdfj.tfm \
tex-Domitian-Italic-sup-ly1.tfm \
tex-Domitian-Italic-sup-ly1.vf \
tex-Domitian-Italic-sup-ot1--base.tfm \
tex-Domitian-Italic-sup-ot1--lcdfj.tfm \
tex-Domitian-Italic-sup-ot1.tfm \
tex-Domitian-Italic-sup-ot1.vf \
tex-Domitian-Italic-sup-t1--base.tfm \
tex-Domitian-Italic-sup-t1--lcdfj.tfm \
tex-Domitian-Italic-sup-t1.tfm \
tex-Domitian-Italic-sup-t1.vf \
tex-Domitian-Italic-sup-t2a--base.tfm \
tex-Domitian-Italic-sup-t2a--lcdfj.tfm \
tex-Domitian-Italic-sup-t2a.tfm \
tex-Domitian-Italic-sup-t2a.vf \
tex-Domitian-Italic-sup-t2b--base.tfm \
tex-Domitian-Italic-sup-t2b--lcdfj.tfm \
tex-Domitian-Italic-sup-t2b.tfm \
tex-Domitian-Italic-sup-t2b.vf \
tex-Domitian-Italic-sup-t2c--base.tfm \
tex-Domitian-Italic-sup-t2c--lcdfj.tfm \
tex-Domitian-Italic-sup-t2c.tfm \
tex-Domitian-Italic-sup-t2c.vf \
tex-Domitian-Italic-sup-t3--base.tfm \
tex-Domitian-Italic-sup-t3--lcdfj.tfm \
tex-Domitian-Italic-sup-t3.tfm \
tex-Domitian-Italic-sup-t3.vf \
tex-Domitian-Italic-sup-ts3.tfm \
tex-Domitian-Italic-tlf-lgr--base.tfm \
tex-Domitian-Italic-tlf-lgr.tfm \
tex-Domitian-Italic-tlf-lgr.vf \
tex-Domitian-Italic-tlf-ly1--base.tfm \
tex-Domitian-Italic-tlf-ly1--lcdfj.tfm \
tex-Domitian-Italic-tlf-ly1.tfm \
tex-Domitian-Italic-tlf-ly1.vf \
tex-Domitian-Italic-tlf-ot1--base.tfm \
tex-Domitian-Italic-tlf-ot1--lcdfj.tfm \
tex-Domitian-Italic-tlf-ot1.tfm \
tex-Domitian-Italic-tlf-ot1.vf \
tex-Domitian-Italic-tlf-t1--base.tfm \
tex-Domitian-Italic-tlf-t1--lcdfj.tfm \
tex-Domitian-Italic-tlf-t1.tfm \
tex-Domitian-Italic-tlf-t1.vf \
tex-Domitian-Italic-tlf-t2a--base.tfm \
tex-Domitian-Italic-tlf-t2a--lcdfj.tfm \
tex-Domitian-Italic-tlf-t2a.tfm \
tex-Domitian-Italic-tlf-t2a.vf \
tex-Domitian-Italic-tlf-t2b--base.tfm \
tex-Domitian-Italic-tlf-t2b--lcdfj.tfm \
tex-Domitian-Italic-tlf-t2b.tfm \
tex-Domitian-Italic-tlf-t2b.vf \
tex-Domitian-Italic-tlf-t2c--base.tfm \
tex-Domitian-Italic-tlf-t2c--lcdfj.tfm \
tex-Domitian-Italic-tlf-t2c.tfm \
tex-Domitian-Italic-tlf-t2c.vf \
tex-Domitian-Italic-tlf-t3--base.tfm \
tex-Domitian-Italic-tlf-t3--lcdfj.tfm \
tex-Domitian-Italic-tlf-t3.tfm \
tex-Domitian-Italic-tlf-t3.vf \
tex-Domitian-Italic-tlf-ts1--base.tfm \
tex-Domitian-Italic-tlf-ts1.tfm \
tex-Domitian-Italic-tlf-ts1.vf \
tex-Domitian-Italic-tlf-ts3.tfm \
tex-Domitian-Italic-tosf-lgr--base.tfm \
tex-Domitian-Italic-tosf-lgr.tfm \
tex-Domitian-Italic-tosf-lgr.vf \
tex-Domitian-Italic-tosf-ly1--base.tfm \
tex-Domitian-Italic-tosf-ly1--lcdfj.tfm \
tex-Domitian-Italic-tosf-ly1.tfm \
tex-Domitian-Italic-tosf-ly1.vf \
tex-Domitian-Italic-tosf-ot1--base.tfm \
tex-Domitian-Italic-tosf-ot1--lcdfj.tfm \
tex-Domitian-Italic-tosf-ot1.tfm \
tex-Domitian-Italic-tosf-ot1.vf \
tex-Domitian-Italic-tosf-t1--base.tfm \
tex-Domitian-Italic-tosf-t1--lcdfj.tfm \
tex-Domitian-Italic-tosf-t1.tfm \
tex-Domitian-Italic-tosf-t1.vf \
tex-Domitian-Italic-tosf-t2a--base.tfm \
tex-Domitian-Italic-tosf-t2a--lcdfj.tfm \
tex-Domitian-Italic-tosf-t2a.tfm \
tex-Domitian-Italic-tosf-t2a.vf \
tex-Domitian-Italic-tosf-t2b--base.tfm \
tex-Domitian-Italic-tosf-t2b--lcdfj.tfm \
tex-Domitian-Italic-tosf-t2b.tfm \
tex-Domitian-Italic-tosf-t2b.vf \
tex-Domitian-Italic-tosf-t2c--base.tfm \
tex-Domitian-Italic-tosf-t2c--lcdfj.tfm \
tex-Domitian-Italic-tosf-t2c.tfm \
tex-Domitian-Italic-tosf-t2c.vf \
tex-Domitian-Italic-tosf-t3--base.tfm \
tex-Domitian-Italic-tosf-t3--lcdfj.tfm \
tex-Domitian-Italic-tosf-t3.tfm \
tex-Domitian-Italic-tosf-t3.vf \
tex-Domitian-Italic-tosf-ts1--base.tfm \
tex-Domitian-Italic-tosf-ts1.tfm \
tex-Domitian-Italic-tosf-ts1.vf \
tex-Domitian-Italic-tosf-ts3.tfm \
tex-Domitian-Roman-inf-lgr--base.tfm \
tex-Domitian-Roman-inf-lgr.tfm \
tex-Domitian-Roman-inf-lgr.vf \
tex-Domitian-Roman-inf-ly1--base.tfm \
tex-Domitian-Roman-inf-ly1--lcdfj.tfm \
tex-Domitian-Roman-inf-ly1.tfm \
tex-Domitian-Roman-inf-ly1.vf \
tex-Domitian-Roman-inf-ot1--base.tfm \
tex-Domitian-Roman-inf-ot1--lcdfj.tfm \
tex-Domitian-Roman-inf-ot1.tfm \
tex-Domitian-Roman-inf-ot1.vf \
tex-Domitian-Roman-inf-t1--base.tfm \
tex-Domitian-Roman-inf-t1--lcdfj.tfm \
tex-Domitian-Roman-inf-t1.tfm \
tex-Domitian-Roman-inf-t1.vf \
tex-Domitian-Roman-inf-t2a--base.tfm \
tex-Domitian-Roman-inf-t2a--lcdfj.tfm \
tex-Domitian-Roman-inf-t2a.tfm \
tex-Domitian-Roman-inf-t2a.vf \
tex-Domitian-Roman-inf-t2b--base.tfm \
tex-Domitian-Roman-inf-t2b--lcdfj.tfm \
tex-Domitian-Roman-inf-t2b.tfm \
tex-Domitian-Roman-inf-t2b.vf \
tex-Domitian-Roman-inf-t2c--base.tfm \
tex-Domitian-Roman-inf-t2c--lcdfj.tfm \
tex-Domitian-Roman-inf-t2c.tfm \
tex-Domitian-Roman-inf-t2c.vf \
tex-Domitian-Roman-inf-t3--base.tfm \
tex-Domitian-Roman-inf-t3--lcdfj.tfm \
tex-Domitian-Roman-inf-t3.tfm \
tex-Domitian-Roman-inf-t3.vf \
tex-Domitian-Roman-inf-ts3.tfm \
tex-Domitian-Roman-sup-lgr--base.tfm \
tex-Domitian-Roman-sup-lgr.tfm \
tex-Domitian-Roman-sup-lgr.vf \
tex-Domitian-Roman-sup-ly1--base.tfm \
tex-Domitian-Roman-sup-ly1--lcdfj.tfm \
tex-Domitian-Roman-sup-ly1.tfm \
tex-Domitian-Roman-sup-ly1.vf \
tex-Domitian-Roman-sup-ot1--base.tfm \
tex-Domitian-Roman-sup-ot1--lcdfj.tfm \
tex-Domitian-Roman-sup-ot1.tfm \
tex-Domitian-Roman-sup-ot1.vf \
tex-Domitian-Roman-sup-t1--base.tfm \
tex-Domitian-Roman-sup-t1--lcdfj.tfm \
tex-Domitian-Roman-sup-t1.tfm \
tex-Domitian-Roman-sup-t1.vf \
tex-Domitian-Roman-sup-t2a--base.tfm \
tex-Domitian-Roman-sup-t2a--lcdfj.tfm \
tex-Domitian-Roman-sup-t2a.tfm \
tex-Domitian-Roman-sup-t2a.vf \
tex-Domitian-Roman-sup-t2b--base.tfm \
tex-Domitian-Roman-sup-t2b--lcdfj.tfm \
tex-Domitian-Roman-sup-t2b.tfm \
tex-Domitian-Roman-sup-t2b.vf \
tex-Domitian-Roman-sup-t2c--base.tfm \
tex-Domitian-Roman-sup-t2c--lcdfj.tfm \
tex-Domitian-Roman-sup-t2c.tfm \
tex-Domitian-Roman-sup-t2c.vf \
tex-Domitian-Roman-sup-t3--base.tfm \
tex-Domitian-Roman-sup-t3--lcdfj.tfm \
tex-Domitian-Roman-sup-t3.tfm \
tex-Domitian-Roman-sup-t3.vf \
tex-Domitian-Roman-sup-ts3.tfm \
tex-Domitian-Roman-tlf-lgr--base.tfm \
tex-Domitian-Roman-tlf-lgr.tfm \
tex-Domitian-Roman-tlf-lgr.vf \
tex-Domitian-Roman-tlf-ly1--base.tfm \
tex-Domitian-Roman-tlf-ly1--lcdfj.tfm \
tex-Domitian-Roman-tlf-ly1.tfm \
tex-Domitian-Roman-tlf-ly1.vf \
tex-Domitian-Roman-tlf-ot1--base.tfm \
tex-Domitian-Roman-tlf-ot1--lcdfj.tfm \
tex-Domitian-Roman-tlf-ot1.tfm \
tex-Domitian-Roman-tlf-ot1.vf \
tex-Domitian-Roman-tlf-sc-lgr--base.tfm \
tex-Domitian-Roman-tlf-sc-lgr.tfm \
tex-Domitian-Roman-tlf-sc-lgr.vf \
tex-Domitian-Roman-tlf-sc-ly1--base.tfm \
tex-Domitian-Roman-tlf-sc-ly1--lcdfj.tfm \
tex-Domitian-Roman-tlf-sc-ly1.tfm \
tex-Domitian-Roman-tlf-sc-ly1.vf \
tex-Domitian-Roman-tlf-sc-ot1--base.tfm \
tex-Domitian-Roman-tlf-sc-ot1--lcdfj.tfm \
tex-Domitian-Roman-tlf-sc-ot1.tfm \
tex-Domitian-Roman-tlf-sc-ot1.vf \
tex-Domitian-Roman-tlf-sc-t1--base.tfm \
tex-Domitian-Roman-tlf-sc-t1--lcdfj.tfm \
tex-Domitian-Roman-tlf-sc-t1.tfm \
tex-Domitian-Roman-tlf-sc-t1.vf \
tex-Domitian-Roman-tlf-sc-t2a--base.tfm \
tex-Domitian-Roman-tlf-sc-t2a--lcdfj.tfm \
tex-Domitian-Roman-tlf-sc-t2a.tfm \
tex-Domitian-Roman-tlf-sc-t2a.vf \
tex-Domitian-Roman-tlf-sc-t2b--base.tfm \
tex-Domitian-Roman-tlf-sc-t2b--lcdfj.tfm \
tex-Domitian-Roman-tlf-sc-t2b.tfm \
tex-Domitian-Roman-tlf-sc-t2b.vf \
tex-Domitian-Roman-tlf-sc-t2c--base.tfm \
tex-Domitian-Roman-tlf-sc-t2c--lcdfj.tfm \
tex-Domitian-Roman-tlf-sc-t2c.tfm \
tex-Domitian-Roman-tlf-sc-t2c.vf \
tex-Domitian-Roman-tlf-sc-t3--base.tfm \
tex-Domitian-Roman-tlf-sc-t3--lcdfj.tfm \
tex-Domitian-Roman-tlf-sc-t3.tfm \
tex-Domitian-Roman-tlf-sc-t3.vf \
tex-Domitian-Roman-tlf-sc-ts3.tfm \
tex-Domitian-Roman-tlf-t1--base.tfm \
tex-Domitian-Roman-tlf-t1--lcdfj.tfm \
tex-Domitian-Roman-tlf-t1.tfm \
tex-Domitian-Roman-tlf-t1.vf \
tex-Domitian-Roman-tlf-t2a--base.tfm \
tex-Domitian-Roman-tlf-t2a--lcdfj.tfm \
tex-Domitian-Roman-tlf-t2a.tfm \
tex-Domitian-Roman-tlf-t2a.vf \
tex-Domitian-Roman-tlf-t2b--base.tfm \
tex-Domitian-Roman-tlf-t2b--lcdfj.tfm \
tex-Domitian-Roman-tlf-t2b.tfm \
tex-Domitian-Roman-tlf-t2b.vf \
tex-Domitian-Roman-tlf-t2c--base.tfm \
tex-Domitian-Roman-tlf-t2c--lcdfj.tfm \
tex-Domitian-Roman-tlf-t2c.tfm \
tex-Domitian-Roman-tlf-t2c.vf \
tex-Domitian-Roman-tlf-t3--base.tfm \
tex-Domitian-Roman-tlf-t3--lcdfj.tfm \
tex-Domitian-Roman-tlf-t3.tfm \
tex-Domitian-Roman-tlf-t3.vf \
tex-Domitian-Roman-tlf-ts1--base.tfm \
tex-Domitian-Roman-tlf-ts1.tfm \
tex-Domitian-Roman-tlf-ts1.vf \
tex-Domitian-Roman-tlf-ts3.tfm \
tex-Domitian-Roman-tosf-lgr--base.tfm \
tex-Domitian-Roman-tosf-lgr.tfm \
tex-Domitian-Roman-tosf-lgr.vf \
tex-Domitian-Roman-tosf-ly1--base.tfm \
tex-Domitian-Roman-tosf-ly1--lcdfj.tfm \
tex-Domitian-Roman-tosf-ly1.tfm \
tex-Domitian-Roman-tosf-ly1.vf \
tex-Domitian-Roman-tosf-ot1--base.tfm \
tex-Domitian-Roman-tosf-ot1--lcdfj.tfm \
tex-Domitian-Roman-tosf-ot1.tfm \
tex-Domitian-Roman-tosf-ot1.vf \
tex-Domitian-Roman-tosf-sc-lgr--base.tfm \
tex-Domitian-Roman-tosf-sc-lgr.tfm \
tex-Domitian-Roman-tosf-sc-lgr.vf \
tex-Domitian-Roman-tosf-sc-ly1--base.tfm \
tex-Domitian-Roman-tosf-sc-ly1--lcdfj.tfm \
tex-Domitian-Roman-tosf-sc-ly1.tfm \
tex-Domitian-Roman-tosf-sc-ly1.vf \
tex-Domitian-Roman-tosf-sc-ot1--base.tfm \
tex-Domitian-Roman-tosf-sc-ot1--lcdfj.tfm \
tex-Domitian-Roman-tosf-sc-ot1.tfm \
tex-Domitian-Roman-tosf-sc-ot1.vf \
tex-Domitian-Roman-tosf-sc-t1--base.tfm \
tex-Domitian-Roman-tosf-sc-t1--lcdfj.tfm \
tex-Domitian-Roman-tosf-sc-t1.tfm \
tex-Domitian-Roman-tosf-sc-t1.vf \
tex-Domitian-Roman-tosf-sc-t2a--base.tfm \
tex-Domitian-Roman-tosf-sc-t2a--lcdfj.tfm \
tex-Domitian-Roman-tosf-sc-t2a.tfm \
tex-Domitian-Roman-tosf-sc-t2a.vf \
tex-Domitian-Roman-tosf-sc-t2b--base.tfm \
tex-Domitian-Roman-tosf-sc-t2b--lcdfj.tfm \
tex-Domitian-Roman-tosf-sc-t2b.tfm \
tex-Domitian-Roman-tosf-sc-t2b.vf \
tex-Domitian-Roman-tosf-sc-t2c--base.tfm \
tex-Domitian-Roman-tosf-sc-t2c--lcdfj.tfm \
tex-Domitian-Roman-tosf-sc-t2c.tfm \
tex-Domitian-Roman-tosf-sc-t2c.vf \
tex-Domitian-Roman-tosf-sc-ts3.tfm \
tex-Domitian-Roman-tosf-t1--base.tfm \
tex-Domitian-Roman-tosf-t1--lcdfj.tfm \
tex-Domitian-Roman-tosf-t1.tfm \
tex-Domitian-Roman-tosf-t1.vf \
tex-Domitian-Roman-tosf-t2a--base.tfm \
tex-Domitian-Roman-tosf-t2a--lcdfj.tfm \
tex-Domitian-Roman-tosf-t2a.tfm \
tex-Domitian-Roman-tosf-t2a.vf \
tex-Domitian-Roman-tosf-t2b--base.tfm \
tex-Domitian-Roman-tosf-t2b--lcdfj.tfm \
tex-Domitian-Roman-tosf-t2b.tfm \
tex-Domitian-Roman-tosf-t2b.vf \
tex-Domitian-Roman-tosf-t2c--base.tfm \
tex-Domitian-Roman-tosf-t2c--lcdfj.tfm \
tex-Domitian-Roman-tosf-t2c.tfm \
tex-Domitian-Roman-tosf-t2c.vf \
tex-Domitian-Roman-tosf-t3--base.tfm \
tex-Domitian-Roman-tosf-t3--lcdfj.tfm \
tex-Domitian-Roman-tosf-t3.tfm \
tex-Domitian-Roman-tosf-t3.vf \
tex-Domitian-Roman-tosf-ts1--base.tfm \
tex-Domitian-Roman-tosf-ts1.tfm \
tex-Domitian-Roman-tosf-ts1.vf \
tex-Domitian-Roman-tosf-ts3.tfm \
tex-Domitian.map \
tex-LGRDomitian-Inf.fd \
tex-LGRDomitian-Sup.fd \
tex-LGRDomitian-TLF.fd \
tex-LGRDomitian-TOsF.fd \
tex-LY1Domitian-Inf.fd \
tex-LY1Domitian-Sup.fd \
tex-LY1Domitian-TLF.fd \
tex-LY1Domitian-TOsF.fd \
tex-OT1Domitian-Inf.fd \
tex-OT1Domitian-Sup.fd \
tex-OT1Domitian-TLF.fd \
tex-OT1Domitian-TOsF.fd \
tex-T1Domitian-Inf.fd \
tex-T1Domitian-Sup.fd \
tex-T1Domitian-TLF.fd \
tex-T1Domitian-TOsF.fd \
tex-T2ADomitian-Inf.fd \
tex-T2ADomitian-Sup.fd \
tex-T2ADomitian-TLF.fd \
tex-T2ADomitian-TOsF.fd \
tex-T2BDomitian-Inf.fd \
tex-T2BDomitian-Sup.fd \
tex-T2BDomitian-TLF.fd \
tex-T2BDomitian-TOsF.fd \
tex-T2CDomitian-Inf.fd \
tex-T2CDomitian-Sup.fd \
tex-T2CDomitian-TLF.fd \
tex-T2CDomitian-TOsF.fd \
tex-T3Domitian-Inf.fd \
tex-T3Domitian-Sup.fd \
tex-T3Domitian-TLF.fd \
tex-T3Domitian-TOsF.fd \
tex-TS1Domitian-TLF.fd \
tex-TS1Domitian-TOsF.fd \
tex-TS3Domitian-Inf.fd \
tex-TS3Domitian-Sup.fd \
tex-TS3Domitian-TLF.fd \
tex-TS3Domitian-TOsF.fd \
tex-a-35nio2.enc \
tex-a-3pltbn.enc \
tex-a-3w3llx.enc \
tex-a-4ivb7d.enc \
tex-a-6377uz.enc \
tex-a-67soe5.enc \
tex-a-6i6esj.enc \
tex-a-6scvia.enc \
tex-a-7xosgq.enc \
tex-a-b7m3mh.enc \
tex-a-bhlgjd.enc \
tex-a-bwxm6z.enc \
tex-a-c6a6zb.enc \
tex-a-cekwsu.enc \
tex-a-clsg45.enc \
tex-a-d6ffl3.enc \
tex-a-emqd3c.enc \
tex-a-ghqtel.enc \
tex-a-h7ftxd.enc \
tex-a-hjkpcv.enc \
tex-a-hxu6ib.enc \
tex-a-i2hixx.enc \
tex-a-iobvua.enc \
tex-a-jdvb5w.enc \
tex-a-kqwyxb.enc \
tex-a-kvnmfl.enc \
tex-a-lrhprf.enc \
tex-a-m4gebc.enc \
tex-a-mndshu.enc \
tex-a-mpk3tx.enc \
tex-a-ms3bme.enc \
tex-a-mwmumz.enc \
tex-a-mwtjfi.enc \
tex-a-o47vim.enc \
tex-a-oozihx.enc \
tex-a-p3vr7e.enc \
tex-a-p56tga.enc \
tex-a-qd6cjk.enc \
tex-a-qenzo5.enc \
tex-a-qn46nm.enc \
tex-a-rs25bv.enc \
tex-a-rxs5r4.enc \
tex-a-rxxvt2.enc \
tex-a-s2ytkg.enc \
tex-a-uih534.enc \
tex-a-ulgwo3.enc \
tex-a-vbh7z5.enc \
tex-a-veicm7.enc \
tex-a-walexi.enc \
tex-a-x44hng.enc \
tex-a-xammmp.enc \
tex-a-xhkga7.enc \
tex-a-ze7hit.enc \
tex-a-zkzzwq.enc \
tex-domitian.sty \
texlive-domitian"

RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontaxes.sty \
tex-mweights.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-domitian-fonts \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
