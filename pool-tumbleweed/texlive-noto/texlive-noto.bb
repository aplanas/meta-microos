SUMMARY = "Support for Noto fonts"
DESCRIPTION = "This package provides LaTeX, pdfLaTeX, XeLaTeX and LuaLaTeX \
support for the NotoSerif, NotoSans and NotoSansMono families \
of fonts, designed by Steve Matteson for Google."
LICENSE = "LPPL-1.0"

PV = "2023.201.svn64351"

RPM_NAME = "texlive-noto-2023.201.svn64351-54.1.noarch.rpm"
RPM_HASH = "42529fce4d263d6b0fc972625b8b5e63a4914054ecc0360d9a49a0edef59230904edeb93d96a3c7031b9a73012cd7144fdd8affee2e6ed5a1a8921aba896287c"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex(LGRNotoSans-LF.fd) \
tex(LGRNotoSans-OsF.fd) \
tex(LGRNotoSans-Sup.fd) \
tex(LGRNotoSans-TLF.fd) \
tex(LGRNotoSans-TOsF.fd) \
tex(LGRNotoSansMono-Sup.fd) \
tex(LGRNotoSansMono-TLF.fd) \
tex(LGRNotoSansMono-TOsF.fd) \
tex(LGRNotoSerif-LF.fd) \
tex(LGRNotoSerif-OsF.fd) \
tex(LGRNotoSerif-Sup.fd) \
tex(LGRNotoSerif-TLF.fd) \
tex(LGRNotoSerif-TOsF.fd) \
tex(LY1NotoSans-LF.fd) \
tex(LY1NotoSans-OsF.fd) \
tex(LY1NotoSans-Sup.fd) \
tex(LY1NotoSans-TLF.fd) \
tex(LY1NotoSans-TOsF.fd) \
tex(LY1NotoSansMono-Sup.fd) \
tex(LY1NotoSansMono-TLF.fd) \
tex(LY1NotoSansMono-TOsF.fd) \
tex(LY1NotoSerif-LF.fd) \
tex(LY1NotoSerif-OsF.fd) \
tex(LY1NotoSerif-Sup.fd) \
tex(LY1NotoSerif-TLF.fd) \
tex(LY1NotoSerif-TOsF.fd) \
tex(NotoSans-Black-lf-lgr.tfm) \
tex(NotoSans-Black-lf-ly1.tfm) \
tex(NotoSans-Black-lf-ot1.tfm) \
tex(NotoSans-Black-lf-sc-lgr.tfm) \
tex(NotoSans-Black-lf-sc-ly1--base.tfm) \
tex(NotoSans-Black-lf-sc-ly1.tfm) \
tex(NotoSans-Black-lf-sc-ly1.vf) \
tex(NotoSans-Black-lf-sc-ot1--base.tfm) \
tex(NotoSans-Black-lf-sc-ot1.tfm) \
tex(NotoSans-Black-lf-sc-ot1.vf) \
tex(NotoSans-Black-lf-sc-t1--base.tfm) \
tex(NotoSans-Black-lf-sc-t1.tfm) \
tex(NotoSans-Black-lf-sc-t1.vf) \
tex(NotoSans-Black-lf-sc-t2a--base.tfm) \
tex(NotoSans-Black-lf-sc-t2a.tfm) \
tex(NotoSans-Black-lf-sc-t2a.vf) \
tex(NotoSans-Black-lf-sc-t2b--base.tfm) \
tex(NotoSans-Black-lf-sc-t2b.tfm) \
tex(NotoSans-Black-lf-sc-t2b.vf) \
tex(NotoSans-Black-lf-sc-t2c--base.tfm) \
tex(NotoSans-Black-lf-sc-t2c.tfm) \
tex(NotoSans-Black-lf-sc-t2c.vf) \
tex(NotoSans-Black-lf-t1--base.tfm) \
tex(NotoSans-Black-lf-t1.tfm) \
tex(NotoSans-Black-lf-t1.vf) \
tex(NotoSans-Black-lf-t2a.tfm) \
tex(NotoSans-Black-lf-t2b.tfm) \
tex(NotoSans-Black-lf-t2c.tfm) \
tex(NotoSans-Black-lf-ts1--base.tfm) \
tex(NotoSans-Black-lf-ts1.tfm) \
tex(NotoSans-Black-lf-ts1.vf) \
tex(NotoSans-Black-osf-lgr.tfm) \
tex(NotoSans-Black-osf-ly1.tfm) \
tex(NotoSans-Black-osf-ot1.tfm) \
tex(NotoSans-Black-osf-sc-lgr.tfm) \
tex(NotoSans-Black-osf-sc-ly1--base.tfm) \
tex(NotoSans-Black-osf-sc-ly1.tfm) \
tex(NotoSans-Black-osf-sc-ly1.vf) \
tex(NotoSans-Black-osf-sc-ot1--base.tfm) \
tex(NotoSans-Black-osf-sc-ot1.tfm) \
tex(NotoSans-Black-osf-sc-ot1.vf) \
tex(NotoSans-Black-osf-sc-t1--base.tfm) \
tex(NotoSans-Black-osf-sc-t1.tfm) \
tex(NotoSans-Black-osf-sc-t1.vf) \
tex(NotoSans-Black-osf-sc-t2a--base.tfm) \
tex(NotoSans-Black-osf-sc-t2a.tfm) \
tex(NotoSans-Black-osf-sc-t2a.vf) \
tex(NotoSans-Black-osf-sc-t2b--base.tfm) \
tex(NotoSans-Black-osf-sc-t2b.tfm) \
tex(NotoSans-Black-osf-sc-t2b.vf) \
tex(NotoSans-Black-osf-sc-t2c--base.tfm) \
tex(NotoSans-Black-osf-sc-t2c.tfm) \
tex(NotoSans-Black-osf-sc-t2c.vf) \
tex(NotoSans-Black-osf-t1--base.tfm) \
tex(NotoSans-Black-osf-t1.tfm) \
tex(NotoSans-Black-osf-t1.vf) \
tex(NotoSans-Black-osf-t2a.tfm) \
tex(NotoSans-Black-osf-t2b.tfm) \
tex(NotoSans-Black-osf-t2c.tfm) \
tex(NotoSans-Black-osf-ts1--base.tfm) \
tex(NotoSans-Black-osf-ts1.tfm) \
tex(NotoSans-Black-osf-ts1.vf) \
tex(NotoSans-Black-sup-lgr.tfm) \
tex(NotoSans-Black-sup-ly1.tfm) \
tex(NotoSans-Black-sup-ot1.tfm) \
tex(NotoSans-Black-sup-t1--base.tfm) \
tex(NotoSans-Black-sup-t1.tfm) \
tex(NotoSans-Black-sup-t1.vf) \
tex(NotoSans-Black-sup-t2a.tfm) \
tex(NotoSans-Black-sup-t2b.tfm) \
tex(NotoSans-Black-sup-t2c.tfm) \
tex(NotoSans-Black-tlf-lgr.tfm) \
tex(NotoSans-Black-tlf-ly1.tfm) \
tex(NotoSans-Black-tlf-ot1.tfm) \
tex(NotoSans-Black-tlf-sc-lgr.tfm) \
tex(NotoSans-Black-tlf-sc-ly1--base.tfm) \
tex(NotoSans-Black-tlf-sc-ly1.tfm) \
tex(NotoSans-Black-tlf-sc-ly1.vf) \
tex(NotoSans-Black-tlf-sc-ot1--base.tfm) \
tex(NotoSans-Black-tlf-sc-ot1.tfm) \
tex(NotoSans-Black-tlf-sc-ot1.vf) \
tex(NotoSans-Black-tlf-sc-t1--base.tfm) \
tex(NotoSans-Black-tlf-sc-t1.tfm) \
tex(NotoSans-Black-tlf-sc-t1.vf) \
tex(NotoSans-Black-tlf-sc-t2a--base.tfm) \
tex(NotoSans-Black-tlf-sc-t2a.tfm) \
tex(NotoSans-Black-tlf-sc-t2a.vf) \
tex(NotoSans-Black-tlf-sc-t2b--base.tfm) \
tex(NotoSans-Black-tlf-sc-t2b.tfm) \
tex(NotoSans-Black-tlf-sc-t2b.vf) \
tex(NotoSans-Black-tlf-sc-t2c--base.tfm) \
tex(NotoSans-Black-tlf-sc-t2c.tfm) \
tex(NotoSans-Black-tlf-sc-t2c.vf) \
tex(NotoSans-Black-tlf-t1--base.tfm) \
tex(NotoSans-Black-tlf-t1.tfm) \
tex(NotoSans-Black-tlf-t1.vf) \
tex(NotoSans-Black-tlf-t2a.tfm) \
tex(NotoSans-Black-tlf-t2b.tfm) \
tex(NotoSans-Black-tlf-t2c.tfm) \
tex(NotoSans-Black-tlf-ts1--base.tfm) \
tex(NotoSans-Black-tlf-ts1.tfm) \
tex(NotoSans-Black-tlf-ts1.vf) \
tex(NotoSans-Black-tosf-lgr.tfm) \
tex(NotoSans-Black-tosf-ly1.tfm) \
tex(NotoSans-Black-tosf-ot1.tfm) \
tex(NotoSans-Black-tosf-sc-lgr.tfm) \
tex(NotoSans-Black-tosf-sc-ly1--base.tfm) \
tex(NotoSans-Black-tosf-sc-ly1.tfm) \
tex(NotoSans-Black-tosf-sc-ly1.vf) \
tex(NotoSans-Black-tosf-sc-ot1--base.tfm) \
tex(NotoSans-Black-tosf-sc-ot1.tfm) \
tex(NotoSans-Black-tosf-sc-ot1.vf) \
tex(NotoSans-Black-tosf-sc-t1--base.tfm) \
tex(NotoSans-Black-tosf-sc-t1.tfm) \
tex(NotoSans-Black-tosf-sc-t1.vf) \
tex(NotoSans-Black-tosf-sc-t2a--base.tfm) \
tex(NotoSans-Black-tosf-sc-t2a.tfm) \
tex(NotoSans-Black-tosf-sc-t2a.vf) \
tex(NotoSans-Black-tosf-sc-t2b--base.tfm) \
tex(NotoSans-Black-tosf-sc-t2b.tfm) \
tex(NotoSans-Black-tosf-sc-t2b.vf) \
tex(NotoSans-Black-tosf-sc-t2c--base.tfm) \
tex(NotoSans-Black-tosf-sc-t2c.tfm) \
tex(NotoSans-Black-tosf-sc-t2c.vf) \
tex(NotoSans-Black-tosf-t1--base.tfm) \
tex(NotoSans-Black-tosf-t1.tfm) \
tex(NotoSans-Black-tosf-t1.vf) \
tex(NotoSans-Black-tosf-t2a.tfm) \
tex(NotoSans-Black-tosf-t2b.tfm) \
tex(NotoSans-Black-tosf-t2c.tfm) \
tex(NotoSans-Black-tosf-ts1--base.tfm) \
tex(NotoSans-Black-tosf-ts1.tfm) \
tex(NotoSans-Black-tosf-ts1.vf) \
tex(NotoSans-BlackItalic-lf-lgr.tfm) \
tex(NotoSans-BlackItalic-lf-ly1.tfm) \
tex(NotoSans-BlackItalic-lf-ot1.tfm) \
tex(NotoSans-BlackItalic-lf-sc-lgr.tfm) \
tex(NotoSans-BlackItalic-lf-sc-ly1--base.tfm) \
tex(NotoSans-BlackItalic-lf-sc-ly1.tfm) \
tex(NotoSans-BlackItalic-lf-sc-ly1.vf) \
tex(NotoSans-BlackItalic-lf-sc-ot1--base.tfm) \
tex(NotoSans-BlackItalic-lf-sc-ot1.tfm) \
tex(NotoSans-BlackItalic-lf-sc-ot1.vf) \
tex(NotoSans-BlackItalic-lf-sc-t1--base.tfm) \
tex(NotoSans-BlackItalic-lf-sc-t1.tfm) \
tex(NotoSans-BlackItalic-lf-sc-t1.vf) \
tex(NotoSans-BlackItalic-lf-sc-t2a--base.tfm) \
tex(NotoSans-BlackItalic-lf-sc-t2a.tfm) \
tex(NotoSans-BlackItalic-lf-sc-t2a.vf) \
tex(NotoSans-BlackItalic-lf-sc-t2b--base.tfm) \
tex(NotoSans-BlackItalic-lf-sc-t2b.tfm) \
tex(NotoSans-BlackItalic-lf-sc-t2b.vf) \
tex(NotoSans-BlackItalic-lf-sc-t2c--base.tfm) \
tex(NotoSans-BlackItalic-lf-sc-t2c.tfm) \
tex(NotoSans-BlackItalic-lf-sc-t2c.vf) \
tex(NotoSans-BlackItalic-lf-t1--base.tfm) \
tex(NotoSans-BlackItalic-lf-t1.tfm) \
tex(NotoSans-BlackItalic-lf-t1.vf) \
tex(NotoSans-BlackItalic-lf-t2a.tfm) \
tex(NotoSans-BlackItalic-lf-t2b.tfm) \
tex(NotoSans-BlackItalic-lf-t2c.tfm) \
tex(NotoSans-BlackItalic-lf-ts1--base.tfm) \
tex(NotoSans-BlackItalic-lf-ts1.tfm) \
tex(NotoSans-BlackItalic-lf-ts1.vf) \
tex(NotoSans-BlackItalic-osf-lgr.tfm) \
tex(NotoSans-BlackItalic-osf-ly1.tfm) \
tex(NotoSans-BlackItalic-osf-ot1.tfm) \
tex(NotoSans-BlackItalic-osf-sc-lgr.tfm) \
tex(NotoSans-BlackItalic-osf-sc-ly1--base.tfm) \
tex(NotoSans-BlackItalic-osf-sc-ly1.tfm) \
tex(NotoSans-BlackItalic-osf-sc-ly1.vf) \
tex(NotoSans-BlackItalic-osf-sc-ot1--base.tfm) \
tex(NotoSans-BlackItalic-osf-sc-ot1.tfm) \
tex(NotoSans-BlackItalic-osf-sc-ot1.vf) \
tex(NotoSans-BlackItalic-osf-sc-t1--base.tfm) \
tex(NotoSans-BlackItalic-osf-sc-t1.tfm) \
tex(NotoSans-BlackItalic-osf-sc-t1.vf) \
tex(NotoSans-BlackItalic-osf-sc-t2a--base.tfm) \
tex(NotoSans-BlackItalic-osf-sc-t2a.tfm) \
tex(NotoSans-BlackItalic-osf-sc-t2a.vf) \
tex(NotoSans-BlackItalic-osf-sc-t2b--base.tfm) \
tex(NotoSans-BlackItalic-osf-sc-t2b.tfm) \
tex(NotoSans-BlackItalic-osf-sc-t2b.vf) \
tex(NotoSans-BlackItalic-osf-sc-t2c--base.tfm) \
tex(NotoSans-BlackItalic-osf-sc-t2c.tfm) \
tex(NotoSans-BlackItalic-osf-sc-t2c.vf) \
tex(NotoSans-BlackItalic-osf-t1--base.tfm) \
tex(NotoSans-BlackItalic-osf-t1.tfm) \
tex(NotoSans-BlackItalic-osf-t1.vf) \
tex(NotoSans-BlackItalic-osf-t2a.tfm) \
tex(NotoSans-BlackItalic-osf-t2b.tfm) \
tex(NotoSans-BlackItalic-osf-t2c.tfm) \
tex(NotoSans-BlackItalic-osf-ts1--base.tfm) \
tex(NotoSans-BlackItalic-osf-ts1.tfm) \
tex(NotoSans-BlackItalic-osf-ts1.vf) \
tex(NotoSans-BlackItalic-sup-lgr.tfm) \
tex(NotoSans-BlackItalic-sup-ly1.tfm) \
tex(NotoSans-BlackItalic-sup-ot1.tfm) \
tex(NotoSans-BlackItalic-sup-t1--base.tfm) \
tex(NotoSans-BlackItalic-sup-t1.tfm) \
tex(NotoSans-BlackItalic-sup-t1.vf) \
tex(NotoSans-BlackItalic-sup-t2a.tfm) \
tex(NotoSans-BlackItalic-sup-t2b.tfm) \
tex(NotoSans-BlackItalic-sup-t2c.tfm) \
tex(NotoSans-BlackItalic-tlf-lgr.tfm) \
tex(NotoSans-BlackItalic-tlf-ly1.tfm) \
tex(NotoSans-BlackItalic-tlf-ot1.tfm) \
tex(NotoSans-BlackItalic-tlf-sc-lgr.tfm) \
tex(NotoSans-BlackItalic-tlf-sc-ly1--base.tfm) \
tex(NotoSans-BlackItalic-tlf-sc-ly1.tfm) \
tex(NotoSans-BlackItalic-tlf-sc-ly1.vf) \
tex(NotoSans-BlackItalic-tlf-sc-ot1--base.tfm) \
tex(NotoSans-BlackItalic-tlf-sc-ot1.tfm) \
tex(NotoSans-BlackItalic-tlf-sc-ot1.vf) \
tex(NotoSans-BlackItalic-tlf-sc-t1--base.tfm) \
tex(NotoSans-BlackItalic-tlf-sc-t1.tfm) \
tex(NotoSans-BlackItalic-tlf-sc-t1.vf) \
tex(NotoSans-BlackItalic-tlf-sc-t2a--base.tfm) \
tex(NotoSans-BlackItalic-tlf-sc-t2a.tfm) \
tex(NotoSans-BlackItalic-tlf-sc-t2a.vf) \
tex(NotoSans-BlackItalic-tlf-sc-t2b--base.tfm) \
tex(NotoSans-BlackItalic-tlf-sc-t2b.tfm) \
tex(NotoSans-BlackItalic-tlf-sc-t2b.vf) \
tex(NotoSans-BlackItalic-tlf-sc-t2c--base.tfm) \
tex(NotoSans-BlackItalic-tlf-sc-t2c.tfm) \
tex(NotoSans-BlackItalic-tlf-sc-t2c.vf) \
tex(NotoSans-BlackItalic-tlf-t1--base.tfm) \
tex(NotoSans-BlackItalic-tlf-t1.tfm) \
tex(NotoSans-BlackItalic-tlf-t1.vf) \
tex(NotoSans-BlackItalic-tlf-t2a.tfm) \
tex(NotoSans-BlackItalic-tlf-t2b.tfm) \
tex(NotoSans-BlackItalic-tlf-t2c.tfm) \
tex(NotoSans-BlackItalic-tlf-ts1--base.tfm) \
tex(NotoSans-BlackItalic-tlf-ts1.tfm) \
tex(NotoSans-BlackItalic-tlf-ts1.vf) \
tex(NotoSans-BlackItalic-tosf-lgr.tfm) \
tex(NotoSans-BlackItalic-tosf-ly1.tfm) \
tex(NotoSans-BlackItalic-tosf-ot1.tfm) \
tex(NotoSans-BlackItalic-tosf-sc-lgr.tfm) \
tex(NotoSans-BlackItalic-tosf-sc-ly1--base.tfm) \
tex(NotoSans-BlackItalic-tosf-sc-ly1.tfm) \
tex(NotoSans-BlackItalic-tosf-sc-ly1.vf) \
tex(NotoSans-BlackItalic-tosf-sc-ot1--base.tfm) \
tex(NotoSans-BlackItalic-tosf-sc-ot1.tfm) \
tex(NotoSans-BlackItalic-tosf-sc-ot1.vf) \
tex(NotoSans-BlackItalic-tosf-sc-t1--base.tfm) \
tex(NotoSans-BlackItalic-tosf-sc-t1.tfm) \
tex(NotoSans-BlackItalic-tosf-sc-t1.vf) \
tex(NotoSans-BlackItalic-tosf-sc-t2a--base.tfm) \
tex(NotoSans-BlackItalic-tosf-sc-t2a.tfm) \
tex(NotoSans-BlackItalic-tosf-sc-t2a.vf) \
tex(NotoSans-BlackItalic-tosf-sc-t2b--base.tfm) \
tex(NotoSans-BlackItalic-tosf-sc-t2b.tfm) \
tex(NotoSans-BlackItalic-tosf-sc-t2b.vf) \
tex(NotoSans-BlackItalic-tosf-sc-t2c--base.tfm) \
tex(NotoSans-BlackItalic-tosf-sc-t2c.tfm) \
tex(NotoSans-BlackItalic-tosf-sc-t2c.vf) \
tex(NotoSans-BlackItalic-tosf-t1--base.tfm) \
tex(NotoSans-BlackItalic-tosf-t1.tfm) \
tex(NotoSans-BlackItalic-tosf-t1.vf) \
tex(NotoSans-BlackItalic-tosf-t2a.tfm) \
tex(NotoSans-BlackItalic-tosf-t2b.tfm) \
tex(NotoSans-BlackItalic-tosf-t2c.tfm) \
tex(NotoSans-BlackItalic-tosf-ts1--base.tfm) \
tex(NotoSans-BlackItalic-tosf-ts1.tfm) \
tex(NotoSans-BlackItalic-tosf-ts1.vf) \
tex(NotoSans-Bold-lf-lgr.tfm) \
tex(NotoSans-Bold-lf-ly1.tfm) \
tex(NotoSans-Bold-lf-ot1.tfm) \
tex(NotoSans-Bold-lf-sc-lgr.tfm) \
tex(NotoSans-Bold-lf-sc-ly1--base.tfm) \
tex(NotoSans-Bold-lf-sc-ly1.tfm) \
tex(NotoSans-Bold-lf-sc-ly1.vf) \
tex(NotoSans-Bold-lf-sc-ot1--base.tfm) \
tex(NotoSans-Bold-lf-sc-ot1.tfm) \
tex(NotoSans-Bold-lf-sc-ot1.vf) \
tex(NotoSans-Bold-lf-sc-t1--base.tfm) \
tex(NotoSans-Bold-lf-sc-t1.tfm) \
tex(NotoSans-Bold-lf-sc-t1.vf) \
tex(NotoSans-Bold-lf-sc-t2a--base.tfm) \
tex(NotoSans-Bold-lf-sc-t2a.tfm) \
tex(NotoSans-Bold-lf-sc-t2a.vf) \
tex(NotoSans-Bold-lf-sc-t2b--base.tfm) \
tex(NotoSans-Bold-lf-sc-t2b.tfm) \
tex(NotoSans-Bold-lf-sc-t2b.vf) \
tex(NotoSans-Bold-lf-sc-t2c--base.tfm) \
tex(NotoSans-Bold-lf-sc-t2c.tfm) \
tex(NotoSans-Bold-lf-sc-t2c.vf) \
tex(NotoSans-Bold-lf-t1--base.tfm) \
tex(NotoSans-Bold-lf-t1.tfm) \
tex(NotoSans-Bold-lf-t1.vf) \
tex(NotoSans-Bold-lf-t2a.tfm) \
tex(NotoSans-Bold-lf-t2b.tfm) \
tex(NotoSans-Bold-lf-t2c.tfm) \
tex(NotoSans-Bold-lf-ts1--base.tfm) \
tex(NotoSans-Bold-lf-ts1.tfm) \
tex(NotoSans-Bold-lf-ts1.vf) \
tex(NotoSans-Bold-osf-lgr.tfm) \
tex(NotoSans-Bold-osf-ly1.tfm) \
tex(NotoSans-Bold-osf-ot1.tfm) \
tex(NotoSans-Bold-osf-sc-lgr.tfm) \
tex(NotoSans-Bold-osf-sc-ly1--base.tfm) \
tex(NotoSans-Bold-osf-sc-ly1.tfm) \
tex(NotoSans-Bold-osf-sc-ly1.vf) \
tex(NotoSans-Bold-osf-sc-ot1--base.tfm) \
tex(NotoSans-Bold-osf-sc-ot1.tfm) \
tex(NotoSans-Bold-osf-sc-ot1.vf) \
tex(NotoSans-Bold-osf-sc-t1--base.tfm) \
tex(NotoSans-Bold-osf-sc-t1.tfm) \
tex(NotoSans-Bold-osf-sc-t1.vf) \
tex(NotoSans-Bold-osf-sc-t2a--base.tfm) \
tex(NotoSans-Bold-osf-sc-t2a.tfm) \
tex(NotoSans-Bold-osf-sc-t2a.vf) \
tex(NotoSans-Bold-osf-sc-t2b--base.tfm) \
tex(NotoSans-Bold-osf-sc-t2b.tfm) \
tex(NotoSans-Bold-osf-sc-t2b.vf) \
tex(NotoSans-Bold-osf-sc-t2c--base.tfm) \
tex(NotoSans-Bold-osf-sc-t2c.tfm) \
tex(NotoSans-Bold-osf-sc-t2c.vf) \
tex(NotoSans-Bold-osf-t1--base.tfm) \
tex(NotoSans-Bold-osf-t1.tfm) \
tex(NotoSans-Bold-osf-t1.vf) \
tex(NotoSans-Bold-osf-t2a.tfm) \
tex(NotoSans-Bold-osf-t2b.tfm) \
tex(NotoSans-Bold-osf-t2c.tfm) \
tex(NotoSans-Bold-osf-ts1--base.tfm) \
tex(NotoSans-Bold-osf-ts1.tfm) \
tex(NotoSans-Bold-osf-ts1.vf) \
tex(NotoSans-Bold-sup-lgr.tfm) \
tex(NotoSans-Bold-sup-ly1.tfm) \
tex(NotoSans-Bold-sup-ot1.tfm) \
tex(NotoSans-Bold-sup-t1--base.tfm) \
tex(NotoSans-Bold-sup-t1.tfm) \
tex(NotoSans-Bold-sup-t1.vf) \
tex(NotoSans-Bold-sup-t2a.tfm) \
tex(NotoSans-Bold-sup-t2b.tfm) \
tex(NotoSans-Bold-sup-t2c.tfm) \
tex(NotoSans-Bold-tlf-lgr.tfm) \
tex(NotoSans-Bold-tlf-ly1.tfm) \
tex(NotoSans-Bold-tlf-ot1.tfm) \
tex(NotoSans-Bold-tlf-sc-lgr.tfm) \
tex(NotoSans-Bold-tlf-sc-ly1--base.tfm) \
tex(NotoSans-Bold-tlf-sc-ly1.tfm) \
tex(NotoSans-Bold-tlf-sc-ly1.vf) \
tex(NotoSans-Bold-tlf-sc-ot1--base.tfm) \
tex(NotoSans-Bold-tlf-sc-ot1.tfm) \
tex(NotoSans-Bold-tlf-sc-ot1.vf) \
tex(NotoSans-Bold-tlf-sc-t1--base.tfm) \
tex(NotoSans-Bold-tlf-sc-t1.tfm) \
tex(NotoSans-Bold-tlf-sc-t1.vf) \
tex(NotoSans-Bold-tlf-sc-t2a--base.tfm) \
tex(NotoSans-Bold-tlf-sc-t2a.tfm) \
tex(NotoSans-Bold-tlf-sc-t2a.vf) \
tex(NotoSans-Bold-tlf-sc-t2b--base.tfm) \
tex(NotoSans-Bold-tlf-sc-t2b.tfm) \
tex(NotoSans-Bold-tlf-sc-t2b.vf) \
tex(NotoSans-Bold-tlf-sc-t2c--base.tfm) \
tex(NotoSans-Bold-tlf-sc-t2c.tfm) \
tex(NotoSans-Bold-tlf-sc-t2c.vf) \
tex(NotoSans-Bold-tlf-t1--base.tfm) \
tex(NotoSans-Bold-tlf-t1.tfm) \
tex(NotoSans-Bold-tlf-t1.vf) \
tex(NotoSans-Bold-tlf-t2a.tfm) \
tex(NotoSans-Bold-tlf-t2b.tfm) \
tex(NotoSans-Bold-tlf-t2c.tfm) \
tex(NotoSans-Bold-tlf-ts1--base.tfm) \
tex(NotoSans-Bold-tlf-ts1.tfm) \
tex(NotoSans-Bold-tlf-ts1.vf) \
tex(NotoSans-Bold-tosf-lgr.tfm) \
tex(NotoSans-Bold-tosf-ly1.tfm) \
tex(NotoSans-Bold-tosf-ot1.tfm) \
tex(NotoSans-Bold-tosf-sc-lgr.tfm) \
tex(NotoSans-Bold-tosf-sc-ly1--base.tfm) \
tex(NotoSans-Bold-tosf-sc-ly1.tfm) \
tex(NotoSans-Bold-tosf-sc-ly1.vf) \
tex(NotoSans-Bold-tosf-sc-ot1--base.tfm) \
tex(NotoSans-Bold-tosf-sc-ot1.tfm) \
tex(NotoSans-Bold-tosf-sc-ot1.vf) \
tex(NotoSans-Bold-tosf-sc-t1--base.tfm) \
tex(NotoSans-Bold-tosf-sc-t1.tfm) \
tex(NotoSans-Bold-tosf-sc-t1.vf) \
tex(NotoSans-Bold-tosf-sc-t2a--base.tfm) \
tex(NotoSans-Bold-tosf-sc-t2a.tfm) \
tex(NotoSans-Bold-tosf-sc-t2a.vf) \
tex(NotoSans-Bold-tosf-sc-t2b--base.tfm) \
tex(NotoSans-Bold-tosf-sc-t2b.tfm) \
tex(NotoSans-Bold-tosf-sc-t2b.vf) \
tex(NotoSans-Bold-tosf-sc-t2c--base.tfm) \
tex(NotoSans-Bold-tosf-sc-t2c.tfm) \
tex(NotoSans-Bold-tosf-sc-t2c.vf) \
tex(NotoSans-Bold-tosf-t1--base.tfm) \
tex(NotoSans-Bold-tosf-t1.tfm) \
tex(NotoSans-Bold-tosf-t1.vf) \
tex(NotoSans-Bold-tosf-t2a.tfm) \
tex(NotoSans-Bold-tosf-t2b.tfm) \
tex(NotoSans-Bold-tosf-t2c.tfm) \
tex(NotoSans-Bold-tosf-ts1--base.tfm) \
tex(NotoSans-Bold-tosf-ts1.tfm) \
tex(NotoSans-Bold-tosf-ts1.vf) \
tex(NotoSans-BoldItalic-lf-lgr.tfm) \
tex(NotoSans-BoldItalic-lf-ly1.tfm) \
tex(NotoSans-BoldItalic-lf-ot1.tfm) \
tex(NotoSans-BoldItalic-lf-sc-lgr.tfm) \
tex(NotoSans-BoldItalic-lf-sc-ly1--base.tfm) \
tex(NotoSans-BoldItalic-lf-sc-ly1.tfm) \
tex(NotoSans-BoldItalic-lf-sc-ly1.vf) \
tex(NotoSans-BoldItalic-lf-sc-ot1--base.tfm) \
tex(NotoSans-BoldItalic-lf-sc-ot1.tfm) \
tex(NotoSans-BoldItalic-lf-sc-ot1.vf) \
tex(NotoSans-BoldItalic-lf-sc-t1--base.tfm) \
tex(NotoSans-BoldItalic-lf-sc-t1.tfm) \
tex(NotoSans-BoldItalic-lf-sc-t1.vf) \
tex(NotoSans-BoldItalic-lf-sc-t2a--base.tfm) \
tex(NotoSans-BoldItalic-lf-sc-t2a.tfm) \
tex(NotoSans-BoldItalic-lf-sc-t2a.vf) \
tex(NotoSans-BoldItalic-lf-sc-t2b--base.tfm) \
tex(NotoSans-BoldItalic-lf-sc-t2b.tfm) \
tex(NotoSans-BoldItalic-lf-sc-t2b.vf) \
tex(NotoSans-BoldItalic-lf-sc-t2c--base.tfm) \
tex(NotoSans-BoldItalic-lf-sc-t2c.tfm) \
tex(NotoSans-BoldItalic-lf-sc-t2c.vf) \
tex(NotoSans-BoldItalic-lf-t1--base.tfm) \
tex(NotoSans-BoldItalic-lf-t1.tfm) \
tex(NotoSans-BoldItalic-lf-t1.vf) \
tex(NotoSans-BoldItalic-lf-t2a.tfm) \
tex(NotoSans-BoldItalic-lf-t2b.tfm) \
tex(NotoSans-BoldItalic-lf-t2c.tfm) \
tex(NotoSans-BoldItalic-lf-ts1--base.tfm) \
tex(NotoSans-BoldItalic-lf-ts1.tfm) \
tex(NotoSans-BoldItalic-lf-ts1.vf) \
tex(NotoSans-BoldItalic-osf-lgr.tfm) \
tex(NotoSans-BoldItalic-osf-ly1.tfm) \
tex(NotoSans-BoldItalic-osf-ot1.tfm) \
tex(NotoSans-BoldItalic-osf-sc-lgr.tfm) \
tex(NotoSans-BoldItalic-osf-sc-ly1--base.tfm) \
tex(NotoSans-BoldItalic-osf-sc-ly1.tfm) \
tex(NotoSans-BoldItalic-osf-sc-ly1.vf) \
tex(NotoSans-BoldItalic-osf-sc-ot1--base.tfm) \
tex(NotoSans-BoldItalic-osf-sc-ot1.tfm) \
tex(NotoSans-BoldItalic-osf-sc-ot1.vf) \
tex(NotoSans-BoldItalic-osf-sc-t1--base.tfm) \
tex(NotoSans-BoldItalic-osf-sc-t1.tfm) \
tex(NotoSans-BoldItalic-osf-sc-t1.vf) \
tex(NotoSans-BoldItalic-osf-sc-t2a--base.tfm) \
tex(NotoSans-BoldItalic-osf-sc-t2a.tfm) \
tex(NotoSans-BoldItalic-osf-sc-t2a.vf) \
tex(NotoSans-BoldItalic-osf-sc-t2b--base.tfm) \
tex(NotoSans-BoldItalic-osf-sc-t2b.tfm) \
tex(NotoSans-BoldItalic-osf-sc-t2b.vf) \
tex(NotoSans-BoldItalic-osf-sc-t2c--base.tfm) \
tex(NotoSans-BoldItalic-osf-sc-t2c.tfm) \
tex(NotoSans-BoldItalic-osf-sc-t2c.vf) \
tex(NotoSans-BoldItalic-osf-t1--base.tfm) \
tex(NotoSans-BoldItalic-osf-t1.tfm) \
tex(NotoSans-BoldItalic-osf-t1.vf) \
tex(NotoSans-BoldItalic-osf-t2a.tfm) \
tex(NotoSans-BoldItalic-osf-t2b.tfm) \
tex(NotoSans-BoldItalic-osf-t2c.tfm) \
tex(NotoSans-BoldItalic-osf-ts1--base.tfm) \
tex(NotoSans-BoldItalic-osf-ts1.tfm) \
tex(NotoSans-BoldItalic-osf-ts1.vf) \
tex(NotoSans-BoldItalic-sup-lgr.tfm) \
tex(NotoSans-BoldItalic-sup-ly1.tfm) \
tex(NotoSans-BoldItalic-sup-ot1.tfm) \
tex(NotoSans-BoldItalic-sup-t1--base.tfm) \
tex(NotoSans-BoldItalic-sup-t1.tfm) \
tex(NotoSans-BoldItalic-sup-t1.vf) \
tex(NotoSans-BoldItalic-sup-t2a.tfm) \
tex(NotoSans-BoldItalic-sup-t2b.tfm) \
tex(NotoSans-BoldItalic-sup-t2c.tfm) \
tex(NotoSans-BoldItalic-tlf-lgr.tfm) \
tex(NotoSans-BoldItalic-tlf-ly1.tfm) \
tex(NotoSans-BoldItalic-tlf-ot1.tfm) \
tex(NotoSans-BoldItalic-tlf-sc-lgr.tfm) \
tex(NotoSans-BoldItalic-tlf-sc-ly1--base.tfm) \
tex(NotoSans-BoldItalic-tlf-sc-ly1.tfm) \
tex(NotoSans-BoldItalic-tlf-sc-ly1.vf) \
tex(NotoSans-BoldItalic-tlf-sc-ot1--base.tfm) \
tex(NotoSans-BoldItalic-tlf-sc-ot1.tfm) \
tex(NotoSans-BoldItalic-tlf-sc-ot1.vf) \
tex(NotoSans-BoldItalic-tlf-sc-t1--base.tfm) \
tex(NotoSans-BoldItalic-tlf-sc-t1.tfm) \
tex(NotoSans-BoldItalic-tlf-sc-t1.vf) \
tex(NotoSans-BoldItalic-tlf-sc-t2a--base.tfm) \
tex(NotoSans-BoldItalic-tlf-sc-t2a.tfm) \
tex(NotoSans-BoldItalic-tlf-sc-t2a.vf) \
tex(NotoSans-BoldItalic-tlf-sc-t2b--base.tfm) \
tex(NotoSans-BoldItalic-tlf-sc-t2b.tfm) \
tex(NotoSans-BoldItalic-tlf-sc-t2b.vf) \
tex(NotoSans-BoldItalic-tlf-sc-t2c--base.tfm) \
tex(NotoSans-BoldItalic-tlf-sc-t2c.tfm) \
tex(NotoSans-BoldItalic-tlf-sc-t2c.vf) \
tex(NotoSans-BoldItalic-tlf-t1--base.tfm) \
tex(NotoSans-BoldItalic-tlf-t1.tfm) \
tex(NotoSans-BoldItalic-tlf-t1.vf) \
tex(NotoSans-BoldItalic-tlf-t2a.tfm) \
tex(NotoSans-BoldItalic-tlf-t2b.tfm) \
tex(NotoSans-BoldItalic-tlf-t2c.tfm) \
tex(NotoSans-BoldItalic-tlf-ts1--base.tfm) \
tex(NotoSans-BoldItalic-tlf-ts1.tfm) \
tex(NotoSans-BoldItalic-tlf-ts1.vf) \
tex(NotoSans-BoldItalic-tosf-lgr.tfm) \
tex(NotoSans-BoldItalic-tosf-ly1.tfm) \
tex(NotoSans-BoldItalic-tosf-ot1.tfm) \
tex(NotoSans-BoldItalic-tosf-sc-lgr.tfm) \
tex(NotoSans-BoldItalic-tosf-sc-ly1--base.tfm) \
tex(NotoSans-BoldItalic-tosf-sc-ly1.tfm) \
tex(NotoSans-BoldItalic-tosf-sc-ly1.vf) \
tex(NotoSans-BoldItalic-tosf-sc-ot1--base.tfm) \
tex(NotoSans-BoldItalic-tosf-sc-ot1.tfm) \
tex(NotoSans-BoldItalic-tosf-sc-ot1.vf) \
tex(NotoSans-BoldItalic-tosf-sc-t1--base.tfm) \
tex(NotoSans-BoldItalic-tosf-sc-t1.tfm) \
tex(NotoSans-BoldItalic-tosf-sc-t1.vf) \
tex(NotoSans-BoldItalic-tosf-sc-t2a--base.tfm) \
tex(NotoSans-BoldItalic-tosf-sc-t2a.tfm) \
tex(NotoSans-BoldItalic-tosf-sc-t2a.vf) \
tex(NotoSans-BoldItalic-tosf-sc-t2b--base.tfm) \
tex(NotoSans-BoldItalic-tosf-sc-t2b.tfm) \
tex(NotoSans-BoldItalic-tosf-sc-t2b.vf) \
tex(NotoSans-BoldItalic-tosf-sc-t2c--base.tfm) \
tex(NotoSans-BoldItalic-tosf-sc-t2c.tfm) \
tex(NotoSans-BoldItalic-tosf-sc-t2c.vf) \
tex(NotoSans-BoldItalic-tosf-t1--base.tfm) \
tex(NotoSans-BoldItalic-tosf-t1.tfm) \
tex(NotoSans-BoldItalic-tosf-t1.vf) \
tex(NotoSans-BoldItalic-tosf-t2a.tfm) \
tex(NotoSans-BoldItalic-tosf-t2b.tfm) \
tex(NotoSans-BoldItalic-tosf-t2c.tfm) \
tex(NotoSans-BoldItalic-tosf-ts1--base.tfm) \
tex(NotoSans-BoldItalic-tosf-ts1.tfm) \
tex(NotoSans-BoldItalic-tosf-ts1.vf) \
tex(NotoSans-ExtraBold-lf-lgr.tfm) \
tex(NotoSans-ExtraBold-lf-ly1.tfm) \
tex(NotoSans-ExtraBold-lf-ot1.tfm) \
tex(NotoSans-ExtraBold-lf-sc-lgr.tfm) \
tex(NotoSans-ExtraBold-lf-sc-ly1--base.tfm) \
tex(NotoSans-ExtraBold-lf-sc-ly1.tfm) \
tex(NotoSans-ExtraBold-lf-sc-ly1.vf) \
tex(NotoSans-ExtraBold-lf-sc-ot1--base.tfm) \
tex(NotoSans-ExtraBold-lf-sc-ot1.tfm) \
tex(NotoSans-ExtraBold-lf-sc-ot1.vf) \
tex(NotoSans-ExtraBold-lf-sc-t1--base.tfm) \
tex(NotoSans-ExtraBold-lf-sc-t1.tfm) \
tex(NotoSans-ExtraBold-lf-sc-t1.vf) \
tex(NotoSans-ExtraBold-lf-sc-t2a--base.tfm) \
tex(NotoSans-ExtraBold-lf-sc-t2a.tfm) \
tex(NotoSans-ExtraBold-lf-sc-t2a.vf) \
tex(NotoSans-ExtraBold-lf-sc-t2b--base.tfm) \
tex(NotoSans-ExtraBold-lf-sc-t2b.tfm) \
tex(NotoSans-ExtraBold-lf-sc-t2b.vf) \
tex(NotoSans-ExtraBold-lf-sc-t2c--base.tfm) \
tex(NotoSans-ExtraBold-lf-sc-t2c.tfm) \
tex(NotoSans-ExtraBold-lf-sc-t2c.vf) \
tex(NotoSans-ExtraBold-lf-t1--base.tfm) \
tex(NotoSans-ExtraBold-lf-t1.tfm) \
tex(NotoSans-ExtraBold-lf-t1.vf) \
tex(NotoSans-ExtraBold-lf-t2a.tfm) \
tex(NotoSans-ExtraBold-lf-t2b.tfm) \
tex(NotoSans-ExtraBold-lf-t2c.tfm) \
tex(NotoSans-ExtraBold-lf-ts1--base.tfm) \
tex(NotoSans-ExtraBold-lf-ts1.tfm) \
tex(NotoSans-ExtraBold-lf-ts1.vf) \
tex(NotoSans-ExtraBold-osf-lgr.tfm) \
tex(NotoSans-ExtraBold-osf-ly1.tfm) \
tex(NotoSans-ExtraBold-osf-ot1.tfm) \
tex(NotoSans-ExtraBold-osf-sc-lgr.tfm) \
tex(NotoSans-ExtraBold-osf-sc-ly1--base.tfm) \
tex(NotoSans-ExtraBold-osf-sc-ly1.tfm) \
tex(NotoSans-ExtraBold-osf-sc-ly1.vf) \
tex(NotoSans-ExtraBold-osf-sc-ot1--base.tfm) \
tex(NotoSans-ExtraBold-osf-sc-ot1.tfm) \
tex(NotoSans-ExtraBold-osf-sc-ot1.vf) \
tex(NotoSans-ExtraBold-osf-sc-t1--base.tfm) \
tex(NotoSans-ExtraBold-osf-sc-t1.tfm) \
tex(NotoSans-ExtraBold-osf-sc-t1.vf) \
tex(NotoSans-ExtraBold-osf-sc-t2a--base.tfm) \
tex(NotoSans-ExtraBold-osf-sc-t2a.tfm) \
tex(NotoSans-ExtraBold-osf-sc-t2a.vf) \
tex(NotoSans-ExtraBold-osf-sc-t2b--base.tfm) \
tex(NotoSans-ExtraBold-osf-sc-t2b.tfm) \
tex(NotoSans-ExtraBold-osf-sc-t2b.vf) \
tex(NotoSans-ExtraBold-osf-sc-t2c--base.tfm) \
tex(NotoSans-ExtraBold-osf-sc-t2c.tfm) \
tex(NotoSans-ExtraBold-osf-sc-t2c.vf) \
tex(NotoSans-ExtraBold-osf-t1--base.tfm) \
tex(NotoSans-ExtraBold-osf-t1.tfm) \
tex(NotoSans-ExtraBold-osf-t1.vf) \
tex(NotoSans-ExtraBold-osf-t2a.tfm) \
tex(NotoSans-ExtraBold-osf-t2b.tfm) \
tex(NotoSans-ExtraBold-osf-t2c.tfm) \
tex(NotoSans-ExtraBold-osf-ts1--base.tfm) \
tex(NotoSans-ExtraBold-osf-ts1.tfm) \
tex(NotoSans-ExtraBold-osf-ts1.vf) \
tex(NotoSans-ExtraBold-sup-lgr.tfm) \
tex(NotoSans-ExtraBold-sup-ly1.tfm) \
tex(NotoSans-ExtraBold-sup-ot1.tfm) \
tex(NotoSans-ExtraBold-sup-t1--base.tfm) \
tex(NotoSans-ExtraBold-sup-t1.tfm) \
tex(NotoSans-ExtraBold-sup-t1.vf) \
tex(NotoSans-ExtraBold-sup-t2a.tfm) \
tex(NotoSans-ExtraBold-sup-t2b.tfm) \
tex(NotoSans-ExtraBold-sup-t2c.tfm) \
tex(NotoSans-ExtraBold-tlf-lgr.tfm) \
tex(NotoSans-ExtraBold-tlf-ly1.tfm) \
tex(NotoSans-ExtraBold-tlf-ot1.tfm) \
tex(NotoSans-ExtraBold-tlf-sc-lgr.tfm) \
tex(NotoSans-ExtraBold-tlf-sc-ly1--base.tfm) \
tex(NotoSans-ExtraBold-tlf-sc-ly1.tfm) \
tex(NotoSans-ExtraBold-tlf-sc-ly1.vf) \
tex(NotoSans-ExtraBold-tlf-sc-ot1--base.tfm) \
tex(NotoSans-ExtraBold-tlf-sc-ot1.tfm) \
tex(NotoSans-ExtraBold-tlf-sc-ot1.vf) \
tex(NotoSans-ExtraBold-tlf-sc-t1--base.tfm) \
tex(NotoSans-ExtraBold-tlf-sc-t1.tfm) \
tex(NotoSans-ExtraBold-tlf-sc-t1.vf) \
tex(NotoSans-ExtraBold-tlf-sc-t2a--base.tfm) \
tex(NotoSans-ExtraBold-tlf-sc-t2a.tfm) \
tex(NotoSans-ExtraBold-tlf-sc-t2a.vf) \
tex(NotoSans-ExtraBold-tlf-sc-t2b--base.tfm) \
tex(NotoSans-ExtraBold-tlf-sc-t2b.tfm) \
tex(NotoSans-ExtraBold-tlf-sc-t2b.vf) \
tex(NotoSans-ExtraBold-tlf-sc-t2c--base.tfm) \
tex(NotoSans-ExtraBold-tlf-sc-t2c.tfm) \
tex(NotoSans-ExtraBold-tlf-sc-t2c.vf) \
tex(NotoSans-ExtraBold-tlf-t1--base.tfm) \
tex(NotoSans-ExtraBold-tlf-t1.tfm) \
tex(NotoSans-ExtraBold-tlf-t1.vf) \
tex(NotoSans-ExtraBold-tlf-t2a.tfm) \
tex(NotoSans-ExtraBold-tlf-t2b.tfm) \
tex(NotoSans-ExtraBold-tlf-t2c.tfm) \
tex(NotoSans-ExtraBold-tlf-ts1--base.tfm) \
tex(NotoSans-ExtraBold-tlf-ts1.tfm) \
tex(NotoSans-ExtraBold-tlf-ts1.vf) \
tex(NotoSans-ExtraBold-tosf-lgr.tfm) \
tex(NotoSans-ExtraBold-tosf-ly1.tfm) \
tex(NotoSans-ExtraBold-tosf-ot1.tfm) \
tex(NotoSans-ExtraBold-tosf-sc-lgr.tfm) \
tex(NotoSans-ExtraBold-tosf-sc-ly1--base.tfm) \
tex(NotoSans-ExtraBold-tosf-sc-ly1.tfm) \
tex(NotoSans-ExtraBold-tosf-sc-ly1.vf) \
tex(NotoSans-ExtraBold-tosf-sc-ot1--base.tfm) \
tex(NotoSans-ExtraBold-tosf-sc-ot1.tfm) \
tex(NotoSans-ExtraBold-tosf-sc-ot1.vf) \
tex(NotoSans-ExtraBold-tosf-sc-t1--base.tfm) \
tex(NotoSans-ExtraBold-tosf-sc-t1.tfm) \
tex(NotoSans-ExtraBold-tosf-sc-t1.vf) \
tex(NotoSans-ExtraBold-tosf-sc-t2a--base.tfm) \
tex(NotoSans-ExtraBold-tosf-sc-t2a.tfm) \
tex(NotoSans-ExtraBold-tosf-sc-t2a.vf) \
tex(NotoSans-ExtraBold-tosf-sc-t2b--base.tfm) \
tex(NotoSans-ExtraBold-tosf-sc-t2b.tfm) \
tex(NotoSans-ExtraBold-tosf-sc-t2b.vf) \
tex(NotoSans-ExtraBold-tosf-sc-t2c--base.tfm) \
tex(NotoSans-ExtraBold-tosf-sc-t2c.tfm) \
tex(NotoSans-ExtraBold-tosf-sc-t2c.vf) \
tex(NotoSans-ExtraBold-tosf-t1--base.tfm) \
tex(NotoSans-ExtraBold-tosf-t1.tfm) \
tex(NotoSans-ExtraBold-tosf-t1.vf) \
tex(NotoSans-ExtraBold-tosf-t2a.tfm) \
tex(NotoSans-ExtraBold-tosf-t2b.tfm) \
tex(NotoSans-ExtraBold-tosf-t2c.tfm) \
tex(NotoSans-ExtraBold-tosf-ts1--base.tfm) \
tex(NotoSans-ExtraBold-tosf-ts1.tfm) \
tex(NotoSans-ExtraBold-tosf-ts1.vf) \
tex(NotoSans-ExtraBoldItalic-lf-lgr.tfm) \
tex(NotoSans-ExtraBoldItalic-lf-ly1.tfm) \
tex(NotoSans-ExtraBoldItalic-lf-ot1.tfm) \
tex(NotoSans-ExtraBoldItalic-lf-sc-lgr.tfm) \
tex(NotoSans-ExtraBoldItalic-lf-sc-ly1--base.tfm) \
tex(NotoSans-ExtraBoldItalic-lf-sc-ly1.tfm) \
tex(NotoSans-ExtraBoldItalic-lf-sc-ly1.vf) \
tex(NotoSans-ExtraBoldItalic-lf-sc-ot1--base.tfm) \
tex(NotoSans-ExtraBoldItalic-lf-sc-ot1.tfm) \
tex(NotoSans-ExtraBoldItalic-lf-sc-ot1.vf) \
tex(NotoSans-ExtraBoldItalic-lf-sc-t1--base.tfm) \
tex(NotoSans-ExtraBoldItalic-lf-sc-t1.tfm) \
tex(NotoSans-ExtraBoldItalic-lf-sc-t1.vf) \
tex(NotoSans-ExtraBoldItalic-lf-sc-t2a--base.tfm) \
tex(NotoSans-ExtraBoldItalic-lf-sc-t2a.tfm) \
tex(NotoSans-ExtraBoldItalic-lf-sc-t2a.vf) \
tex(NotoSans-ExtraBoldItalic-lf-sc-t2b--base.tfm) \
tex(NotoSans-ExtraBoldItalic-lf-sc-t2b.tfm) \
tex(NotoSans-ExtraBoldItalic-lf-sc-t2b.vf) \
tex(NotoSans-ExtraBoldItalic-lf-sc-t2c--base.tfm) \
tex(NotoSans-ExtraBoldItalic-lf-sc-t2c.tfm) \
tex(NotoSans-ExtraBoldItalic-lf-sc-t2c.vf) \
tex(NotoSans-ExtraBoldItalic-lf-t1--base.tfm) \
tex(NotoSans-ExtraBoldItalic-lf-t1.tfm) \
tex(NotoSans-ExtraBoldItalic-lf-t1.vf) \
tex(NotoSans-ExtraBoldItalic-lf-t2a.tfm) \
tex(NotoSans-ExtraBoldItalic-lf-t2b.tfm) \
tex(NotoSans-ExtraBoldItalic-lf-t2c.tfm) \
tex(NotoSans-ExtraBoldItalic-lf-ts1--base.tfm) \
tex(NotoSans-ExtraBoldItalic-lf-ts1.tfm) \
tex(NotoSans-ExtraBoldItalic-lf-ts1.vf) \
tex(NotoSans-ExtraBoldItalic-osf-lgr.tfm) \
tex(NotoSans-ExtraBoldItalic-osf-ly1.tfm) \
tex(NotoSans-ExtraBoldItalic-osf-ot1.tfm) \
tex(NotoSans-ExtraBoldItalic-osf-sc-lgr.tfm) \
tex(NotoSans-ExtraBoldItalic-osf-sc-ly1--base.tfm) \
tex(NotoSans-ExtraBoldItalic-osf-sc-ly1.tfm) \
tex(NotoSans-ExtraBoldItalic-osf-sc-ly1.vf) \
tex(NotoSans-ExtraBoldItalic-osf-sc-ot1--base.tfm) \
tex(NotoSans-ExtraBoldItalic-osf-sc-ot1.tfm) \
tex(NotoSans-ExtraBoldItalic-osf-sc-ot1.vf) \
tex(NotoSans-ExtraBoldItalic-osf-sc-t1--base.tfm) \
tex(NotoSans-ExtraBoldItalic-osf-sc-t1.tfm) \
tex(NotoSans-ExtraBoldItalic-osf-sc-t1.vf) \
tex(NotoSans-ExtraBoldItalic-osf-sc-t2a--base.tfm) \
tex(NotoSans-ExtraBoldItalic-osf-sc-t2a.tfm) \
tex(NotoSans-ExtraBoldItalic-osf-sc-t2a.vf) \
tex(NotoSans-ExtraBoldItalic-osf-sc-t2b--base.tfm) \
tex(NotoSans-ExtraBoldItalic-osf-sc-t2b.tfm) \
tex(NotoSans-ExtraBoldItalic-osf-sc-t2b.vf) \
tex(NotoSans-ExtraBoldItalic-osf-sc-t2c--base.tfm) \
tex(NotoSans-ExtraBoldItalic-osf-sc-t2c.tfm) \
tex(NotoSans-ExtraBoldItalic-osf-sc-t2c.vf) \
tex(NotoSans-ExtraBoldItalic-osf-t1--base.tfm) \
tex(NotoSans-ExtraBoldItalic-osf-t1.tfm) \
tex(NotoSans-ExtraBoldItalic-osf-t1.vf) \
tex(NotoSans-ExtraBoldItalic-osf-t2a.tfm) \
tex(NotoSans-ExtraBoldItalic-osf-t2b.tfm) \
tex(NotoSans-ExtraBoldItalic-osf-t2c.tfm) \
tex(NotoSans-ExtraBoldItalic-osf-ts1--base.tfm) \
tex(NotoSans-ExtraBoldItalic-osf-ts1.tfm) \
tex(NotoSans-ExtraBoldItalic-osf-ts1.vf) \
tex(NotoSans-ExtraBoldItalic-sup-lgr.tfm) \
tex(NotoSans-ExtraBoldItalic-sup-ly1.tfm) \
tex(NotoSans-ExtraBoldItalic-sup-ot1.tfm) \
tex(NotoSans-ExtraBoldItalic-sup-t1--base.tfm) \
tex(NotoSans-ExtraBoldItalic-sup-t1.tfm) \
tex(NotoSans-ExtraBoldItalic-sup-t1.vf) \
tex(NotoSans-ExtraBoldItalic-sup-t2a.tfm) \
tex(NotoSans-ExtraBoldItalic-sup-t2b.tfm) \
tex(NotoSans-ExtraBoldItalic-sup-t2c.tfm) \
tex(NotoSans-ExtraBoldItalic-tlf-lgr.tfm) \
tex(NotoSans-ExtraBoldItalic-tlf-ly1.tfm) \
tex(NotoSans-ExtraBoldItalic-tlf-ot1.tfm) \
tex(NotoSans-ExtraBoldItalic-tlf-sc-lgr.tfm) \
tex(NotoSans-ExtraBoldItalic-tlf-sc-ly1--base.tfm) \
tex(NotoSans-ExtraBoldItalic-tlf-sc-ly1.tfm) \
tex(NotoSans-ExtraBoldItalic-tlf-sc-ly1.vf) \
tex(NotoSans-ExtraBoldItalic-tlf-sc-ot1--base.tfm) \
tex(NotoSans-ExtraBoldItalic-tlf-sc-ot1.tfm) \
tex(NotoSans-ExtraBoldItalic-tlf-sc-ot1.vf) \
tex(NotoSans-ExtraBoldItalic-tlf-sc-t1--base.tfm) \
tex(NotoSans-ExtraBoldItalic-tlf-sc-t1.tfm) \
tex(NotoSans-ExtraBoldItalic-tlf-sc-t1.vf) \
tex(NotoSans-ExtraBoldItalic-tlf-sc-t2a--base.tfm) \
tex(NotoSans-ExtraBoldItalic-tlf-sc-t2a.tfm) \
tex(NotoSans-ExtraBoldItalic-tlf-sc-t2a.vf) \
tex(NotoSans-ExtraBoldItalic-tlf-sc-t2b--base.tfm) \
tex(NotoSans-ExtraBoldItalic-tlf-sc-t2b.tfm) \
tex(NotoSans-ExtraBoldItalic-tlf-sc-t2b.vf) \
tex(NotoSans-ExtraBoldItalic-tlf-sc-t2c--base.tfm) \
tex(NotoSans-ExtraBoldItalic-tlf-sc-t2c.tfm) \
tex(NotoSans-ExtraBoldItalic-tlf-sc-t2c.vf) \
tex(NotoSans-ExtraBoldItalic-tlf-t1--base.tfm) \
tex(NotoSans-ExtraBoldItalic-tlf-t1.tfm) \
tex(NotoSans-ExtraBoldItalic-tlf-t1.vf) \
tex(NotoSans-ExtraBoldItalic-tlf-t2a.tfm) \
tex(NotoSans-ExtraBoldItalic-tlf-t2b.tfm) \
tex(NotoSans-ExtraBoldItalic-tlf-t2c.tfm) \
tex(NotoSans-ExtraBoldItalic-tlf-ts1--base.tfm) \
tex(NotoSans-ExtraBoldItalic-tlf-ts1.tfm) \
tex(NotoSans-ExtraBoldItalic-tlf-ts1.vf) \
tex(NotoSans-ExtraBoldItalic-tosf-lgr.tfm) \
tex(NotoSans-ExtraBoldItalic-tosf-ly1.tfm) \
tex(NotoSans-ExtraBoldItalic-tosf-ot1.tfm) \
tex(NotoSans-ExtraBoldItalic-tosf-sc-lgr.tfm) \
tex(NotoSans-ExtraBoldItalic-tosf-sc-ly1--base.tfm) \
tex(NotoSans-ExtraBoldItalic-tosf-sc-ly1.tfm) \
tex(NotoSans-ExtraBoldItalic-tosf-sc-ly1.vf) \
tex(NotoSans-ExtraBoldItalic-tosf-sc-ot1--base.tfm) \
tex(NotoSans-ExtraBoldItalic-tosf-sc-ot1.tfm) \
tex(NotoSans-ExtraBoldItalic-tosf-sc-ot1.vf) \
tex(NotoSans-ExtraBoldItalic-tosf-sc-t1--base.tfm) \
tex(NotoSans-ExtraBoldItalic-tosf-sc-t1.tfm) \
tex(NotoSans-ExtraBoldItalic-tosf-sc-t1.vf) \
tex(NotoSans-ExtraBoldItalic-tosf-sc-t2a--base.tfm) \
tex(NotoSans-ExtraBoldItalic-tosf-sc-t2a.tfm) \
tex(NotoSans-ExtraBoldItalic-tosf-sc-t2a.vf) \
tex(NotoSans-ExtraBoldItalic-tosf-sc-t2b--base.tfm) \
tex(NotoSans-ExtraBoldItalic-tosf-sc-t2b.tfm) \
tex(NotoSans-ExtraBoldItalic-tosf-sc-t2b.vf) \
tex(NotoSans-ExtraBoldItalic-tosf-sc-t2c--base.tfm) \
tex(NotoSans-ExtraBoldItalic-tosf-sc-t2c.tfm) \
tex(NotoSans-ExtraBoldItalic-tosf-sc-t2c.vf) \
tex(NotoSans-ExtraBoldItalic-tosf-t1--base.tfm) \
tex(NotoSans-ExtraBoldItalic-tosf-t1.tfm) \
tex(NotoSans-ExtraBoldItalic-tosf-t1.vf) \
tex(NotoSans-ExtraBoldItalic-tosf-t2a.tfm) \
tex(NotoSans-ExtraBoldItalic-tosf-t2b.tfm) \
tex(NotoSans-ExtraBoldItalic-tosf-t2c.tfm) \
tex(NotoSans-ExtraBoldItalic-tosf-ts1--base.tfm) \
tex(NotoSans-ExtraBoldItalic-tosf-ts1.tfm) \
tex(NotoSans-ExtraBoldItalic-tosf-ts1.vf) \
tex(NotoSans-ExtraLight-lf-lgr.tfm) \
tex(NotoSans-ExtraLight-lf-ly1.tfm) \
tex(NotoSans-ExtraLight-lf-ot1.tfm) \
tex(NotoSans-ExtraLight-lf-sc-lgr.tfm) \
tex(NotoSans-ExtraLight-lf-sc-ly1--base.tfm) \
tex(NotoSans-ExtraLight-lf-sc-ly1.tfm) \
tex(NotoSans-ExtraLight-lf-sc-ly1.vf) \
tex(NotoSans-ExtraLight-lf-sc-ot1--base.tfm) \
tex(NotoSans-ExtraLight-lf-sc-ot1.tfm) \
tex(NotoSans-ExtraLight-lf-sc-ot1.vf) \
tex(NotoSans-ExtraLight-lf-sc-t1--base.tfm) \
tex(NotoSans-ExtraLight-lf-sc-t1.tfm) \
tex(NotoSans-ExtraLight-lf-sc-t1.vf) \
tex(NotoSans-ExtraLight-lf-sc-t2a--base.tfm) \
tex(NotoSans-ExtraLight-lf-sc-t2a.tfm) \
tex(NotoSans-ExtraLight-lf-sc-t2a.vf) \
tex(NotoSans-ExtraLight-lf-sc-t2b--base.tfm) \
tex(NotoSans-ExtraLight-lf-sc-t2b.tfm) \
tex(NotoSans-ExtraLight-lf-sc-t2b.vf) \
tex(NotoSans-ExtraLight-lf-sc-t2c--base.tfm) \
tex(NotoSans-ExtraLight-lf-sc-t2c.tfm) \
tex(NotoSans-ExtraLight-lf-sc-t2c.vf) \
tex(NotoSans-ExtraLight-lf-t1--base.tfm) \
tex(NotoSans-ExtraLight-lf-t1.tfm) \
tex(NotoSans-ExtraLight-lf-t1.vf) \
tex(NotoSans-ExtraLight-lf-t2a.tfm) \
tex(NotoSans-ExtraLight-lf-t2b.tfm) \
tex(NotoSans-ExtraLight-lf-t2c.tfm) \
tex(NotoSans-ExtraLight-lf-ts1--base.tfm) \
tex(NotoSans-ExtraLight-lf-ts1.tfm) \
tex(NotoSans-ExtraLight-lf-ts1.vf) \
tex(NotoSans-ExtraLight-osf-lgr.tfm) \
tex(NotoSans-ExtraLight-osf-ly1.tfm) \
tex(NotoSans-ExtraLight-osf-ot1.tfm) \
tex(NotoSans-ExtraLight-osf-sc-lgr.tfm) \
tex(NotoSans-ExtraLight-osf-sc-ly1--base.tfm) \
tex(NotoSans-ExtraLight-osf-sc-ly1.tfm) \
tex(NotoSans-ExtraLight-osf-sc-ly1.vf) \
tex(NotoSans-ExtraLight-osf-sc-ot1--base.tfm) \
tex(NotoSans-ExtraLight-osf-sc-ot1.tfm) \
tex(NotoSans-ExtraLight-osf-sc-ot1.vf) \
tex(NotoSans-ExtraLight-osf-sc-t1--base.tfm) \
tex(NotoSans-ExtraLight-osf-sc-t1.tfm) \
tex(NotoSans-ExtraLight-osf-sc-t1.vf) \
tex(NotoSans-ExtraLight-osf-sc-t2a--base.tfm) \
tex(NotoSans-ExtraLight-osf-sc-t2a.tfm) \
tex(NotoSans-ExtraLight-osf-sc-t2a.vf) \
tex(NotoSans-ExtraLight-osf-sc-t2b--base.tfm) \
tex(NotoSans-ExtraLight-osf-sc-t2b.tfm) \
tex(NotoSans-ExtraLight-osf-sc-t2b.vf) \
tex(NotoSans-ExtraLight-osf-sc-t2c--base.tfm) \
tex(NotoSans-ExtraLight-osf-sc-t2c.tfm) \
tex(NotoSans-ExtraLight-osf-sc-t2c.vf) \
tex(NotoSans-ExtraLight-osf-t1--base.tfm) \
tex(NotoSans-ExtraLight-osf-t1.tfm) \
tex(NotoSans-ExtraLight-osf-t1.vf) \
tex(NotoSans-ExtraLight-osf-t2a.tfm) \
tex(NotoSans-ExtraLight-osf-t2b.tfm) \
tex(NotoSans-ExtraLight-osf-t2c.tfm) \
tex(NotoSans-ExtraLight-osf-ts1--base.tfm) \
tex(NotoSans-ExtraLight-osf-ts1.tfm) \
tex(NotoSans-ExtraLight-osf-ts1.vf) \
tex(NotoSans-ExtraLight-sup-lgr.tfm) \
tex(NotoSans-ExtraLight-sup-ly1.tfm) \
tex(NotoSans-ExtraLight-sup-ot1.tfm) \
tex(NotoSans-ExtraLight-sup-t1--base.tfm) \
tex(NotoSans-ExtraLight-sup-t1.tfm) \
tex(NotoSans-ExtraLight-sup-t1.vf) \
tex(NotoSans-ExtraLight-sup-t2a.tfm) \
tex(NotoSans-ExtraLight-sup-t2b.tfm) \
tex(NotoSans-ExtraLight-sup-t2c.tfm) \
tex(NotoSans-ExtraLight-tlf-lgr.tfm) \
tex(NotoSans-ExtraLight-tlf-ly1.tfm) \
tex(NotoSans-ExtraLight-tlf-ot1.tfm) \
tex(NotoSans-ExtraLight-tlf-sc-lgr.tfm) \
tex(NotoSans-ExtraLight-tlf-sc-ly1--base.tfm) \
tex(NotoSans-ExtraLight-tlf-sc-ly1.tfm) \
tex(NotoSans-ExtraLight-tlf-sc-ly1.vf) \
tex(NotoSans-ExtraLight-tlf-sc-ot1--base.tfm) \
tex(NotoSans-ExtraLight-tlf-sc-ot1.tfm) \
tex(NotoSans-ExtraLight-tlf-sc-ot1.vf) \
tex(NotoSans-ExtraLight-tlf-sc-t1--base.tfm) \
tex(NotoSans-ExtraLight-tlf-sc-t1.tfm) \
tex(NotoSans-ExtraLight-tlf-sc-t1.vf) \
tex(NotoSans-ExtraLight-tlf-sc-t2a--base.tfm) \
tex(NotoSans-ExtraLight-tlf-sc-t2a.tfm) \
tex(NotoSans-ExtraLight-tlf-sc-t2a.vf) \
tex(NotoSans-ExtraLight-tlf-sc-t2b--base.tfm) \
tex(NotoSans-ExtraLight-tlf-sc-t2b.tfm) \
tex(NotoSans-ExtraLight-tlf-sc-t2b.vf) \
tex(NotoSans-ExtraLight-tlf-sc-t2c--base.tfm) \
tex(NotoSans-ExtraLight-tlf-sc-t2c.tfm) \
tex(NotoSans-ExtraLight-tlf-sc-t2c.vf) \
tex(NotoSans-ExtraLight-tlf-t1--base.tfm) \
tex(NotoSans-ExtraLight-tlf-t1.tfm) \
tex(NotoSans-ExtraLight-tlf-t1.vf) \
tex(NotoSans-ExtraLight-tlf-t2a.tfm) \
tex(NotoSans-ExtraLight-tlf-t2b.tfm) \
tex(NotoSans-ExtraLight-tlf-t2c.tfm) \
tex(NotoSans-ExtraLight-tlf-ts1--base.tfm) \
tex(NotoSans-ExtraLight-tlf-ts1.tfm) \
tex(NotoSans-ExtraLight-tlf-ts1.vf) \
tex(NotoSans-ExtraLight-tosf-lgr.tfm) \
tex(NotoSans-ExtraLight-tosf-ly1.tfm) \
tex(NotoSans-ExtraLight-tosf-ot1.tfm) \
tex(NotoSans-ExtraLight-tosf-sc-lgr.tfm) \
tex(NotoSans-ExtraLight-tosf-sc-ly1--base.tfm) \
tex(NotoSans-ExtraLight-tosf-sc-ly1.tfm) \
tex(NotoSans-ExtraLight-tosf-sc-ly1.vf) \
tex(NotoSans-ExtraLight-tosf-sc-ot1--base.tfm) \
tex(NotoSans-ExtraLight-tosf-sc-ot1.tfm) \
tex(NotoSans-ExtraLight-tosf-sc-ot1.vf) \
tex(NotoSans-ExtraLight-tosf-sc-t1--base.tfm) \
tex(NotoSans-ExtraLight-tosf-sc-t1.tfm) \
tex(NotoSans-ExtraLight-tosf-sc-t1.vf) \
tex(NotoSans-ExtraLight-tosf-sc-t2a--base.tfm) \
tex(NotoSans-ExtraLight-tosf-sc-t2a.tfm) \
tex(NotoSans-ExtraLight-tosf-sc-t2a.vf) \
tex(NotoSans-ExtraLight-tosf-sc-t2b--base.tfm) \
tex(NotoSans-ExtraLight-tosf-sc-t2b.tfm) \
tex(NotoSans-ExtraLight-tosf-sc-t2b.vf) \
tex(NotoSans-ExtraLight-tosf-sc-t2c--base.tfm) \
tex(NotoSans-ExtraLight-tosf-sc-t2c.tfm) \
tex(NotoSans-ExtraLight-tosf-sc-t2c.vf) \
tex(NotoSans-ExtraLight-tosf-t1--base.tfm) \
tex(NotoSans-ExtraLight-tosf-t1.tfm) \
tex(NotoSans-ExtraLight-tosf-t1.vf) \
tex(NotoSans-ExtraLight-tosf-t2a.tfm) \
tex(NotoSans-ExtraLight-tosf-t2b.tfm) \
tex(NotoSans-ExtraLight-tosf-t2c.tfm) \
tex(NotoSans-ExtraLight-tosf-ts1--base.tfm) \
tex(NotoSans-ExtraLight-tosf-ts1.tfm) \
tex(NotoSans-ExtraLight-tosf-ts1.vf) \
tex(NotoSans-ExtraLightItalic-lf-lgr.tfm) \
tex(NotoSans-ExtraLightItalic-lf-ly1.tfm) \
tex(NotoSans-ExtraLightItalic-lf-ot1.tfm) \
tex(NotoSans-ExtraLightItalic-lf-sc-lgr.tfm) \
tex(NotoSans-ExtraLightItalic-lf-sc-ly1--base.tfm) \
tex(NotoSans-ExtraLightItalic-lf-sc-ly1.tfm) \
tex(NotoSans-ExtraLightItalic-lf-sc-ly1.vf) \
tex(NotoSans-ExtraLightItalic-lf-sc-ot1--base.tfm) \
tex(NotoSans-ExtraLightItalic-lf-sc-ot1.tfm) \
tex(NotoSans-ExtraLightItalic-lf-sc-ot1.vf) \
tex(NotoSans-ExtraLightItalic-lf-sc-t1--base.tfm) \
tex(NotoSans-ExtraLightItalic-lf-sc-t1.tfm) \
tex(NotoSans-ExtraLightItalic-lf-sc-t1.vf) \
tex(NotoSans-ExtraLightItalic-lf-sc-t2a--base.tfm) \
tex(NotoSans-ExtraLightItalic-lf-sc-t2a.tfm) \
tex(NotoSans-ExtraLightItalic-lf-sc-t2a.vf) \
tex(NotoSans-ExtraLightItalic-lf-sc-t2b--base.tfm) \
tex(NotoSans-ExtraLightItalic-lf-sc-t2b.tfm) \
tex(NotoSans-ExtraLightItalic-lf-sc-t2b.vf) \
tex(NotoSans-ExtraLightItalic-lf-sc-t2c--base.tfm) \
tex(NotoSans-ExtraLightItalic-lf-sc-t2c.tfm) \
tex(NotoSans-ExtraLightItalic-lf-sc-t2c.vf) \
tex(NotoSans-ExtraLightItalic-lf-t1--base.tfm) \
tex(NotoSans-ExtraLightItalic-lf-t1.tfm) \
tex(NotoSans-ExtraLightItalic-lf-t1.vf) \
tex(NotoSans-ExtraLightItalic-lf-t2a.tfm) \
tex(NotoSans-ExtraLightItalic-lf-t2b.tfm) \
tex(NotoSans-ExtraLightItalic-lf-t2c.tfm) \
tex(NotoSans-ExtraLightItalic-lf-ts1--base.tfm) \
tex(NotoSans-ExtraLightItalic-lf-ts1.tfm) \
tex(NotoSans-ExtraLightItalic-lf-ts1.vf) \
tex(NotoSans-ExtraLightItalic-osf-lgr.tfm) \
tex(NotoSans-ExtraLightItalic-osf-ly1.tfm) \
tex(NotoSans-ExtraLightItalic-osf-ot1.tfm) \
tex(NotoSans-ExtraLightItalic-osf-sc-lgr.tfm) \
tex(NotoSans-ExtraLightItalic-osf-sc-ly1--base.tfm) \
tex(NotoSans-ExtraLightItalic-osf-sc-ly1.tfm) \
tex(NotoSans-ExtraLightItalic-osf-sc-ly1.vf) \
tex(NotoSans-ExtraLightItalic-osf-sc-ot1--base.tfm) \
tex(NotoSans-ExtraLightItalic-osf-sc-ot1.tfm) \
tex(NotoSans-ExtraLightItalic-osf-sc-ot1.vf) \
tex(NotoSans-ExtraLightItalic-osf-sc-t1--base.tfm) \
tex(NotoSans-ExtraLightItalic-osf-sc-t1.tfm) \
tex(NotoSans-ExtraLightItalic-osf-sc-t1.vf) \
tex(NotoSans-ExtraLightItalic-osf-sc-t2a--base.tfm) \
tex(NotoSans-ExtraLightItalic-osf-sc-t2a.tfm) \
tex(NotoSans-ExtraLightItalic-osf-sc-t2a.vf) \
tex(NotoSans-ExtraLightItalic-osf-sc-t2b--base.tfm) \
tex(NotoSans-ExtraLightItalic-osf-sc-t2b.tfm) \
tex(NotoSans-ExtraLightItalic-osf-sc-t2b.vf) \
tex(NotoSans-ExtraLightItalic-osf-sc-t2c--base.tfm) \
tex(NotoSans-ExtraLightItalic-osf-sc-t2c.tfm) \
tex(NotoSans-ExtraLightItalic-osf-sc-t2c.vf) \
tex(NotoSans-ExtraLightItalic-osf-t1--base.tfm) \
tex(NotoSans-ExtraLightItalic-osf-t1.tfm) \
tex(NotoSans-ExtraLightItalic-osf-t1.vf) \
tex(NotoSans-ExtraLightItalic-osf-t2a.tfm) \
tex(NotoSans-ExtraLightItalic-osf-t2b.tfm) \
tex(NotoSans-ExtraLightItalic-osf-t2c.tfm) \
tex(NotoSans-ExtraLightItalic-osf-ts1--base.tfm) \
tex(NotoSans-ExtraLightItalic-osf-ts1.tfm) \
tex(NotoSans-ExtraLightItalic-osf-ts1.vf) \
tex(NotoSans-ExtraLightItalic-sup-lgr.tfm) \
tex(NotoSans-ExtraLightItalic-sup-ly1.tfm) \
tex(NotoSans-ExtraLightItalic-sup-ot1.tfm) \
tex(NotoSans-ExtraLightItalic-sup-t1--base.tfm) \
tex(NotoSans-ExtraLightItalic-sup-t1.tfm) \
tex(NotoSans-ExtraLightItalic-sup-t1.vf) \
tex(NotoSans-ExtraLightItalic-sup-t2a.tfm) \
tex(NotoSans-ExtraLightItalic-sup-t2b.tfm) \
tex(NotoSans-ExtraLightItalic-sup-t2c.tfm) \
tex(NotoSans-ExtraLightItalic-tlf-lgr.tfm) \
tex(NotoSans-ExtraLightItalic-tlf-ly1.tfm) \
tex(NotoSans-ExtraLightItalic-tlf-ot1.tfm) \
tex(NotoSans-ExtraLightItalic-tlf-sc-lgr.tfm) \
tex(NotoSans-ExtraLightItalic-tlf-sc-ly1--base.tfm) \
tex(NotoSans-ExtraLightItalic-tlf-sc-ly1.tfm) \
tex(NotoSans-ExtraLightItalic-tlf-sc-ly1.vf) \
tex(NotoSans-ExtraLightItalic-tlf-sc-ot1--base.tfm) \
tex(NotoSans-ExtraLightItalic-tlf-sc-ot1.tfm) \
tex(NotoSans-ExtraLightItalic-tlf-sc-ot1.vf) \
tex(NotoSans-ExtraLightItalic-tlf-sc-t1--base.tfm) \
tex(NotoSans-ExtraLightItalic-tlf-sc-t1.tfm) \
tex(NotoSans-ExtraLightItalic-tlf-sc-t1.vf) \
tex(NotoSans-ExtraLightItalic-tlf-sc-t2a--base.tfm) \
tex(NotoSans-ExtraLightItalic-tlf-sc-t2a.tfm) \
tex(NotoSans-ExtraLightItalic-tlf-sc-t2a.vf) \
tex(NotoSans-ExtraLightItalic-tlf-sc-t2b--base.tfm) \
tex(NotoSans-ExtraLightItalic-tlf-sc-t2b.tfm) \
tex(NotoSans-ExtraLightItalic-tlf-sc-t2b.vf) \
tex(NotoSans-ExtraLightItalic-tlf-sc-t2c--base.tfm) \
tex(NotoSans-ExtraLightItalic-tlf-sc-t2c.tfm) \
tex(NotoSans-ExtraLightItalic-tlf-sc-t2c.vf) \
tex(NotoSans-ExtraLightItalic-tlf-t1--base.tfm) \
tex(NotoSans-ExtraLightItalic-tlf-t1.tfm) \
tex(NotoSans-ExtraLightItalic-tlf-t1.vf) \
tex(NotoSans-ExtraLightItalic-tlf-t2a.tfm) \
tex(NotoSans-ExtraLightItalic-tlf-t2b.tfm) \
tex(NotoSans-ExtraLightItalic-tlf-t2c.tfm) \
tex(NotoSans-ExtraLightItalic-tlf-ts1--base.tfm) \
tex(NotoSans-ExtraLightItalic-tlf-ts1.tfm) \
tex(NotoSans-ExtraLightItalic-tlf-ts1.vf) \
tex(NotoSans-ExtraLightItalic-tosf-lgr.tfm) \
tex(NotoSans-ExtraLightItalic-tosf-ly1.tfm) \
tex(NotoSans-ExtraLightItalic-tosf-ot1.tfm) \
tex(NotoSans-ExtraLightItalic-tosf-sc-lgr.tfm) \
tex(NotoSans-ExtraLightItalic-tosf-sc-ly1--base.tfm) \
tex(NotoSans-ExtraLightItalic-tosf-sc-ly1.tfm) \
tex(NotoSans-ExtraLightItalic-tosf-sc-ly1.vf) \
tex(NotoSans-ExtraLightItalic-tosf-sc-ot1--base.tfm) \
tex(NotoSans-ExtraLightItalic-tosf-sc-ot1.tfm) \
tex(NotoSans-ExtraLightItalic-tosf-sc-ot1.vf) \
tex(NotoSans-ExtraLightItalic-tosf-sc-t1--base.tfm) \
tex(NotoSans-ExtraLightItalic-tosf-sc-t1.tfm) \
tex(NotoSans-ExtraLightItalic-tosf-sc-t1.vf) \
tex(NotoSans-ExtraLightItalic-tosf-sc-t2a--base.tfm) \
tex(NotoSans-ExtraLightItalic-tosf-sc-t2a.tfm) \
tex(NotoSans-ExtraLightItalic-tosf-sc-t2a.vf) \
tex(NotoSans-ExtraLightItalic-tosf-sc-t2b--base.tfm) \
tex(NotoSans-ExtraLightItalic-tosf-sc-t2b.tfm) \
tex(NotoSans-ExtraLightItalic-tosf-sc-t2b.vf) \
tex(NotoSans-ExtraLightItalic-tosf-sc-t2c--base.tfm) \
tex(NotoSans-ExtraLightItalic-tosf-sc-t2c.tfm) \
tex(NotoSans-ExtraLightItalic-tosf-sc-t2c.vf) \
tex(NotoSans-ExtraLightItalic-tosf-t1--base.tfm) \
tex(NotoSans-ExtraLightItalic-tosf-t1.tfm) \
tex(NotoSans-ExtraLightItalic-tosf-t1.vf) \
tex(NotoSans-ExtraLightItalic-tosf-t2a.tfm) \
tex(NotoSans-ExtraLightItalic-tosf-t2b.tfm) \
tex(NotoSans-ExtraLightItalic-tosf-t2c.tfm) \
tex(NotoSans-ExtraLightItalic-tosf-ts1--base.tfm) \
tex(NotoSans-ExtraLightItalic-tosf-ts1.tfm) \
tex(NotoSans-ExtraLightItalic-tosf-ts1.vf) \
tex(NotoSans-Italic-lf-lgr.tfm) \
tex(NotoSans-Italic-lf-ly1.tfm) \
tex(NotoSans-Italic-lf-ot1.tfm) \
tex(NotoSans-Italic-lf-sc-lgr.tfm) \
tex(NotoSans-Italic-lf-sc-ly1--base.tfm) \
tex(NotoSans-Italic-lf-sc-ly1.tfm) \
tex(NotoSans-Italic-lf-sc-ly1.vf) \
tex(NotoSans-Italic-lf-sc-ot1--base.tfm) \
tex(NotoSans-Italic-lf-sc-ot1.tfm) \
tex(NotoSans-Italic-lf-sc-ot1.vf) \
tex(NotoSans-Italic-lf-sc-t1--base.tfm) \
tex(NotoSans-Italic-lf-sc-t1.tfm) \
tex(NotoSans-Italic-lf-sc-t1.vf) \
tex(NotoSans-Italic-lf-sc-t2a--base.tfm) \
tex(NotoSans-Italic-lf-sc-t2a.tfm) \
tex(NotoSans-Italic-lf-sc-t2a.vf) \
tex(NotoSans-Italic-lf-sc-t2b--base.tfm) \
tex(NotoSans-Italic-lf-sc-t2b.tfm) \
tex(NotoSans-Italic-lf-sc-t2b.vf) \
tex(NotoSans-Italic-lf-sc-t2c--base.tfm) \
tex(NotoSans-Italic-lf-sc-t2c.tfm) \
tex(NotoSans-Italic-lf-sc-t2c.vf) \
tex(NotoSans-Italic-lf-t1--base.tfm) \
tex(NotoSans-Italic-lf-t1.tfm) \
tex(NotoSans-Italic-lf-t1.vf) \
tex(NotoSans-Italic-lf-t2a.tfm) \
tex(NotoSans-Italic-lf-t2b.tfm) \
tex(NotoSans-Italic-lf-t2c.tfm) \
tex(NotoSans-Italic-lf-ts1--base.tfm) \
tex(NotoSans-Italic-lf-ts1.tfm) \
tex(NotoSans-Italic-lf-ts1.vf) \
tex(NotoSans-Italic-osf-lgr.tfm) \
tex(NotoSans-Italic-osf-ly1.tfm) \
tex(NotoSans-Italic-osf-ot1.tfm) \
tex(NotoSans-Italic-osf-sc-lgr.tfm) \
tex(NotoSans-Italic-osf-sc-ly1--base.tfm) \
tex(NotoSans-Italic-osf-sc-ly1.tfm) \
tex(NotoSans-Italic-osf-sc-ly1.vf) \
tex(NotoSans-Italic-osf-sc-ot1--base.tfm) \
tex(NotoSans-Italic-osf-sc-ot1.tfm) \
tex(NotoSans-Italic-osf-sc-ot1.vf) \
tex(NotoSans-Italic-osf-sc-t1--base.tfm) \
tex(NotoSans-Italic-osf-sc-t1.tfm) \
tex(NotoSans-Italic-osf-sc-t1.vf) \
tex(NotoSans-Italic-osf-sc-t2a--base.tfm) \
tex(NotoSans-Italic-osf-sc-t2a.tfm) \
tex(NotoSans-Italic-osf-sc-t2a.vf) \
tex(NotoSans-Italic-osf-sc-t2b--base.tfm) \
tex(NotoSans-Italic-osf-sc-t2b.tfm) \
tex(NotoSans-Italic-osf-sc-t2b.vf) \
tex(NotoSans-Italic-osf-sc-t2c--base.tfm) \
tex(NotoSans-Italic-osf-sc-t2c.tfm) \
tex(NotoSans-Italic-osf-sc-t2c.vf) \
tex(NotoSans-Italic-osf-t1--base.tfm) \
tex(NotoSans-Italic-osf-t1.tfm) \
tex(NotoSans-Italic-osf-t1.vf) \
tex(NotoSans-Italic-osf-t2a.tfm) \
tex(NotoSans-Italic-osf-t2b.tfm) \
tex(NotoSans-Italic-osf-t2c.tfm) \
tex(NotoSans-Italic-osf-ts1--base.tfm) \
tex(NotoSans-Italic-osf-ts1.tfm) \
tex(NotoSans-Italic-osf-ts1.vf) \
tex(NotoSans-Italic-sup-lgr.tfm) \
tex(NotoSans-Italic-sup-ly1.tfm) \
tex(NotoSans-Italic-sup-ot1.tfm) \
tex(NotoSans-Italic-sup-t1--base.tfm) \
tex(NotoSans-Italic-sup-t1.tfm) \
tex(NotoSans-Italic-sup-t1.vf) \
tex(NotoSans-Italic-sup-t2a.tfm) \
tex(NotoSans-Italic-sup-t2b.tfm) \
tex(NotoSans-Italic-sup-t2c.tfm) \
tex(NotoSans-Italic-tlf-lgr.tfm) \
tex(NotoSans-Italic-tlf-ly1.tfm) \
tex(NotoSans-Italic-tlf-ot1.tfm) \
tex(NotoSans-Italic-tlf-sc-lgr.tfm) \
tex(NotoSans-Italic-tlf-sc-ly1--base.tfm) \
tex(NotoSans-Italic-tlf-sc-ly1.tfm) \
tex(NotoSans-Italic-tlf-sc-ly1.vf) \
tex(NotoSans-Italic-tlf-sc-ot1--base.tfm) \
tex(NotoSans-Italic-tlf-sc-ot1.tfm) \
tex(NotoSans-Italic-tlf-sc-ot1.vf) \
tex(NotoSans-Italic-tlf-sc-t1--base.tfm) \
tex(NotoSans-Italic-tlf-sc-t1.tfm) \
tex(NotoSans-Italic-tlf-sc-t1.vf) \
tex(NotoSans-Italic-tlf-sc-t2a--base.tfm) \
tex(NotoSans-Italic-tlf-sc-t2a.tfm) \
tex(NotoSans-Italic-tlf-sc-t2a.vf) \
tex(NotoSans-Italic-tlf-sc-t2b--base.tfm) \
tex(NotoSans-Italic-tlf-sc-t2b.tfm) \
tex(NotoSans-Italic-tlf-sc-t2b.vf) \
tex(NotoSans-Italic-tlf-sc-t2c--base.tfm) \
tex(NotoSans-Italic-tlf-sc-t2c.tfm) \
tex(NotoSans-Italic-tlf-sc-t2c.vf) \
tex(NotoSans-Italic-tlf-t1--base.tfm) \
tex(NotoSans-Italic-tlf-t1.tfm) \
tex(NotoSans-Italic-tlf-t1.vf) \
tex(NotoSans-Italic-tlf-t2a.tfm) \
tex(NotoSans-Italic-tlf-t2b.tfm) \
tex(NotoSans-Italic-tlf-t2c.tfm) \
tex(NotoSans-Italic-tlf-ts1--base.tfm) \
tex(NotoSans-Italic-tlf-ts1.tfm) \
tex(NotoSans-Italic-tlf-ts1.vf) \
tex(NotoSans-Italic-tosf-lgr.tfm) \
tex(NotoSans-Italic-tosf-ly1.tfm) \
tex(NotoSans-Italic-tosf-ot1.tfm) \
tex(NotoSans-Italic-tosf-sc-lgr.tfm) \
tex(NotoSans-Italic-tosf-sc-ly1--base.tfm) \
tex(NotoSans-Italic-tosf-sc-ly1.tfm) \
tex(NotoSans-Italic-tosf-sc-ly1.vf) \
tex(NotoSans-Italic-tosf-sc-ot1--base.tfm) \
tex(NotoSans-Italic-tosf-sc-ot1.tfm) \
tex(NotoSans-Italic-tosf-sc-ot1.vf) \
tex(NotoSans-Italic-tosf-sc-t1--base.tfm) \
tex(NotoSans-Italic-tosf-sc-t1.tfm) \
tex(NotoSans-Italic-tosf-sc-t1.vf) \
tex(NotoSans-Italic-tosf-sc-t2a--base.tfm) \
tex(NotoSans-Italic-tosf-sc-t2a.tfm) \
tex(NotoSans-Italic-tosf-sc-t2a.vf) \
tex(NotoSans-Italic-tosf-sc-t2b--base.tfm) \
tex(NotoSans-Italic-tosf-sc-t2b.tfm) \
tex(NotoSans-Italic-tosf-sc-t2b.vf) \
tex(NotoSans-Italic-tosf-sc-t2c--base.tfm) \
tex(NotoSans-Italic-tosf-sc-t2c.tfm) \
tex(NotoSans-Italic-tosf-sc-t2c.vf) \
tex(NotoSans-Italic-tosf-t1--base.tfm) \
tex(NotoSans-Italic-tosf-t1.tfm) \
tex(NotoSans-Italic-tosf-t1.vf) \
tex(NotoSans-Italic-tosf-t2a.tfm) \
tex(NotoSans-Italic-tosf-t2b.tfm) \
tex(NotoSans-Italic-tosf-t2c.tfm) \
tex(NotoSans-Italic-tosf-ts1--base.tfm) \
tex(NotoSans-Italic-tosf-ts1.tfm) \
tex(NotoSans-Italic-tosf-ts1.vf) \
tex(NotoSans-Light-lf-lgr.tfm) \
tex(NotoSans-Light-lf-ly1.tfm) \
tex(NotoSans-Light-lf-ot1.tfm) \
tex(NotoSans-Light-lf-sc-lgr.tfm) \
tex(NotoSans-Light-lf-sc-ly1--base.tfm) \
tex(NotoSans-Light-lf-sc-ly1.tfm) \
tex(NotoSans-Light-lf-sc-ly1.vf) \
tex(NotoSans-Light-lf-sc-ot1--base.tfm) \
tex(NotoSans-Light-lf-sc-ot1.tfm) \
tex(NotoSans-Light-lf-sc-ot1.vf) \
tex(NotoSans-Light-lf-sc-t1--base.tfm) \
tex(NotoSans-Light-lf-sc-t1.tfm) \
tex(NotoSans-Light-lf-sc-t1.vf) \
tex(NotoSans-Light-lf-sc-t2a--base.tfm) \
tex(NotoSans-Light-lf-sc-t2a.tfm) \
tex(NotoSans-Light-lf-sc-t2a.vf) \
tex(NotoSans-Light-lf-sc-t2b--base.tfm) \
tex(NotoSans-Light-lf-sc-t2b.tfm) \
tex(NotoSans-Light-lf-sc-t2b.vf) \
tex(NotoSans-Light-lf-sc-t2c--base.tfm) \
tex(NotoSans-Light-lf-sc-t2c.tfm) \
tex(NotoSans-Light-lf-sc-t2c.vf) \
tex(NotoSans-Light-lf-t1--base.tfm) \
tex(NotoSans-Light-lf-t1.tfm) \
tex(NotoSans-Light-lf-t1.vf) \
tex(NotoSans-Light-lf-t2a.tfm) \
tex(NotoSans-Light-lf-t2b.tfm) \
tex(NotoSans-Light-lf-t2c.tfm) \
tex(NotoSans-Light-lf-ts1--base.tfm) \
tex(NotoSans-Light-lf-ts1.tfm) \
tex(NotoSans-Light-lf-ts1.vf) \
tex(NotoSans-Light-osf-lgr.tfm) \
tex(NotoSans-Light-osf-ly1.tfm) \
tex(NotoSans-Light-osf-ot1.tfm) \
tex(NotoSans-Light-osf-sc-lgr.tfm) \
tex(NotoSans-Light-osf-sc-ly1--base.tfm) \
tex(NotoSans-Light-osf-sc-ly1.tfm) \
tex(NotoSans-Light-osf-sc-ly1.vf) \
tex(NotoSans-Light-osf-sc-ot1--base.tfm) \
tex(NotoSans-Light-osf-sc-ot1.tfm) \
tex(NotoSans-Light-osf-sc-ot1.vf) \
tex(NotoSans-Light-osf-sc-t1--base.tfm) \
tex(NotoSans-Light-osf-sc-t1.tfm) \
tex(NotoSans-Light-osf-sc-t1.vf) \
tex(NotoSans-Light-osf-sc-t2a--base.tfm) \
tex(NotoSans-Light-osf-sc-t2a.tfm) \
tex(NotoSans-Light-osf-sc-t2a.vf) \
tex(NotoSans-Light-osf-sc-t2b--base.tfm) \
tex(NotoSans-Light-osf-sc-t2b.tfm) \
tex(NotoSans-Light-osf-sc-t2b.vf) \
tex(NotoSans-Light-osf-sc-t2c--base.tfm) \
tex(NotoSans-Light-osf-sc-t2c.tfm) \
tex(NotoSans-Light-osf-sc-t2c.vf) \
tex(NotoSans-Light-osf-t1--base.tfm) \
tex(NotoSans-Light-osf-t1.tfm) \
tex(NotoSans-Light-osf-t1.vf) \
tex(NotoSans-Light-osf-t2a.tfm) \
tex(NotoSans-Light-osf-t2b.tfm) \
tex(NotoSans-Light-osf-t2c.tfm) \
tex(NotoSans-Light-osf-ts1--base.tfm) \
tex(NotoSans-Light-osf-ts1.tfm) \
tex(NotoSans-Light-osf-ts1.vf) \
tex(NotoSans-Light-sup-lgr.tfm) \
tex(NotoSans-Light-sup-ly1.tfm) \
tex(NotoSans-Light-sup-ot1.tfm) \
tex(NotoSans-Light-sup-t1--base.tfm) \
tex(NotoSans-Light-sup-t1.tfm) \
tex(NotoSans-Light-sup-t1.vf) \
tex(NotoSans-Light-sup-t2a.tfm) \
tex(NotoSans-Light-sup-t2b.tfm) \
tex(NotoSans-Light-sup-t2c.tfm) \
tex(NotoSans-Light-tlf-lgr.tfm) \
tex(NotoSans-Light-tlf-ly1.tfm) \
tex(NotoSans-Light-tlf-ot1.tfm) \
tex(NotoSans-Light-tlf-sc-lgr.tfm) \
tex(NotoSans-Light-tlf-sc-ly1--base.tfm) \
tex(NotoSans-Light-tlf-sc-ly1.tfm) \
tex(NotoSans-Light-tlf-sc-ly1.vf) \
tex(NotoSans-Light-tlf-sc-ot1--base.tfm) \
tex(NotoSans-Light-tlf-sc-ot1.tfm) \
tex(NotoSans-Light-tlf-sc-ot1.vf) \
tex(NotoSans-Light-tlf-sc-t1--base.tfm) \
tex(NotoSans-Light-tlf-sc-t1.tfm) \
tex(NotoSans-Light-tlf-sc-t1.vf) \
tex(NotoSans-Light-tlf-sc-t2a--base.tfm) \
tex(NotoSans-Light-tlf-sc-t2a.tfm) \
tex(NotoSans-Light-tlf-sc-t2a.vf) \
tex(NotoSans-Light-tlf-sc-t2b--base.tfm) \
tex(NotoSans-Light-tlf-sc-t2b.tfm) \
tex(NotoSans-Light-tlf-sc-t2b.vf) \
tex(NotoSans-Light-tlf-sc-t2c--base.tfm) \
tex(NotoSans-Light-tlf-sc-t2c.tfm) \
tex(NotoSans-Light-tlf-sc-t2c.vf) \
tex(NotoSans-Light-tlf-t1--base.tfm) \
tex(NotoSans-Light-tlf-t1.tfm) \
tex(NotoSans-Light-tlf-t1.vf) \
tex(NotoSans-Light-tlf-t2a.tfm) \
tex(NotoSans-Light-tlf-t2b.tfm) \
tex(NotoSans-Light-tlf-t2c.tfm) \
tex(NotoSans-Light-tlf-ts1--base.tfm) \
tex(NotoSans-Light-tlf-ts1.tfm) \
tex(NotoSans-Light-tlf-ts1.vf) \
tex(NotoSans-Light-tosf-lgr.tfm) \
tex(NotoSans-Light-tosf-ly1.tfm) \
tex(NotoSans-Light-tosf-ot1.tfm) \
tex(NotoSans-Light-tosf-sc-lgr.tfm) \
tex(NotoSans-Light-tosf-sc-ly1--base.tfm) \
tex(NotoSans-Light-tosf-sc-ly1.tfm) \
tex(NotoSans-Light-tosf-sc-ly1.vf) \
tex(NotoSans-Light-tosf-sc-ot1--base.tfm) \
tex(NotoSans-Light-tosf-sc-ot1.tfm) \
tex(NotoSans-Light-tosf-sc-ot1.vf) \
tex(NotoSans-Light-tosf-sc-t1--base.tfm) \
tex(NotoSans-Light-tosf-sc-t1.tfm) \
tex(NotoSans-Light-tosf-sc-t1.vf) \
tex(NotoSans-Light-tosf-sc-t2a--base.tfm) \
tex(NotoSans-Light-tosf-sc-t2a.tfm) \
tex(NotoSans-Light-tosf-sc-t2a.vf) \
tex(NotoSans-Light-tosf-sc-t2b--base.tfm) \
tex(NotoSans-Light-tosf-sc-t2b.tfm) \
tex(NotoSans-Light-tosf-sc-t2b.vf) \
tex(NotoSans-Light-tosf-sc-t2c--base.tfm) \
tex(NotoSans-Light-tosf-sc-t2c.tfm) \
tex(NotoSans-Light-tosf-sc-t2c.vf) \
tex(NotoSans-Light-tosf-t1--base.tfm) \
tex(NotoSans-Light-tosf-t1.tfm) \
tex(NotoSans-Light-tosf-t1.vf) \
tex(NotoSans-Light-tosf-t2a.tfm) \
tex(NotoSans-Light-tosf-t2b.tfm) \
tex(NotoSans-Light-tosf-t2c.tfm) \
tex(NotoSans-Light-tosf-ts1--base.tfm) \
tex(NotoSans-Light-tosf-ts1.tfm) \
tex(NotoSans-Light-tosf-ts1.vf) \
tex(NotoSans-LightItalic-lf-lgr.tfm) \
tex(NotoSans-LightItalic-lf-ly1.tfm) \
tex(NotoSans-LightItalic-lf-ot1.tfm) \
tex(NotoSans-LightItalic-lf-sc-lgr.tfm) \
tex(NotoSans-LightItalic-lf-sc-ly1--base.tfm) \
tex(NotoSans-LightItalic-lf-sc-ly1.tfm) \
tex(NotoSans-LightItalic-lf-sc-ly1.vf) \
tex(NotoSans-LightItalic-lf-sc-ot1--base.tfm) \
tex(NotoSans-LightItalic-lf-sc-ot1.tfm) \
tex(NotoSans-LightItalic-lf-sc-ot1.vf) \
tex(NotoSans-LightItalic-lf-sc-t1--base.tfm) \
tex(NotoSans-LightItalic-lf-sc-t1.tfm) \
tex(NotoSans-LightItalic-lf-sc-t1.vf) \
tex(NotoSans-LightItalic-lf-sc-t2a--base.tfm) \
tex(NotoSans-LightItalic-lf-sc-t2a.tfm) \
tex(NotoSans-LightItalic-lf-sc-t2a.vf) \
tex(NotoSans-LightItalic-lf-sc-t2b--base.tfm) \
tex(NotoSans-LightItalic-lf-sc-t2b.tfm) \
tex(NotoSans-LightItalic-lf-sc-t2b.vf) \
tex(NotoSans-LightItalic-lf-sc-t2c--base.tfm) \
tex(NotoSans-LightItalic-lf-sc-t2c.tfm) \
tex(NotoSans-LightItalic-lf-sc-t2c.vf) \
tex(NotoSans-LightItalic-lf-t1--base.tfm) \
tex(NotoSans-LightItalic-lf-t1.tfm) \
tex(NotoSans-LightItalic-lf-t1.vf) \
tex(NotoSans-LightItalic-lf-t2a.tfm) \
tex(NotoSans-LightItalic-lf-t2b.tfm) \
tex(NotoSans-LightItalic-lf-t2c.tfm) \
tex(NotoSans-LightItalic-lf-ts1--base.tfm) \
tex(NotoSans-LightItalic-lf-ts1.tfm) \
tex(NotoSans-LightItalic-lf-ts1.vf) \
tex(NotoSans-LightItalic-osf-lgr.tfm) \
tex(NotoSans-LightItalic-osf-ly1.tfm) \
tex(NotoSans-LightItalic-osf-ot1.tfm) \
tex(NotoSans-LightItalic-osf-sc-lgr.tfm) \
tex(NotoSans-LightItalic-osf-sc-ly1--base.tfm) \
tex(NotoSans-LightItalic-osf-sc-ly1.tfm) \
tex(NotoSans-LightItalic-osf-sc-ly1.vf) \
tex(NotoSans-LightItalic-osf-sc-ot1--base.tfm) \
tex(NotoSans-LightItalic-osf-sc-ot1.tfm) \
tex(NotoSans-LightItalic-osf-sc-ot1.vf) \
tex(NotoSans-LightItalic-osf-sc-t1--base.tfm) \
tex(NotoSans-LightItalic-osf-sc-t1.tfm) \
tex(NotoSans-LightItalic-osf-sc-t1.vf) \
tex(NotoSans-LightItalic-osf-sc-t2a--base.tfm) \
tex(NotoSans-LightItalic-osf-sc-t2a.tfm) \
tex(NotoSans-LightItalic-osf-sc-t2a.vf) \
tex(NotoSans-LightItalic-osf-sc-t2b--base.tfm) \
tex(NotoSans-LightItalic-osf-sc-t2b.tfm) \
tex(NotoSans-LightItalic-osf-sc-t2b.vf) \
tex(NotoSans-LightItalic-osf-sc-t2c--base.tfm) \
tex(NotoSans-LightItalic-osf-sc-t2c.tfm) \
tex(NotoSans-LightItalic-osf-sc-t2c.vf) \
tex(NotoSans-LightItalic-osf-t1--base.tfm) \
tex(NotoSans-LightItalic-osf-t1.tfm) \
tex(NotoSans-LightItalic-osf-t1.vf) \
tex(NotoSans-LightItalic-osf-t2a.tfm) \
tex(NotoSans-LightItalic-osf-t2b.tfm) \
tex(NotoSans-LightItalic-osf-t2c.tfm) \
tex(NotoSans-LightItalic-osf-ts1--base.tfm) \
tex(NotoSans-LightItalic-osf-ts1.tfm) \
tex(NotoSans-LightItalic-osf-ts1.vf) \
tex(NotoSans-LightItalic-sup-lgr.tfm) \
tex(NotoSans-LightItalic-sup-ly1.tfm) \
tex(NotoSans-LightItalic-sup-ot1.tfm) \
tex(NotoSans-LightItalic-sup-t1--base.tfm) \
tex(NotoSans-LightItalic-sup-t1.tfm) \
tex(NotoSans-LightItalic-sup-t1.vf) \
tex(NotoSans-LightItalic-sup-t2a.tfm) \
tex(NotoSans-LightItalic-sup-t2b.tfm) \
tex(NotoSans-LightItalic-sup-t2c.tfm) \
tex(NotoSans-LightItalic-tlf-lgr.tfm) \
tex(NotoSans-LightItalic-tlf-ly1.tfm) \
tex(NotoSans-LightItalic-tlf-ot1.tfm) \
tex(NotoSans-LightItalic-tlf-sc-lgr.tfm) \
tex(NotoSans-LightItalic-tlf-sc-ly1--base.tfm) \
tex(NotoSans-LightItalic-tlf-sc-ly1.tfm) \
tex(NotoSans-LightItalic-tlf-sc-ly1.vf) \
tex(NotoSans-LightItalic-tlf-sc-ot1--base.tfm) \
tex(NotoSans-LightItalic-tlf-sc-ot1.tfm) \
tex(NotoSans-LightItalic-tlf-sc-ot1.vf) \
tex(NotoSans-LightItalic-tlf-sc-t1--base.tfm) \
tex(NotoSans-LightItalic-tlf-sc-t1.tfm) \
tex(NotoSans-LightItalic-tlf-sc-t1.vf) \
tex(NotoSans-LightItalic-tlf-sc-t2a--base.tfm) \
tex(NotoSans-LightItalic-tlf-sc-t2a.tfm) \
tex(NotoSans-LightItalic-tlf-sc-t2a.vf) \
tex(NotoSans-LightItalic-tlf-sc-t2b--base.tfm) \
tex(NotoSans-LightItalic-tlf-sc-t2b.tfm) \
tex(NotoSans-LightItalic-tlf-sc-t2b.vf) \
tex(NotoSans-LightItalic-tlf-sc-t2c--base.tfm) \
tex(NotoSans-LightItalic-tlf-sc-t2c.tfm) \
tex(NotoSans-LightItalic-tlf-sc-t2c.vf) \
tex(NotoSans-LightItalic-tlf-t1--base.tfm) \
tex(NotoSans-LightItalic-tlf-t1.tfm) \
tex(NotoSans-LightItalic-tlf-t1.vf) \
tex(NotoSans-LightItalic-tlf-t2a.tfm) \
tex(NotoSans-LightItalic-tlf-t2b.tfm) \
tex(NotoSans-LightItalic-tlf-t2c.tfm) \
tex(NotoSans-LightItalic-tlf-ts1--base.tfm) \
tex(NotoSans-LightItalic-tlf-ts1.tfm) \
tex(NotoSans-LightItalic-tlf-ts1.vf) \
tex(NotoSans-LightItalic-tosf-lgr.tfm) \
tex(NotoSans-LightItalic-tosf-ly1.tfm) \
tex(NotoSans-LightItalic-tosf-ot1.tfm) \
tex(NotoSans-LightItalic-tosf-sc-lgr.tfm) \
tex(NotoSans-LightItalic-tosf-sc-ly1--base.tfm) \
tex(NotoSans-LightItalic-tosf-sc-ly1.tfm) \
tex(NotoSans-LightItalic-tosf-sc-ly1.vf) \
tex(NotoSans-LightItalic-tosf-sc-ot1--base.tfm) \
tex(NotoSans-LightItalic-tosf-sc-ot1.tfm) \
tex(NotoSans-LightItalic-tosf-sc-ot1.vf) \
tex(NotoSans-LightItalic-tosf-sc-t1--base.tfm) \
tex(NotoSans-LightItalic-tosf-sc-t1.tfm) \
tex(NotoSans-LightItalic-tosf-sc-t1.vf) \
tex(NotoSans-LightItalic-tosf-sc-t2a--base.tfm) \
tex(NotoSans-LightItalic-tosf-sc-t2a.tfm) \
tex(NotoSans-LightItalic-tosf-sc-t2a.vf) \
tex(NotoSans-LightItalic-tosf-sc-t2b--base.tfm) \
tex(NotoSans-LightItalic-tosf-sc-t2b.tfm) \
tex(NotoSans-LightItalic-tosf-sc-t2b.vf) \
tex(NotoSans-LightItalic-tosf-sc-t2c--base.tfm) \
tex(NotoSans-LightItalic-tosf-sc-t2c.tfm) \
tex(NotoSans-LightItalic-tosf-sc-t2c.vf) \
tex(NotoSans-LightItalic-tosf-t1--base.tfm) \
tex(NotoSans-LightItalic-tosf-t1.tfm) \
tex(NotoSans-LightItalic-tosf-t1.vf) \
tex(NotoSans-LightItalic-tosf-t2a.tfm) \
tex(NotoSans-LightItalic-tosf-t2b.tfm) \
tex(NotoSans-LightItalic-tosf-t2c.tfm) \
tex(NotoSans-LightItalic-tosf-ts1--base.tfm) \
tex(NotoSans-LightItalic-tosf-ts1.tfm) \
tex(NotoSans-LightItalic-tosf-ts1.vf) \
tex(NotoSans-Medium-lf-lgr.tfm) \
tex(NotoSans-Medium-lf-ly1.tfm) \
tex(NotoSans-Medium-lf-ot1.tfm) \
tex(NotoSans-Medium-lf-sc-lgr.tfm) \
tex(NotoSans-Medium-lf-sc-ly1--base.tfm) \
tex(NotoSans-Medium-lf-sc-ly1.tfm) \
tex(NotoSans-Medium-lf-sc-ly1.vf) \
tex(NotoSans-Medium-lf-sc-ot1--base.tfm) \
tex(NotoSans-Medium-lf-sc-ot1.tfm) \
tex(NotoSans-Medium-lf-sc-ot1.vf) \
tex(NotoSans-Medium-lf-sc-t1--base.tfm) \
tex(NotoSans-Medium-lf-sc-t1.tfm) \
tex(NotoSans-Medium-lf-sc-t1.vf) \
tex(NotoSans-Medium-lf-sc-t2a--base.tfm) \
tex(NotoSans-Medium-lf-sc-t2a.tfm) \
tex(NotoSans-Medium-lf-sc-t2a.vf) \
tex(NotoSans-Medium-lf-sc-t2b--base.tfm) \
tex(NotoSans-Medium-lf-sc-t2b.tfm) \
tex(NotoSans-Medium-lf-sc-t2b.vf) \
tex(NotoSans-Medium-lf-sc-t2c--base.tfm) \
tex(NotoSans-Medium-lf-sc-t2c.tfm) \
tex(NotoSans-Medium-lf-sc-t2c.vf) \
tex(NotoSans-Medium-lf-t1--base.tfm) \
tex(NotoSans-Medium-lf-t1.tfm) \
tex(NotoSans-Medium-lf-t1.vf) \
tex(NotoSans-Medium-lf-t2a.tfm) \
tex(NotoSans-Medium-lf-t2b.tfm) \
tex(NotoSans-Medium-lf-t2c.tfm) \
tex(NotoSans-Medium-lf-ts1--base.tfm) \
tex(NotoSans-Medium-lf-ts1.tfm) \
tex(NotoSans-Medium-lf-ts1.vf) \
tex(NotoSans-Medium-osf-lgr.tfm) \
tex(NotoSans-Medium-osf-ly1.tfm) \
tex(NotoSans-Medium-osf-ot1.tfm) \
tex(NotoSans-Medium-osf-sc-lgr.tfm) \
tex(NotoSans-Medium-osf-sc-ly1--base.tfm) \
tex(NotoSans-Medium-osf-sc-ly1.tfm) \
tex(NotoSans-Medium-osf-sc-ly1.vf) \
tex(NotoSans-Medium-osf-sc-ot1--base.tfm) \
tex(NotoSans-Medium-osf-sc-ot1.tfm) \
tex(NotoSans-Medium-osf-sc-ot1.vf) \
tex(NotoSans-Medium-osf-sc-t1--base.tfm) \
tex(NotoSans-Medium-osf-sc-t1.tfm) \
tex(NotoSans-Medium-osf-sc-t1.vf) \
tex(NotoSans-Medium-osf-sc-t2a--base.tfm) \
tex(NotoSans-Medium-osf-sc-t2a.tfm) \
tex(NotoSans-Medium-osf-sc-t2a.vf) \
tex(NotoSans-Medium-osf-sc-t2b--base.tfm) \
tex(NotoSans-Medium-osf-sc-t2b.tfm) \
tex(NotoSans-Medium-osf-sc-t2b.vf) \
tex(NotoSans-Medium-osf-sc-t2c--base.tfm) \
tex(NotoSans-Medium-osf-sc-t2c.tfm) \
tex(NotoSans-Medium-osf-sc-t2c.vf) \
tex(NotoSans-Medium-osf-t1--base.tfm) \
tex(NotoSans-Medium-osf-t1.tfm) \
tex(NotoSans-Medium-osf-t1.vf) \
tex(NotoSans-Medium-osf-t2a.tfm) \
tex(NotoSans-Medium-osf-t2b.tfm) \
tex(NotoSans-Medium-osf-t2c.tfm) \
tex(NotoSans-Medium-osf-ts1--base.tfm) \
tex(NotoSans-Medium-osf-ts1.tfm) \
tex(NotoSans-Medium-osf-ts1.vf) \
tex(NotoSans-Medium-sup-lgr.tfm) \
tex(NotoSans-Medium-sup-ly1.tfm) \
tex(NotoSans-Medium-sup-ot1.tfm) \
tex(NotoSans-Medium-sup-t1--base.tfm) \
tex(NotoSans-Medium-sup-t1.tfm) \
tex(NotoSans-Medium-sup-t1.vf) \
tex(NotoSans-Medium-sup-t2a.tfm) \
tex(NotoSans-Medium-sup-t2b.tfm) \
tex(NotoSans-Medium-sup-t2c.tfm) \
tex(NotoSans-Medium-tlf-lgr.tfm) \
tex(NotoSans-Medium-tlf-ly1.tfm) \
tex(NotoSans-Medium-tlf-ot1.tfm) \
tex(NotoSans-Medium-tlf-sc-lgr.tfm) \
tex(NotoSans-Medium-tlf-sc-ly1--base.tfm) \
tex(NotoSans-Medium-tlf-sc-ly1.tfm) \
tex(NotoSans-Medium-tlf-sc-ly1.vf) \
tex(NotoSans-Medium-tlf-sc-ot1--base.tfm) \
tex(NotoSans-Medium-tlf-sc-ot1.tfm) \
tex(NotoSans-Medium-tlf-sc-ot1.vf) \
tex(NotoSans-Medium-tlf-sc-t1--base.tfm) \
tex(NotoSans-Medium-tlf-sc-t1.tfm) \
tex(NotoSans-Medium-tlf-sc-t1.vf) \
tex(NotoSans-Medium-tlf-sc-t2a--base.tfm) \
tex(NotoSans-Medium-tlf-sc-t2a.tfm) \
tex(NotoSans-Medium-tlf-sc-t2a.vf) \
tex(NotoSans-Medium-tlf-sc-t2b--base.tfm) \
tex(NotoSans-Medium-tlf-sc-t2b.tfm) \
tex(NotoSans-Medium-tlf-sc-t2b.vf) \
tex(NotoSans-Medium-tlf-sc-t2c--base.tfm) \
tex(NotoSans-Medium-tlf-sc-t2c.tfm) \
tex(NotoSans-Medium-tlf-sc-t2c.vf) \
tex(NotoSans-Medium-tlf-t1--base.tfm) \
tex(NotoSans-Medium-tlf-t1.tfm) \
tex(NotoSans-Medium-tlf-t1.vf) \
tex(NotoSans-Medium-tlf-t2a.tfm) \
tex(NotoSans-Medium-tlf-t2b.tfm) \
tex(NotoSans-Medium-tlf-t2c.tfm) \
tex(NotoSans-Medium-tlf-ts1--base.tfm) \
tex(NotoSans-Medium-tlf-ts1.tfm) \
tex(NotoSans-Medium-tlf-ts1.vf) \
tex(NotoSans-Medium-tosf-lgr.tfm) \
tex(NotoSans-Medium-tosf-ly1.tfm) \
tex(NotoSans-Medium-tosf-ot1.tfm) \
tex(NotoSans-Medium-tosf-sc-lgr.tfm) \
tex(NotoSans-Medium-tosf-sc-ly1--base.tfm) \
tex(NotoSans-Medium-tosf-sc-ly1.tfm) \
tex(NotoSans-Medium-tosf-sc-ly1.vf) \
tex(NotoSans-Medium-tosf-sc-ot1--base.tfm) \
tex(NotoSans-Medium-tosf-sc-ot1.tfm) \
tex(NotoSans-Medium-tosf-sc-ot1.vf) \
tex(NotoSans-Medium-tosf-sc-t1--base.tfm) \
tex(NotoSans-Medium-tosf-sc-t1.tfm) \
tex(NotoSans-Medium-tosf-sc-t1.vf) \
tex(NotoSans-Medium-tosf-sc-t2a--base.tfm) \
tex(NotoSans-Medium-tosf-sc-t2a.tfm) \
tex(NotoSans-Medium-tosf-sc-t2a.vf) \
tex(NotoSans-Medium-tosf-sc-t2b--base.tfm) \
tex(NotoSans-Medium-tosf-sc-t2b.tfm) \
tex(NotoSans-Medium-tosf-sc-t2b.vf) \
tex(NotoSans-Medium-tosf-sc-t2c--base.tfm) \
tex(NotoSans-Medium-tosf-sc-t2c.tfm) \
tex(NotoSans-Medium-tosf-sc-t2c.vf) \
tex(NotoSans-Medium-tosf-t1--base.tfm) \
tex(NotoSans-Medium-tosf-t1.tfm) \
tex(NotoSans-Medium-tosf-t1.vf) \
tex(NotoSans-Medium-tosf-t2a.tfm) \
tex(NotoSans-Medium-tosf-t2b.tfm) \
tex(NotoSans-Medium-tosf-t2c.tfm) \
tex(NotoSans-Medium-tosf-ts1--base.tfm) \
tex(NotoSans-Medium-tosf-ts1.tfm) \
tex(NotoSans-Medium-tosf-ts1.vf) \
tex(NotoSans-MediumItalic-lf-lgr.tfm) \
tex(NotoSans-MediumItalic-lf-ly1.tfm) \
tex(NotoSans-MediumItalic-lf-ot1.tfm) \
tex(NotoSans-MediumItalic-lf-sc-lgr.tfm) \
tex(NotoSans-MediumItalic-lf-sc-ly1--base.tfm) \
tex(NotoSans-MediumItalic-lf-sc-ly1.tfm) \
tex(NotoSans-MediumItalic-lf-sc-ly1.vf) \
tex(NotoSans-MediumItalic-lf-sc-ot1--base.tfm) \
tex(NotoSans-MediumItalic-lf-sc-ot1.tfm) \
tex(NotoSans-MediumItalic-lf-sc-ot1.vf) \
tex(NotoSans-MediumItalic-lf-sc-t1--base.tfm) \
tex(NotoSans-MediumItalic-lf-sc-t1.tfm) \
tex(NotoSans-MediumItalic-lf-sc-t1.vf) \
tex(NotoSans-MediumItalic-lf-sc-t2a--base.tfm) \
tex(NotoSans-MediumItalic-lf-sc-t2a.tfm) \
tex(NotoSans-MediumItalic-lf-sc-t2a.vf) \
tex(NotoSans-MediumItalic-lf-sc-t2b--base.tfm) \
tex(NotoSans-MediumItalic-lf-sc-t2b.tfm) \
tex(NotoSans-MediumItalic-lf-sc-t2b.vf) \
tex(NotoSans-MediumItalic-lf-sc-t2c--base.tfm) \
tex(NotoSans-MediumItalic-lf-sc-t2c.tfm) \
tex(NotoSans-MediumItalic-lf-sc-t2c.vf) \
tex(NotoSans-MediumItalic-lf-t1--base.tfm) \
tex(NotoSans-MediumItalic-lf-t1.tfm) \
tex(NotoSans-MediumItalic-lf-t1.vf) \
tex(NotoSans-MediumItalic-lf-t2a.tfm) \
tex(NotoSans-MediumItalic-lf-t2b.tfm) \
tex(NotoSans-MediumItalic-lf-t2c.tfm) \
tex(NotoSans-MediumItalic-lf-ts1--base.tfm) \
tex(NotoSans-MediumItalic-lf-ts1.tfm) \
tex(NotoSans-MediumItalic-lf-ts1.vf) \
tex(NotoSans-MediumItalic-osf-lgr.tfm) \
tex(NotoSans-MediumItalic-osf-ly1.tfm) \
tex(NotoSans-MediumItalic-osf-ot1.tfm) \
tex(NotoSans-MediumItalic-osf-sc-lgr.tfm) \
tex(NotoSans-MediumItalic-osf-sc-ly1--base.tfm) \
tex(NotoSans-MediumItalic-osf-sc-ly1.tfm) \
tex(NotoSans-MediumItalic-osf-sc-ly1.vf) \
tex(NotoSans-MediumItalic-osf-sc-ot1--base.tfm) \
tex(NotoSans-MediumItalic-osf-sc-ot1.tfm) \
tex(NotoSans-MediumItalic-osf-sc-ot1.vf) \
tex(NotoSans-MediumItalic-osf-sc-t1--base.tfm) \
tex(NotoSans-MediumItalic-osf-sc-t1.tfm) \
tex(NotoSans-MediumItalic-osf-sc-t1.vf) \
tex(NotoSans-MediumItalic-osf-sc-t2a--base.tfm) \
tex(NotoSans-MediumItalic-osf-sc-t2a.tfm) \
tex(NotoSans-MediumItalic-osf-sc-t2a.vf) \
tex(NotoSans-MediumItalic-osf-sc-t2b--base.tfm) \
tex(NotoSans-MediumItalic-osf-sc-t2b.tfm) \
tex(NotoSans-MediumItalic-osf-sc-t2b.vf) \
tex(NotoSans-MediumItalic-osf-sc-t2c--base.tfm) \
tex(NotoSans-MediumItalic-osf-sc-t2c.tfm) \
tex(NotoSans-MediumItalic-osf-sc-t2c.vf) \
tex(NotoSans-MediumItalic-osf-t1--base.tfm) \
tex(NotoSans-MediumItalic-osf-t1.tfm) \
tex(NotoSans-MediumItalic-osf-t1.vf) \
tex(NotoSans-MediumItalic-osf-t2a.tfm) \
tex(NotoSans-MediumItalic-osf-t2b.tfm) \
tex(NotoSans-MediumItalic-osf-t2c.tfm) \
tex(NotoSans-MediumItalic-osf-ts1--base.tfm) \
tex(NotoSans-MediumItalic-osf-ts1.tfm) \
tex(NotoSans-MediumItalic-osf-ts1.vf) \
tex(NotoSans-MediumItalic-sup-lgr.tfm) \
tex(NotoSans-MediumItalic-sup-ly1.tfm) \
tex(NotoSans-MediumItalic-sup-ot1.tfm) \
tex(NotoSans-MediumItalic-sup-t1--base.tfm) \
tex(NotoSans-MediumItalic-sup-t1.tfm) \
tex(NotoSans-MediumItalic-sup-t1.vf) \
tex(NotoSans-MediumItalic-sup-t2a.tfm) \
tex(NotoSans-MediumItalic-sup-t2b.tfm) \
tex(NotoSans-MediumItalic-sup-t2c.tfm) \
tex(NotoSans-MediumItalic-tlf-lgr.tfm) \
tex(NotoSans-MediumItalic-tlf-ly1.tfm) \
tex(NotoSans-MediumItalic-tlf-ot1.tfm) \
tex(NotoSans-MediumItalic-tlf-sc-lgr.tfm) \
tex(NotoSans-MediumItalic-tlf-sc-ly1--base.tfm) \
tex(NotoSans-MediumItalic-tlf-sc-ly1.tfm) \
tex(NotoSans-MediumItalic-tlf-sc-ly1.vf) \
tex(NotoSans-MediumItalic-tlf-sc-ot1--base.tfm) \
tex(NotoSans-MediumItalic-tlf-sc-ot1.tfm) \
tex(NotoSans-MediumItalic-tlf-sc-ot1.vf) \
tex(NotoSans-MediumItalic-tlf-sc-t1--base.tfm) \
tex(NotoSans-MediumItalic-tlf-sc-t1.tfm) \
tex(NotoSans-MediumItalic-tlf-sc-t1.vf) \
tex(NotoSans-MediumItalic-tlf-sc-t2a--base.tfm) \
tex(NotoSans-MediumItalic-tlf-sc-t2a.tfm) \
tex(NotoSans-MediumItalic-tlf-sc-t2a.vf) \
tex(NotoSans-MediumItalic-tlf-sc-t2b--base.tfm) \
tex(NotoSans-MediumItalic-tlf-sc-t2b.tfm) \
tex(NotoSans-MediumItalic-tlf-sc-t2b.vf) \
tex(NotoSans-MediumItalic-tlf-sc-t2c--base.tfm) \
tex(NotoSans-MediumItalic-tlf-sc-t2c.tfm) \
tex(NotoSans-MediumItalic-tlf-sc-t2c.vf) \
tex(NotoSans-MediumItalic-tlf-t1--base.tfm) \
tex(NotoSans-MediumItalic-tlf-t1.tfm) \
tex(NotoSans-MediumItalic-tlf-t1.vf) \
tex(NotoSans-MediumItalic-tlf-t2a.tfm) \
tex(NotoSans-MediumItalic-tlf-t2b.tfm) \
tex(NotoSans-MediumItalic-tlf-t2c.tfm) \
tex(NotoSans-MediumItalic-tlf-ts1--base.tfm) \
tex(NotoSans-MediumItalic-tlf-ts1.tfm) \
tex(NotoSans-MediumItalic-tlf-ts1.vf) \
tex(NotoSans-MediumItalic-tosf-lgr.tfm) \
tex(NotoSans-MediumItalic-tosf-ly1.tfm) \
tex(NotoSans-MediumItalic-tosf-ot1.tfm) \
tex(NotoSans-MediumItalic-tosf-sc-lgr.tfm) \
tex(NotoSans-MediumItalic-tosf-sc-ly1--base.tfm) \
tex(NotoSans-MediumItalic-tosf-sc-ly1.tfm) \
tex(NotoSans-MediumItalic-tosf-sc-ly1.vf) \
tex(NotoSans-MediumItalic-tosf-sc-ot1--base.tfm) \
tex(NotoSans-MediumItalic-tosf-sc-ot1.tfm) \
tex(NotoSans-MediumItalic-tosf-sc-ot1.vf) \
tex(NotoSans-MediumItalic-tosf-sc-t1--base.tfm) \
tex(NotoSans-MediumItalic-tosf-sc-t1.tfm) \
tex(NotoSans-MediumItalic-tosf-sc-t1.vf) \
tex(NotoSans-MediumItalic-tosf-sc-t2a--base.tfm) \
tex(NotoSans-MediumItalic-tosf-sc-t2a.tfm) \
tex(NotoSans-MediumItalic-tosf-sc-t2a.vf) \
tex(NotoSans-MediumItalic-tosf-sc-t2b--base.tfm) \
tex(NotoSans-MediumItalic-tosf-sc-t2b.tfm) \
tex(NotoSans-MediumItalic-tosf-sc-t2b.vf) \
tex(NotoSans-MediumItalic-tosf-sc-t2c--base.tfm) \
tex(NotoSans-MediumItalic-tosf-sc-t2c.tfm) \
tex(NotoSans-MediumItalic-tosf-sc-t2c.vf) \
tex(NotoSans-MediumItalic-tosf-t1--base.tfm) \
tex(NotoSans-MediumItalic-tosf-t1.tfm) \
tex(NotoSans-MediumItalic-tosf-t1.vf) \
tex(NotoSans-MediumItalic-tosf-t2a.tfm) \
tex(NotoSans-MediumItalic-tosf-t2b.tfm) \
tex(NotoSans-MediumItalic-tosf-t2c.tfm) \
tex(NotoSans-MediumItalic-tosf-ts1--base.tfm) \
tex(NotoSans-MediumItalic-tosf-ts1.tfm) \
tex(NotoSans-MediumItalic-tosf-ts1.vf) \
tex(NotoSans-Regular-lf-lgr.tfm) \
tex(NotoSans-Regular-lf-ly1.tfm) \
tex(NotoSans-Regular-lf-ot1.tfm) \
tex(NotoSans-Regular-lf-sc-lgr.tfm) \
tex(NotoSans-Regular-lf-sc-ly1--base.tfm) \
tex(NotoSans-Regular-lf-sc-ly1.tfm) \
tex(NotoSans-Regular-lf-sc-ly1.vf) \
tex(NotoSans-Regular-lf-sc-ot1--base.tfm) \
tex(NotoSans-Regular-lf-sc-ot1.tfm) \
tex(NotoSans-Regular-lf-sc-ot1.vf) \
tex(NotoSans-Regular-lf-sc-t1--base.tfm) \
tex(NotoSans-Regular-lf-sc-t1.tfm) \
tex(NotoSans-Regular-lf-sc-t1.vf) \
tex(NotoSans-Regular-lf-sc-t2a--base.tfm) \
tex(NotoSans-Regular-lf-sc-t2a.tfm) \
tex(NotoSans-Regular-lf-sc-t2a.vf) \
tex(NotoSans-Regular-lf-sc-t2b--base.tfm) \
tex(NotoSans-Regular-lf-sc-t2b.tfm) \
tex(NotoSans-Regular-lf-sc-t2b.vf) \
tex(NotoSans-Regular-lf-sc-t2c--base.tfm) \
tex(NotoSans-Regular-lf-sc-t2c.tfm) \
tex(NotoSans-Regular-lf-sc-t2c.vf) \
tex(NotoSans-Regular-lf-t1--base.tfm) \
tex(NotoSans-Regular-lf-t1.tfm) \
tex(NotoSans-Regular-lf-t1.vf) \
tex(NotoSans-Regular-lf-t2a.tfm) \
tex(NotoSans-Regular-lf-t2b.tfm) \
tex(NotoSans-Regular-lf-t2c.tfm) \
tex(NotoSans-Regular-lf-ts1--base.tfm) \
tex(NotoSans-Regular-lf-ts1.tfm) \
tex(NotoSans-Regular-lf-ts1.vf) \
tex(NotoSans-Regular-osf-lgr.tfm) \
tex(NotoSans-Regular-osf-ly1.tfm) \
tex(NotoSans-Regular-osf-ot1.tfm) \
tex(NotoSans-Regular-osf-sc-lgr.tfm) \
tex(NotoSans-Regular-osf-sc-ly1--base.tfm) \
tex(NotoSans-Regular-osf-sc-ly1.tfm) \
tex(NotoSans-Regular-osf-sc-ly1.vf) \
tex(NotoSans-Regular-osf-sc-ot1--base.tfm) \
tex(NotoSans-Regular-osf-sc-ot1.tfm) \
tex(NotoSans-Regular-osf-sc-ot1.vf) \
tex(NotoSans-Regular-osf-sc-t1--base.tfm) \
tex(NotoSans-Regular-osf-sc-t1.tfm) \
tex(NotoSans-Regular-osf-sc-t1.vf) \
tex(NotoSans-Regular-osf-sc-t2a--base.tfm) \
tex(NotoSans-Regular-osf-sc-t2a.tfm) \
tex(NotoSans-Regular-osf-sc-t2a.vf) \
tex(NotoSans-Regular-osf-sc-t2b--base.tfm) \
tex(NotoSans-Regular-osf-sc-t2b.tfm) \
tex(NotoSans-Regular-osf-sc-t2b.vf) \
tex(NotoSans-Regular-osf-sc-t2c--base.tfm) \
tex(NotoSans-Regular-osf-sc-t2c.tfm) \
tex(NotoSans-Regular-osf-sc-t2c.vf) \
tex(NotoSans-Regular-osf-t1--base.tfm) \
tex(NotoSans-Regular-osf-t1.tfm) \
tex(NotoSans-Regular-osf-t1.vf) \
tex(NotoSans-Regular-osf-t2a.tfm) \
tex(NotoSans-Regular-osf-t2b.tfm) \
tex(NotoSans-Regular-osf-t2c.tfm) \
tex(NotoSans-Regular-osf-ts1--base.tfm) \
tex(NotoSans-Regular-osf-ts1.tfm) \
tex(NotoSans-Regular-osf-ts1.vf) \
tex(NotoSans-Regular-sup-lgr.tfm) \
tex(NotoSans-Regular-sup-ly1.tfm) \
tex(NotoSans-Regular-sup-ot1.tfm) \
tex(NotoSans-Regular-sup-t1--base.tfm) \
tex(NotoSans-Regular-sup-t1.tfm) \
tex(NotoSans-Regular-sup-t1.vf) \
tex(NotoSans-Regular-sup-t2a.tfm) \
tex(NotoSans-Regular-sup-t2b.tfm) \
tex(NotoSans-Regular-sup-t2c.tfm) \
tex(NotoSans-Regular-tlf-lgr.tfm) \
tex(NotoSans-Regular-tlf-ly1.tfm) \
tex(NotoSans-Regular-tlf-ot1.tfm) \
tex(NotoSans-Regular-tlf-sc-lgr.tfm) \
tex(NotoSans-Regular-tlf-sc-ly1--base.tfm) \
tex(NotoSans-Regular-tlf-sc-ly1.tfm) \
tex(NotoSans-Regular-tlf-sc-ly1.vf) \
tex(NotoSans-Regular-tlf-sc-ot1--base.tfm) \
tex(NotoSans-Regular-tlf-sc-ot1.tfm) \
tex(NotoSans-Regular-tlf-sc-ot1.vf) \
tex(NotoSans-Regular-tlf-sc-t1--base.tfm) \
tex(NotoSans-Regular-tlf-sc-t1.tfm) \
tex(NotoSans-Regular-tlf-sc-t1.vf) \
tex(NotoSans-Regular-tlf-sc-t2a--base.tfm) \
tex(NotoSans-Regular-tlf-sc-t2a.tfm) \
tex(NotoSans-Regular-tlf-sc-t2a.vf) \
tex(NotoSans-Regular-tlf-sc-t2b--base.tfm) \
tex(NotoSans-Regular-tlf-sc-t2b.tfm) \
tex(NotoSans-Regular-tlf-sc-t2b.vf) \
tex(NotoSans-Regular-tlf-sc-t2c--base.tfm) \
tex(NotoSans-Regular-tlf-sc-t2c.tfm) \
tex(NotoSans-Regular-tlf-sc-t2c.vf) \
tex(NotoSans-Regular-tlf-t1--base.tfm) \
tex(NotoSans-Regular-tlf-t1.tfm) \
tex(NotoSans-Regular-tlf-t1.vf) \
tex(NotoSans-Regular-tlf-t2a.tfm) \
tex(NotoSans-Regular-tlf-t2b.tfm) \
tex(NotoSans-Regular-tlf-t2c.tfm) \
tex(NotoSans-Regular-tlf-ts1--base.tfm) \
tex(NotoSans-Regular-tlf-ts1.tfm) \
tex(NotoSans-Regular-tlf-ts1.vf) \
tex(NotoSans-Regular-tosf-lgr.tfm) \
tex(NotoSans-Regular-tosf-ly1.tfm) \
tex(NotoSans-Regular-tosf-ot1.tfm) \
tex(NotoSans-Regular-tosf-sc-lgr.tfm) \
tex(NotoSans-Regular-tosf-sc-ly1--base.tfm) \
tex(NotoSans-Regular-tosf-sc-ly1.tfm) \
tex(NotoSans-Regular-tosf-sc-ly1.vf) \
tex(NotoSans-Regular-tosf-sc-ot1--base.tfm) \
tex(NotoSans-Regular-tosf-sc-ot1.tfm) \
tex(NotoSans-Regular-tosf-sc-ot1.vf) \
tex(NotoSans-Regular-tosf-sc-t1--base.tfm) \
tex(NotoSans-Regular-tosf-sc-t1.tfm) \
tex(NotoSans-Regular-tosf-sc-t1.vf) \
tex(NotoSans-Regular-tosf-sc-t2a--base.tfm) \
tex(NotoSans-Regular-tosf-sc-t2a.tfm) \
tex(NotoSans-Regular-tosf-sc-t2a.vf) \
tex(NotoSans-Regular-tosf-sc-t2b--base.tfm) \
tex(NotoSans-Regular-tosf-sc-t2b.tfm) \
tex(NotoSans-Regular-tosf-sc-t2b.vf) \
tex(NotoSans-Regular-tosf-sc-t2c--base.tfm) \
tex(NotoSans-Regular-tosf-sc-t2c.tfm) \
tex(NotoSans-Regular-tosf-sc-t2c.vf) \
tex(NotoSans-Regular-tosf-t1--base.tfm) \
tex(NotoSans-Regular-tosf-t1.tfm) \
tex(NotoSans-Regular-tosf-t1.vf) \
tex(NotoSans-Regular-tosf-t2a.tfm) \
tex(NotoSans-Regular-tosf-t2b.tfm) \
tex(NotoSans-Regular-tosf-t2c.tfm) \
tex(NotoSans-Regular-tosf-ts1--base.tfm) \
tex(NotoSans-Regular-tosf-ts1.tfm) \
tex(NotoSans-Regular-tosf-ts1.vf) \
tex(NotoSans-SemiBold-lf-lgr.tfm) \
tex(NotoSans-SemiBold-lf-ly1.tfm) \
tex(NotoSans-SemiBold-lf-ot1.tfm) \
tex(NotoSans-SemiBold-lf-sc-lgr.tfm) \
tex(NotoSans-SemiBold-lf-sc-ly1--base.tfm) \
tex(NotoSans-SemiBold-lf-sc-ly1.tfm) \
tex(NotoSans-SemiBold-lf-sc-ly1.vf) \
tex(NotoSans-SemiBold-lf-sc-ot1--base.tfm) \
tex(NotoSans-SemiBold-lf-sc-ot1.tfm) \
tex(NotoSans-SemiBold-lf-sc-ot1.vf) \
tex(NotoSans-SemiBold-lf-sc-t1--base.tfm) \
tex(NotoSans-SemiBold-lf-sc-t1.tfm) \
tex(NotoSans-SemiBold-lf-sc-t1.vf) \
tex(NotoSans-SemiBold-lf-sc-t2a--base.tfm) \
tex(NotoSans-SemiBold-lf-sc-t2a.tfm) \
tex(NotoSans-SemiBold-lf-sc-t2a.vf) \
tex(NotoSans-SemiBold-lf-sc-t2b--base.tfm) \
tex(NotoSans-SemiBold-lf-sc-t2b.tfm) \
tex(NotoSans-SemiBold-lf-sc-t2b.vf) \
tex(NotoSans-SemiBold-lf-sc-t2c--base.tfm) \
tex(NotoSans-SemiBold-lf-sc-t2c.tfm) \
tex(NotoSans-SemiBold-lf-sc-t2c.vf) \
tex(NotoSans-SemiBold-lf-t1--base.tfm) \
tex(NotoSans-SemiBold-lf-t1.tfm) \
tex(NotoSans-SemiBold-lf-t1.vf) \
tex(NotoSans-SemiBold-lf-t2a.tfm) \
tex(NotoSans-SemiBold-lf-t2b.tfm) \
tex(NotoSans-SemiBold-lf-t2c.tfm) \
tex(NotoSans-SemiBold-lf-ts1--base.tfm) \
tex(NotoSans-SemiBold-lf-ts1.tfm) \
tex(NotoSans-SemiBold-lf-ts1.vf) \
tex(NotoSans-SemiBold-osf-lgr.tfm) \
tex(NotoSans-SemiBold-osf-ly1.tfm) \
tex(NotoSans-SemiBold-osf-ot1.tfm) \
tex(NotoSans-SemiBold-osf-sc-lgr.tfm) \
tex(NotoSans-SemiBold-osf-sc-ly1--base.tfm) \
tex(NotoSans-SemiBold-osf-sc-ly1.tfm) \
tex(NotoSans-SemiBold-osf-sc-ly1.vf) \
tex(NotoSans-SemiBold-osf-sc-ot1--base.tfm) \
tex(NotoSans-SemiBold-osf-sc-ot1.tfm) \
tex(NotoSans-SemiBold-osf-sc-ot1.vf) \
tex(NotoSans-SemiBold-osf-sc-t1--base.tfm) \
tex(NotoSans-SemiBold-osf-sc-t1.tfm) \
tex(NotoSans-SemiBold-osf-sc-t1.vf) \
tex(NotoSans-SemiBold-osf-sc-t2a--base.tfm) \
tex(NotoSans-SemiBold-osf-sc-t2a.tfm) \
tex(NotoSans-SemiBold-osf-sc-t2a.vf) \
tex(NotoSans-SemiBold-osf-sc-t2b--base.tfm) \
tex(NotoSans-SemiBold-osf-sc-t2b.tfm) \
tex(NotoSans-SemiBold-osf-sc-t2b.vf) \
tex(NotoSans-SemiBold-osf-sc-t2c--base.tfm) \
tex(NotoSans-SemiBold-osf-sc-t2c.tfm) \
tex(NotoSans-SemiBold-osf-sc-t2c.vf) \
tex(NotoSans-SemiBold-osf-t1--base.tfm) \
tex(NotoSans-SemiBold-osf-t1.tfm) \
tex(NotoSans-SemiBold-osf-t1.vf) \
tex(NotoSans-SemiBold-osf-t2a.tfm) \
tex(NotoSans-SemiBold-osf-t2b.tfm) \
tex(NotoSans-SemiBold-osf-t2c.tfm) \
tex(NotoSans-SemiBold-osf-ts1--base.tfm) \
tex(NotoSans-SemiBold-osf-ts1.tfm) \
tex(NotoSans-SemiBold-osf-ts1.vf) \
tex(NotoSans-SemiBold-sup-lgr.tfm) \
tex(NotoSans-SemiBold-sup-ly1.tfm) \
tex(NotoSans-SemiBold-sup-ot1.tfm) \
tex(NotoSans-SemiBold-sup-t1--base.tfm) \
tex(NotoSans-SemiBold-sup-t1.tfm) \
tex(NotoSans-SemiBold-sup-t1.vf) \
tex(NotoSans-SemiBold-sup-t2a.tfm) \
tex(NotoSans-SemiBold-sup-t2b.tfm) \
tex(NotoSans-SemiBold-sup-t2c.tfm) \
tex(NotoSans-SemiBold-tlf-lgr.tfm) \
tex(NotoSans-SemiBold-tlf-ly1.tfm) \
tex(NotoSans-SemiBold-tlf-ot1.tfm) \
tex(NotoSans-SemiBold-tlf-sc-lgr.tfm) \
tex(NotoSans-SemiBold-tlf-sc-ly1--base.tfm) \
tex(NotoSans-SemiBold-tlf-sc-ly1.tfm) \
tex(NotoSans-SemiBold-tlf-sc-ly1.vf) \
tex(NotoSans-SemiBold-tlf-sc-ot1--base.tfm) \
tex(NotoSans-SemiBold-tlf-sc-ot1.tfm) \
tex(NotoSans-SemiBold-tlf-sc-ot1.vf) \
tex(NotoSans-SemiBold-tlf-sc-t1--base.tfm) \
tex(NotoSans-SemiBold-tlf-sc-t1.tfm) \
tex(NotoSans-SemiBold-tlf-sc-t1.vf) \
tex(NotoSans-SemiBold-tlf-sc-t2a--base.tfm) \
tex(NotoSans-SemiBold-tlf-sc-t2a.tfm) \
tex(NotoSans-SemiBold-tlf-sc-t2a.vf) \
tex(NotoSans-SemiBold-tlf-sc-t2b--base.tfm) \
tex(NotoSans-SemiBold-tlf-sc-t2b.tfm) \
tex(NotoSans-SemiBold-tlf-sc-t2b.vf) \
tex(NotoSans-SemiBold-tlf-sc-t2c--base.tfm) \
tex(NotoSans-SemiBold-tlf-sc-t2c.tfm) \
tex(NotoSans-SemiBold-tlf-sc-t2c.vf) \
tex(NotoSans-SemiBold-tlf-t1--base.tfm) \
tex(NotoSans-SemiBold-tlf-t1.tfm) \
tex(NotoSans-SemiBold-tlf-t1.vf) \
tex(NotoSans-SemiBold-tlf-t2a.tfm) \
tex(NotoSans-SemiBold-tlf-t2b.tfm) \
tex(NotoSans-SemiBold-tlf-t2c.tfm) \
tex(NotoSans-SemiBold-tlf-ts1--base.tfm) \
tex(NotoSans-SemiBold-tlf-ts1.tfm) \
tex(NotoSans-SemiBold-tlf-ts1.vf) \
tex(NotoSans-SemiBold-tosf-lgr.tfm) \
tex(NotoSans-SemiBold-tosf-ly1.tfm) \
tex(NotoSans-SemiBold-tosf-ot1.tfm) \
tex(NotoSans-SemiBold-tosf-sc-lgr.tfm) \
tex(NotoSans-SemiBold-tosf-sc-ly1--base.tfm) \
tex(NotoSans-SemiBold-tosf-sc-ly1.tfm) \
tex(NotoSans-SemiBold-tosf-sc-ly1.vf) \
tex(NotoSans-SemiBold-tosf-sc-ot1--base.tfm) \
tex(NotoSans-SemiBold-tosf-sc-ot1.tfm) \
tex(NotoSans-SemiBold-tosf-sc-ot1.vf) \
tex(NotoSans-SemiBold-tosf-sc-t1--base.tfm) \
tex(NotoSans-SemiBold-tosf-sc-t1.tfm) \
tex(NotoSans-SemiBold-tosf-sc-t1.vf) \
tex(NotoSans-SemiBold-tosf-sc-t2a--base.tfm) \
tex(NotoSans-SemiBold-tosf-sc-t2a.tfm) \
tex(NotoSans-SemiBold-tosf-sc-t2a.vf) \
tex(NotoSans-SemiBold-tosf-sc-t2b--base.tfm) \
tex(NotoSans-SemiBold-tosf-sc-t2b.tfm) \
tex(NotoSans-SemiBold-tosf-sc-t2b.vf) \
tex(NotoSans-SemiBold-tosf-sc-t2c--base.tfm) \
tex(NotoSans-SemiBold-tosf-sc-t2c.tfm) \
tex(NotoSans-SemiBold-tosf-sc-t2c.vf) \
tex(NotoSans-SemiBold-tosf-t1--base.tfm) \
tex(NotoSans-SemiBold-tosf-t1.tfm) \
tex(NotoSans-SemiBold-tosf-t1.vf) \
tex(NotoSans-SemiBold-tosf-t2a.tfm) \
tex(NotoSans-SemiBold-tosf-t2b.tfm) \
tex(NotoSans-SemiBold-tosf-t2c.tfm) \
tex(NotoSans-SemiBold-tosf-ts1--base.tfm) \
tex(NotoSans-SemiBold-tosf-ts1.tfm) \
tex(NotoSans-SemiBold-tosf-ts1.vf) \
tex(NotoSans-SemiBoldItalic-lf-lgr.tfm) \
tex(NotoSans-SemiBoldItalic-lf-ly1.tfm) \
tex(NotoSans-SemiBoldItalic-lf-ot1.tfm) \
tex(NotoSans-SemiBoldItalic-lf-sc-lgr.tfm) \
tex(NotoSans-SemiBoldItalic-lf-sc-ly1--base.tfm) \
tex(NotoSans-SemiBoldItalic-lf-sc-ly1.tfm) \
tex(NotoSans-SemiBoldItalic-lf-sc-ly1.vf) \
tex(NotoSans-SemiBoldItalic-lf-sc-ot1--base.tfm) \
tex(NotoSans-SemiBoldItalic-lf-sc-ot1.tfm) \
tex(NotoSans-SemiBoldItalic-lf-sc-ot1.vf) \
tex(NotoSans-SemiBoldItalic-lf-sc-t1--base.tfm) \
tex(NotoSans-SemiBoldItalic-lf-sc-t1.tfm) \
tex(NotoSans-SemiBoldItalic-lf-sc-t1.vf) \
tex(NotoSans-SemiBoldItalic-lf-sc-t2a--base.tfm) \
tex(NotoSans-SemiBoldItalic-lf-sc-t2a.tfm) \
tex(NotoSans-SemiBoldItalic-lf-sc-t2a.vf) \
tex(NotoSans-SemiBoldItalic-lf-sc-t2b--base.tfm) \
tex(NotoSans-SemiBoldItalic-lf-sc-t2b.tfm) \
tex(NotoSans-SemiBoldItalic-lf-sc-t2b.vf) \
tex(NotoSans-SemiBoldItalic-lf-sc-t2c--base.tfm) \
tex(NotoSans-SemiBoldItalic-lf-sc-t2c.tfm) \
tex(NotoSans-SemiBoldItalic-lf-sc-t2c.vf) \
tex(NotoSans-SemiBoldItalic-lf-t1--base.tfm) \
tex(NotoSans-SemiBoldItalic-lf-t1.tfm) \
tex(NotoSans-SemiBoldItalic-lf-t1.vf) \
tex(NotoSans-SemiBoldItalic-lf-t2a.tfm) \
tex(NotoSans-SemiBoldItalic-lf-t2b.tfm) \
tex(NotoSans-SemiBoldItalic-lf-t2c.tfm) \
tex(NotoSans-SemiBoldItalic-lf-ts1--base.tfm) \
tex(NotoSans-SemiBoldItalic-lf-ts1.tfm) \
tex(NotoSans-SemiBoldItalic-lf-ts1.vf) \
tex(NotoSans-SemiBoldItalic-osf-lgr.tfm) \
tex(NotoSans-SemiBoldItalic-osf-ly1.tfm) \
tex(NotoSans-SemiBoldItalic-osf-ot1.tfm) \
tex(NotoSans-SemiBoldItalic-osf-sc-lgr.tfm) \
tex(NotoSans-SemiBoldItalic-osf-sc-ly1--base.tfm) \
tex(NotoSans-SemiBoldItalic-osf-sc-ly1.tfm) \
tex(NotoSans-SemiBoldItalic-osf-sc-ly1.vf) \
tex(NotoSans-SemiBoldItalic-osf-sc-ot1--base.tfm) \
tex(NotoSans-SemiBoldItalic-osf-sc-ot1.tfm) \
tex(NotoSans-SemiBoldItalic-osf-sc-ot1.vf) \
tex(NotoSans-SemiBoldItalic-osf-sc-t1--base.tfm) \
tex(NotoSans-SemiBoldItalic-osf-sc-t1.tfm) \
tex(NotoSans-SemiBoldItalic-osf-sc-t1.vf) \
tex(NotoSans-SemiBoldItalic-osf-sc-t2a--base.tfm) \
tex(NotoSans-SemiBoldItalic-osf-sc-t2a.tfm) \
tex(NotoSans-SemiBoldItalic-osf-sc-t2a.vf) \
tex(NotoSans-SemiBoldItalic-osf-sc-t2b--base.tfm) \
tex(NotoSans-SemiBoldItalic-osf-sc-t2b.tfm) \
tex(NotoSans-SemiBoldItalic-osf-sc-t2b.vf) \
tex(NotoSans-SemiBoldItalic-osf-sc-t2c--base.tfm) \
tex(NotoSans-SemiBoldItalic-osf-sc-t2c.tfm) \
tex(NotoSans-SemiBoldItalic-osf-sc-t2c.vf) \
tex(NotoSans-SemiBoldItalic-osf-t1--base.tfm) \
tex(NotoSans-SemiBoldItalic-osf-t1.tfm) \
tex(NotoSans-SemiBoldItalic-osf-t1.vf) \
tex(NotoSans-SemiBoldItalic-osf-t2a.tfm) \
tex(NotoSans-SemiBoldItalic-osf-t2b.tfm) \
tex(NotoSans-SemiBoldItalic-osf-t2c.tfm) \
tex(NotoSans-SemiBoldItalic-osf-ts1--base.tfm) \
tex(NotoSans-SemiBoldItalic-osf-ts1.tfm) \
tex(NotoSans-SemiBoldItalic-osf-ts1.vf) \
tex(NotoSans-SemiBoldItalic-sup-lgr.tfm) \
tex(NotoSans-SemiBoldItalic-sup-ly1.tfm) \
tex(NotoSans-SemiBoldItalic-sup-ot1.tfm) \
tex(NotoSans-SemiBoldItalic-sup-t1--base.tfm) \
tex(NotoSans-SemiBoldItalic-sup-t1.tfm) \
tex(NotoSans-SemiBoldItalic-sup-t1.vf) \
tex(NotoSans-SemiBoldItalic-sup-t2a.tfm) \
tex(NotoSans-SemiBoldItalic-sup-t2b.tfm) \
tex(NotoSans-SemiBoldItalic-sup-t2c.tfm) \
tex(NotoSans-SemiBoldItalic-tlf-lgr.tfm) \
tex(NotoSans-SemiBoldItalic-tlf-ly1.tfm) \
tex(NotoSans-SemiBoldItalic-tlf-ot1.tfm) \
tex(NotoSans-SemiBoldItalic-tlf-sc-lgr.tfm) \
tex(NotoSans-SemiBoldItalic-tlf-sc-ly1--base.tfm) \
tex(NotoSans-SemiBoldItalic-tlf-sc-ly1.tfm) \
tex(NotoSans-SemiBoldItalic-tlf-sc-ly1.vf) \
tex(NotoSans-SemiBoldItalic-tlf-sc-ot1--base.tfm) \
tex(NotoSans-SemiBoldItalic-tlf-sc-ot1.tfm) \
tex(NotoSans-SemiBoldItalic-tlf-sc-ot1.vf) \
tex(NotoSans-SemiBoldItalic-tlf-sc-t1--base.tfm) \
tex(NotoSans-SemiBoldItalic-tlf-sc-t1.tfm) \
tex(NotoSans-SemiBoldItalic-tlf-sc-t1.vf) \
tex(NotoSans-SemiBoldItalic-tlf-sc-t2a--base.tfm) \
tex(NotoSans-SemiBoldItalic-tlf-sc-t2a.tfm) \
tex(NotoSans-SemiBoldItalic-tlf-sc-t2a.vf) \
tex(NotoSans-SemiBoldItalic-tlf-sc-t2b--base.tfm) \
tex(NotoSans-SemiBoldItalic-tlf-sc-t2b.tfm) \
tex(NotoSans-SemiBoldItalic-tlf-sc-t2b.vf) \
tex(NotoSans-SemiBoldItalic-tlf-sc-t2c--base.tfm) \
tex(NotoSans-SemiBoldItalic-tlf-sc-t2c.tfm) \
tex(NotoSans-SemiBoldItalic-tlf-sc-t2c.vf) \
tex(NotoSans-SemiBoldItalic-tlf-t1--base.tfm) \
tex(NotoSans-SemiBoldItalic-tlf-t1.tfm) \
tex(NotoSans-SemiBoldItalic-tlf-t1.vf) \
tex(NotoSans-SemiBoldItalic-tlf-t2a.tfm) \
tex(NotoSans-SemiBoldItalic-tlf-t2b.tfm) \
tex(NotoSans-SemiBoldItalic-tlf-t2c.tfm) \
tex(NotoSans-SemiBoldItalic-tlf-ts1--base.tfm) \
tex(NotoSans-SemiBoldItalic-tlf-ts1.tfm) \
tex(NotoSans-SemiBoldItalic-tlf-ts1.vf) \
tex(NotoSans-SemiBoldItalic-tosf-lgr.tfm) \
tex(NotoSans-SemiBoldItalic-tosf-ly1.tfm) \
tex(NotoSans-SemiBoldItalic-tosf-ot1.tfm) \
tex(NotoSans-SemiBoldItalic-tosf-sc-lgr.tfm) \
tex(NotoSans-SemiBoldItalic-tosf-sc-ly1--base.tfm) \
tex(NotoSans-SemiBoldItalic-tosf-sc-ly1.tfm) \
tex(NotoSans-SemiBoldItalic-tosf-sc-ly1.vf) \
tex(NotoSans-SemiBoldItalic-tosf-sc-ot1--base.tfm) \
tex(NotoSans-SemiBoldItalic-tosf-sc-ot1.tfm) \
tex(NotoSans-SemiBoldItalic-tosf-sc-ot1.vf) \
tex(NotoSans-SemiBoldItalic-tosf-sc-t1--base.tfm) \
tex(NotoSans-SemiBoldItalic-tosf-sc-t1.tfm) \
tex(NotoSans-SemiBoldItalic-tosf-sc-t1.vf) \
tex(NotoSans-SemiBoldItalic-tosf-sc-t2a--base.tfm) \
tex(NotoSans-SemiBoldItalic-tosf-sc-t2a.tfm) \
tex(NotoSans-SemiBoldItalic-tosf-sc-t2a.vf) \
tex(NotoSans-SemiBoldItalic-tosf-sc-t2b--base.tfm) \
tex(NotoSans-SemiBoldItalic-tosf-sc-t2b.tfm) \
tex(NotoSans-SemiBoldItalic-tosf-sc-t2b.vf) \
tex(NotoSans-SemiBoldItalic-tosf-sc-t2c--base.tfm) \
tex(NotoSans-SemiBoldItalic-tosf-sc-t2c.tfm) \
tex(NotoSans-SemiBoldItalic-tosf-sc-t2c.vf) \
tex(NotoSans-SemiBoldItalic-tosf-t1--base.tfm) \
tex(NotoSans-SemiBoldItalic-tosf-t1.tfm) \
tex(NotoSans-SemiBoldItalic-tosf-t1.vf) \
tex(NotoSans-SemiBoldItalic-tosf-t2a.tfm) \
tex(NotoSans-SemiBoldItalic-tosf-t2b.tfm) \
tex(NotoSans-SemiBoldItalic-tosf-t2c.tfm) \
tex(NotoSans-SemiBoldItalic-tosf-ts1--base.tfm) \
tex(NotoSans-SemiBoldItalic-tosf-ts1.tfm) \
tex(NotoSans-SemiBoldItalic-tosf-ts1.vf) \
tex(NotoSans-Thin-lf-lgr.tfm) \
tex(NotoSans-Thin-lf-ly1.tfm) \
tex(NotoSans-Thin-lf-ot1.tfm) \
tex(NotoSans-Thin-lf-sc-lgr.tfm) \
tex(NotoSans-Thin-lf-sc-ly1--base.tfm) \
tex(NotoSans-Thin-lf-sc-ly1.tfm) \
tex(NotoSans-Thin-lf-sc-ly1.vf) \
tex(NotoSans-Thin-lf-sc-ot1--base.tfm) \
tex(NotoSans-Thin-lf-sc-ot1.tfm) \
tex(NotoSans-Thin-lf-sc-ot1.vf) \
tex(NotoSans-Thin-lf-sc-t1--base.tfm) \
tex(NotoSans-Thin-lf-sc-t1.tfm) \
tex(NotoSans-Thin-lf-sc-t1.vf) \
tex(NotoSans-Thin-lf-sc-t2a--base.tfm) \
tex(NotoSans-Thin-lf-sc-t2a.tfm) \
tex(NotoSans-Thin-lf-sc-t2a.vf) \
tex(NotoSans-Thin-lf-sc-t2b--base.tfm) \
tex(NotoSans-Thin-lf-sc-t2b.tfm) \
tex(NotoSans-Thin-lf-sc-t2b.vf) \
tex(NotoSans-Thin-lf-sc-t2c--base.tfm) \
tex(NotoSans-Thin-lf-sc-t2c.tfm) \
tex(NotoSans-Thin-lf-sc-t2c.vf) \
tex(NotoSans-Thin-lf-t1--base.tfm) \
tex(NotoSans-Thin-lf-t1.tfm) \
tex(NotoSans-Thin-lf-t1.vf) \
tex(NotoSans-Thin-lf-t2a.tfm) \
tex(NotoSans-Thin-lf-t2b.tfm) \
tex(NotoSans-Thin-lf-t2c.tfm) \
tex(NotoSans-Thin-lf-ts1--base.tfm) \
tex(NotoSans-Thin-lf-ts1.tfm) \
tex(NotoSans-Thin-lf-ts1.vf) \
tex(NotoSans-Thin-osf-lgr.tfm) \
tex(NotoSans-Thin-osf-ly1.tfm) \
tex(NotoSans-Thin-osf-ot1.tfm) \
tex(NotoSans-Thin-osf-sc-lgr.tfm) \
tex(NotoSans-Thin-osf-sc-ly1--base.tfm) \
tex(NotoSans-Thin-osf-sc-ly1.tfm) \
tex(NotoSans-Thin-osf-sc-ly1.vf) \
tex(NotoSans-Thin-osf-sc-ot1--base.tfm) \
tex(NotoSans-Thin-osf-sc-ot1.tfm) \
tex(NotoSans-Thin-osf-sc-ot1.vf) \
tex(NotoSans-Thin-osf-sc-t1--base.tfm) \
tex(NotoSans-Thin-osf-sc-t1.tfm) \
tex(NotoSans-Thin-osf-sc-t1.vf) \
tex(NotoSans-Thin-osf-sc-t2a--base.tfm) \
tex(NotoSans-Thin-osf-sc-t2a.tfm) \
tex(NotoSans-Thin-osf-sc-t2a.vf) \
tex(NotoSans-Thin-osf-sc-t2b--base.tfm) \
tex(NotoSans-Thin-osf-sc-t2b.tfm) \
tex(NotoSans-Thin-osf-sc-t2b.vf) \
tex(NotoSans-Thin-osf-sc-t2c--base.tfm) \
tex(NotoSans-Thin-osf-sc-t2c.tfm) \
tex(NotoSans-Thin-osf-sc-t2c.vf) \
tex(NotoSans-Thin-osf-t1--base.tfm) \
tex(NotoSans-Thin-osf-t1.tfm) \
tex(NotoSans-Thin-osf-t1.vf) \
tex(NotoSans-Thin-osf-t2a.tfm) \
tex(NotoSans-Thin-osf-t2b.tfm) \
tex(NotoSans-Thin-osf-t2c.tfm) \
tex(NotoSans-Thin-osf-ts1--base.tfm) \
tex(NotoSans-Thin-osf-ts1.tfm) \
tex(NotoSans-Thin-osf-ts1.vf) \
tex(NotoSans-Thin-sup-lgr.tfm) \
tex(NotoSans-Thin-sup-ly1.tfm) \
tex(NotoSans-Thin-sup-ot1.tfm) \
tex(NotoSans-Thin-sup-t1--base.tfm) \
tex(NotoSans-Thin-sup-t1.tfm) \
tex(NotoSans-Thin-sup-t1.vf) \
tex(NotoSans-Thin-sup-t2a.tfm) \
tex(NotoSans-Thin-sup-t2b.tfm) \
tex(NotoSans-Thin-sup-t2c.tfm) \
tex(NotoSans-Thin-tlf-lgr.tfm) \
tex(NotoSans-Thin-tlf-ly1.tfm) \
tex(NotoSans-Thin-tlf-ot1.tfm) \
tex(NotoSans-Thin-tlf-sc-lgr.tfm) \
tex(NotoSans-Thin-tlf-sc-ly1--base.tfm) \
tex(NotoSans-Thin-tlf-sc-ly1.tfm) \
tex(NotoSans-Thin-tlf-sc-ly1.vf) \
tex(NotoSans-Thin-tlf-sc-ot1--base.tfm) \
tex(NotoSans-Thin-tlf-sc-ot1.tfm) \
tex(NotoSans-Thin-tlf-sc-ot1.vf) \
tex(NotoSans-Thin-tlf-sc-t1--base.tfm) \
tex(NotoSans-Thin-tlf-sc-t1.tfm) \
tex(NotoSans-Thin-tlf-sc-t1.vf) \
tex(NotoSans-Thin-tlf-sc-t2a--base.tfm) \
tex(NotoSans-Thin-tlf-sc-t2a.tfm) \
tex(NotoSans-Thin-tlf-sc-t2a.vf) \
tex(NotoSans-Thin-tlf-sc-t2b--base.tfm) \
tex(NotoSans-Thin-tlf-sc-t2b.tfm) \
tex(NotoSans-Thin-tlf-sc-t2b.vf) \
tex(NotoSans-Thin-tlf-sc-t2c--base.tfm) \
tex(NotoSans-Thin-tlf-sc-t2c.tfm) \
tex(NotoSans-Thin-tlf-sc-t2c.vf) \
tex(NotoSans-Thin-tlf-t1--base.tfm) \
tex(NotoSans-Thin-tlf-t1.tfm) \
tex(NotoSans-Thin-tlf-t1.vf) \
tex(NotoSans-Thin-tlf-t2a.tfm) \
tex(NotoSans-Thin-tlf-t2b.tfm) \
tex(NotoSans-Thin-tlf-t2c.tfm) \
tex(NotoSans-Thin-tlf-ts1--base.tfm) \
tex(NotoSans-Thin-tlf-ts1.tfm) \
tex(NotoSans-Thin-tlf-ts1.vf) \
tex(NotoSans-Thin-tosf-lgr.tfm) \
tex(NotoSans-Thin-tosf-ly1.tfm) \
tex(NotoSans-Thin-tosf-ot1.tfm) \
tex(NotoSans-Thin-tosf-sc-lgr.tfm) \
tex(NotoSans-Thin-tosf-sc-ly1--base.tfm) \
tex(NotoSans-Thin-tosf-sc-ly1.tfm) \
tex(NotoSans-Thin-tosf-sc-ly1.vf) \
tex(NotoSans-Thin-tosf-sc-ot1--base.tfm) \
tex(NotoSans-Thin-tosf-sc-ot1.tfm) \
tex(NotoSans-Thin-tosf-sc-ot1.vf) \
tex(NotoSans-Thin-tosf-sc-t1--base.tfm) \
tex(NotoSans-Thin-tosf-sc-t1.tfm) \
tex(NotoSans-Thin-tosf-sc-t1.vf) \
tex(NotoSans-Thin-tosf-sc-t2a--base.tfm) \
tex(NotoSans-Thin-tosf-sc-t2a.tfm) \
tex(NotoSans-Thin-tosf-sc-t2a.vf) \
tex(NotoSans-Thin-tosf-sc-t2b--base.tfm) \
tex(NotoSans-Thin-tosf-sc-t2b.tfm) \
tex(NotoSans-Thin-tosf-sc-t2b.vf) \
tex(NotoSans-Thin-tosf-sc-t2c--base.tfm) \
tex(NotoSans-Thin-tosf-sc-t2c.tfm) \
tex(NotoSans-Thin-tosf-sc-t2c.vf) \
tex(NotoSans-Thin-tosf-t1--base.tfm) \
tex(NotoSans-Thin-tosf-t1.tfm) \
tex(NotoSans-Thin-tosf-t1.vf) \
tex(NotoSans-Thin-tosf-t2a.tfm) \
tex(NotoSans-Thin-tosf-t2b.tfm) \
tex(NotoSans-Thin-tosf-t2c.tfm) \
tex(NotoSans-Thin-tosf-ts1--base.tfm) \
tex(NotoSans-Thin-tosf-ts1.tfm) \
tex(NotoSans-Thin-tosf-ts1.vf) \
tex(NotoSans-ThinItalic-lf-lgr.tfm) \
tex(NotoSans-ThinItalic-lf-ly1.tfm) \
tex(NotoSans-ThinItalic-lf-ot1.tfm) \
tex(NotoSans-ThinItalic-lf-sc-lgr.tfm) \
tex(NotoSans-ThinItalic-lf-sc-ly1--base.tfm) \
tex(NotoSans-ThinItalic-lf-sc-ly1.tfm) \
tex(NotoSans-ThinItalic-lf-sc-ly1.vf) \
tex(NotoSans-ThinItalic-lf-sc-ot1--base.tfm) \
tex(NotoSans-ThinItalic-lf-sc-ot1.tfm) \
tex(NotoSans-ThinItalic-lf-sc-ot1.vf) \
tex(NotoSans-ThinItalic-lf-sc-t1--base.tfm) \
tex(NotoSans-ThinItalic-lf-sc-t1.tfm) \
tex(NotoSans-ThinItalic-lf-sc-t1.vf) \
tex(NotoSans-ThinItalic-lf-sc-t2a--base.tfm) \
tex(NotoSans-ThinItalic-lf-sc-t2a.tfm) \
tex(NotoSans-ThinItalic-lf-sc-t2a.vf) \
tex(NotoSans-ThinItalic-lf-sc-t2b--base.tfm) \
tex(NotoSans-ThinItalic-lf-sc-t2b.tfm) \
tex(NotoSans-ThinItalic-lf-sc-t2b.vf) \
tex(NotoSans-ThinItalic-lf-sc-t2c--base.tfm) \
tex(NotoSans-ThinItalic-lf-sc-t2c.tfm) \
tex(NotoSans-ThinItalic-lf-sc-t2c.vf) \
tex(NotoSans-ThinItalic-lf-t1--base.tfm) \
tex(NotoSans-ThinItalic-lf-t1.tfm) \
tex(NotoSans-ThinItalic-lf-t1.vf) \
tex(NotoSans-ThinItalic-lf-t2a.tfm) \
tex(NotoSans-ThinItalic-lf-t2b.tfm) \
tex(NotoSans-ThinItalic-lf-t2c.tfm) \
tex(NotoSans-ThinItalic-lf-ts1--base.tfm) \
tex(NotoSans-ThinItalic-lf-ts1.tfm) \
tex(NotoSans-ThinItalic-lf-ts1.vf) \
tex(NotoSans-ThinItalic-osf-lgr.tfm) \
tex(NotoSans-ThinItalic-osf-ly1.tfm) \
tex(NotoSans-ThinItalic-osf-ot1.tfm) \
tex(NotoSans-ThinItalic-osf-sc-lgr.tfm) \
tex(NotoSans-ThinItalic-osf-sc-ly1--base.tfm) \
tex(NotoSans-ThinItalic-osf-sc-ly1.tfm) \
tex(NotoSans-ThinItalic-osf-sc-ly1.vf) \
tex(NotoSans-ThinItalic-osf-sc-ot1--base.tfm) \
tex(NotoSans-ThinItalic-osf-sc-ot1.tfm) \
tex(NotoSans-ThinItalic-osf-sc-ot1.vf) \
tex(NotoSans-ThinItalic-osf-sc-t1--base.tfm) \
tex(NotoSans-ThinItalic-osf-sc-t1.tfm) \
tex(NotoSans-ThinItalic-osf-sc-t1.vf) \
tex(NotoSans-ThinItalic-osf-sc-t2a--base.tfm) \
tex(NotoSans-ThinItalic-osf-sc-t2a.tfm) \
tex(NotoSans-ThinItalic-osf-sc-t2a.vf) \
tex(NotoSans-ThinItalic-osf-sc-t2b--base.tfm) \
tex(NotoSans-ThinItalic-osf-sc-t2b.tfm) \
tex(NotoSans-ThinItalic-osf-sc-t2b.vf) \
tex(NotoSans-ThinItalic-osf-sc-t2c--base.tfm) \
tex(NotoSans-ThinItalic-osf-sc-t2c.tfm) \
tex(NotoSans-ThinItalic-osf-sc-t2c.vf) \
tex(NotoSans-ThinItalic-osf-t1--base.tfm) \
tex(NotoSans-ThinItalic-osf-t1.tfm) \
tex(NotoSans-ThinItalic-osf-t1.vf) \
tex(NotoSans-ThinItalic-osf-t2a.tfm) \
tex(NotoSans-ThinItalic-osf-t2b.tfm) \
tex(NotoSans-ThinItalic-osf-t2c.tfm) \
tex(NotoSans-ThinItalic-osf-ts1--base.tfm) \
tex(NotoSans-ThinItalic-osf-ts1.tfm) \
tex(NotoSans-ThinItalic-osf-ts1.vf) \
tex(NotoSans-ThinItalic-sup-lgr.tfm) \
tex(NotoSans-ThinItalic-sup-ly1.tfm) \
tex(NotoSans-ThinItalic-sup-ot1.tfm) \
tex(NotoSans-ThinItalic-sup-t1--base.tfm) \
tex(NotoSans-ThinItalic-sup-t1.tfm) \
tex(NotoSans-ThinItalic-sup-t1.vf) \
tex(NotoSans-ThinItalic-sup-t2a.tfm) \
tex(NotoSans-ThinItalic-sup-t2b.tfm) \
tex(NotoSans-ThinItalic-sup-t2c.tfm) \
tex(NotoSans-ThinItalic-tlf-lgr.tfm) \
tex(NotoSans-ThinItalic-tlf-ly1.tfm) \
tex(NotoSans-ThinItalic-tlf-ot1.tfm) \
tex(NotoSans-ThinItalic-tlf-sc-lgr.tfm) \
tex(NotoSans-ThinItalic-tlf-sc-ly1--base.tfm) \
tex(NotoSans-ThinItalic-tlf-sc-ly1.tfm) \
tex(NotoSans-ThinItalic-tlf-sc-ly1.vf) \
tex(NotoSans-ThinItalic-tlf-sc-ot1--base.tfm) \
tex(NotoSans-ThinItalic-tlf-sc-ot1.tfm) \
tex(NotoSans-ThinItalic-tlf-sc-ot1.vf) \
tex(NotoSans-ThinItalic-tlf-sc-t1--base.tfm) \
tex(NotoSans-ThinItalic-tlf-sc-t1.tfm) \
tex(NotoSans-ThinItalic-tlf-sc-t1.vf) \
tex(NotoSans-ThinItalic-tlf-sc-t2a--base.tfm) \
tex(NotoSans-ThinItalic-tlf-sc-t2a.tfm) \
tex(NotoSans-ThinItalic-tlf-sc-t2a.vf) \
tex(NotoSans-ThinItalic-tlf-sc-t2b--base.tfm) \
tex(NotoSans-ThinItalic-tlf-sc-t2b.tfm) \
tex(NotoSans-ThinItalic-tlf-sc-t2b.vf) \
tex(NotoSans-ThinItalic-tlf-sc-t2c--base.tfm) \
tex(NotoSans-ThinItalic-tlf-sc-t2c.tfm) \
tex(NotoSans-ThinItalic-tlf-sc-t2c.vf) \
tex(NotoSans-ThinItalic-tlf-t1--base.tfm) \
tex(NotoSans-ThinItalic-tlf-t1.tfm) \
tex(NotoSans-ThinItalic-tlf-t1.vf) \
tex(NotoSans-ThinItalic-tlf-t2a.tfm) \
tex(NotoSans-ThinItalic-tlf-t2b.tfm) \
tex(NotoSans-ThinItalic-tlf-t2c.tfm) \
tex(NotoSans-ThinItalic-tlf-ts1--base.tfm) \
tex(NotoSans-ThinItalic-tlf-ts1.tfm) \
tex(NotoSans-ThinItalic-tlf-ts1.vf) \
tex(NotoSans-ThinItalic-tosf-lgr.tfm) \
tex(NotoSans-ThinItalic-tosf-ly1.tfm) \
tex(NotoSans-ThinItalic-tosf-ot1.tfm) \
tex(NotoSans-ThinItalic-tosf-sc-lgr.tfm) \
tex(NotoSans-ThinItalic-tosf-sc-ly1--base.tfm) \
tex(NotoSans-ThinItalic-tosf-sc-ly1.tfm) \
tex(NotoSans-ThinItalic-tosf-sc-ly1.vf) \
tex(NotoSans-ThinItalic-tosf-sc-ot1--base.tfm) \
tex(NotoSans-ThinItalic-tosf-sc-ot1.tfm) \
tex(NotoSans-ThinItalic-tosf-sc-ot1.vf) \
tex(NotoSans-ThinItalic-tosf-sc-t1--base.tfm) \
tex(NotoSans-ThinItalic-tosf-sc-t1.tfm) \
tex(NotoSans-ThinItalic-tosf-sc-t1.vf) \
tex(NotoSans-ThinItalic-tosf-sc-t2a--base.tfm) \
tex(NotoSans-ThinItalic-tosf-sc-t2a.tfm) \
tex(NotoSans-ThinItalic-tosf-sc-t2a.vf) \
tex(NotoSans-ThinItalic-tosf-sc-t2b--base.tfm) \
tex(NotoSans-ThinItalic-tosf-sc-t2b.tfm) \
tex(NotoSans-ThinItalic-tosf-sc-t2b.vf) \
tex(NotoSans-ThinItalic-tosf-sc-t2c--base.tfm) \
tex(NotoSans-ThinItalic-tosf-sc-t2c.tfm) \
tex(NotoSans-ThinItalic-tosf-sc-t2c.vf) \
tex(NotoSans-ThinItalic-tosf-t1--base.tfm) \
tex(NotoSans-ThinItalic-tosf-t1.tfm) \
tex(NotoSans-ThinItalic-tosf-t1.vf) \
tex(NotoSans-ThinItalic-tosf-t2a.tfm) \
tex(NotoSans-ThinItalic-tosf-t2b.tfm) \
tex(NotoSans-ThinItalic-tosf-t2c.tfm) \
tex(NotoSans-ThinItalic-tosf-ts1--base.tfm) \
tex(NotoSans-ThinItalic-tosf-ts1.tfm) \
tex(NotoSans-ThinItalic-tosf-ts1.vf) \
tex(NotoSansMono-Black-sup-lgr.tfm) \
tex(NotoSansMono-Black-sup-ly1.tfm) \
tex(NotoSansMono-Black-sup-ot1.tfm) \
tex(NotoSansMono-Black-sup-t1--base.tfm) \
tex(NotoSansMono-Black-sup-t1.tfm) \
tex(NotoSansMono-Black-sup-t1.vf) \
tex(NotoSansMono-Black-sup-t2a.tfm) \
tex(NotoSansMono-Black-sup-t2b.tfm) \
tex(NotoSansMono-Black-sup-t2c.tfm) \
tex(NotoSansMono-Black-tlf-lgr.tfm) \
tex(NotoSansMono-Black-tlf-ly1.tfm) \
tex(NotoSansMono-Black-tlf-ot1.tfm) \
tex(NotoSansMono-Black-tlf-sc-lgr.tfm) \
tex(NotoSansMono-Black-tlf-sc-ly1--base.tfm) \
tex(NotoSansMono-Black-tlf-sc-ly1.tfm) \
tex(NotoSansMono-Black-tlf-sc-ly1.vf) \
tex(NotoSansMono-Black-tlf-sc-ot1--base.tfm) \
tex(NotoSansMono-Black-tlf-sc-ot1.tfm) \
tex(NotoSansMono-Black-tlf-sc-ot1.vf) \
tex(NotoSansMono-Black-tlf-sc-t1--base.tfm) \
tex(NotoSansMono-Black-tlf-sc-t1.tfm) \
tex(NotoSansMono-Black-tlf-sc-t1.vf) \
tex(NotoSansMono-Black-tlf-sc-t2a--base.tfm) \
tex(NotoSansMono-Black-tlf-sc-t2a.tfm) \
tex(NotoSansMono-Black-tlf-sc-t2a.vf) \
tex(NotoSansMono-Black-tlf-sc-t2b--base.tfm) \
tex(NotoSansMono-Black-tlf-sc-t2b.tfm) \
tex(NotoSansMono-Black-tlf-sc-t2b.vf) \
tex(NotoSansMono-Black-tlf-sc-t2c--base.tfm) \
tex(NotoSansMono-Black-tlf-sc-t2c.tfm) \
tex(NotoSansMono-Black-tlf-sc-t2c.vf) \
tex(NotoSansMono-Black-tlf-t1--base.tfm) \
tex(NotoSansMono-Black-tlf-t1.tfm) \
tex(NotoSansMono-Black-tlf-t1.vf) \
tex(NotoSansMono-Black-tlf-t2a.tfm) \
tex(NotoSansMono-Black-tlf-t2b.tfm) \
tex(NotoSansMono-Black-tlf-t2c.tfm) \
tex(NotoSansMono-Black-tlf-ts1--base.tfm) \
tex(NotoSansMono-Black-tlf-ts1.tfm) \
tex(NotoSansMono-Black-tlf-ts1.vf) \
tex(NotoSansMono-Black-tosf-lgr.tfm) \
tex(NotoSansMono-Black-tosf-ly1.tfm) \
tex(NotoSansMono-Black-tosf-ot1.tfm) \
tex(NotoSansMono-Black-tosf-sc-lgr.tfm) \
tex(NotoSansMono-Black-tosf-sc-ly1--base.tfm) \
tex(NotoSansMono-Black-tosf-sc-ly1.tfm) \
tex(NotoSansMono-Black-tosf-sc-ly1.vf) \
tex(NotoSansMono-Black-tosf-sc-ot1--base.tfm) \
tex(NotoSansMono-Black-tosf-sc-ot1.tfm) \
tex(NotoSansMono-Black-tosf-sc-ot1.vf) \
tex(NotoSansMono-Black-tosf-sc-t1--base.tfm) \
tex(NotoSansMono-Black-tosf-sc-t1.tfm) \
tex(NotoSansMono-Black-tosf-sc-t1.vf) \
tex(NotoSansMono-Black-tosf-sc-t2a--base.tfm) \
tex(NotoSansMono-Black-tosf-sc-t2a.tfm) \
tex(NotoSansMono-Black-tosf-sc-t2a.vf) \
tex(NotoSansMono-Black-tosf-sc-t2b--base.tfm) \
tex(NotoSansMono-Black-tosf-sc-t2b.tfm) \
tex(NotoSansMono-Black-tosf-sc-t2b.vf) \
tex(NotoSansMono-Black-tosf-sc-t2c--base.tfm) \
tex(NotoSansMono-Black-tosf-sc-t2c.tfm) \
tex(NotoSansMono-Black-tosf-sc-t2c.vf) \
tex(NotoSansMono-Black-tosf-t1--base.tfm) \
tex(NotoSansMono-Black-tosf-t1.tfm) \
tex(NotoSansMono-Black-tosf-t1.vf) \
tex(NotoSansMono-Black-tosf-t2a.tfm) \
tex(NotoSansMono-Black-tosf-t2b.tfm) \
tex(NotoSansMono-Black-tosf-t2c.tfm) \
tex(NotoSansMono-Black-tosf-ts1--base.tfm) \
tex(NotoSansMono-Black-tosf-ts1.tfm) \
tex(NotoSansMono-Black-tosf-ts1.vf) \
tex(NotoSansMono-Bold-sup-lgr.tfm) \
tex(NotoSansMono-Bold-sup-ly1.tfm) \
tex(NotoSansMono-Bold-sup-ot1.tfm) \
tex(NotoSansMono-Bold-sup-t1--base.tfm) \
tex(NotoSansMono-Bold-sup-t1.tfm) \
tex(NotoSansMono-Bold-sup-t1.vf) \
tex(NotoSansMono-Bold-sup-t2a.tfm) \
tex(NotoSansMono-Bold-sup-t2b.tfm) \
tex(NotoSansMono-Bold-sup-t2c.tfm) \
tex(NotoSansMono-Bold-tlf-lgr.tfm) \
tex(NotoSansMono-Bold-tlf-ly1.tfm) \
tex(NotoSansMono-Bold-tlf-ot1.tfm) \
tex(NotoSansMono-Bold-tlf-sc-lgr.tfm) \
tex(NotoSansMono-Bold-tlf-sc-ly1--base.tfm) \
tex(NotoSansMono-Bold-tlf-sc-ly1.tfm) \
tex(NotoSansMono-Bold-tlf-sc-ly1.vf) \
tex(NotoSansMono-Bold-tlf-sc-ot1--base.tfm) \
tex(NotoSansMono-Bold-tlf-sc-ot1.tfm) \
tex(NotoSansMono-Bold-tlf-sc-ot1.vf) \
tex(NotoSansMono-Bold-tlf-sc-t1--base.tfm) \
tex(NotoSansMono-Bold-tlf-sc-t1.tfm) \
tex(NotoSansMono-Bold-tlf-sc-t1.vf) \
tex(NotoSansMono-Bold-tlf-sc-t2a--base.tfm) \
tex(NotoSansMono-Bold-tlf-sc-t2a.tfm) \
tex(NotoSansMono-Bold-tlf-sc-t2a.vf) \
tex(NotoSansMono-Bold-tlf-sc-t2b--base.tfm) \
tex(NotoSansMono-Bold-tlf-sc-t2b.tfm) \
tex(NotoSansMono-Bold-tlf-sc-t2b.vf) \
tex(NotoSansMono-Bold-tlf-sc-t2c--base.tfm) \
tex(NotoSansMono-Bold-tlf-sc-t2c.tfm) \
tex(NotoSansMono-Bold-tlf-sc-t2c.vf) \
tex(NotoSansMono-Bold-tlf-t1--base.tfm) \
tex(NotoSansMono-Bold-tlf-t1.tfm) \
tex(NotoSansMono-Bold-tlf-t1.vf) \
tex(NotoSansMono-Bold-tlf-t2a.tfm) \
tex(NotoSansMono-Bold-tlf-t2b.tfm) \
tex(NotoSansMono-Bold-tlf-t2c.tfm) \
tex(NotoSansMono-Bold-tlf-ts1--base.tfm) \
tex(NotoSansMono-Bold-tlf-ts1.tfm) \
tex(NotoSansMono-Bold-tlf-ts1.vf) \
tex(NotoSansMono-Bold-tosf-lgr.tfm) \
tex(NotoSansMono-Bold-tosf-ly1.tfm) \
tex(NotoSansMono-Bold-tosf-ot1.tfm) \
tex(NotoSansMono-Bold-tosf-sc-lgr.tfm) \
tex(NotoSansMono-Bold-tosf-sc-ly1--base.tfm) \
tex(NotoSansMono-Bold-tosf-sc-ly1.tfm) \
tex(NotoSansMono-Bold-tosf-sc-ly1.vf) \
tex(NotoSansMono-Bold-tosf-sc-ot1--base.tfm) \
tex(NotoSansMono-Bold-tosf-sc-ot1.tfm) \
tex(NotoSansMono-Bold-tosf-sc-ot1.vf) \
tex(NotoSansMono-Bold-tosf-sc-t1--base.tfm) \
tex(NotoSansMono-Bold-tosf-sc-t1.tfm) \
tex(NotoSansMono-Bold-tosf-sc-t1.vf) \
tex(NotoSansMono-Bold-tosf-sc-t2a--base.tfm) \
tex(NotoSansMono-Bold-tosf-sc-t2a.tfm) \
tex(NotoSansMono-Bold-tosf-sc-t2a.vf) \
tex(NotoSansMono-Bold-tosf-sc-t2b--base.tfm) \
tex(NotoSansMono-Bold-tosf-sc-t2b.tfm) \
tex(NotoSansMono-Bold-tosf-sc-t2b.vf) \
tex(NotoSansMono-Bold-tosf-sc-t2c--base.tfm) \
tex(NotoSansMono-Bold-tosf-sc-t2c.tfm) \
tex(NotoSansMono-Bold-tosf-sc-t2c.vf) \
tex(NotoSansMono-Bold-tosf-t1--base.tfm) \
tex(NotoSansMono-Bold-tosf-t1.tfm) \
tex(NotoSansMono-Bold-tosf-t1.vf) \
tex(NotoSansMono-Bold-tosf-t2a.tfm) \
tex(NotoSansMono-Bold-tosf-t2b.tfm) \
tex(NotoSansMono-Bold-tosf-t2c.tfm) \
tex(NotoSansMono-Bold-tosf-ts1--base.tfm) \
tex(NotoSansMono-Bold-tosf-ts1.tfm) \
tex(NotoSansMono-Bold-tosf-ts1.vf) \
tex(NotoSansMono-ExtraBold-sup-lgr.tfm) \
tex(NotoSansMono-ExtraBold-sup-ly1.tfm) \
tex(NotoSansMono-ExtraBold-sup-ot1.tfm) \
tex(NotoSansMono-ExtraBold-sup-t1--base.tfm) \
tex(NotoSansMono-ExtraBold-sup-t1.tfm) \
tex(NotoSansMono-ExtraBold-sup-t1.vf) \
tex(NotoSansMono-ExtraBold-sup-t2a.tfm) \
tex(NotoSansMono-ExtraBold-sup-t2b.tfm) \
tex(NotoSansMono-ExtraBold-sup-t2c.tfm) \
tex(NotoSansMono-ExtraBold-tlf-lgr.tfm) \
tex(NotoSansMono-ExtraBold-tlf-ly1.tfm) \
tex(NotoSansMono-ExtraBold-tlf-ot1.tfm) \
tex(NotoSansMono-ExtraBold-tlf-sc-lgr.tfm) \
tex(NotoSansMono-ExtraBold-tlf-sc-ly1--base.tfm) \
tex(NotoSansMono-ExtraBold-tlf-sc-ly1.tfm) \
tex(NotoSansMono-ExtraBold-tlf-sc-ly1.vf) \
tex(NotoSansMono-ExtraBold-tlf-sc-ot1--base.tfm) \
tex(NotoSansMono-ExtraBold-tlf-sc-ot1.tfm) \
tex(NotoSansMono-ExtraBold-tlf-sc-ot1.vf) \
tex(NotoSansMono-ExtraBold-tlf-sc-t1--base.tfm) \
tex(NotoSansMono-ExtraBold-tlf-sc-t1.tfm) \
tex(NotoSansMono-ExtraBold-tlf-sc-t1.vf) \
tex(NotoSansMono-ExtraBold-tlf-sc-t2a--base.tfm) \
tex(NotoSansMono-ExtraBold-tlf-sc-t2a.tfm) \
tex(NotoSansMono-ExtraBold-tlf-sc-t2a.vf) \
tex(NotoSansMono-ExtraBold-tlf-sc-t2b--base.tfm) \
tex(NotoSansMono-ExtraBold-tlf-sc-t2b.tfm) \
tex(NotoSansMono-ExtraBold-tlf-sc-t2b.vf) \
tex(NotoSansMono-ExtraBold-tlf-sc-t2c--base.tfm) \
tex(NotoSansMono-ExtraBold-tlf-sc-t2c.tfm) \
tex(NotoSansMono-ExtraBold-tlf-sc-t2c.vf) \
tex(NotoSansMono-ExtraBold-tlf-t1--base.tfm) \
tex(NotoSansMono-ExtraBold-tlf-t1.tfm) \
tex(NotoSansMono-ExtraBold-tlf-t1.vf) \
tex(NotoSansMono-ExtraBold-tlf-t2a.tfm) \
tex(NotoSansMono-ExtraBold-tlf-t2b.tfm) \
tex(NotoSansMono-ExtraBold-tlf-t2c.tfm) \
tex(NotoSansMono-ExtraBold-tlf-ts1--base.tfm) \
tex(NotoSansMono-ExtraBold-tlf-ts1.tfm) \
tex(NotoSansMono-ExtraBold-tlf-ts1.vf) \
tex(NotoSansMono-ExtraBold-tosf-lgr.tfm) \
tex(NotoSansMono-ExtraBold-tosf-ly1.tfm) \
tex(NotoSansMono-ExtraBold-tosf-ot1.tfm) \
tex(NotoSansMono-ExtraBold-tosf-sc-lgr.tfm) \
tex(NotoSansMono-ExtraBold-tosf-sc-ly1--base.tfm) \
tex(NotoSansMono-ExtraBold-tosf-sc-ly1.tfm) \
tex(NotoSansMono-ExtraBold-tosf-sc-ly1.vf) \
tex(NotoSansMono-ExtraBold-tosf-sc-ot1--base.tfm) \
tex(NotoSansMono-ExtraBold-tosf-sc-ot1.tfm) \
tex(NotoSansMono-ExtraBold-tosf-sc-ot1.vf) \
tex(NotoSansMono-ExtraBold-tosf-sc-t1--base.tfm) \
tex(NotoSansMono-ExtraBold-tosf-sc-t1.tfm) \
tex(NotoSansMono-ExtraBold-tosf-sc-t1.vf) \
tex(NotoSansMono-ExtraBold-tosf-sc-t2a--base.tfm) \
tex(NotoSansMono-ExtraBold-tosf-sc-t2a.tfm) \
tex(NotoSansMono-ExtraBold-tosf-sc-t2a.vf) \
tex(NotoSansMono-ExtraBold-tosf-sc-t2b--base.tfm) \
tex(NotoSansMono-ExtraBold-tosf-sc-t2b.tfm) \
tex(NotoSansMono-ExtraBold-tosf-sc-t2b.vf) \
tex(NotoSansMono-ExtraBold-tosf-sc-t2c--base.tfm) \
tex(NotoSansMono-ExtraBold-tosf-sc-t2c.tfm) \
tex(NotoSansMono-ExtraBold-tosf-sc-t2c.vf) \
tex(NotoSansMono-ExtraBold-tosf-t1--base.tfm) \
tex(NotoSansMono-ExtraBold-tosf-t1.tfm) \
tex(NotoSansMono-ExtraBold-tosf-t1.vf) \
tex(NotoSansMono-ExtraBold-tosf-t2a.tfm) \
tex(NotoSansMono-ExtraBold-tosf-t2b.tfm) \
tex(NotoSansMono-ExtraBold-tosf-t2c.tfm) \
tex(NotoSansMono-ExtraBold-tosf-ts1--base.tfm) \
tex(NotoSansMono-ExtraBold-tosf-ts1.tfm) \
tex(NotoSansMono-ExtraBold-tosf-ts1.vf) \
tex(NotoSansMono-ExtraLight-sup-lgr.tfm) \
tex(NotoSansMono-ExtraLight-sup-ly1.tfm) \
tex(NotoSansMono-ExtraLight-sup-ot1.tfm) \
tex(NotoSansMono-ExtraLight-sup-t1--base.tfm) \
tex(NotoSansMono-ExtraLight-sup-t1.tfm) \
tex(NotoSansMono-ExtraLight-sup-t1.vf) \
tex(NotoSansMono-ExtraLight-sup-t2a.tfm) \
tex(NotoSansMono-ExtraLight-sup-t2b.tfm) \
tex(NotoSansMono-ExtraLight-sup-t2c.tfm) \
tex(NotoSansMono-ExtraLight-tlf-lgr.tfm) \
tex(NotoSansMono-ExtraLight-tlf-ly1.tfm) \
tex(NotoSansMono-ExtraLight-tlf-ot1.tfm) \
tex(NotoSansMono-ExtraLight-tlf-sc-lgr.tfm) \
tex(NotoSansMono-ExtraLight-tlf-sc-ly1--base.tfm) \
tex(NotoSansMono-ExtraLight-tlf-sc-ly1.tfm) \
tex(NotoSansMono-ExtraLight-tlf-sc-ly1.vf) \
tex(NotoSansMono-ExtraLight-tlf-sc-ot1--base.tfm) \
tex(NotoSansMono-ExtraLight-tlf-sc-ot1.tfm) \
tex(NotoSansMono-ExtraLight-tlf-sc-ot1.vf) \
tex(NotoSansMono-ExtraLight-tlf-sc-t1--base.tfm) \
tex(NotoSansMono-ExtraLight-tlf-sc-t1.tfm) \
tex(NotoSansMono-ExtraLight-tlf-sc-t1.vf) \
tex(NotoSansMono-ExtraLight-tlf-sc-t2a--base.tfm) \
tex(NotoSansMono-ExtraLight-tlf-sc-t2a.tfm) \
tex(NotoSansMono-ExtraLight-tlf-sc-t2a.vf) \
tex(NotoSansMono-ExtraLight-tlf-sc-t2b--base.tfm) \
tex(NotoSansMono-ExtraLight-tlf-sc-t2b.tfm) \
tex(NotoSansMono-ExtraLight-tlf-sc-t2b.vf) \
tex(NotoSansMono-ExtraLight-tlf-sc-t2c--base.tfm) \
tex(NotoSansMono-ExtraLight-tlf-sc-t2c.tfm) \
tex(NotoSansMono-ExtraLight-tlf-sc-t2c.vf) \
tex(NotoSansMono-ExtraLight-tlf-t1--base.tfm) \
tex(NotoSansMono-ExtraLight-tlf-t1.tfm) \
tex(NotoSansMono-ExtraLight-tlf-t1.vf) \
tex(NotoSansMono-ExtraLight-tlf-t2a.tfm) \
tex(NotoSansMono-ExtraLight-tlf-t2b.tfm) \
tex(NotoSansMono-ExtraLight-tlf-t2c.tfm) \
tex(NotoSansMono-ExtraLight-tlf-ts1--base.tfm) \
tex(NotoSansMono-ExtraLight-tlf-ts1.tfm) \
tex(NotoSansMono-ExtraLight-tlf-ts1.vf) \
tex(NotoSansMono-ExtraLight-tosf-lgr.tfm) \
tex(NotoSansMono-ExtraLight-tosf-ly1.tfm) \
tex(NotoSansMono-ExtraLight-tosf-ot1.tfm) \
tex(NotoSansMono-ExtraLight-tosf-sc-lgr.tfm) \
tex(NotoSansMono-ExtraLight-tosf-sc-ly1--base.tfm) \
tex(NotoSansMono-ExtraLight-tosf-sc-ly1.tfm) \
tex(NotoSansMono-ExtraLight-tosf-sc-ly1.vf) \
tex(NotoSansMono-ExtraLight-tosf-sc-ot1--base.tfm) \
tex(NotoSansMono-ExtraLight-tosf-sc-ot1.tfm) \
tex(NotoSansMono-ExtraLight-tosf-sc-ot1.vf) \
tex(NotoSansMono-ExtraLight-tosf-sc-t1--base.tfm) \
tex(NotoSansMono-ExtraLight-tosf-sc-t1.tfm) \
tex(NotoSansMono-ExtraLight-tosf-sc-t1.vf) \
tex(NotoSansMono-ExtraLight-tosf-sc-t2a--base.tfm) \
tex(NotoSansMono-ExtraLight-tosf-sc-t2a.tfm) \
tex(NotoSansMono-ExtraLight-tosf-sc-t2a.vf) \
tex(NotoSansMono-ExtraLight-tosf-sc-t2b--base.tfm) \
tex(NotoSansMono-ExtraLight-tosf-sc-t2b.tfm) \
tex(NotoSansMono-ExtraLight-tosf-sc-t2b.vf) \
tex(NotoSansMono-ExtraLight-tosf-sc-t2c--base.tfm) \
tex(NotoSansMono-ExtraLight-tosf-sc-t2c.tfm) \
tex(NotoSansMono-ExtraLight-tosf-sc-t2c.vf) \
tex(NotoSansMono-ExtraLight-tosf-t1--base.tfm) \
tex(NotoSansMono-ExtraLight-tosf-t1.tfm) \
tex(NotoSansMono-ExtraLight-tosf-t1.vf) \
tex(NotoSansMono-ExtraLight-tosf-t2a.tfm) \
tex(NotoSansMono-ExtraLight-tosf-t2b.tfm) \
tex(NotoSansMono-ExtraLight-tosf-t2c.tfm) \
tex(NotoSansMono-ExtraLight-tosf-ts1--base.tfm) \
tex(NotoSansMono-ExtraLight-tosf-ts1.tfm) \
tex(NotoSansMono-ExtraLight-tosf-ts1.vf) \
tex(NotoSansMono-Light-sup-lgr.tfm) \
tex(NotoSansMono-Light-sup-ly1.tfm) \
tex(NotoSansMono-Light-sup-ot1.tfm) \
tex(NotoSansMono-Light-sup-t1--base.tfm) \
tex(NotoSansMono-Light-sup-t1.tfm) \
tex(NotoSansMono-Light-sup-t1.vf) \
tex(NotoSansMono-Light-sup-t2a.tfm) \
tex(NotoSansMono-Light-sup-t2b.tfm) \
tex(NotoSansMono-Light-sup-t2c.tfm) \
tex(NotoSansMono-Light-tlf-lgr.tfm) \
tex(NotoSansMono-Light-tlf-ly1.tfm) \
tex(NotoSansMono-Light-tlf-ot1.tfm) \
tex(NotoSansMono-Light-tlf-sc-lgr.tfm) \
tex(NotoSansMono-Light-tlf-sc-ly1--base.tfm) \
tex(NotoSansMono-Light-tlf-sc-ly1.tfm) \
tex(NotoSansMono-Light-tlf-sc-ly1.vf) \
tex(NotoSansMono-Light-tlf-sc-ot1--base.tfm) \
tex(NotoSansMono-Light-tlf-sc-ot1.tfm) \
tex(NotoSansMono-Light-tlf-sc-ot1.vf) \
tex(NotoSansMono-Light-tlf-sc-t1--base.tfm) \
tex(NotoSansMono-Light-tlf-sc-t1.tfm) \
tex(NotoSansMono-Light-tlf-sc-t1.vf) \
tex(NotoSansMono-Light-tlf-sc-t2a--base.tfm) \
tex(NotoSansMono-Light-tlf-sc-t2a.tfm) \
tex(NotoSansMono-Light-tlf-sc-t2a.vf) \
tex(NotoSansMono-Light-tlf-sc-t2b--base.tfm) \
tex(NotoSansMono-Light-tlf-sc-t2b.tfm) \
tex(NotoSansMono-Light-tlf-sc-t2b.vf) \
tex(NotoSansMono-Light-tlf-sc-t2c--base.tfm) \
tex(NotoSansMono-Light-tlf-sc-t2c.tfm) \
tex(NotoSansMono-Light-tlf-sc-t2c.vf) \
tex(NotoSansMono-Light-tlf-t1--base.tfm) \
tex(NotoSansMono-Light-tlf-t1.tfm) \
tex(NotoSansMono-Light-tlf-t1.vf) \
tex(NotoSansMono-Light-tlf-t2a.tfm) \
tex(NotoSansMono-Light-tlf-t2b.tfm) \
tex(NotoSansMono-Light-tlf-t2c.tfm) \
tex(NotoSansMono-Light-tlf-ts1--base.tfm) \
tex(NotoSansMono-Light-tlf-ts1.tfm) \
tex(NotoSansMono-Light-tlf-ts1.vf) \
tex(NotoSansMono-Light-tosf-lgr.tfm) \
tex(NotoSansMono-Light-tosf-ly1.tfm) \
tex(NotoSansMono-Light-tosf-ot1.tfm) \
tex(NotoSansMono-Light-tosf-sc-lgr.tfm) \
tex(NotoSansMono-Light-tosf-sc-ly1--base.tfm) \
tex(NotoSansMono-Light-tosf-sc-ly1.tfm) \
tex(NotoSansMono-Light-tosf-sc-ly1.vf) \
tex(NotoSansMono-Light-tosf-sc-ot1--base.tfm) \
tex(NotoSansMono-Light-tosf-sc-ot1.tfm) \
tex(NotoSansMono-Light-tosf-sc-ot1.vf) \
tex(NotoSansMono-Light-tosf-sc-t1--base.tfm) \
tex(NotoSansMono-Light-tosf-sc-t1.tfm) \
tex(NotoSansMono-Light-tosf-sc-t1.vf) \
tex(NotoSansMono-Light-tosf-sc-t2a--base.tfm) \
tex(NotoSansMono-Light-tosf-sc-t2a.tfm) \
tex(NotoSansMono-Light-tosf-sc-t2a.vf) \
tex(NotoSansMono-Light-tosf-sc-t2b--base.tfm) \
tex(NotoSansMono-Light-tosf-sc-t2b.tfm) \
tex(NotoSansMono-Light-tosf-sc-t2b.vf) \
tex(NotoSansMono-Light-tosf-sc-t2c--base.tfm) \
tex(NotoSansMono-Light-tosf-sc-t2c.tfm) \
tex(NotoSansMono-Light-tosf-sc-t2c.vf) \
tex(NotoSansMono-Light-tosf-t1--base.tfm) \
tex(NotoSansMono-Light-tosf-t1.tfm) \
tex(NotoSansMono-Light-tosf-t1.vf) \
tex(NotoSansMono-Light-tosf-t2a.tfm) \
tex(NotoSansMono-Light-tosf-t2b.tfm) \
tex(NotoSansMono-Light-tosf-t2c.tfm) \
tex(NotoSansMono-Light-tosf-ts1--base.tfm) \
tex(NotoSansMono-Light-tosf-ts1.tfm) \
tex(NotoSansMono-Light-tosf-ts1.vf) \
tex(NotoSansMono-Medium-sup-lgr.tfm) \
tex(NotoSansMono-Medium-sup-ly1.tfm) \
tex(NotoSansMono-Medium-sup-ot1.tfm) \
tex(NotoSansMono-Medium-sup-t1--base.tfm) \
tex(NotoSansMono-Medium-sup-t1.tfm) \
tex(NotoSansMono-Medium-sup-t1.vf) \
tex(NotoSansMono-Medium-sup-t2a.tfm) \
tex(NotoSansMono-Medium-sup-t2b.tfm) \
tex(NotoSansMono-Medium-sup-t2c.tfm) \
tex(NotoSansMono-Medium-tlf-lgr.tfm) \
tex(NotoSansMono-Medium-tlf-ly1.tfm) \
tex(NotoSansMono-Medium-tlf-ot1.tfm) \
tex(NotoSansMono-Medium-tlf-sc-lgr.tfm) \
tex(NotoSansMono-Medium-tlf-sc-ly1--base.tfm) \
tex(NotoSansMono-Medium-tlf-sc-ly1.tfm) \
tex(NotoSansMono-Medium-tlf-sc-ly1.vf) \
tex(NotoSansMono-Medium-tlf-sc-ot1--base.tfm) \
tex(NotoSansMono-Medium-tlf-sc-ot1.tfm) \
tex(NotoSansMono-Medium-tlf-sc-ot1.vf) \
tex(NotoSansMono-Medium-tlf-sc-t1--base.tfm) \
tex(NotoSansMono-Medium-tlf-sc-t1.tfm) \
tex(NotoSansMono-Medium-tlf-sc-t1.vf) \
tex(NotoSansMono-Medium-tlf-sc-t2a--base.tfm) \
tex(NotoSansMono-Medium-tlf-sc-t2a.tfm) \
tex(NotoSansMono-Medium-tlf-sc-t2a.vf) \
tex(NotoSansMono-Medium-tlf-sc-t2b--base.tfm) \
tex(NotoSansMono-Medium-tlf-sc-t2b.tfm) \
tex(NotoSansMono-Medium-tlf-sc-t2b.vf) \
tex(NotoSansMono-Medium-tlf-sc-t2c--base.tfm) \
tex(NotoSansMono-Medium-tlf-sc-t2c.tfm) \
tex(NotoSansMono-Medium-tlf-sc-t2c.vf) \
tex(NotoSansMono-Medium-tlf-t1--base.tfm) \
tex(NotoSansMono-Medium-tlf-t1.tfm) \
tex(NotoSansMono-Medium-tlf-t1.vf) \
tex(NotoSansMono-Medium-tlf-t2a.tfm) \
tex(NotoSansMono-Medium-tlf-t2b.tfm) \
tex(NotoSansMono-Medium-tlf-t2c.tfm) \
tex(NotoSansMono-Medium-tlf-ts1--base.tfm) \
tex(NotoSansMono-Medium-tlf-ts1.tfm) \
tex(NotoSansMono-Medium-tlf-ts1.vf) \
tex(NotoSansMono-Medium-tosf-lgr.tfm) \
tex(NotoSansMono-Medium-tosf-ly1.tfm) \
tex(NotoSansMono-Medium-tosf-ot1.tfm) \
tex(NotoSansMono-Medium-tosf-sc-lgr.tfm) \
tex(NotoSansMono-Medium-tosf-sc-ly1--base.tfm) \
tex(NotoSansMono-Medium-tosf-sc-ly1.tfm) \
tex(NotoSansMono-Medium-tosf-sc-ly1.vf) \
tex(NotoSansMono-Medium-tosf-sc-ot1--base.tfm) \
tex(NotoSansMono-Medium-tosf-sc-ot1.tfm) \
tex(NotoSansMono-Medium-tosf-sc-ot1.vf) \
tex(NotoSansMono-Medium-tosf-sc-t1--base.tfm) \
tex(NotoSansMono-Medium-tosf-sc-t1.tfm) \
tex(NotoSansMono-Medium-tosf-sc-t1.vf) \
tex(NotoSansMono-Medium-tosf-sc-t2a--base.tfm) \
tex(NotoSansMono-Medium-tosf-sc-t2a.tfm) \
tex(NotoSansMono-Medium-tosf-sc-t2a.vf) \
tex(NotoSansMono-Medium-tosf-sc-t2b--base.tfm) \
tex(NotoSansMono-Medium-tosf-sc-t2b.tfm) \
tex(NotoSansMono-Medium-tosf-sc-t2b.vf) \
tex(NotoSansMono-Medium-tosf-sc-t2c--base.tfm) \
tex(NotoSansMono-Medium-tosf-sc-t2c.tfm) \
tex(NotoSansMono-Medium-tosf-sc-t2c.vf) \
tex(NotoSansMono-Medium-tosf-t1--base.tfm) \
tex(NotoSansMono-Medium-tosf-t1.tfm) \
tex(NotoSansMono-Medium-tosf-t1.vf) \
tex(NotoSansMono-Medium-tosf-t2a.tfm) \
tex(NotoSansMono-Medium-tosf-t2b.tfm) \
tex(NotoSansMono-Medium-tosf-t2c.tfm) \
tex(NotoSansMono-Medium-tosf-ts1--base.tfm) \
tex(NotoSansMono-Medium-tosf-ts1.tfm) \
tex(NotoSansMono-Medium-tosf-ts1.vf) \
tex(NotoSansMono-Regular-sup-lgr.tfm) \
tex(NotoSansMono-Regular-sup-ly1.tfm) \
tex(NotoSansMono-Regular-sup-ot1.tfm) \
tex(NotoSansMono-Regular-sup-t1--base.tfm) \
tex(NotoSansMono-Regular-sup-t1.tfm) \
tex(NotoSansMono-Regular-sup-t1.vf) \
tex(NotoSansMono-Regular-sup-t2a.tfm) \
tex(NotoSansMono-Regular-sup-t2b.tfm) \
tex(NotoSansMono-Regular-sup-t2c.tfm) \
tex(NotoSansMono-Regular-tlf-lgr.tfm) \
tex(NotoSansMono-Regular-tlf-ly1.tfm) \
tex(NotoSansMono-Regular-tlf-ot1.tfm) \
tex(NotoSansMono-Regular-tlf-sc-lgr.tfm) \
tex(NotoSansMono-Regular-tlf-sc-ly1--base.tfm) \
tex(NotoSansMono-Regular-tlf-sc-ly1.tfm) \
tex(NotoSansMono-Regular-tlf-sc-ly1.vf) \
tex(NotoSansMono-Regular-tlf-sc-ot1--base.tfm) \
tex(NotoSansMono-Regular-tlf-sc-ot1.tfm) \
tex(NotoSansMono-Regular-tlf-sc-ot1.vf) \
tex(NotoSansMono-Regular-tlf-sc-t1--base.tfm) \
tex(NotoSansMono-Regular-tlf-sc-t1.tfm) \
tex(NotoSansMono-Regular-tlf-sc-t1.vf) \
tex(NotoSansMono-Regular-tlf-sc-t2a--base.tfm) \
tex(NotoSansMono-Regular-tlf-sc-t2a.tfm) \
tex(NotoSansMono-Regular-tlf-sc-t2a.vf) \
tex(NotoSansMono-Regular-tlf-sc-t2b--base.tfm) \
tex(NotoSansMono-Regular-tlf-sc-t2b.tfm) \
tex(NotoSansMono-Regular-tlf-sc-t2b.vf) \
tex(NotoSansMono-Regular-tlf-sc-t2c--base.tfm) \
tex(NotoSansMono-Regular-tlf-sc-t2c.tfm) \
tex(NotoSansMono-Regular-tlf-sc-t2c.vf) \
tex(NotoSansMono-Regular-tlf-t1--base.tfm) \
tex(NotoSansMono-Regular-tlf-t1.tfm) \
tex(NotoSansMono-Regular-tlf-t1.vf) \
tex(NotoSansMono-Regular-tlf-t2a.tfm) \
tex(NotoSansMono-Regular-tlf-t2b.tfm) \
tex(NotoSansMono-Regular-tlf-t2c.tfm) \
tex(NotoSansMono-Regular-tlf-ts1--base.tfm) \
tex(NotoSansMono-Regular-tlf-ts1.tfm) \
tex(NotoSansMono-Regular-tlf-ts1.vf) \
tex(NotoSansMono-Regular-tosf-lgr.tfm) \
tex(NotoSansMono-Regular-tosf-ly1.tfm) \
tex(NotoSansMono-Regular-tosf-ot1.tfm) \
tex(NotoSansMono-Regular-tosf-sc-lgr.tfm) \
tex(NotoSansMono-Regular-tosf-sc-ly1--base.tfm) \
tex(NotoSansMono-Regular-tosf-sc-ly1.tfm) \
tex(NotoSansMono-Regular-tosf-sc-ly1.vf) \
tex(NotoSansMono-Regular-tosf-sc-ot1--base.tfm) \
tex(NotoSansMono-Regular-tosf-sc-ot1.tfm) \
tex(NotoSansMono-Regular-tosf-sc-ot1.vf) \
tex(NotoSansMono-Regular-tosf-sc-t1--base.tfm) \
tex(NotoSansMono-Regular-tosf-sc-t1.tfm) \
tex(NotoSansMono-Regular-tosf-sc-t1.vf) \
tex(NotoSansMono-Regular-tosf-sc-t2a--base.tfm) \
tex(NotoSansMono-Regular-tosf-sc-t2a.tfm) \
tex(NotoSansMono-Regular-tosf-sc-t2a.vf) \
tex(NotoSansMono-Regular-tosf-sc-t2b--base.tfm) \
tex(NotoSansMono-Regular-tosf-sc-t2b.tfm) \
tex(NotoSansMono-Regular-tosf-sc-t2b.vf) \
tex(NotoSansMono-Regular-tosf-sc-t2c--base.tfm) \
tex(NotoSansMono-Regular-tosf-sc-t2c.tfm) \
tex(NotoSansMono-Regular-tosf-sc-t2c.vf) \
tex(NotoSansMono-Regular-tosf-t1--base.tfm) \
tex(NotoSansMono-Regular-tosf-t1.tfm) \
tex(NotoSansMono-Regular-tosf-t1.vf) \
tex(NotoSansMono-Regular-tosf-t2a.tfm) \
tex(NotoSansMono-Regular-tosf-t2b.tfm) \
tex(NotoSansMono-Regular-tosf-t2c.tfm) \
tex(NotoSansMono-Regular-tosf-ts1--base.tfm) \
tex(NotoSansMono-Regular-tosf-ts1.tfm) \
tex(NotoSansMono-Regular-tosf-ts1.vf) \
tex(NotoSansMono-SemiBold-sup-lgr.tfm) \
tex(NotoSansMono-SemiBold-sup-ly1.tfm) \
tex(NotoSansMono-SemiBold-sup-ot1.tfm) \
tex(NotoSansMono-SemiBold-sup-t1--base.tfm) \
tex(NotoSansMono-SemiBold-sup-t1.tfm) \
tex(NotoSansMono-SemiBold-sup-t1.vf) \
tex(NotoSansMono-SemiBold-sup-t2a.tfm) \
tex(NotoSansMono-SemiBold-sup-t2b.tfm) \
tex(NotoSansMono-SemiBold-sup-t2c.tfm) \
tex(NotoSansMono-SemiBold-tlf-lgr.tfm) \
tex(NotoSansMono-SemiBold-tlf-ly1.tfm) \
tex(NotoSansMono-SemiBold-tlf-ot1.tfm) \
tex(NotoSansMono-SemiBold-tlf-sc-lgr.tfm) \
tex(NotoSansMono-SemiBold-tlf-sc-ly1--base.tfm) \
tex(NotoSansMono-SemiBold-tlf-sc-ly1.tfm) \
tex(NotoSansMono-SemiBold-tlf-sc-ly1.vf) \
tex(NotoSansMono-SemiBold-tlf-sc-ot1--base.tfm) \
tex(NotoSansMono-SemiBold-tlf-sc-ot1.tfm) \
tex(NotoSansMono-SemiBold-tlf-sc-ot1.vf) \
tex(NotoSansMono-SemiBold-tlf-sc-t1--base.tfm) \
tex(NotoSansMono-SemiBold-tlf-sc-t1.tfm) \
tex(NotoSansMono-SemiBold-tlf-sc-t1.vf) \
tex(NotoSansMono-SemiBold-tlf-sc-t2a--base.tfm) \
tex(NotoSansMono-SemiBold-tlf-sc-t2a.tfm) \
tex(NotoSansMono-SemiBold-tlf-sc-t2a.vf) \
tex(NotoSansMono-SemiBold-tlf-sc-t2b--base.tfm) \
tex(NotoSansMono-SemiBold-tlf-sc-t2b.tfm) \
tex(NotoSansMono-SemiBold-tlf-sc-t2b.vf) \
tex(NotoSansMono-SemiBold-tlf-sc-t2c--base.tfm) \
tex(NotoSansMono-SemiBold-tlf-sc-t2c.tfm) \
tex(NotoSansMono-SemiBold-tlf-sc-t2c.vf) \
tex(NotoSansMono-SemiBold-tlf-t1--base.tfm) \
tex(NotoSansMono-SemiBold-tlf-t1.tfm) \
tex(NotoSansMono-SemiBold-tlf-t1.vf) \
tex(NotoSansMono-SemiBold-tlf-t2a.tfm) \
tex(NotoSansMono-SemiBold-tlf-t2b.tfm) \
tex(NotoSansMono-SemiBold-tlf-t2c.tfm) \
tex(NotoSansMono-SemiBold-tlf-ts1--base.tfm) \
tex(NotoSansMono-SemiBold-tlf-ts1.tfm) \
tex(NotoSansMono-SemiBold-tlf-ts1.vf) \
tex(NotoSansMono-SemiBold-tosf-lgr.tfm) \
tex(NotoSansMono-SemiBold-tosf-ly1.tfm) \
tex(NotoSansMono-SemiBold-tosf-ot1.tfm) \
tex(NotoSansMono-SemiBold-tosf-sc-lgr.tfm) \
tex(NotoSansMono-SemiBold-tosf-sc-ly1--base.tfm) \
tex(NotoSansMono-SemiBold-tosf-sc-ly1.tfm) \
tex(NotoSansMono-SemiBold-tosf-sc-ly1.vf) \
tex(NotoSansMono-SemiBold-tosf-sc-ot1--base.tfm) \
tex(NotoSansMono-SemiBold-tosf-sc-ot1.tfm) \
tex(NotoSansMono-SemiBold-tosf-sc-ot1.vf) \
tex(NotoSansMono-SemiBold-tosf-sc-t1--base.tfm) \
tex(NotoSansMono-SemiBold-tosf-sc-t1.tfm) \
tex(NotoSansMono-SemiBold-tosf-sc-t1.vf) \
tex(NotoSansMono-SemiBold-tosf-sc-t2a--base.tfm) \
tex(NotoSansMono-SemiBold-tosf-sc-t2a.tfm) \
tex(NotoSansMono-SemiBold-tosf-sc-t2a.vf) \
tex(NotoSansMono-SemiBold-tosf-sc-t2b--base.tfm) \
tex(NotoSansMono-SemiBold-tosf-sc-t2b.tfm) \
tex(NotoSansMono-SemiBold-tosf-sc-t2b.vf) \
tex(NotoSansMono-SemiBold-tosf-sc-t2c--base.tfm) \
tex(NotoSansMono-SemiBold-tosf-sc-t2c.tfm) \
tex(NotoSansMono-SemiBold-tosf-sc-t2c.vf) \
tex(NotoSansMono-SemiBold-tosf-t1--base.tfm) \
tex(NotoSansMono-SemiBold-tosf-t1.tfm) \
tex(NotoSansMono-SemiBold-tosf-t1.vf) \
tex(NotoSansMono-SemiBold-tosf-t2a.tfm) \
tex(NotoSansMono-SemiBold-tosf-t2b.tfm) \
tex(NotoSansMono-SemiBold-tosf-t2c.tfm) \
tex(NotoSansMono-SemiBold-tosf-ts1--base.tfm) \
tex(NotoSansMono-SemiBold-tosf-ts1.tfm) \
tex(NotoSansMono-SemiBold-tosf-ts1.vf) \
tex(NotoSansMono-Thin-sup-lgr.tfm) \
tex(NotoSansMono-Thin-sup-ly1.tfm) \
tex(NotoSansMono-Thin-sup-ot1.tfm) \
tex(NotoSansMono-Thin-sup-t1--base.tfm) \
tex(NotoSansMono-Thin-sup-t1.tfm) \
tex(NotoSansMono-Thin-sup-t1.vf) \
tex(NotoSansMono-Thin-sup-t2a.tfm) \
tex(NotoSansMono-Thin-sup-t2b.tfm) \
tex(NotoSansMono-Thin-sup-t2c.tfm) \
tex(NotoSansMono-Thin-tlf-lgr.tfm) \
tex(NotoSansMono-Thin-tlf-ly1.tfm) \
tex(NotoSansMono-Thin-tlf-ot1.tfm) \
tex(NotoSansMono-Thin-tlf-sc-lgr.tfm) \
tex(NotoSansMono-Thin-tlf-sc-ly1--base.tfm) \
tex(NotoSansMono-Thin-tlf-sc-ly1.tfm) \
tex(NotoSansMono-Thin-tlf-sc-ly1.vf) \
tex(NotoSansMono-Thin-tlf-sc-ot1--base.tfm) \
tex(NotoSansMono-Thin-tlf-sc-ot1.tfm) \
tex(NotoSansMono-Thin-tlf-sc-ot1.vf) \
tex(NotoSansMono-Thin-tlf-sc-t1--base.tfm) \
tex(NotoSansMono-Thin-tlf-sc-t1.tfm) \
tex(NotoSansMono-Thin-tlf-sc-t1.vf) \
tex(NotoSansMono-Thin-tlf-sc-t2a--base.tfm) \
tex(NotoSansMono-Thin-tlf-sc-t2a.tfm) \
tex(NotoSansMono-Thin-tlf-sc-t2a.vf) \
tex(NotoSansMono-Thin-tlf-sc-t2b--base.tfm) \
tex(NotoSansMono-Thin-tlf-sc-t2b.tfm) \
tex(NotoSansMono-Thin-tlf-sc-t2b.vf) \
tex(NotoSansMono-Thin-tlf-sc-t2c--base.tfm) \
tex(NotoSansMono-Thin-tlf-sc-t2c.tfm) \
tex(NotoSansMono-Thin-tlf-sc-t2c.vf) \
tex(NotoSansMono-Thin-tlf-t1--base.tfm) \
tex(NotoSansMono-Thin-tlf-t1.tfm) \
tex(NotoSansMono-Thin-tlf-t1.vf) \
tex(NotoSansMono-Thin-tlf-t2a.tfm) \
tex(NotoSansMono-Thin-tlf-t2b.tfm) \
tex(NotoSansMono-Thin-tlf-t2c.tfm) \
tex(NotoSansMono-Thin-tlf-ts1--base.tfm) \
tex(NotoSansMono-Thin-tlf-ts1.tfm) \
tex(NotoSansMono-Thin-tlf-ts1.vf) \
tex(NotoSansMono-Thin-tosf-lgr.tfm) \
tex(NotoSansMono-Thin-tosf-ly1.tfm) \
tex(NotoSansMono-Thin-tosf-ot1.tfm) \
tex(NotoSansMono-Thin-tosf-sc-lgr.tfm) \
tex(NotoSansMono-Thin-tosf-sc-ly1--base.tfm) \
tex(NotoSansMono-Thin-tosf-sc-ly1.tfm) \
tex(NotoSansMono-Thin-tosf-sc-ly1.vf) \
tex(NotoSansMono-Thin-tosf-sc-ot1--base.tfm) \
tex(NotoSansMono-Thin-tosf-sc-ot1.tfm) \
tex(NotoSansMono-Thin-tosf-sc-ot1.vf) \
tex(NotoSansMono-Thin-tosf-sc-t1--base.tfm) \
tex(NotoSansMono-Thin-tosf-sc-t1.tfm) \
tex(NotoSansMono-Thin-tosf-sc-t1.vf) \
tex(NotoSansMono-Thin-tosf-sc-t2a--base.tfm) \
tex(NotoSansMono-Thin-tosf-sc-t2a.tfm) \
tex(NotoSansMono-Thin-tosf-sc-t2a.vf) \
tex(NotoSansMono-Thin-tosf-sc-t2b--base.tfm) \
tex(NotoSansMono-Thin-tosf-sc-t2b.tfm) \
tex(NotoSansMono-Thin-tosf-sc-t2b.vf) \
tex(NotoSansMono-Thin-tosf-sc-t2c--base.tfm) \
tex(NotoSansMono-Thin-tosf-sc-t2c.tfm) \
tex(NotoSansMono-Thin-tosf-sc-t2c.vf) \
tex(NotoSansMono-Thin-tosf-t1--base.tfm) \
tex(NotoSansMono-Thin-tosf-t1.tfm) \
tex(NotoSansMono-Thin-tosf-t1.vf) \
tex(NotoSansMono-Thin-tosf-t2a.tfm) \
tex(NotoSansMono-Thin-tosf-t2b.tfm) \
tex(NotoSansMono-Thin-tosf-t2c.tfm) \
tex(NotoSansMono-Thin-tosf-ts1--base.tfm) \
tex(NotoSansMono-Thin-tosf-ts1.tfm) \
tex(NotoSansMono-Thin-tosf-ts1.vf) \
tex(NotoSerif-Black-lf-lgr.tfm) \
tex(NotoSerif-Black-lf-ly1.tfm) \
tex(NotoSerif-Black-lf-ot1.tfm) \
tex(NotoSerif-Black-lf-sc-lgr.tfm) \
tex(NotoSerif-Black-lf-sc-ly1--base.tfm) \
tex(NotoSerif-Black-lf-sc-ly1.tfm) \
tex(NotoSerif-Black-lf-sc-ly1.vf) \
tex(NotoSerif-Black-lf-sc-ot1--base.tfm) \
tex(NotoSerif-Black-lf-sc-ot1.tfm) \
tex(NotoSerif-Black-lf-sc-ot1.vf) \
tex(NotoSerif-Black-lf-sc-t1--base.tfm) \
tex(NotoSerif-Black-lf-sc-t1.tfm) \
tex(NotoSerif-Black-lf-sc-t1.vf) \
tex(NotoSerif-Black-lf-sc-t2a--base.tfm) \
tex(NotoSerif-Black-lf-sc-t2a.tfm) \
tex(NotoSerif-Black-lf-sc-t2a.vf) \
tex(NotoSerif-Black-lf-sc-t2b--base.tfm) \
tex(NotoSerif-Black-lf-sc-t2b.tfm) \
tex(NotoSerif-Black-lf-sc-t2b.vf) \
tex(NotoSerif-Black-lf-sc-t2c--base.tfm) \
tex(NotoSerif-Black-lf-sc-t2c.tfm) \
tex(NotoSerif-Black-lf-sc-t2c.vf) \
tex(NotoSerif-Black-lf-t1--base.tfm) \
tex(NotoSerif-Black-lf-t1.tfm) \
tex(NotoSerif-Black-lf-t1.vf) \
tex(NotoSerif-Black-lf-t2a.tfm) \
tex(NotoSerif-Black-lf-t2b.tfm) \
tex(NotoSerif-Black-lf-t2c.tfm) \
tex(NotoSerif-Black-lf-ts1--base.tfm) \
tex(NotoSerif-Black-lf-ts1.tfm) \
tex(NotoSerif-Black-lf-ts1.vf) \
tex(NotoSerif-Black-osf-lgr.tfm) \
tex(NotoSerif-Black-osf-ly1.tfm) \
tex(NotoSerif-Black-osf-ot1.tfm) \
tex(NotoSerif-Black-osf-sc-lgr.tfm) \
tex(NotoSerif-Black-osf-sc-ly1--base.tfm) \
tex(NotoSerif-Black-osf-sc-ly1.tfm) \
tex(NotoSerif-Black-osf-sc-ly1.vf) \
tex(NotoSerif-Black-osf-sc-ot1--base.tfm) \
tex(NotoSerif-Black-osf-sc-ot1.tfm) \
tex(NotoSerif-Black-osf-sc-ot1.vf) \
tex(NotoSerif-Black-osf-sc-t1--base.tfm) \
tex(NotoSerif-Black-osf-sc-t1.tfm) \
tex(NotoSerif-Black-osf-sc-t1.vf) \
tex(NotoSerif-Black-osf-sc-t2a--base.tfm) \
tex(NotoSerif-Black-osf-sc-t2a.tfm) \
tex(NotoSerif-Black-osf-sc-t2a.vf) \
tex(NotoSerif-Black-osf-sc-t2b--base.tfm) \
tex(NotoSerif-Black-osf-sc-t2b.tfm) \
tex(NotoSerif-Black-osf-sc-t2b.vf) \
tex(NotoSerif-Black-osf-sc-t2c--base.tfm) \
tex(NotoSerif-Black-osf-sc-t2c.tfm) \
tex(NotoSerif-Black-osf-sc-t2c.vf) \
tex(NotoSerif-Black-osf-t1--base.tfm) \
tex(NotoSerif-Black-osf-t1.tfm) \
tex(NotoSerif-Black-osf-t1.vf) \
tex(NotoSerif-Black-osf-t2a.tfm) \
tex(NotoSerif-Black-osf-t2b.tfm) \
tex(NotoSerif-Black-osf-t2c.tfm) \
tex(NotoSerif-Black-osf-ts1--base.tfm) \
tex(NotoSerif-Black-osf-ts1.tfm) \
tex(NotoSerif-Black-osf-ts1.vf) \
tex(NotoSerif-Black-sup-lgr.tfm) \
tex(NotoSerif-Black-sup-ly1.tfm) \
tex(NotoSerif-Black-sup-ot1.tfm) \
tex(NotoSerif-Black-sup-t1--base.tfm) \
tex(NotoSerif-Black-sup-t1.tfm) \
tex(NotoSerif-Black-sup-t1.vf) \
tex(NotoSerif-Black-sup-t2a.tfm) \
tex(NotoSerif-Black-sup-t2b.tfm) \
tex(NotoSerif-Black-sup-t2c.tfm) \
tex(NotoSerif-Black-tlf-lgr.tfm) \
tex(NotoSerif-Black-tlf-ly1.tfm) \
tex(NotoSerif-Black-tlf-ot1.tfm) \
tex(NotoSerif-Black-tlf-sc-lgr.tfm) \
tex(NotoSerif-Black-tlf-sc-ly1--base.tfm) \
tex(NotoSerif-Black-tlf-sc-ly1.tfm) \
tex(NotoSerif-Black-tlf-sc-ly1.vf) \
tex(NotoSerif-Black-tlf-sc-ot1--base.tfm) \
tex(NotoSerif-Black-tlf-sc-ot1.tfm) \
tex(NotoSerif-Black-tlf-sc-ot1.vf) \
tex(NotoSerif-Black-tlf-sc-t1--base.tfm) \
tex(NotoSerif-Black-tlf-sc-t1.tfm) \
tex(NotoSerif-Black-tlf-sc-t1.vf) \
tex(NotoSerif-Black-tlf-sc-t2a--base.tfm) \
tex(NotoSerif-Black-tlf-sc-t2a.tfm) \
tex(NotoSerif-Black-tlf-sc-t2a.vf) \
tex(NotoSerif-Black-tlf-sc-t2b--base.tfm) \
tex(NotoSerif-Black-tlf-sc-t2b.tfm) \
tex(NotoSerif-Black-tlf-sc-t2b.vf) \
tex(NotoSerif-Black-tlf-sc-t2c--base.tfm) \
tex(NotoSerif-Black-tlf-sc-t2c.tfm) \
tex(NotoSerif-Black-tlf-sc-t2c.vf) \
tex(NotoSerif-Black-tlf-t1--base.tfm) \
tex(NotoSerif-Black-tlf-t1.tfm) \
tex(NotoSerif-Black-tlf-t1.vf) \
tex(NotoSerif-Black-tlf-t2a.tfm) \
tex(NotoSerif-Black-tlf-t2b.tfm) \
tex(NotoSerif-Black-tlf-t2c.tfm) \
tex(NotoSerif-Black-tlf-ts1--base.tfm) \
tex(NotoSerif-Black-tlf-ts1.tfm) \
tex(NotoSerif-Black-tlf-ts1.vf) \
tex(NotoSerif-Black-tosf-lgr.tfm) \
tex(NotoSerif-Black-tosf-ly1.tfm) \
tex(NotoSerif-Black-tosf-ot1.tfm) \
tex(NotoSerif-Black-tosf-sc-lgr.tfm) \
tex(NotoSerif-Black-tosf-sc-ly1--base.tfm) \
tex(NotoSerif-Black-tosf-sc-ly1.tfm) \
tex(NotoSerif-Black-tosf-sc-ly1.vf) \
tex(NotoSerif-Black-tosf-sc-ot1--base.tfm) \
tex(NotoSerif-Black-tosf-sc-ot1.tfm) \
tex(NotoSerif-Black-tosf-sc-ot1.vf) \
tex(NotoSerif-Black-tosf-sc-t1--base.tfm) \
tex(NotoSerif-Black-tosf-sc-t1.tfm) \
tex(NotoSerif-Black-tosf-sc-t1.vf) \
tex(NotoSerif-Black-tosf-sc-t2a--base.tfm) \
tex(NotoSerif-Black-tosf-sc-t2a.tfm) \
tex(NotoSerif-Black-tosf-sc-t2a.vf) \
tex(NotoSerif-Black-tosf-sc-t2b--base.tfm) \
tex(NotoSerif-Black-tosf-sc-t2b.tfm) \
tex(NotoSerif-Black-tosf-sc-t2b.vf) \
tex(NotoSerif-Black-tosf-sc-t2c--base.tfm) \
tex(NotoSerif-Black-tosf-sc-t2c.tfm) \
tex(NotoSerif-Black-tosf-sc-t2c.vf) \
tex(NotoSerif-Black-tosf-t1--base.tfm) \
tex(NotoSerif-Black-tosf-t1.tfm) \
tex(NotoSerif-Black-tosf-t1.vf) \
tex(NotoSerif-Black-tosf-t2a.tfm) \
tex(NotoSerif-Black-tosf-t2b.tfm) \
tex(NotoSerif-Black-tosf-t2c.tfm) \
tex(NotoSerif-Black-tosf-ts1--base.tfm) \
tex(NotoSerif-Black-tosf-ts1.tfm) \
tex(NotoSerif-Black-tosf-ts1.vf) \
tex(NotoSerif-BlackItalic-lf-lgr.tfm) \
tex(NotoSerif-BlackItalic-lf-ly1.tfm) \
tex(NotoSerif-BlackItalic-lf-ot1.tfm) \
tex(NotoSerif-BlackItalic-lf-sc-lgr.tfm) \
tex(NotoSerif-BlackItalic-lf-sc-ly1--base.tfm) \
tex(NotoSerif-BlackItalic-lf-sc-ly1.tfm) \
tex(NotoSerif-BlackItalic-lf-sc-ly1.vf) \
tex(NotoSerif-BlackItalic-lf-sc-ot1--base.tfm) \
tex(NotoSerif-BlackItalic-lf-sc-ot1.tfm) \
tex(NotoSerif-BlackItalic-lf-sc-ot1.vf) \
tex(NotoSerif-BlackItalic-lf-sc-t1--base.tfm) \
tex(NotoSerif-BlackItalic-lf-sc-t1.tfm) \
tex(NotoSerif-BlackItalic-lf-sc-t1.vf) \
tex(NotoSerif-BlackItalic-lf-sc-t2a--base.tfm) \
tex(NotoSerif-BlackItalic-lf-sc-t2a.tfm) \
tex(NotoSerif-BlackItalic-lf-sc-t2a.vf) \
tex(NotoSerif-BlackItalic-lf-sc-t2b--base.tfm) \
tex(NotoSerif-BlackItalic-lf-sc-t2b.tfm) \
tex(NotoSerif-BlackItalic-lf-sc-t2b.vf) \
tex(NotoSerif-BlackItalic-lf-sc-t2c--base.tfm) \
tex(NotoSerif-BlackItalic-lf-sc-t2c.tfm) \
tex(NotoSerif-BlackItalic-lf-sc-t2c.vf) \
tex(NotoSerif-BlackItalic-lf-t1--base.tfm) \
tex(NotoSerif-BlackItalic-lf-t1.tfm) \
tex(NotoSerif-BlackItalic-lf-t1.vf) \
tex(NotoSerif-BlackItalic-lf-t2a.tfm) \
tex(NotoSerif-BlackItalic-lf-t2b.tfm) \
tex(NotoSerif-BlackItalic-lf-t2c.tfm) \
tex(NotoSerif-BlackItalic-lf-ts1--base.tfm) \
tex(NotoSerif-BlackItalic-lf-ts1.tfm) \
tex(NotoSerif-BlackItalic-lf-ts1.vf) \
tex(NotoSerif-BlackItalic-osf-lgr.tfm) \
tex(NotoSerif-BlackItalic-osf-ly1.tfm) \
tex(NotoSerif-BlackItalic-osf-ot1.tfm) \
tex(NotoSerif-BlackItalic-osf-sc-lgr.tfm) \
tex(NotoSerif-BlackItalic-osf-sc-ly1--base.tfm) \
tex(NotoSerif-BlackItalic-osf-sc-ly1.tfm) \
tex(NotoSerif-BlackItalic-osf-sc-ly1.vf) \
tex(NotoSerif-BlackItalic-osf-sc-ot1--base.tfm) \
tex(NotoSerif-BlackItalic-osf-sc-ot1.tfm) \
tex(NotoSerif-BlackItalic-osf-sc-ot1.vf) \
tex(NotoSerif-BlackItalic-osf-sc-t1--base.tfm) \
tex(NotoSerif-BlackItalic-osf-sc-t1.tfm) \
tex(NotoSerif-BlackItalic-osf-sc-t1.vf) \
tex(NotoSerif-BlackItalic-osf-sc-t2a--base.tfm) \
tex(NotoSerif-BlackItalic-osf-sc-t2a.tfm) \
tex(NotoSerif-BlackItalic-osf-sc-t2a.vf) \
tex(NotoSerif-BlackItalic-osf-sc-t2b--base.tfm) \
tex(NotoSerif-BlackItalic-osf-sc-t2b.tfm) \
tex(NotoSerif-BlackItalic-osf-sc-t2b.vf) \
tex(NotoSerif-BlackItalic-osf-sc-t2c--base.tfm) \
tex(NotoSerif-BlackItalic-osf-sc-t2c.tfm) \
tex(NotoSerif-BlackItalic-osf-sc-t2c.vf) \
tex(NotoSerif-BlackItalic-osf-t1--base.tfm) \
tex(NotoSerif-BlackItalic-osf-t1.tfm) \
tex(NotoSerif-BlackItalic-osf-t1.vf) \
tex(NotoSerif-BlackItalic-osf-t2a.tfm) \
tex(NotoSerif-BlackItalic-osf-t2b.tfm) \
tex(NotoSerif-BlackItalic-osf-t2c.tfm) \
tex(NotoSerif-BlackItalic-osf-ts1--base.tfm) \
tex(NotoSerif-BlackItalic-osf-ts1.tfm) \
tex(NotoSerif-BlackItalic-osf-ts1.vf) \
tex(NotoSerif-BlackItalic-sup-lgr.tfm) \
tex(NotoSerif-BlackItalic-sup-ly1.tfm) \
tex(NotoSerif-BlackItalic-sup-ot1.tfm) \
tex(NotoSerif-BlackItalic-sup-t1--base.tfm) \
tex(NotoSerif-BlackItalic-sup-t1.tfm) \
tex(NotoSerif-BlackItalic-sup-t1.vf) \
tex(NotoSerif-BlackItalic-sup-t2a.tfm) \
tex(NotoSerif-BlackItalic-sup-t2b.tfm) \
tex(NotoSerif-BlackItalic-sup-t2c.tfm) \
tex(NotoSerif-BlackItalic-tlf-lgr.tfm) \
tex(NotoSerif-BlackItalic-tlf-ly1.tfm) \
tex(NotoSerif-BlackItalic-tlf-ot1.tfm) \
tex(NotoSerif-BlackItalic-tlf-sc-lgr.tfm) \
tex(NotoSerif-BlackItalic-tlf-sc-ly1--base.tfm) \
tex(NotoSerif-BlackItalic-tlf-sc-ly1.tfm) \
tex(NotoSerif-BlackItalic-tlf-sc-ly1.vf) \
tex(NotoSerif-BlackItalic-tlf-sc-ot1--base.tfm) \
tex(NotoSerif-BlackItalic-tlf-sc-ot1.tfm) \
tex(NotoSerif-BlackItalic-tlf-sc-ot1.vf) \
tex(NotoSerif-BlackItalic-tlf-sc-t1--base.tfm) \
tex(NotoSerif-BlackItalic-tlf-sc-t1.tfm) \
tex(NotoSerif-BlackItalic-tlf-sc-t1.vf) \
tex(NotoSerif-BlackItalic-tlf-sc-t2a--base.tfm) \
tex(NotoSerif-BlackItalic-tlf-sc-t2a.tfm) \
tex(NotoSerif-BlackItalic-tlf-sc-t2a.vf) \
tex(NotoSerif-BlackItalic-tlf-sc-t2b--base.tfm) \
tex(NotoSerif-BlackItalic-tlf-sc-t2b.tfm) \
tex(NotoSerif-BlackItalic-tlf-sc-t2b.vf) \
tex(NotoSerif-BlackItalic-tlf-sc-t2c--base.tfm) \
tex(NotoSerif-BlackItalic-tlf-sc-t2c.tfm) \
tex(NotoSerif-BlackItalic-tlf-sc-t2c.vf) \
tex(NotoSerif-BlackItalic-tlf-t1--base.tfm) \
tex(NotoSerif-BlackItalic-tlf-t1.tfm) \
tex(NotoSerif-BlackItalic-tlf-t1.vf) \
tex(NotoSerif-BlackItalic-tlf-t2a.tfm) \
tex(NotoSerif-BlackItalic-tlf-t2b.tfm) \
tex(NotoSerif-BlackItalic-tlf-t2c.tfm) \
tex(NotoSerif-BlackItalic-tlf-ts1--base.tfm) \
tex(NotoSerif-BlackItalic-tlf-ts1.tfm) \
tex(NotoSerif-BlackItalic-tlf-ts1.vf) \
tex(NotoSerif-BlackItalic-tosf-lgr.tfm) \
tex(NotoSerif-BlackItalic-tosf-ly1.tfm) \
tex(NotoSerif-BlackItalic-tosf-ot1.tfm) \
tex(NotoSerif-BlackItalic-tosf-sc-lgr.tfm) \
tex(NotoSerif-BlackItalic-tosf-sc-ly1--base.tfm) \
tex(NotoSerif-BlackItalic-tosf-sc-ly1.tfm) \
tex(NotoSerif-BlackItalic-tosf-sc-ly1.vf) \
tex(NotoSerif-BlackItalic-tosf-sc-ot1--base.tfm) \
tex(NotoSerif-BlackItalic-tosf-sc-ot1.tfm) \
tex(NotoSerif-BlackItalic-tosf-sc-ot1.vf) \
tex(NotoSerif-BlackItalic-tosf-sc-t1--base.tfm) \
tex(NotoSerif-BlackItalic-tosf-sc-t1.tfm) \
tex(NotoSerif-BlackItalic-tosf-sc-t1.vf) \
tex(NotoSerif-BlackItalic-tosf-sc-t2a--base.tfm) \
tex(NotoSerif-BlackItalic-tosf-sc-t2a.tfm) \
tex(NotoSerif-BlackItalic-tosf-sc-t2a.vf) \
tex(NotoSerif-BlackItalic-tosf-sc-t2b--base.tfm) \
tex(NotoSerif-BlackItalic-tosf-sc-t2b.tfm) \
tex(NotoSerif-BlackItalic-tosf-sc-t2b.vf) \
tex(NotoSerif-BlackItalic-tosf-sc-t2c--base.tfm) \
tex(NotoSerif-BlackItalic-tosf-sc-t2c.tfm) \
tex(NotoSerif-BlackItalic-tosf-sc-t2c.vf) \
tex(NotoSerif-BlackItalic-tosf-t1--base.tfm) \
tex(NotoSerif-BlackItalic-tosf-t1.tfm) \
tex(NotoSerif-BlackItalic-tosf-t1.vf) \
tex(NotoSerif-BlackItalic-tosf-t2a.tfm) \
tex(NotoSerif-BlackItalic-tosf-t2b.tfm) \
tex(NotoSerif-BlackItalic-tosf-t2c.tfm) \
tex(NotoSerif-BlackItalic-tosf-ts1--base.tfm) \
tex(NotoSerif-BlackItalic-tosf-ts1.tfm) \
tex(NotoSerif-BlackItalic-tosf-ts1.vf) \
tex(NotoSerif-Bold-lf-lgr.tfm) \
tex(NotoSerif-Bold-lf-ly1.tfm) \
tex(NotoSerif-Bold-lf-ot1.tfm) \
tex(NotoSerif-Bold-lf-sc-lgr.tfm) \
tex(NotoSerif-Bold-lf-sc-ly1--base.tfm) \
tex(NotoSerif-Bold-lf-sc-ly1.tfm) \
tex(NotoSerif-Bold-lf-sc-ly1.vf) \
tex(NotoSerif-Bold-lf-sc-ot1--base.tfm) \
tex(NotoSerif-Bold-lf-sc-ot1.tfm) \
tex(NotoSerif-Bold-lf-sc-ot1.vf) \
tex(NotoSerif-Bold-lf-sc-t1--base.tfm) \
tex(NotoSerif-Bold-lf-sc-t1.tfm) \
tex(NotoSerif-Bold-lf-sc-t1.vf) \
tex(NotoSerif-Bold-lf-sc-t2a--base.tfm) \
tex(NotoSerif-Bold-lf-sc-t2a.tfm) \
tex(NotoSerif-Bold-lf-sc-t2a.vf) \
tex(NotoSerif-Bold-lf-sc-t2b--base.tfm) \
tex(NotoSerif-Bold-lf-sc-t2b.tfm) \
tex(NotoSerif-Bold-lf-sc-t2b.vf) \
tex(NotoSerif-Bold-lf-sc-t2c--base.tfm) \
tex(NotoSerif-Bold-lf-sc-t2c.tfm) \
tex(NotoSerif-Bold-lf-sc-t2c.vf) \
tex(NotoSerif-Bold-lf-t1--base.tfm) \
tex(NotoSerif-Bold-lf-t1.tfm) \
tex(NotoSerif-Bold-lf-t1.vf) \
tex(NotoSerif-Bold-lf-t2a.tfm) \
tex(NotoSerif-Bold-lf-t2b.tfm) \
tex(NotoSerif-Bold-lf-t2c.tfm) \
tex(NotoSerif-Bold-lf-ts1--base.tfm) \
tex(NotoSerif-Bold-lf-ts1.tfm) \
tex(NotoSerif-Bold-lf-ts1.vf) \
tex(NotoSerif-Bold-osf-lgr.tfm) \
tex(NotoSerif-Bold-osf-ly1.tfm) \
tex(NotoSerif-Bold-osf-ot1.tfm) \
tex(NotoSerif-Bold-osf-sc-lgr.tfm) \
tex(NotoSerif-Bold-osf-sc-ly1--base.tfm) \
tex(NotoSerif-Bold-osf-sc-ly1.tfm) \
tex(NotoSerif-Bold-osf-sc-ly1.vf) \
tex(NotoSerif-Bold-osf-sc-ot1--base.tfm) \
tex(NotoSerif-Bold-osf-sc-ot1.tfm) \
tex(NotoSerif-Bold-osf-sc-ot1.vf) \
tex(NotoSerif-Bold-osf-sc-t1--base.tfm) \
tex(NotoSerif-Bold-osf-sc-t1.tfm) \
tex(NotoSerif-Bold-osf-sc-t1.vf) \
tex(NotoSerif-Bold-osf-sc-t2a--base.tfm) \
tex(NotoSerif-Bold-osf-sc-t2a.tfm) \
tex(NotoSerif-Bold-osf-sc-t2a.vf) \
tex(NotoSerif-Bold-osf-sc-t2b--base.tfm) \
tex(NotoSerif-Bold-osf-sc-t2b.tfm) \
tex(NotoSerif-Bold-osf-sc-t2b.vf) \
tex(NotoSerif-Bold-osf-sc-t2c--base.tfm) \
tex(NotoSerif-Bold-osf-sc-t2c.tfm) \
tex(NotoSerif-Bold-osf-sc-t2c.vf) \
tex(NotoSerif-Bold-osf-t1--base.tfm) \
tex(NotoSerif-Bold-osf-t1.tfm) \
tex(NotoSerif-Bold-osf-t1.vf) \
tex(NotoSerif-Bold-osf-t2a.tfm) \
tex(NotoSerif-Bold-osf-t2b.tfm) \
tex(NotoSerif-Bold-osf-t2c.tfm) \
tex(NotoSerif-Bold-osf-ts1--base.tfm) \
tex(NotoSerif-Bold-osf-ts1.tfm) \
tex(NotoSerif-Bold-osf-ts1.vf) \
tex(NotoSerif-Bold-sup-lgr.tfm) \
tex(NotoSerif-Bold-sup-ly1.tfm) \
tex(NotoSerif-Bold-sup-ot1.tfm) \
tex(NotoSerif-Bold-sup-t1--base.tfm) \
tex(NotoSerif-Bold-sup-t1.tfm) \
tex(NotoSerif-Bold-sup-t1.vf) \
tex(NotoSerif-Bold-sup-t2a.tfm) \
tex(NotoSerif-Bold-sup-t2b.tfm) \
tex(NotoSerif-Bold-sup-t2c.tfm) \
tex(NotoSerif-Bold-tlf-lgr.tfm) \
tex(NotoSerif-Bold-tlf-ly1.tfm) \
tex(NotoSerif-Bold-tlf-ot1.tfm) \
tex(NotoSerif-Bold-tlf-sc-lgr.tfm) \
tex(NotoSerif-Bold-tlf-sc-ly1--base.tfm) \
tex(NotoSerif-Bold-tlf-sc-ly1.tfm) \
tex(NotoSerif-Bold-tlf-sc-ly1.vf) \
tex(NotoSerif-Bold-tlf-sc-ot1--base.tfm) \
tex(NotoSerif-Bold-tlf-sc-ot1.tfm) \
tex(NotoSerif-Bold-tlf-sc-ot1.vf) \
tex(NotoSerif-Bold-tlf-sc-t1--base.tfm) \
tex(NotoSerif-Bold-tlf-sc-t1.tfm) \
tex(NotoSerif-Bold-tlf-sc-t1.vf) \
tex(NotoSerif-Bold-tlf-sc-t2a--base.tfm) \
tex(NotoSerif-Bold-tlf-sc-t2a.tfm) \
tex(NotoSerif-Bold-tlf-sc-t2a.vf) \
tex(NotoSerif-Bold-tlf-sc-t2b--base.tfm) \
tex(NotoSerif-Bold-tlf-sc-t2b.tfm) \
tex(NotoSerif-Bold-tlf-sc-t2b.vf) \
tex(NotoSerif-Bold-tlf-sc-t2c--base.tfm) \
tex(NotoSerif-Bold-tlf-sc-t2c.tfm) \
tex(NotoSerif-Bold-tlf-sc-t2c.vf) \
tex(NotoSerif-Bold-tlf-t1--base.tfm) \
tex(NotoSerif-Bold-tlf-t1.tfm) \
tex(NotoSerif-Bold-tlf-t1.vf) \
tex(NotoSerif-Bold-tlf-t2a.tfm) \
tex(NotoSerif-Bold-tlf-t2b.tfm) \
tex(NotoSerif-Bold-tlf-t2c.tfm) \
tex(NotoSerif-Bold-tlf-ts1--base.tfm) \
tex(NotoSerif-Bold-tlf-ts1.tfm) \
tex(NotoSerif-Bold-tlf-ts1.vf) \
tex(NotoSerif-Bold-tosf-lgr.tfm) \
tex(NotoSerif-Bold-tosf-ly1.tfm) \
tex(NotoSerif-Bold-tosf-ot1.tfm) \
tex(NotoSerif-Bold-tosf-sc-lgr.tfm) \
tex(NotoSerif-Bold-tosf-sc-ly1--base.tfm) \
tex(NotoSerif-Bold-tosf-sc-ly1.tfm) \
tex(NotoSerif-Bold-tosf-sc-ly1.vf) \
tex(NotoSerif-Bold-tosf-sc-ot1--base.tfm) \
tex(NotoSerif-Bold-tosf-sc-ot1.tfm) \
tex(NotoSerif-Bold-tosf-sc-ot1.vf) \
tex(NotoSerif-Bold-tosf-sc-t1--base.tfm) \
tex(NotoSerif-Bold-tosf-sc-t1.tfm) \
tex(NotoSerif-Bold-tosf-sc-t1.vf) \
tex(NotoSerif-Bold-tosf-sc-t2a--base.tfm) \
tex(NotoSerif-Bold-tosf-sc-t2a.tfm) \
tex(NotoSerif-Bold-tosf-sc-t2a.vf) \
tex(NotoSerif-Bold-tosf-sc-t2b--base.tfm) \
tex(NotoSerif-Bold-tosf-sc-t2b.tfm) \
tex(NotoSerif-Bold-tosf-sc-t2b.vf) \
tex(NotoSerif-Bold-tosf-sc-t2c--base.tfm) \
tex(NotoSerif-Bold-tosf-sc-t2c.tfm) \
tex(NotoSerif-Bold-tosf-sc-t2c.vf) \
tex(NotoSerif-Bold-tosf-t1--base.tfm) \
tex(NotoSerif-Bold-tosf-t1.tfm) \
tex(NotoSerif-Bold-tosf-t1.vf) \
tex(NotoSerif-Bold-tosf-t2a.tfm) \
tex(NotoSerif-Bold-tosf-t2b.tfm) \
tex(NotoSerif-Bold-tosf-t2c.tfm) \
tex(NotoSerif-Bold-tosf-ts1--base.tfm) \
tex(NotoSerif-Bold-tosf-ts1.tfm) \
tex(NotoSerif-Bold-tosf-ts1.vf) \
tex(NotoSerif-BoldItalic-lf-lgr.tfm) \
tex(NotoSerif-BoldItalic-lf-ly1.tfm) \
tex(NotoSerif-BoldItalic-lf-ot1.tfm) \
tex(NotoSerif-BoldItalic-lf-sc-lgr.tfm) \
tex(NotoSerif-BoldItalic-lf-sc-ly1--base.tfm) \
tex(NotoSerif-BoldItalic-lf-sc-ly1.tfm) \
tex(NotoSerif-BoldItalic-lf-sc-ly1.vf) \
tex(NotoSerif-BoldItalic-lf-sc-ot1--base.tfm) \
tex(NotoSerif-BoldItalic-lf-sc-ot1.tfm) \
tex(NotoSerif-BoldItalic-lf-sc-ot1.vf) \
tex(NotoSerif-BoldItalic-lf-sc-t1--base.tfm) \
tex(NotoSerif-BoldItalic-lf-sc-t1.tfm) \
tex(NotoSerif-BoldItalic-lf-sc-t1.vf) \
tex(NotoSerif-BoldItalic-lf-sc-t2a--base.tfm) \
tex(NotoSerif-BoldItalic-lf-sc-t2a.tfm) \
tex(NotoSerif-BoldItalic-lf-sc-t2a.vf) \
tex(NotoSerif-BoldItalic-lf-sc-t2b--base.tfm) \
tex(NotoSerif-BoldItalic-lf-sc-t2b.tfm) \
tex(NotoSerif-BoldItalic-lf-sc-t2b.vf) \
tex(NotoSerif-BoldItalic-lf-sc-t2c--base.tfm) \
tex(NotoSerif-BoldItalic-lf-sc-t2c.tfm) \
tex(NotoSerif-BoldItalic-lf-sc-t2c.vf) \
tex(NotoSerif-BoldItalic-lf-t1--base.tfm) \
tex(NotoSerif-BoldItalic-lf-t1.tfm) \
tex(NotoSerif-BoldItalic-lf-t1.vf) \
tex(NotoSerif-BoldItalic-lf-t2a.tfm) \
tex(NotoSerif-BoldItalic-lf-t2b.tfm) \
tex(NotoSerif-BoldItalic-lf-t2c.tfm) \
tex(NotoSerif-BoldItalic-lf-ts1--base.tfm) \
tex(NotoSerif-BoldItalic-lf-ts1.tfm) \
tex(NotoSerif-BoldItalic-lf-ts1.vf) \
tex(NotoSerif-BoldItalic-osf-lgr.tfm) \
tex(NotoSerif-BoldItalic-osf-ly1.tfm) \
tex(NotoSerif-BoldItalic-osf-ot1.tfm) \
tex(NotoSerif-BoldItalic-osf-sc-lgr.tfm) \
tex(NotoSerif-BoldItalic-osf-sc-ly1--base.tfm) \
tex(NotoSerif-BoldItalic-osf-sc-ly1.tfm) \
tex(NotoSerif-BoldItalic-osf-sc-ly1.vf) \
tex(NotoSerif-BoldItalic-osf-sc-ot1--base.tfm) \
tex(NotoSerif-BoldItalic-osf-sc-ot1.tfm) \
tex(NotoSerif-BoldItalic-osf-sc-ot1.vf) \
tex(NotoSerif-BoldItalic-osf-sc-t1--base.tfm) \
tex(NotoSerif-BoldItalic-osf-sc-t1.tfm) \
tex(NotoSerif-BoldItalic-osf-sc-t1.vf) \
tex(NotoSerif-BoldItalic-osf-sc-t2a--base.tfm) \
tex(NotoSerif-BoldItalic-osf-sc-t2a.tfm) \
tex(NotoSerif-BoldItalic-osf-sc-t2a.vf) \
tex(NotoSerif-BoldItalic-osf-sc-t2b--base.tfm) \
tex(NotoSerif-BoldItalic-osf-sc-t2b.tfm) \
tex(NotoSerif-BoldItalic-osf-sc-t2b.vf) \
tex(NotoSerif-BoldItalic-osf-sc-t2c--base.tfm) \
tex(NotoSerif-BoldItalic-osf-sc-t2c.tfm) \
tex(NotoSerif-BoldItalic-osf-sc-t2c.vf) \
tex(NotoSerif-BoldItalic-osf-t1--base.tfm) \
tex(NotoSerif-BoldItalic-osf-t1.tfm) \
tex(NotoSerif-BoldItalic-osf-t1.vf) \
tex(NotoSerif-BoldItalic-osf-t2a.tfm) \
tex(NotoSerif-BoldItalic-osf-t2b.tfm) \
tex(NotoSerif-BoldItalic-osf-t2c.tfm) \
tex(NotoSerif-BoldItalic-osf-ts1--base.tfm) \
tex(NotoSerif-BoldItalic-osf-ts1.tfm) \
tex(NotoSerif-BoldItalic-osf-ts1.vf) \
tex(NotoSerif-BoldItalic-sup-lgr.tfm) \
tex(NotoSerif-BoldItalic-sup-ly1.tfm) \
tex(NotoSerif-BoldItalic-sup-ot1.tfm) \
tex(NotoSerif-BoldItalic-sup-t1--base.tfm) \
tex(NotoSerif-BoldItalic-sup-t1.tfm) \
tex(NotoSerif-BoldItalic-sup-t1.vf) \
tex(NotoSerif-BoldItalic-sup-t2a.tfm) \
tex(NotoSerif-BoldItalic-sup-t2b.tfm) \
tex(NotoSerif-BoldItalic-sup-t2c.tfm) \
tex(NotoSerif-BoldItalic-tlf-lgr.tfm) \
tex(NotoSerif-BoldItalic-tlf-ly1.tfm) \
tex(NotoSerif-BoldItalic-tlf-ot1.tfm) \
tex(NotoSerif-BoldItalic-tlf-sc-lgr.tfm) \
tex(NotoSerif-BoldItalic-tlf-sc-ly1--base.tfm) \
tex(NotoSerif-BoldItalic-tlf-sc-ly1.tfm) \
tex(NotoSerif-BoldItalic-tlf-sc-ly1.vf) \
tex(NotoSerif-BoldItalic-tlf-sc-ot1--base.tfm) \
tex(NotoSerif-BoldItalic-tlf-sc-ot1.tfm) \
tex(NotoSerif-BoldItalic-tlf-sc-ot1.vf) \
tex(NotoSerif-BoldItalic-tlf-sc-t1--base.tfm) \
tex(NotoSerif-BoldItalic-tlf-sc-t1.tfm) \
tex(NotoSerif-BoldItalic-tlf-sc-t1.vf) \
tex(NotoSerif-BoldItalic-tlf-sc-t2a--base.tfm) \
tex(NotoSerif-BoldItalic-tlf-sc-t2a.tfm) \
tex(NotoSerif-BoldItalic-tlf-sc-t2a.vf) \
tex(NotoSerif-BoldItalic-tlf-sc-t2b--base.tfm) \
tex(NotoSerif-BoldItalic-tlf-sc-t2b.tfm) \
tex(NotoSerif-BoldItalic-tlf-sc-t2b.vf) \
tex(NotoSerif-BoldItalic-tlf-sc-t2c--base.tfm) \
tex(NotoSerif-BoldItalic-tlf-sc-t2c.tfm) \
tex(NotoSerif-BoldItalic-tlf-sc-t2c.vf) \
tex(NotoSerif-BoldItalic-tlf-t1--base.tfm) \
tex(NotoSerif-BoldItalic-tlf-t1.tfm) \
tex(NotoSerif-BoldItalic-tlf-t1.vf) \
tex(NotoSerif-BoldItalic-tlf-t2a.tfm) \
tex(NotoSerif-BoldItalic-tlf-t2b.tfm) \
tex(NotoSerif-BoldItalic-tlf-t2c.tfm) \
tex(NotoSerif-BoldItalic-tlf-ts1--base.tfm) \
tex(NotoSerif-BoldItalic-tlf-ts1.tfm) \
tex(NotoSerif-BoldItalic-tlf-ts1.vf) \
tex(NotoSerif-BoldItalic-tosf-lgr.tfm) \
tex(NotoSerif-BoldItalic-tosf-ly1.tfm) \
tex(NotoSerif-BoldItalic-tosf-ot1.tfm) \
tex(NotoSerif-BoldItalic-tosf-sc-lgr.tfm) \
tex(NotoSerif-BoldItalic-tosf-sc-ly1--base.tfm) \
tex(NotoSerif-BoldItalic-tosf-sc-ly1.tfm) \
tex(NotoSerif-BoldItalic-tosf-sc-ly1.vf) \
tex(NotoSerif-BoldItalic-tosf-sc-ot1--base.tfm) \
tex(NotoSerif-BoldItalic-tosf-sc-ot1.tfm) \
tex(NotoSerif-BoldItalic-tosf-sc-ot1.vf) \
tex(NotoSerif-BoldItalic-tosf-sc-t1--base.tfm) \
tex(NotoSerif-BoldItalic-tosf-sc-t1.tfm) \
tex(NotoSerif-BoldItalic-tosf-sc-t1.vf) \
tex(NotoSerif-BoldItalic-tosf-sc-t2a--base.tfm) \
tex(NotoSerif-BoldItalic-tosf-sc-t2a.tfm) \
tex(NotoSerif-BoldItalic-tosf-sc-t2a.vf) \
tex(NotoSerif-BoldItalic-tosf-sc-t2b--base.tfm) \
tex(NotoSerif-BoldItalic-tosf-sc-t2b.tfm) \
tex(NotoSerif-BoldItalic-tosf-sc-t2b.vf) \
tex(NotoSerif-BoldItalic-tosf-sc-t2c--base.tfm) \
tex(NotoSerif-BoldItalic-tosf-sc-t2c.tfm) \
tex(NotoSerif-BoldItalic-tosf-sc-t2c.vf) \
tex(NotoSerif-BoldItalic-tosf-t1--base.tfm) \
tex(NotoSerif-BoldItalic-tosf-t1.tfm) \
tex(NotoSerif-BoldItalic-tosf-t1.vf) \
tex(NotoSerif-BoldItalic-tosf-t2a.tfm) \
tex(NotoSerif-BoldItalic-tosf-t2b.tfm) \
tex(NotoSerif-BoldItalic-tosf-t2c.tfm) \
tex(NotoSerif-BoldItalic-tosf-ts1--base.tfm) \
tex(NotoSerif-BoldItalic-tosf-ts1.tfm) \
tex(NotoSerif-BoldItalic-tosf-ts1.vf) \
tex(NotoSerif-ExtraBold-lf-lgr.tfm) \
tex(NotoSerif-ExtraBold-lf-ly1.tfm) \
tex(NotoSerif-ExtraBold-lf-ot1.tfm) \
tex(NotoSerif-ExtraBold-lf-sc-lgr.tfm) \
tex(NotoSerif-ExtraBold-lf-sc-ly1--base.tfm) \
tex(NotoSerif-ExtraBold-lf-sc-ly1.tfm) \
tex(NotoSerif-ExtraBold-lf-sc-ly1.vf) \
tex(NotoSerif-ExtraBold-lf-sc-ot1--base.tfm) \
tex(NotoSerif-ExtraBold-lf-sc-ot1.tfm) \
tex(NotoSerif-ExtraBold-lf-sc-ot1.vf) \
tex(NotoSerif-ExtraBold-lf-sc-t1--base.tfm) \
tex(NotoSerif-ExtraBold-lf-sc-t1.tfm) \
tex(NotoSerif-ExtraBold-lf-sc-t1.vf) \
tex(NotoSerif-ExtraBold-lf-sc-t2a--base.tfm) \
tex(NotoSerif-ExtraBold-lf-sc-t2a.tfm) \
tex(NotoSerif-ExtraBold-lf-sc-t2a.vf) \
tex(NotoSerif-ExtraBold-lf-sc-t2b--base.tfm) \
tex(NotoSerif-ExtraBold-lf-sc-t2b.tfm) \
tex(NotoSerif-ExtraBold-lf-sc-t2b.vf) \
tex(NotoSerif-ExtraBold-lf-sc-t2c--base.tfm) \
tex(NotoSerif-ExtraBold-lf-sc-t2c.tfm) \
tex(NotoSerif-ExtraBold-lf-sc-t2c.vf) \
tex(NotoSerif-ExtraBold-lf-t1--base.tfm) \
tex(NotoSerif-ExtraBold-lf-t1.tfm) \
tex(NotoSerif-ExtraBold-lf-t1.vf) \
tex(NotoSerif-ExtraBold-lf-t2a.tfm) \
tex(NotoSerif-ExtraBold-lf-t2b.tfm) \
tex(NotoSerif-ExtraBold-lf-t2c.tfm) \
tex(NotoSerif-ExtraBold-lf-ts1--base.tfm) \
tex(NotoSerif-ExtraBold-lf-ts1.tfm) \
tex(NotoSerif-ExtraBold-lf-ts1.vf) \
tex(NotoSerif-ExtraBold-osf-lgr.tfm) \
tex(NotoSerif-ExtraBold-osf-ly1.tfm) \
tex(NotoSerif-ExtraBold-osf-ot1.tfm) \
tex(NotoSerif-ExtraBold-osf-sc-lgr.tfm) \
tex(NotoSerif-ExtraBold-osf-sc-ly1--base.tfm) \
tex(NotoSerif-ExtraBold-osf-sc-ly1.tfm) \
tex(NotoSerif-ExtraBold-osf-sc-ly1.vf) \
tex(NotoSerif-ExtraBold-osf-sc-ot1--base.tfm) \
tex(NotoSerif-ExtraBold-osf-sc-ot1.tfm) \
tex(NotoSerif-ExtraBold-osf-sc-ot1.vf) \
tex(NotoSerif-ExtraBold-osf-sc-t1--base.tfm) \
tex(NotoSerif-ExtraBold-osf-sc-t1.tfm) \
tex(NotoSerif-ExtraBold-osf-sc-t1.vf) \
tex(NotoSerif-ExtraBold-osf-sc-t2a--base.tfm) \
tex(NotoSerif-ExtraBold-osf-sc-t2a.tfm) \
tex(NotoSerif-ExtraBold-osf-sc-t2a.vf) \
tex(NotoSerif-ExtraBold-osf-sc-t2b--base.tfm) \
tex(NotoSerif-ExtraBold-osf-sc-t2b.tfm) \
tex(NotoSerif-ExtraBold-osf-sc-t2b.vf) \
tex(NotoSerif-ExtraBold-osf-sc-t2c--base.tfm) \
tex(NotoSerif-ExtraBold-osf-sc-t2c.tfm) \
tex(NotoSerif-ExtraBold-osf-sc-t2c.vf) \
tex(NotoSerif-ExtraBold-osf-t1--base.tfm) \
tex(NotoSerif-ExtraBold-osf-t1.tfm) \
tex(NotoSerif-ExtraBold-osf-t1.vf) \
tex(NotoSerif-ExtraBold-osf-t2a.tfm) \
tex(NotoSerif-ExtraBold-osf-t2b.tfm) \
tex(NotoSerif-ExtraBold-osf-t2c.tfm) \
tex(NotoSerif-ExtraBold-osf-ts1--base.tfm) \
tex(NotoSerif-ExtraBold-osf-ts1.tfm) \
tex(NotoSerif-ExtraBold-osf-ts1.vf) \
tex(NotoSerif-ExtraBold-sup-lgr.tfm) \
tex(NotoSerif-ExtraBold-sup-ly1.tfm) \
tex(NotoSerif-ExtraBold-sup-ot1.tfm) \
tex(NotoSerif-ExtraBold-sup-t1--base.tfm) \
tex(NotoSerif-ExtraBold-sup-t1.tfm) \
tex(NotoSerif-ExtraBold-sup-t1.vf) \
tex(NotoSerif-ExtraBold-sup-t2a.tfm) \
tex(NotoSerif-ExtraBold-sup-t2b.tfm) \
tex(NotoSerif-ExtraBold-sup-t2c.tfm) \
tex(NotoSerif-ExtraBold-tlf-lgr.tfm) \
tex(NotoSerif-ExtraBold-tlf-ly1.tfm) \
tex(NotoSerif-ExtraBold-tlf-ot1.tfm) \
tex(NotoSerif-ExtraBold-tlf-sc-lgr.tfm) \
tex(NotoSerif-ExtraBold-tlf-sc-ly1--base.tfm) \
tex(NotoSerif-ExtraBold-tlf-sc-ly1.tfm) \
tex(NotoSerif-ExtraBold-tlf-sc-ly1.vf) \
tex(NotoSerif-ExtraBold-tlf-sc-ot1--base.tfm) \
tex(NotoSerif-ExtraBold-tlf-sc-ot1.tfm) \
tex(NotoSerif-ExtraBold-tlf-sc-ot1.vf) \
tex(NotoSerif-ExtraBold-tlf-sc-t1--base.tfm) \
tex(NotoSerif-ExtraBold-tlf-sc-t1.tfm) \
tex(NotoSerif-ExtraBold-tlf-sc-t1.vf) \
tex(NotoSerif-ExtraBold-tlf-sc-t2a--base.tfm) \
tex(NotoSerif-ExtraBold-tlf-sc-t2a.tfm) \
tex(NotoSerif-ExtraBold-tlf-sc-t2a.vf) \
tex(NotoSerif-ExtraBold-tlf-sc-t2b--base.tfm) \
tex(NotoSerif-ExtraBold-tlf-sc-t2b.tfm) \
tex(NotoSerif-ExtraBold-tlf-sc-t2b.vf) \
tex(NotoSerif-ExtraBold-tlf-sc-t2c--base.tfm) \
tex(NotoSerif-ExtraBold-tlf-sc-t2c.tfm) \
tex(NotoSerif-ExtraBold-tlf-sc-t2c.vf) \
tex(NotoSerif-ExtraBold-tlf-t1--base.tfm) \
tex(NotoSerif-ExtraBold-tlf-t1.tfm) \
tex(NotoSerif-ExtraBold-tlf-t1.vf) \
tex(NotoSerif-ExtraBold-tlf-t2a.tfm) \
tex(NotoSerif-ExtraBold-tlf-t2b.tfm) \
tex(NotoSerif-ExtraBold-tlf-t2c.tfm) \
tex(NotoSerif-ExtraBold-tlf-ts1--base.tfm) \
tex(NotoSerif-ExtraBold-tlf-ts1.tfm) \
tex(NotoSerif-ExtraBold-tlf-ts1.vf) \
tex(NotoSerif-ExtraBold-tosf-lgr.tfm) \
tex(NotoSerif-ExtraBold-tosf-ly1.tfm) \
tex(NotoSerif-ExtraBold-tosf-ot1.tfm) \
tex(NotoSerif-ExtraBold-tosf-sc-lgr.tfm) \
tex(NotoSerif-ExtraBold-tosf-sc-ly1--base.tfm) \
tex(NotoSerif-ExtraBold-tosf-sc-ly1.tfm) \
tex(NotoSerif-ExtraBold-tosf-sc-ly1.vf) \
tex(NotoSerif-ExtraBold-tosf-sc-ot1--base.tfm) \
tex(NotoSerif-ExtraBold-tosf-sc-ot1.tfm) \
tex(NotoSerif-ExtraBold-tosf-sc-ot1.vf) \
tex(NotoSerif-ExtraBold-tosf-sc-t1--base.tfm) \
tex(NotoSerif-ExtraBold-tosf-sc-t1.tfm) \
tex(NotoSerif-ExtraBold-tosf-sc-t1.vf) \
tex(NotoSerif-ExtraBold-tosf-sc-t2a--base.tfm) \
tex(NotoSerif-ExtraBold-tosf-sc-t2a.tfm) \
tex(NotoSerif-ExtraBold-tosf-sc-t2a.vf) \
tex(NotoSerif-ExtraBold-tosf-sc-t2b--base.tfm) \
tex(NotoSerif-ExtraBold-tosf-sc-t2b.tfm) \
tex(NotoSerif-ExtraBold-tosf-sc-t2b.vf) \
tex(NotoSerif-ExtraBold-tosf-sc-t2c--base.tfm) \
tex(NotoSerif-ExtraBold-tosf-sc-t2c.tfm) \
tex(NotoSerif-ExtraBold-tosf-sc-t2c.vf) \
tex(NotoSerif-ExtraBold-tosf-t1--base.tfm) \
tex(NotoSerif-ExtraBold-tosf-t1.tfm) \
tex(NotoSerif-ExtraBold-tosf-t1.vf) \
tex(NotoSerif-ExtraBold-tosf-t2a.tfm) \
tex(NotoSerif-ExtraBold-tosf-t2b.tfm) \
tex(NotoSerif-ExtraBold-tosf-t2c.tfm) \
tex(NotoSerif-ExtraBold-tosf-ts1--base.tfm) \
tex(NotoSerif-ExtraBold-tosf-ts1.tfm) \
tex(NotoSerif-ExtraBold-tosf-ts1.vf) \
tex(NotoSerif-ExtraBoldItalic-lf-lgr.tfm) \
tex(NotoSerif-ExtraBoldItalic-lf-ly1.tfm) \
tex(NotoSerif-ExtraBoldItalic-lf-ot1.tfm) \
tex(NotoSerif-ExtraBoldItalic-lf-sc-lgr.tfm) \
tex(NotoSerif-ExtraBoldItalic-lf-sc-ly1--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-lf-sc-ly1.tfm) \
tex(NotoSerif-ExtraBoldItalic-lf-sc-ly1.vf) \
tex(NotoSerif-ExtraBoldItalic-lf-sc-ot1--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-lf-sc-ot1.tfm) \
tex(NotoSerif-ExtraBoldItalic-lf-sc-ot1.vf) \
tex(NotoSerif-ExtraBoldItalic-lf-sc-t1--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-lf-sc-t1.tfm) \
tex(NotoSerif-ExtraBoldItalic-lf-sc-t1.vf) \
tex(NotoSerif-ExtraBoldItalic-lf-sc-t2a--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-lf-sc-t2a.tfm) \
tex(NotoSerif-ExtraBoldItalic-lf-sc-t2a.vf) \
tex(NotoSerif-ExtraBoldItalic-lf-sc-t2b--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-lf-sc-t2b.tfm) \
tex(NotoSerif-ExtraBoldItalic-lf-sc-t2b.vf) \
tex(NotoSerif-ExtraBoldItalic-lf-sc-t2c--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-lf-sc-t2c.tfm) \
tex(NotoSerif-ExtraBoldItalic-lf-sc-t2c.vf) \
tex(NotoSerif-ExtraBoldItalic-lf-t1--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-lf-t1.tfm) \
tex(NotoSerif-ExtraBoldItalic-lf-t1.vf) \
tex(NotoSerif-ExtraBoldItalic-lf-t2a.tfm) \
tex(NotoSerif-ExtraBoldItalic-lf-t2b.tfm) \
tex(NotoSerif-ExtraBoldItalic-lf-t2c.tfm) \
tex(NotoSerif-ExtraBoldItalic-lf-ts1--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-lf-ts1.tfm) \
tex(NotoSerif-ExtraBoldItalic-lf-ts1.vf) \
tex(NotoSerif-ExtraBoldItalic-osf-lgr.tfm) \
tex(NotoSerif-ExtraBoldItalic-osf-ly1.tfm) \
tex(NotoSerif-ExtraBoldItalic-osf-ot1.tfm) \
tex(NotoSerif-ExtraBoldItalic-osf-sc-lgr.tfm) \
tex(NotoSerif-ExtraBoldItalic-osf-sc-ly1--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-osf-sc-ly1.tfm) \
tex(NotoSerif-ExtraBoldItalic-osf-sc-ly1.vf) \
tex(NotoSerif-ExtraBoldItalic-osf-sc-ot1--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-osf-sc-ot1.tfm) \
tex(NotoSerif-ExtraBoldItalic-osf-sc-ot1.vf) \
tex(NotoSerif-ExtraBoldItalic-osf-sc-t1--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-osf-sc-t1.tfm) \
tex(NotoSerif-ExtraBoldItalic-osf-sc-t1.vf) \
tex(NotoSerif-ExtraBoldItalic-osf-sc-t2a--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-osf-sc-t2a.tfm) \
tex(NotoSerif-ExtraBoldItalic-osf-sc-t2a.vf) \
tex(NotoSerif-ExtraBoldItalic-osf-sc-t2b--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-osf-sc-t2b.tfm) \
tex(NotoSerif-ExtraBoldItalic-osf-sc-t2b.vf) \
tex(NotoSerif-ExtraBoldItalic-osf-sc-t2c--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-osf-sc-t2c.tfm) \
tex(NotoSerif-ExtraBoldItalic-osf-sc-t2c.vf) \
tex(NotoSerif-ExtraBoldItalic-osf-t1--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-osf-t1.tfm) \
tex(NotoSerif-ExtraBoldItalic-osf-t1.vf) \
tex(NotoSerif-ExtraBoldItalic-osf-t2a.tfm) \
tex(NotoSerif-ExtraBoldItalic-osf-t2b.tfm) \
tex(NotoSerif-ExtraBoldItalic-osf-t2c.tfm) \
tex(NotoSerif-ExtraBoldItalic-osf-ts1--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-osf-ts1.tfm) \
tex(NotoSerif-ExtraBoldItalic-osf-ts1.vf) \
tex(NotoSerif-ExtraBoldItalic-sup-lgr.tfm) \
tex(NotoSerif-ExtraBoldItalic-sup-ly1.tfm) \
tex(NotoSerif-ExtraBoldItalic-sup-ot1.tfm) \
tex(NotoSerif-ExtraBoldItalic-sup-t1--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-sup-t1.tfm) \
tex(NotoSerif-ExtraBoldItalic-sup-t1.vf) \
tex(NotoSerif-ExtraBoldItalic-sup-t2a.tfm) \
tex(NotoSerif-ExtraBoldItalic-sup-t2b.tfm) \
tex(NotoSerif-ExtraBoldItalic-sup-t2c.tfm) \
tex(NotoSerif-ExtraBoldItalic-tlf-lgr.tfm) \
tex(NotoSerif-ExtraBoldItalic-tlf-ly1.tfm) \
tex(NotoSerif-ExtraBoldItalic-tlf-ot1.tfm) \
tex(NotoSerif-ExtraBoldItalic-tlf-sc-lgr.tfm) \
tex(NotoSerif-ExtraBoldItalic-tlf-sc-ly1--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-tlf-sc-ly1.tfm) \
tex(NotoSerif-ExtraBoldItalic-tlf-sc-ly1.vf) \
tex(NotoSerif-ExtraBoldItalic-tlf-sc-ot1--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-tlf-sc-ot1.tfm) \
tex(NotoSerif-ExtraBoldItalic-tlf-sc-ot1.vf) \
tex(NotoSerif-ExtraBoldItalic-tlf-sc-t1--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-tlf-sc-t1.tfm) \
tex(NotoSerif-ExtraBoldItalic-tlf-sc-t1.vf) \
tex(NotoSerif-ExtraBoldItalic-tlf-sc-t2a--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-tlf-sc-t2a.tfm) \
tex(NotoSerif-ExtraBoldItalic-tlf-sc-t2a.vf) \
tex(NotoSerif-ExtraBoldItalic-tlf-sc-t2b--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-tlf-sc-t2b.tfm) \
tex(NotoSerif-ExtraBoldItalic-tlf-sc-t2b.vf) \
tex(NotoSerif-ExtraBoldItalic-tlf-sc-t2c--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-tlf-sc-t2c.tfm) \
tex(NotoSerif-ExtraBoldItalic-tlf-sc-t2c.vf) \
tex(NotoSerif-ExtraBoldItalic-tlf-t1--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-tlf-t1.tfm) \
tex(NotoSerif-ExtraBoldItalic-tlf-t1.vf) \
tex(NotoSerif-ExtraBoldItalic-tlf-t2a.tfm) \
tex(NotoSerif-ExtraBoldItalic-tlf-t2b.tfm) \
tex(NotoSerif-ExtraBoldItalic-tlf-t2c.tfm) \
tex(NotoSerif-ExtraBoldItalic-tlf-ts1--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-tlf-ts1.tfm) \
tex(NotoSerif-ExtraBoldItalic-tlf-ts1.vf) \
tex(NotoSerif-ExtraBoldItalic-tosf-lgr.tfm) \
tex(NotoSerif-ExtraBoldItalic-tosf-ly1.tfm) \
tex(NotoSerif-ExtraBoldItalic-tosf-ot1.tfm) \
tex(NotoSerif-ExtraBoldItalic-tosf-sc-lgr.tfm) \
tex(NotoSerif-ExtraBoldItalic-tosf-sc-ly1--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-tosf-sc-ly1.tfm) \
tex(NotoSerif-ExtraBoldItalic-tosf-sc-ly1.vf) \
tex(NotoSerif-ExtraBoldItalic-tosf-sc-ot1--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-tosf-sc-ot1.tfm) \
tex(NotoSerif-ExtraBoldItalic-tosf-sc-ot1.vf) \
tex(NotoSerif-ExtraBoldItalic-tosf-sc-t1--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-tosf-sc-t1.tfm) \
tex(NotoSerif-ExtraBoldItalic-tosf-sc-t1.vf) \
tex(NotoSerif-ExtraBoldItalic-tosf-sc-t2a--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-tosf-sc-t2a.tfm) \
tex(NotoSerif-ExtraBoldItalic-tosf-sc-t2a.vf) \
tex(NotoSerif-ExtraBoldItalic-tosf-sc-t2b--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-tosf-sc-t2b.tfm) \
tex(NotoSerif-ExtraBoldItalic-tosf-sc-t2b.vf) \
tex(NotoSerif-ExtraBoldItalic-tosf-sc-t2c--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-tosf-sc-t2c.tfm) \
tex(NotoSerif-ExtraBoldItalic-tosf-sc-t2c.vf) \
tex(NotoSerif-ExtraBoldItalic-tosf-t1--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-tosf-t1.tfm) \
tex(NotoSerif-ExtraBoldItalic-tosf-t1.vf) \
tex(NotoSerif-ExtraBoldItalic-tosf-t2a.tfm) \
tex(NotoSerif-ExtraBoldItalic-tosf-t2b.tfm) \
tex(NotoSerif-ExtraBoldItalic-tosf-t2c.tfm) \
tex(NotoSerif-ExtraBoldItalic-tosf-ts1--base.tfm) \
tex(NotoSerif-ExtraBoldItalic-tosf-ts1.tfm) \
tex(NotoSerif-ExtraBoldItalic-tosf-ts1.vf) \
tex(NotoSerif-ExtraLight-lf-lgr.tfm) \
tex(NotoSerif-ExtraLight-lf-ly1.tfm) \
tex(NotoSerif-ExtraLight-lf-ot1.tfm) \
tex(NotoSerif-ExtraLight-lf-sc-lgr.tfm) \
tex(NotoSerif-ExtraLight-lf-sc-ly1--base.tfm) \
tex(NotoSerif-ExtraLight-lf-sc-ly1.tfm) \
tex(NotoSerif-ExtraLight-lf-sc-ly1.vf) \
tex(NotoSerif-ExtraLight-lf-sc-ot1--base.tfm) \
tex(NotoSerif-ExtraLight-lf-sc-ot1.tfm) \
tex(NotoSerif-ExtraLight-lf-sc-ot1.vf) \
tex(NotoSerif-ExtraLight-lf-sc-t1--base.tfm) \
tex(NotoSerif-ExtraLight-lf-sc-t1.tfm) \
tex(NotoSerif-ExtraLight-lf-sc-t1.vf) \
tex(NotoSerif-ExtraLight-lf-sc-t2a--base.tfm) \
tex(NotoSerif-ExtraLight-lf-sc-t2a.tfm) \
tex(NotoSerif-ExtraLight-lf-sc-t2a.vf) \
tex(NotoSerif-ExtraLight-lf-sc-t2b--base.tfm) \
tex(NotoSerif-ExtraLight-lf-sc-t2b.tfm) \
tex(NotoSerif-ExtraLight-lf-sc-t2b.vf) \
tex(NotoSerif-ExtraLight-lf-sc-t2c--base.tfm) \
tex(NotoSerif-ExtraLight-lf-sc-t2c.tfm) \
tex(NotoSerif-ExtraLight-lf-sc-t2c.vf) \
tex(NotoSerif-ExtraLight-lf-t1--base.tfm) \
tex(NotoSerif-ExtraLight-lf-t1.tfm) \
tex(NotoSerif-ExtraLight-lf-t1.vf) \
tex(NotoSerif-ExtraLight-lf-t2a.tfm) \
tex(NotoSerif-ExtraLight-lf-t2b.tfm) \
tex(NotoSerif-ExtraLight-lf-t2c.tfm) \
tex(NotoSerif-ExtraLight-lf-ts1--base.tfm) \
tex(NotoSerif-ExtraLight-lf-ts1.tfm) \
tex(NotoSerif-ExtraLight-lf-ts1.vf) \
tex(NotoSerif-ExtraLight-osf-lgr.tfm) \
tex(NotoSerif-ExtraLight-osf-ly1.tfm) \
tex(NotoSerif-ExtraLight-osf-ot1.tfm) \
tex(NotoSerif-ExtraLight-osf-sc-lgr.tfm) \
tex(NotoSerif-ExtraLight-osf-sc-ly1--base.tfm) \
tex(NotoSerif-ExtraLight-osf-sc-ly1.tfm) \
tex(NotoSerif-ExtraLight-osf-sc-ly1.vf) \
tex(NotoSerif-ExtraLight-osf-sc-ot1--base.tfm) \
tex(NotoSerif-ExtraLight-osf-sc-ot1.tfm) \
tex(NotoSerif-ExtraLight-osf-sc-ot1.vf) \
tex(NotoSerif-ExtraLight-osf-sc-t1--base.tfm) \
tex(NotoSerif-ExtraLight-osf-sc-t1.tfm) \
tex(NotoSerif-ExtraLight-osf-sc-t1.vf) \
tex(NotoSerif-ExtraLight-osf-sc-t2a--base.tfm) \
tex(NotoSerif-ExtraLight-osf-sc-t2a.tfm) \
tex(NotoSerif-ExtraLight-osf-sc-t2a.vf) \
tex(NotoSerif-ExtraLight-osf-sc-t2b--base.tfm) \
tex(NotoSerif-ExtraLight-osf-sc-t2b.tfm) \
tex(NotoSerif-ExtraLight-osf-sc-t2b.vf) \
tex(NotoSerif-ExtraLight-osf-sc-t2c--base.tfm) \
tex(NotoSerif-ExtraLight-osf-sc-t2c.tfm) \
tex(NotoSerif-ExtraLight-osf-sc-t2c.vf) \
tex(NotoSerif-ExtraLight-osf-t1--base.tfm) \
tex(NotoSerif-ExtraLight-osf-t1.tfm) \
tex(NotoSerif-ExtraLight-osf-t1.vf) \
tex(NotoSerif-ExtraLight-osf-t2a.tfm) \
tex(NotoSerif-ExtraLight-osf-t2b.tfm) \
tex(NotoSerif-ExtraLight-osf-t2c.tfm) \
tex(NotoSerif-ExtraLight-osf-ts1--base.tfm) \
tex(NotoSerif-ExtraLight-osf-ts1.tfm) \
tex(NotoSerif-ExtraLight-osf-ts1.vf) \
tex(NotoSerif-ExtraLight-sup-lgr.tfm) \
tex(NotoSerif-ExtraLight-sup-ly1.tfm) \
tex(NotoSerif-ExtraLight-sup-ot1.tfm) \
tex(NotoSerif-ExtraLight-sup-t1--base.tfm) \
tex(NotoSerif-ExtraLight-sup-t1.tfm) \
tex(NotoSerif-ExtraLight-sup-t1.vf) \
tex(NotoSerif-ExtraLight-sup-t2a.tfm) \
tex(NotoSerif-ExtraLight-sup-t2b.tfm) \
tex(NotoSerif-ExtraLight-sup-t2c.tfm) \
tex(NotoSerif-ExtraLight-tlf-lgr.tfm) \
tex(NotoSerif-ExtraLight-tlf-ly1.tfm) \
tex(NotoSerif-ExtraLight-tlf-ot1.tfm) \
tex(NotoSerif-ExtraLight-tlf-sc-lgr.tfm) \
tex(NotoSerif-ExtraLight-tlf-sc-ly1--base.tfm) \
tex(NotoSerif-ExtraLight-tlf-sc-ly1.tfm) \
tex(NotoSerif-ExtraLight-tlf-sc-ly1.vf) \
tex(NotoSerif-ExtraLight-tlf-sc-ot1--base.tfm) \
tex(NotoSerif-ExtraLight-tlf-sc-ot1.tfm) \
tex(NotoSerif-ExtraLight-tlf-sc-ot1.vf) \
tex(NotoSerif-ExtraLight-tlf-sc-t1--base.tfm) \
tex(NotoSerif-ExtraLight-tlf-sc-t1.tfm) \
tex(NotoSerif-ExtraLight-tlf-sc-t1.vf) \
tex(NotoSerif-ExtraLight-tlf-sc-t2a--base.tfm) \
tex(NotoSerif-ExtraLight-tlf-sc-t2a.tfm) \
tex(NotoSerif-ExtraLight-tlf-sc-t2a.vf) \
tex(NotoSerif-ExtraLight-tlf-sc-t2b--base.tfm) \
tex(NotoSerif-ExtraLight-tlf-sc-t2b.tfm) \
tex(NotoSerif-ExtraLight-tlf-sc-t2b.vf) \
tex(NotoSerif-ExtraLight-tlf-sc-t2c--base.tfm) \
tex(NotoSerif-ExtraLight-tlf-sc-t2c.tfm) \
tex(NotoSerif-ExtraLight-tlf-sc-t2c.vf) \
tex(NotoSerif-ExtraLight-tlf-t1--base.tfm) \
tex(NotoSerif-ExtraLight-tlf-t1.tfm) \
tex(NotoSerif-ExtraLight-tlf-t1.vf) \
tex(NotoSerif-ExtraLight-tlf-t2a.tfm) \
tex(NotoSerif-ExtraLight-tlf-t2b.tfm) \
tex(NotoSerif-ExtraLight-tlf-t2c.tfm) \
tex(NotoSerif-ExtraLight-tlf-ts1--base.tfm) \
tex(NotoSerif-ExtraLight-tlf-ts1.tfm) \
tex(NotoSerif-ExtraLight-tlf-ts1.vf) \
tex(NotoSerif-ExtraLight-tosf-lgr.tfm) \
tex(NotoSerif-ExtraLight-tosf-ly1.tfm) \
tex(NotoSerif-ExtraLight-tosf-ot1.tfm) \
tex(NotoSerif-ExtraLight-tosf-sc-lgr.tfm) \
tex(NotoSerif-ExtraLight-tosf-sc-ly1--base.tfm) \
tex(NotoSerif-ExtraLight-tosf-sc-ly1.tfm) \
tex(NotoSerif-ExtraLight-tosf-sc-ly1.vf) \
tex(NotoSerif-ExtraLight-tosf-sc-ot1--base.tfm) \
tex(NotoSerif-ExtraLight-tosf-sc-ot1.tfm) \
tex(NotoSerif-ExtraLight-tosf-sc-ot1.vf) \
tex(NotoSerif-ExtraLight-tosf-sc-t1--base.tfm) \
tex(NotoSerif-ExtraLight-tosf-sc-t1.tfm) \
tex(NotoSerif-ExtraLight-tosf-sc-t1.vf) \
tex(NotoSerif-ExtraLight-tosf-sc-t2a--base.tfm) \
tex(NotoSerif-ExtraLight-tosf-sc-t2a.tfm) \
tex(NotoSerif-ExtraLight-tosf-sc-t2a.vf) \
tex(NotoSerif-ExtraLight-tosf-sc-t2b--base.tfm) \
tex(NotoSerif-ExtraLight-tosf-sc-t2b.tfm) \
tex(NotoSerif-ExtraLight-tosf-sc-t2b.vf) \
tex(NotoSerif-ExtraLight-tosf-sc-t2c--base.tfm) \
tex(NotoSerif-ExtraLight-tosf-sc-t2c.tfm) \
tex(NotoSerif-ExtraLight-tosf-sc-t2c.vf) \
tex(NotoSerif-ExtraLight-tosf-t1--base.tfm) \
tex(NotoSerif-ExtraLight-tosf-t1.tfm) \
tex(NotoSerif-ExtraLight-tosf-t1.vf) \
tex(NotoSerif-ExtraLight-tosf-t2a.tfm) \
tex(NotoSerif-ExtraLight-tosf-t2b.tfm) \
tex(NotoSerif-ExtraLight-tosf-t2c.tfm) \
tex(NotoSerif-ExtraLight-tosf-ts1--base.tfm) \
tex(NotoSerif-ExtraLight-tosf-ts1.tfm) \
tex(NotoSerif-ExtraLight-tosf-ts1.vf) \
tex(NotoSerif-ExtraLightItalic-lf-lgr.tfm) \
tex(NotoSerif-ExtraLightItalic-lf-ly1.tfm) \
tex(NotoSerif-ExtraLightItalic-lf-ot1.tfm) \
tex(NotoSerif-ExtraLightItalic-lf-sc-lgr.tfm) \
tex(NotoSerif-ExtraLightItalic-lf-sc-ly1--base.tfm) \
tex(NotoSerif-ExtraLightItalic-lf-sc-ly1.tfm) \
tex(NotoSerif-ExtraLightItalic-lf-sc-ly1.vf) \
tex(NotoSerif-ExtraLightItalic-lf-sc-ot1--base.tfm) \
tex(NotoSerif-ExtraLightItalic-lf-sc-ot1.tfm) \
tex(NotoSerif-ExtraLightItalic-lf-sc-ot1.vf) \
tex(NotoSerif-ExtraLightItalic-lf-sc-t1--base.tfm) \
tex(NotoSerif-ExtraLightItalic-lf-sc-t1.tfm) \
tex(NotoSerif-ExtraLightItalic-lf-sc-t1.vf) \
tex(NotoSerif-ExtraLightItalic-lf-sc-t2a--base.tfm) \
tex(NotoSerif-ExtraLightItalic-lf-sc-t2a.tfm) \
tex(NotoSerif-ExtraLightItalic-lf-sc-t2a.vf) \
tex(NotoSerif-ExtraLightItalic-lf-sc-t2b--base.tfm) \
tex(NotoSerif-ExtraLightItalic-lf-sc-t2b.tfm) \
tex(NotoSerif-ExtraLightItalic-lf-sc-t2b.vf) \
tex(NotoSerif-ExtraLightItalic-lf-sc-t2c--base.tfm) \
tex(NotoSerif-ExtraLightItalic-lf-sc-t2c.tfm) \
tex(NotoSerif-ExtraLightItalic-lf-sc-t2c.vf) \
tex(NotoSerif-ExtraLightItalic-lf-t1--base.tfm) \
tex(NotoSerif-ExtraLightItalic-lf-t1.tfm) \
tex(NotoSerif-ExtraLightItalic-lf-t1.vf) \
tex(NotoSerif-ExtraLightItalic-lf-t2a.tfm) \
tex(NotoSerif-ExtraLightItalic-lf-t2b.tfm) \
tex(NotoSerif-ExtraLightItalic-lf-t2c.tfm) \
tex(NotoSerif-ExtraLightItalic-lf-ts1--base.tfm) \
tex(NotoSerif-ExtraLightItalic-lf-ts1.tfm) \
tex(NotoSerif-ExtraLightItalic-lf-ts1.vf) \
tex(NotoSerif-ExtraLightItalic-osf-lgr.tfm) \
tex(NotoSerif-ExtraLightItalic-osf-ly1.tfm) \
tex(NotoSerif-ExtraLightItalic-osf-ot1.tfm) \
tex(NotoSerif-ExtraLightItalic-osf-sc-lgr.tfm) \
tex(NotoSerif-ExtraLightItalic-osf-sc-ly1--base.tfm) \
tex(NotoSerif-ExtraLightItalic-osf-sc-ly1.tfm) \
tex(NotoSerif-ExtraLightItalic-osf-sc-ly1.vf) \
tex(NotoSerif-ExtraLightItalic-osf-sc-ot1--base.tfm) \
tex(NotoSerif-ExtraLightItalic-osf-sc-ot1.tfm) \
tex(NotoSerif-ExtraLightItalic-osf-sc-ot1.vf) \
tex(NotoSerif-ExtraLightItalic-osf-sc-t1--base.tfm) \
tex(NotoSerif-ExtraLightItalic-osf-sc-t1.tfm) \
tex(NotoSerif-ExtraLightItalic-osf-sc-t1.vf) \
tex(NotoSerif-ExtraLightItalic-osf-sc-t2a--base.tfm) \
tex(NotoSerif-ExtraLightItalic-osf-sc-t2a.tfm) \
tex(NotoSerif-ExtraLightItalic-osf-sc-t2a.vf) \
tex(NotoSerif-ExtraLightItalic-osf-sc-t2b--base.tfm) \
tex(NotoSerif-ExtraLightItalic-osf-sc-t2b.tfm) \
tex(NotoSerif-ExtraLightItalic-osf-sc-t2b.vf) \
tex(NotoSerif-ExtraLightItalic-osf-sc-t2c--base.tfm) \
tex(NotoSerif-ExtraLightItalic-osf-sc-t2c.tfm) \
tex(NotoSerif-ExtraLightItalic-osf-sc-t2c.vf) \
tex(NotoSerif-ExtraLightItalic-osf-t1--base.tfm) \
tex(NotoSerif-ExtraLightItalic-osf-t1.tfm) \
tex(NotoSerif-ExtraLightItalic-osf-t1.vf) \
tex(NotoSerif-ExtraLightItalic-osf-t2a.tfm) \
tex(NotoSerif-ExtraLightItalic-osf-t2b.tfm) \
tex(NotoSerif-ExtraLightItalic-osf-t2c.tfm) \
tex(NotoSerif-ExtraLightItalic-osf-ts1--base.tfm) \
tex(NotoSerif-ExtraLightItalic-osf-ts1.tfm) \
tex(NotoSerif-ExtraLightItalic-osf-ts1.vf) \
tex(NotoSerif-ExtraLightItalic-sup-lgr.tfm) \
tex(NotoSerif-ExtraLightItalic-sup-ly1.tfm) \
tex(NotoSerif-ExtraLightItalic-sup-ot1.tfm) \
tex(NotoSerif-ExtraLightItalic-sup-t1--base.tfm) \
tex(NotoSerif-ExtraLightItalic-sup-t1.tfm) \
tex(NotoSerif-ExtraLightItalic-sup-t1.vf) \
tex(NotoSerif-ExtraLightItalic-sup-t2a.tfm) \
tex(NotoSerif-ExtraLightItalic-sup-t2b.tfm) \
tex(NotoSerif-ExtraLightItalic-sup-t2c.tfm) \
tex(NotoSerif-ExtraLightItalic-tlf-lgr.tfm) \
tex(NotoSerif-ExtraLightItalic-tlf-ly1.tfm) \
tex(NotoSerif-ExtraLightItalic-tlf-ot1.tfm) \
tex(NotoSerif-ExtraLightItalic-tlf-sc-lgr.tfm) \
tex(NotoSerif-ExtraLightItalic-tlf-sc-ly1--base.tfm) \
tex(NotoSerif-ExtraLightItalic-tlf-sc-ly1.tfm) \
tex(NotoSerif-ExtraLightItalic-tlf-sc-ly1.vf) \
tex(NotoSerif-ExtraLightItalic-tlf-sc-ot1--base.tfm) \
tex(NotoSerif-ExtraLightItalic-tlf-sc-ot1.tfm) \
tex(NotoSerif-ExtraLightItalic-tlf-sc-ot1.vf) \
tex(NotoSerif-ExtraLightItalic-tlf-sc-t1--base.tfm) \
tex(NotoSerif-ExtraLightItalic-tlf-sc-t1.tfm) \
tex(NotoSerif-ExtraLightItalic-tlf-sc-t1.vf) \
tex(NotoSerif-ExtraLightItalic-tlf-sc-t2a--base.tfm) \
tex(NotoSerif-ExtraLightItalic-tlf-sc-t2a.tfm) \
tex(NotoSerif-ExtraLightItalic-tlf-sc-t2a.vf) \
tex(NotoSerif-ExtraLightItalic-tlf-sc-t2b--base.tfm) \
tex(NotoSerif-ExtraLightItalic-tlf-sc-t2b.tfm) \
tex(NotoSerif-ExtraLightItalic-tlf-sc-t2b.vf) \
tex(NotoSerif-ExtraLightItalic-tlf-sc-t2c--base.tfm) \
tex(NotoSerif-ExtraLightItalic-tlf-sc-t2c.tfm) \
tex(NotoSerif-ExtraLightItalic-tlf-sc-t2c.vf) \
tex(NotoSerif-ExtraLightItalic-tlf-t1--base.tfm) \
tex(NotoSerif-ExtraLightItalic-tlf-t1.tfm) \
tex(NotoSerif-ExtraLightItalic-tlf-t1.vf) \
tex(NotoSerif-ExtraLightItalic-tlf-t2a.tfm) \
tex(NotoSerif-ExtraLightItalic-tlf-t2b.tfm) \
tex(NotoSerif-ExtraLightItalic-tlf-t2c.tfm) \
tex(NotoSerif-ExtraLightItalic-tlf-ts1--base.tfm) \
tex(NotoSerif-ExtraLightItalic-tlf-ts1.tfm) \
tex(NotoSerif-ExtraLightItalic-tlf-ts1.vf) \
tex(NotoSerif-ExtraLightItalic-tosf-lgr.tfm) \
tex(NotoSerif-ExtraLightItalic-tosf-ly1.tfm) \
tex(NotoSerif-ExtraLightItalic-tosf-ot1.tfm) \
tex(NotoSerif-ExtraLightItalic-tosf-sc-lgr.tfm) \
tex(NotoSerif-ExtraLightItalic-tosf-sc-ly1--base.tfm) \
tex(NotoSerif-ExtraLightItalic-tosf-sc-ly1.tfm) \
tex(NotoSerif-ExtraLightItalic-tosf-sc-ly1.vf) \
tex(NotoSerif-ExtraLightItalic-tosf-sc-ot1--base.tfm) \
tex(NotoSerif-ExtraLightItalic-tosf-sc-ot1.tfm) \
tex(NotoSerif-ExtraLightItalic-tosf-sc-ot1.vf) \
tex(NotoSerif-ExtraLightItalic-tosf-sc-t1--base.tfm) \
tex(NotoSerif-ExtraLightItalic-tosf-sc-t1.tfm) \
tex(NotoSerif-ExtraLightItalic-tosf-sc-t1.vf) \
tex(NotoSerif-ExtraLightItalic-tosf-sc-t2a--base.tfm) \
tex(NotoSerif-ExtraLightItalic-tosf-sc-t2a.tfm) \
tex(NotoSerif-ExtraLightItalic-tosf-sc-t2a.vf) \
tex(NotoSerif-ExtraLightItalic-tosf-sc-t2b--base.tfm) \
tex(NotoSerif-ExtraLightItalic-tosf-sc-t2b.tfm) \
tex(NotoSerif-ExtraLightItalic-tosf-sc-t2b.vf) \
tex(NotoSerif-ExtraLightItalic-tosf-sc-t2c--base.tfm) \
tex(NotoSerif-ExtraLightItalic-tosf-sc-t2c.tfm) \
tex(NotoSerif-ExtraLightItalic-tosf-sc-t2c.vf) \
tex(NotoSerif-ExtraLightItalic-tosf-t1--base.tfm) \
tex(NotoSerif-ExtraLightItalic-tosf-t1.tfm) \
tex(NotoSerif-ExtraLightItalic-tosf-t1.vf) \
tex(NotoSerif-ExtraLightItalic-tosf-t2a.tfm) \
tex(NotoSerif-ExtraLightItalic-tosf-t2b.tfm) \
tex(NotoSerif-ExtraLightItalic-tosf-t2c.tfm) \
tex(NotoSerif-ExtraLightItalic-tosf-ts1--base.tfm) \
tex(NotoSerif-ExtraLightItalic-tosf-ts1.tfm) \
tex(NotoSerif-ExtraLightItalic-tosf-ts1.vf) \
tex(NotoSerif-Italic-lf-lgr.tfm) \
tex(NotoSerif-Italic-lf-ly1.tfm) \
tex(NotoSerif-Italic-lf-ot1.tfm) \
tex(NotoSerif-Italic-lf-sc-lgr.tfm) \
tex(NotoSerif-Italic-lf-sc-ly1--base.tfm) \
tex(NotoSerif-Italic-lf-sc-ly1.tfm) \
tex(NotoSerif-Italic-lf-sc-ly1.vf) \
tex(NotoSerif-Italic-lf-sc-ot1--base.tfm) \
tex(NotoSerif-Italic-lf-sc-ot1.tfm) \
tex(NotoSerif-Italic-lf-sc-ot1.vf) \
tex(NotoSerif-Italic-lf-sc-t1--base.tfm) \
tex(NotoSerif-Italic-lf-sc-t1.tfm) \
tex(NotoSerif-Italic-lf-sc-t1.vf) \
tex(NotoSerif-Italic-lf-sc-t2a--base.tfm) \
tex(NotoSerif-Italic-lf-sc-t2a.tfm) \
tex(NotoSerif-Italic-lf-sc-t2a.vf) \
tex(NotoSerif-Italic-lf-sc-t2b--base.tfm) \
tex(NotoSerif-Italic-lf-sc-t2b.tfm) \
tex(NotoSerif-Italic-lf-sc-t2b.vf) \
tex(NotoSerif-Italic-lf-sc-t2c--base.tfm) \
tex(NotoSerif-Italic-lf-sc-t2c.tfm) \
tex(NotoSerif-Italic-lf-sc-t2c.vf) \
tex(NotoSerif-Italic-lf-t1--base.tfm) \
tex(NotoSerif-Italic-lf-t1.tfm) \
tex(NotoSerif-Italic-lf-t1.vf) \
tex(NotoSerif-Italic-lf-t2a.tfm) \
tex(NotoSerif-Italic-lf-t2b.tfm) \
tex(NotoSerif-Italic-lf-t2c.tfm) \
tex(NotoSerif-Italic-lf-ts1--base.tfm) \
tex(NotoSerif-Italic-lf-ts1.tfm) \
tex(NotoSerif-Italic-lf-ts1.vf) \
tex(NotoSerif-Italic-osf-lgr.tfm) \
tex(NotoSerif-Italic-osf-ly1.tfm) \
tex(NotoSerif-Italic-osf-ot1.tfm) \
tex(NotoSerif-Italic-osf-sc-lgr.tfm) \
tex(NotoSerif-Italic-osf-sc-ly1--base.tfm) \
tex(NotoSerif-Italic-osf-sc-ly1.tfm) \
tex(NotoSerif-Italic-osf-sc-ly1.vf) \
tex(NotoSerif-Italic-osf-sc-ot1--base.tfm) \
tex(NotoSerif-Italic-osf-sc-ot1.tfm) \
tex(NotoSerif-Italic-osf-sc-ot1.vf) \
tex(NotoSerif-Italic-osf-sc-t1--base.tfm) \
tex(NotoSerif-Italic-osf-sc-t1.tfm) \
tex(NotoSerif-Italic-osf-sc-t1.vf) \
tex(NotoSerif-Italic-osf-sc-t2a--base.tfm) \
tex(NotoSerif-Italic-osf-sc-t2a.tfm) \
tex(NotoSerif-Italic-osf-sc-t2a.vf) \
tex(NotoSerif-Italic-osf-sc-t2b--base.tfm) \
tex(NotoSerif-Italic-osf-sc-t2b.tfm) \
tex(NotoSerif-Italic-osf-sc-t2b.vf) \
tex(NotoSerif-Italic-osf-sc-t2c--base.tfm) \
tex(NotoSerif-Italic-osf-sc-t2c.tfm) \
tex(NotoSerif-Italic-osf-sc-t2c.vf) \
tex(NotoSerif-Italic-osf-t1--base.tfm) \
tex(NotoSerif-Italic-osf-t1.tfm) \
tex(NotoSerif-Italic-osf-t1.vf) \
tex(NotoSerif-Italic-osf-t2a.tfm) \
tex(NotoSerif-Italic-osf-t2b.tfm) \
tex(NotoSerif-Italic-osf-t2c.tfm) \
tex(NotoSerif-Italic-osf-ts1--base.tfm) \
tex(NotoSerif-Italic-osf-ts1.tfm) \
tex(NotoSerif-Italic-osf-ts1.vf) \
tex(NotoSerif-Italic-sup-lgr.tfm) \
tex(NotoSerif-Italic-sup-ly1.tfm) \
tex(NotoSerif-Italic-sup-ot1.tfm) \
tex(NotoSerif-Italic-sup-t1--base.tfm) \
tex(NotoSerif-Italic-sup-t1.tfm) \
tex(NotoSerif-Italic-sup-t1.vf) \
tex(NotoSerif-Italic-sup-t2a.tfm) \
tex(NotoSerif-Italic-sup-t2b.tfm) \
tex(NotoSerif-Italic-sup-t2c.tfm) \
tex(NotoSerif-Italic-tlf-lgr.tfm) \
tex(NotoSerif-Italic-tlf-ly1.tfm) \
tex(NotoSerif-Italic-tlf-ot1.tfm) \
tex(NotoSerif-Italic-tlf-sc-lgr.tfm) \
tex(NotoSerif-Italic-tlf-sc-ly1--base.tfm) \
tex(NotoSerif-Italic-tlf-sc-ly1.tfm) \
tex(NotoSerif-Italic-tlf-sc-ly1.vf) \
tex(NotoSerif-Italic-tlf-sc-ot1--base.tfm) \
tex(NotoSerif-Italic-tlf-sc-ot1.tfm) \
tex(NotoSerif-Italic-tlf-sc-ot1.vf) \
tex(NotoSerif-Italic-tlf-sc-t1--base.tfm) \
tex(NotoSerif-Italic-tlf-sc-t1.tfm) \
tex(NotoSerif-Italic-tlf-sc-t1.vf) \
tex(NotoSerif-Italic-tlf-sc-t2a--base.tfm) \
tex(NotoSerif-Italic-tlf-sc-t2a.tfm) \
tex(NotoSerif-Italic-tlf-sc-t2a.vf) \
tex(NotoSerif-Italic-tlf-sc-t2b--base.tfm) \
tex(NotoSerif-Italic-tlf-sc-t2b.tfm) \
tex(NotoSerif-Italic-tlf-sc-t2b.vf) \
tex(NotoSerif-Italic-tlf-sc-t2c--base.tfm) \
tex(NotoSerif-Italic-tlf-sc-t2c.tfm) \
tex(NotoSerif-Italic-tlf-sc-t2c.vf) \
tex(NotoSerif-Italic-tlf-t1--base.tfm) \
tex(NotoSerif-Italic-tlf-t1.tfm) \
tex(NotoSerif-Italic-tlf-t1.vf) \
tex(NotoSerif-Italic-tlf-t2a.tfm) \
tex(NotoSerif-Italic-tlf-t2b.tfm) \
tex(NotoSerif-Italic-tlf-t2c.tfm) \
tex(NotoSerif-Italic-tlf-ts1--base.tfm) \
tex(NotoSerif-Italic-tlf-ts1.tfm) \
tex(NotoSerif-Italic-tlf-ts1.vf) \
tex(NotoSerif-Italic-tosf-lgr.tfm) \
tex(NotoSerif-Italic-tosf-ly1.tfm) \
tex(NotoSerif-Italic-tosf-ot1.tfm) \
tex(NotoSerif-Italic-tosf-sc-lgr.tfm) \
tex(NotoSerif-Italic-tosf-sc-ly1--base.tfm) \
tex(NotoSerif-Italic-tosf-sc-ly1.tfm) \
tex(NotoSerif-Italic-tosf-sc-ly1.vf) \
tex(NotoSerif-Italic-tosf-sc-ot1--base.tfm) \
tex(NotoSerif-Italic-tosf-sc-ot1.tfm) \
tex(NotoSerif-Italic-tosf-sc-ot1.vf) \
tex(NotoSerif-Italic-tosf-sc-t1--base.tfm) \
tex(NotoSerif-Italic-tosf-sc-t1.tfm) \
tex(NotoSerif-Italic-tosf-sc-t1.vf) \
tex(NotoSerif-Italic-tosf-sc-t2a--base.tfm) \
tex(NotoSerif-Italic-tosf-sc-t2a.tfm) \
tex(NotoSerif-Italic-tosf-sc-t2a.vf) \
tex(NotoSerif-Italic-tosf-sc-t2b--base.tfm) \
tex(NotoSerif-Italic-tosf-sc-t2b.tfm) \
tex(NotoSerif-Italic-tosf-sc-t2b.vf) \
tex(NotoSerif-Italic-tosf-sc-t2c--base.tfm) \
tex(NotoSerif-Italic-tosf-sc-t2c.tfm) \
tex(NotoSerif-Italic-tosf-sc-t2c.vf) \
tex(NotoSerif-Italic-tosf-t1--base.tfm) \
tex(NotoSerif-Italic-tosf-t1.tfm) \
tex(NotoSerif-Italic-tosf-t1.vf) \
tex(NotoSerif-Italic-tosf-t2a.tfm) \
tex(NotoSerif-Italic-tosf-t2b.tfm) \
tex(NotoSerif-Italic-tosf-t2c.tfm) \
tex(NotoSerif-Italic-tosf-ts1--base.tfm) \
tex(NotoSerif-Italic-tosf-ts1.tfm) \
tex(NotoSerif-Italic-tosf-ts1.vf) \
tex(NotoSerif-Light-lf-lgr.tfm) \
tex(NotoSerif-Light-lf-ly1.tfm) \
tex(NotoSerif-Light-lf-ot1.tfm) \
tex(NotoSerif-Light-lf-sc-lgr.tfm) \
tex(NotoSerif-Light-lf-sc-ly1--base.tfm) \
tex(NotoSerif-Light-lf-sc-ly1.tfm) \
tex(NotoSerif-Light-lf-sc-ly1.vf) \
tex(NotoSerif-Light-lf-sc-ot1--base.tfm) \
tex(NotoSerif-Light-lf-sc-ot1.tfm) \
tex(NotoSerif-Light-lf-sc-ot1.vf) \
tex(NotoSerif-Light-lf-sc-t1--base.tfm) \
tex(NotoSerif-Light-lf-sc-t1.tfm) \
tex(NotoSerif-Light-lf-sc-t1.vf) \
tex(NotoSerif-Light-lf-sc-t2a--base.tfm) \
tex(NotoSerif-Light-lf-sc-t2a.tfm) \
tex(NotoSerif-Light-lf-sc-t2a.vf) \
tex(NotoSerif-Light-lf-sc-t2b--base.tfm) \
tex(NotoSerif-Light-lf-sc-t2b.tfm) \
tex(NotoSerif-Light-lf-sc-t2b.vf) \
tex(NotoSerif-Light-lf-sc-t2c--base.tfm) \
tex(NotoSerif-Light-lf-sc-t2c.tfm) \
tex(NotoSerif-Light-lf-sc-t2c.vf) \
tex(NotoSerif-Light-lf-t1--base.tfm) \
tex(NotoSerif-Light-lf-t1.tfm) \
tex(NotoSerif-Light-lf-t1.vf) \
tex(NotoSerif-Light-lf-t2a.tfm) \
tex(NotoSerif-Light-lf-t2b.tfm) \
tex(NotoSerif-Light-lf-t2c.tfm) \
tex(NotoSerif-Light-lf-ts1--base.tfm) \
tex(NotoSerif-Light-lf-ts1.tfm) \
tex(NotoSerif-Light-lf-ts1.vf) \
tex(NotoSerif-Light-osf-lgr.tfm) \
tex(NotoSerif-Light-osf-ly1.tfm) \
tex(NotoSerif-Light-osf-ot1.tfm) \
tex(NotoSerif-Light-osf-sc-lgr.tfm) \
tex(NotoSerif-Light-osf-sc-ly1--base.tfm) \
tex(NotoSerif-Light-osf-sc-ly1.tfm) \
tex(NotoSerif-Light-osf-sc-ly1.vf) \
tex(NotoSerif-Light-osf-sc-ot1--base.tfm) \
tex(NotoSerif-Light-osf-sc-ot1.tfm) \
tex(NotoSerif-Light-osf-sc-ot1.vf) \
tex(NotoSerif-Light-osf-sc-t1--base.tfm) \
tex(NotoSerif-Light-osf-sc-t1.tfm) \
tex(NotoSerif-Light-osf-sc-t1.vf) \
tex(NotoSerif-Light-osf-sc-t2a--base.tfm) \
tex(NotoSerif-Light-osf-sc-t2a.tfm) \
tex(NotoSerif-Light-osf-sc-t2a.vf) \
tex(NotoSerif-Light-osf-sc-t2b--base.tfm) \
tex(NotoSerif-Light-osf-sc-t2b.tfm) \
tex(NotoSerif-Light-osf-sc-t2b.vf) \
tex(NotoSerif-Light-osf-sc-t2c--base.tfm) \
tex(NotoSerif-Light-osf-sc-t2c.tfm) \
tex(NotoSerif-Light-osf-sc-t2c.vf) \
tex(NotoSerif-Light-osf-t1--base.tfm) \
tex(NotoSerif-Light-osf-t1.tfm) \
tex(NotoSerif-Light-osf-t1.vf) \
tex(NotoSerif-Light-osf-t2a.tfm) \
tex(NotoSerif-Light-osf-t2b.tfm) \
tex(NotoSerif-Light-osf-t2c.tfm) \
tex(NotoSerif-Light-osf-ts1--base.tfm) \
tex(NotoSerif-Light-osf-ts1.tfm) \
tex(NotoSerif-Light-osf-ts1.vf) \
tex(NotoSerif-Light-sup-lgr.tfm) \
tex(NotoSerif-Light-sup-ly1.tfm) \
tex(NotoSerif-Light-sup-ot1.tfm) \
tex(NotoSerif-Light-sup-t1--base.tfm) \
tex(NotoSerif-Light-sup-t1.tfm) \
tex(NotoSerif-Light-sup-t1.vf) \
tex(NotoSerif-Light-sup-t2a.tfm) \
tex(NotoSerif-Light-sup-t2b.tfm) \
tex(NotoSerif-Light-sup-t2c.tfm) \
tex(NotoSerif-Light-tlf-lgr.tfm) \
tex(NotoSerif-Light-tlf-ly1.tfm) \
tex(NotoSerif-Light-tlf-ot1.tfm) \
tex(NotoSerif-Light-tlf-sc-lgr.tfm) \
tex(NotoSerif-Light-tlf-sc-ly1--base.tfm) \
tex(NotoSerif-Light-tlf-sc-ly1.tfm) \
tex(NotoSerif-Light-tlf-sc-ly1.vf) \
tex(NotoSerif-Light-tlf-sc-ot1--base.tfm) \
tex(NotoSerif-Light-tlf-sc-ot1.tfm) \
tex(NotoSerif-Light-tlf-sc-ot1.vf) \
tex(NotoSerif-Light-tlf-sc-t1--base.tfm) \
tex(NotoSerif-Light-tlf-sc-t1.tfm) \
tex(NotoSerif-Light-tlf-sc-t1.vf) \
tex(NotoSerif-Light-tlf-sc-t2a--base.tfm) \
tex(NotoSerif-Light-tlf-sc-t2a.tfm) \
tex(NotoSerif-Light-tlf-sc-t2a.vf) \
tex(NotoSerif-Light-tlf-sc-t2b--base.tfm) \
tex(NotoSerif-Light-tlf-sc-t2b.tfm) \
tex(NotoSerif-Light-tlf-sc-t2b.vf) \
tex(NotoSerif-Light-tlf-sc-t2c--base.tfm) \
tex(NotoSerif-Light-tlf-sc-t2c.tfm) \
tex(NotoSerif-Light-tlf-sc-t2c.vf) \
tex(NotoSerif-Light-tlf-t1--base.tfm) \
tex(NotoSerif-Light-tlf-t1.tfm) \
tex(NotoSerif-Light-tlf-t1.vf) \
tex(NotoSerif-Light-tlf-t2a.tfm) \
tex(NotoSerif-Light-tlf-t2b.tfm) \
tex(NotoSerif-Light-tlf-t2c.tfm) \
tex(NotoSerif-Light-tlf-ts1--base.tfm) \
tex(NotoSerif-Light-tlf-ts1.tfm) \
tex(NotoSerif-Light-tlf-ts1.vf) \
tex(NotoSerif-Light-tosf-lgr.tfm) \
tex(NotoSerif-Light-tosf-ly1.tfm) \
tex(NotoSerif-Light-tosf-ot1.tfm) \
tex(NotoSerif-Light-tosf-sc-lgr.tfm) \
tex(NotoSerif-Light-tosf-sc-ly1--base.tfm) \
tex(NotoSerif-Light-tosf-sc-ly1.tfm) \
tex(NotoSerif-Light-tosf-sc-ly1.vf) \
tex(NotoSerif-Light-tosf-sc-ot1--base.tfm) \
tex(NotoSerif-Light-tosf-sc-ot1.tfm) \
tex(NotoSerif-Light-tosf-sc-ot1.vf) \
tex(NotoSerif-Light-tosf-sc-t1--base.tfm) \
tex(NotoSerif-Light-tosf-sc-t1.tfm) \
tex(NotoSerif-Light-tosf-sc-t1.vf) \
tex(NotoSerif-Light-tosf-sc-t2a--base.tfm) \
tex(NotoSerif-Light-tosf-sc-t2a.tfm) \
tex(NotoSerif-Light-tosf-sc-t2a.vf) \
tex(NotoSerif-Light-tosf-sc-t2b--base.tfm) \
tex(NotoSerif-Light-tosf-sc-t2b.tfm) \
tex(NotoSerif-Light-tosf-sc-t2b.vf) \
tex(NotoSerif-Light-tosf-sc-t2c--base.tfm) \
tex(NotoSerif-Light-tosf-sc-t2c.tfm) \
tex(NotoSerif-Light-tosf-sc-t2c.vf) \
tex(NotoSerif-Light-tosf-t1--base.tfm) \
tex(NotoSerif-Light-tosf-t1.tfm) \
tex(NotoSerif-Light-tosf-t1.vf) \
tex(NotoSerif-Light-tosf-t2a.tfm) \
tex(NotoSerif-Light-tosf-t2b.tfm) \
tex(NotoSerif-Light-tosf-t2c.tfm) \
tex(NotoSerif-Light-tosf-ts1--base.tfm) \
tex(NotoSerif-Light-tosf-ts1.tfm) \
tex(NotoSerif-Light-tosf-ts1.vf) \
tex(NotoSerif-LightItalic-lf-lgr.tfm) \
tex(NotoSerif-LightItalic-lf-ly1.tfm) \
tex(NotoSerif-LightItalic-lf-ot1.tfm) \
tex(NotoSerif-LightItalic-lf-sc-lgr.tfm) \
tex(NotoSerif-LightItalic-lf-sc-ly1--base.tfm) \
tex(NotoSerif-LightItalic-lf-sc-ly1.tfm) \
tex(NotoSerif-LightItalic-lf-sc-ly1.vf) \
tex(NotoSerif-LightItalic-lf-sc-ot1--base.tfm) \
tex(NotoSerif-LightItalic-lf-sc-ot1.tfm) \
tex(NotoSerif-LightItalic-lf-sc-ot1.vf) \
tex(NotoSerif-LightItalic-lf-sc-t1--base.tfm) \
tex(NotoSerif-LightItalic-lf-sc-t1.tfm) \
tex(NotoSerif-LightItalic-lf-sc-t1.vf) \
tex(NotoSerif-LightItalic-lf-sc-t2a--base.tfm) \
tex(NotoSerif-LightItalic-lf-sc-t2a.tfm) \
tex(NotoSerif-LightItalic-lf-sc-t2a.vf) \
tex(NotoSerif-LightItalic-lf-sc-t2b--base.tfm) \
tex(NotoSerif-LightItalic-lf-sc-t2b.tfm) \
tex(NotoSerif-LightItalic-lf-sc-t2b.vf) \
tex(NotoSerif-LightItalic-lf-sc-t2c--base.tfm) \
tex(NotoSerif-LightItalic-lf-sc-t2c.tfm) \
tex(NotoSerif-LightItalic-lf-sc-t2c.vf) \
tex(NotoSerif-LightItalic-lf-t1--base.tfm) \
tex(NotoSerif-LightItalic-lf-t1.tfm) \
tex(NotoSerif-LightItalic-lf-t1.vf) \
tex(NotoSerif-LightItalic-lf-t2a.tfm) \
tex(NotoSerif-LightItalic-lf-t2b.tfm) \
tex(NotoSerif-LightItalic-lf-t2c.tfm) \
tex(NotoSerif-LightItalic-lf-ts1--base.tfm) \
tex(NotoSerif-LightItalic-lf-ts1.tfm) \
tex(NotoSerif-LightItalic-lf-ts1.vf) \
tex(NotoSerif-LightItalic-osf-lgr.tfm) \
tex(NotoSerif-LightItalic-osf-ly1.tfm) \
tex(NotoSerif-LightItalic-osf-ot1.tfm) \
tex(NotoSerif-LightItalic-osf-sc-lgr.tfm) \
tex(NotoSerif-LightItalic-osf-sc-ly1--base.tfm) \
tex(NotoSerif-LightItalic-osf-sc-ly1.tfm) \
tex(NotoSerif-LightItalic-osf-sc-ly1.vf) \
tex(NotoSerif-LightItalic-osf-sc-ot1--base.tfm) \
tex(NotoSerif-LightItalic-osf-sc-ot1.tfm) \
tex(NotoSerif-LightItalic-osf-sc-ot1.vf) \
tex(NotoSerif-LightItalic-osf-sc-t1--base.tfm) \
tex(NotoSerif-LightItalic-osf-sc-t1.tfm) \
tex(NotoSerif-LightItalic-osf-sc-t1.vf) \
tex(NotoSerif-LightItalic-osf-sc-t2a--base.tfm) \
tex(NotoSerif-LightItalic-osf-sc-t2a.tfm) \
tex(NotoSerif-LightItalic-osf-sc-t2a.vf) \
tex(NotoSerif-LightItalic-osf-sc-t2b--base.tfm) \
tex(NotoSerif-LightItalic-osf-sc-t2b.tfm) \
tex(NotoSerif-LightItalic-osf-sc-t2b.vf) \
tex(NotoSerif-LightItalic-osf-sc-t2c--base.tfm) \
tex(NotoSerif-LightItalic-osf-sc-t2c.tfm) \
tex(NotoSerif-LightItalic-osf-sc-t2c.vf) \
tex(NotoSerif-LightItalic-osf-t1--base.tfm) \
tex(NotoSerif-LightItalic-osf-t1.tfm) \
tex(NotoSerif-LightItalic-osf-t1.vf) \
tex(NotoSerif-LightItalic-osf-t2a.tfm) \
tex(NotoSerif-LightItalic-osf-t2b.tfm) \
tex(NotoSerif-LightItalic-osf-t2c.tfm) \
tex(NotoSerif-LightItalic-osf-ts1--base.tfm) \
tex(NotoSerif-LightItalic-osf-ts1.tfm) \
tex(NotoSerif-LightItalic-osf-ts1.vf) \
tex(NotoSerif-LightItalic-sup-lgr.tfm) \
tex(NotoSerif-LightItalic-sup-ly1.tfm) \
tex(NotoSerif-LightItalic-sup-ot1.tfm) \
tex(NotoSerif-LightItalic-sup-t1--base.tfm) \
tex(NotoSerif-LightItalic-sup-t1.tfm) \
tex(NotoSerif-LightItalic-sup-t1.vf) \
tex(NotoSerif-LightItalic-sup-t2a.tfm) \
tex(NotoSerif-LightItalic-sup-t2b.tfm) \
tex(NotoSerif-LightItalic-sup-t2c.tfm) \
tex(NotoSerif-LightItalic-tlf-lgr.tfm) \
tex(NotoSerif-LightItalic-tlf-ly1.tfm) \
tex(NotoSerif-LightItalic-tlf-ot1.tfm) \
tex(NotoSerif-LightItalic-tlf-sc-lgr.tfm) \
tex(NotoSerif-LightItalic-tlf-sc-ly1--base.tfm) \
tex(NotoSerif-LightItalic-tlf-sc-ly1.tfm) \
tex(NotoSerif-LightItalic-tlf-sc-ly1.vf) \
tex(NotoSerif-LightItalic-tlf-sc-ot1--base.tfm) \
tex(NotoSerif-LightItalic-tlf-sc-ot1.tfm) \
tex(NotoSerif-LightItalic-tlf-sc-ot1.vf) \
tex(NotoSerif-LightItalic-tlf-sc-t1--base.tfm) \
tex(NotoSerif-LightItalic-tlf-sc-t1.tfm) \
tex(NotoSerif-LightItalic-tlf-sc-t1.vf) \
tex(NotoSerif-LightItalic-tlf-sc-t2a--base.tfm) \
tex(NotoSerif-LightItalic-tlf-sc-t2a.tfm) \
tex(NotoSerif-LightItalic-tlf-sc-t2a.vf) \
tex(NotoSerif-LightItalic-tlf-sc-t2b--base.tfm) \
tex(NotoSerif-LightItalic-tlf-sc-t2b.tfm) \
tex(NotoSerif-LightItalic-tlf-sc-t2b.vf) \
tex(NotoSerif-LightItalic-tlf-sc-t2c--base.tfm) \
tex(NotoSerif-LightItalic-tlf-sc-t2c.tfm) \
tex(NotoSerif-LightItalic-tlf-sc-t2c.vf) \
tex(NotoSerif-LightItalic-tlf-t1--base.tfm) \
tex(NotoSerif-LightItalic-tlf-t1.tfm) \
tex(NotoSerif-LightItalic-tlf-t1.vf) \
tex(NotoSerif-LightItalic-tlf-t2a.tfm) \
tex(NotoSerif-LightItalic-tlf-t2b.tfm) \
tex(NotoSerif-LightItalic-tlf-t2c.tfm) \
tex(NotoSerif-LightItalic-tlf-ts1--base.tfm) \
tex(NotoSerif-LightItalic-tlf-ts1.tfm) \
tex(NotoSerif-LightItalic-tlf-ts1.vf) \
tex(NotoSerif-LightItalic-tosf-lgr.tfm) \
tex(NotoSerif-LightItalic-tosf-ly1.tfm) \
tex(NotoSerif-LightItalic-tosf-ot1.tfm) \
tex(NotoSerif-LightItalic-tosf-sc-lgr.tfm) \
tex(NotoSerif-LightItalic-tosf-sc-ly1--base.tfm) \
tex(NotoSerif-LightItalic-tosf-sc-ly1.tfm) \
tex(NotoSerif-LightItalic-tosf-sc-ly1.vf) \
tex(NotoSerif-LightItalic-tosf-sc-ot1--base.tfm) \
tex(NotoSerif-LightItalic-tosf-sc-ot1.tfm) \
tex(NotoSerif-LightItalic-tosf-sc-ot1.vf) \
tex(NotoSerif-LightItalic-tosf-sc-t1--base.tfm) \
tex(NotoSerif-LightItalic-tosf-sc-t1.tfm) \
tex(NotoSerif-LightItalic-tosf-sc-t1.vf) \
tex(NotoSerif-LightItalic-tosf-sc-t2a--base.tfm) \
tex(NotoSerif-LightItalic-tosf-sc-t2a.tfm) \
tex(NotoSerif-LightItalic-tosf-sc-t2a.vf) \
tex(NotoSerif-LightItalic-tosf-sc-t2b--base.tfm) \
tex(NotoSerif-LightItalic-tosf-sc-t2b.tfm) \
tex(NotoSerif-LightItalic-tosf-sc-t2b.vf) \
tex(NotoSerif-LightItalic-tosf-sc-t2c--base.tfm) \
tex(NotoSerif-LightItalic-tosf-sc-t2c.tfm) \
tex(NotoSerif-LightItalic-tosf-sc-t2c.vf) \
tex(NotoSerif-LightItalic-tosf-t1--base.tfm) \
tex(NotoSerif-LightItalic-tosf-t1.tfm) \
tex(NotoSerif-LightItalic-tosf-t1.vf) \
tex(NotoSerif-LightItalic-tosf-t2a.tfm) \
tex(NotoSerif-LightItalic-tosf-t2b.tfm) \
tex(NotoSerif-LightItalic-tosf-t2c.tfm) \
tex(NotoSerif-LightItalic-tosf-ts1--base.tfm) \
tex(NotoSerif-LightItalic-tosf-ts1.tfm) \
tex(NotoSerif-LightItalic-tosf-ts1.vf) \
tex(NotoSerif-Medium-lf-lgr.tfm) \
tex(NotoSerif-Medium-lf-ly1.tfm) \
tex(NotoSerif-Medium-lf-ot1.tfm) \
tex(NotoSerif-Medium-lf-sc-lgr.tfm) \
tex(NotoSerif-Medium-lf-sc-ly1--base.tfm) \
tex(NotoSerif-Medium-lf-sc-ly1.tfm) \
tex(NotoSerif-Medium-lf-sc-ly1.vf) \
tex(NotoSerif-Medium-lf-sc-ot1--base.tfm) \
tex(NotoSerif-Medium-lf-sc-ot1.tfm) \
tex(NotoSerif-Medium-lf-sc-ot1.vf) \
tex(NotoSerif-Medium-lf-sc-t1--base.tfm) \
tex(NotoSerif-Medium-lf-sc-t1.tfm) \
tex(NotoSerif-Medium-lf-sc-t1.vf) \
tex(NotoSerif-Medium-lf-sc-t2a--base.tfm) \
tex(NotoSerif-Medium-lf-sc-t2a.tfm) \
tex(NotoSerif-Medium-lf-sc-t2a.vf) \
tex(NotoSerif-Medium-lf-sc-t2b--base.tfm) \
tex(NotoSerif-Medium-lf-sc-t2b.tfm) \
tex(NotoSerif-Medium-lf-sc-t2b.vf) \
tex(NotoSerif-Medium-lf-sc-t2c--base.tfm) \
tex(NotoSerif-Medium-lf-sc-t2c.tfm) \
tex(NotoSerif-Medium-lf-sc-t2c.vf) \
tex(NotoSerif-Medium-lf-t1--base.tfm) \
tex(NotoSerif-Medium-lf-t1.tfm) \
tex(NotoSerif-Medium-lf-t1.vf) \
tex(NotoSerif-Medium-lf-t2a.tfm) \
tex(NotoSerif-Medium-lf-t2b.tfm) \
tex(NotoSerif-Medium-lf-t2c.tfm) \
tex(NotoSerif-Medium-lf-ts1--base.tfm) \
tex(NotoSerif-Medium-lf-ts1.tfm) \
tex(NotoSerif-Medium-lf-ts1.vf) \
tex(NotoSerif-Medium-osf-lgr.tfm) \
tex(NotoSerif-Medium-osf-ly1.tfm) \
tex(NotoSerif-Medium-osf-ot1.tfm) \
tex(NotoSerif-Medium-osf-sc-lgr.tfm) \
tex(NotoSerif-Medium-osf-sc-ly1--base.tfm) \
tex(NotoSerif-Medium-osf-sc-ly1.tfm) \
tex(NotoSerif-Medium-osf-sc-ly1.vf) \
tex(NotoSerif-Medium-osf-sc-ot1--base.tfm) \
tex(NotoSerif-Medium-osf-sc-ot1.tfm) \
tex(NotoSerif-Medium-osf-sc-ot1.vf) \
tex(NotoSerif-Medium-osf-sc-t1--base.tfm) \
tex(NotoSerif-Medium-osf-sc-t1.tfm) \
tex(NotoSerif-Medium-osf-sc-t1.vf) \
tex(NotoSerif-Medium-osf-sc-t2a--base.tfm) \
tex(NotoSerif-Medium-osf-sc-t2a.tfm) \
tex(NotoSerif-Medium-osf-sc-t2a.vf) \
tex(NotoSerif-Medium-osf-sc-t2b--base.tfm) \
tex(NotoSerif-Medium-osf-sc-t2b.tfm) \
tex(NotoSerif-Medium-osf-sc-t2b.vf) \
tex(NotoSerif-Medium-osf-sc-t2c--base.tfm) \
tex(NotoSerif-Medium-osf-sc-t2c.tfm) \
tex(NotoSerif-Medium-osf-sc-t2c.vf) \
tex(NotoSerif-Medium-osf-t1--base.tfm) \
tex(NotoSerif-Medium-osf-t1.tfm) \
tex(NotoSerif-Medium-osf-t1.vf) \
tex(NotoSerif-Medium-osf-t2a.tfm) \
tex(NotoSerif-Medium-osf-t2b.tfm) \
tex(NotoSerif-Medium-osf-t2c.tfm) \
tex(NotoSerif-Medium-osf-ts1--base.tfm) \
tex(NotoSerif-Medium-osf-ts1.tfm) \
tex(NotoSerif-Medium-osf-ts1.vf) \
tex(NotoSerif-Medium-sup-lgr.tfm) \
tex(NotoSerif-Medium-sup-ly1.tfm) \
tex(NotoSerif-Medium-sup-ot1.tfm) \
tex(NotoSerif-Medium-sup-t1--base.tfm) \
tex(NotoSerif-Medium-sup-t1.tfm) \
tex(NotoSerif-Medium-sup-t1.vf) \
tex(NotoSerif-Medium-sup-t2a.tfm) \
tex(NotoSerif-Medium-sup-t2b.tfm) \
tex(NotoSerif-Medium-sup-t2c.tfm) \
tex(NotoSerif-Medium-tlf-lgr.tfm) \
tex(NotoSerif-Medium-tlf-ly1.tfm) \
tex(NotoSerif-Medium-tlf-ot1.tfm) \
tex(NotoSerif-Medium-tlf-sc-lgr.tfm) \
tex(NotoSerif-Medium-tlf-sc-ly1--base.tfm) \
tex(NotoSerif-Medium-tlf-sc-ly1.tfm) \
tex(NotoSerif-Medium-tlf-sc-ly1.vf) \
tex(NotoSerif-Medium-tlf-sc-ot1--base.tfm) \
tex(NotoSerif-Medium-tlf-sc-ot1.tfm) \
tex(NotoSerif-Medium-tlf-sc-ot1.vf) \
tex(NotoSerif-Medium-tlf-sc-t1--base.tfm) \
tex(NotoSerif-Medium-tlf-sc-t1.tfm) \
tex(NotoSerif-Medium-tlf-sc-t1.vf) \
tex(NotoSerif-Medium-tlf-sc-t2a--base.tfm) \
tex(NotoSerif-Medium-tlf-sc-t2a.tfm) \
tex(NotoSerif-Medium-tlf-sc-t2a.vf) \
tex(NotoSerif-Medium-tlf-sc-t2b--base.tfm) \
tex(NotoSerif-Medium-tlf-sc-t2b.tfm) \
tex(NotoSerif-Medium-tlf-sc-t2b.vf) \
tex(NotoSerif-Medium-tlf-sc-t2c--base.tfm) \
tex(NotoSerif-Medium-tlf-sc-t2c.tfm) \
tex(NotoSerif-Medium-tlf-sc-t2c.vf) \
tex(NotoSerif-Medium-tlf-t1--base.tfm) \
tex(NotoSerif-Medium-tlf-t1.tfm) \
tex(NotoSerif-Medium-tlf-t1.vf) \
tex(NotoSerif-Medium-tlf-t2a.tfm) \
tex(NotoSerif-Medium-tlf-t2b.tfm) \
tex(NotoSerif-Medium-tlf-t2c.tfm) \
tex(NotoSerif-Medium-tlf-ts1--base.tfm) \
tex(NotoSerif-Medium-tlf-ts1.tfm) \
tex(NotoSerif-Medium-tlf-ts1.vf) \
tex(NotoSerif-Medium-tosf-lgr.tfm) \
tex(NotoSerif-Medium-tosf-ly1.tfm) \
tex(NotoSerif-Medium-tosf-ot1.tfm) \
tex(NotoSerif-Medium-tosf-sc-lgr.tfm) \
tex(NotoSerif-Medium-tosf-sc-ly1--base.tfm) \
tex(NotoSerif-Medium-tosf-sc-ly1.tfm) \
tex(NotoSerif-Medium-tosf-sc-ly1.vf) \
tex(NotoSerif-Medium-tosf-sc-ot1--base.tfm) \
tex(NotoSerif-Medium-tosf-sc-ot1.tfm) \
tex(NotoSerif-Medium-tosf-sc-ot1.vf) \
tex(NotoSerif-Medium-tosf-sc-t1--base.tfm) \
tex(NotoSerif-Medium-tosf-sc-t1.tfm) \
tex(NotoSerif-Medium-tosf-sc-t1.vf) \
tex(NotoSerif-Medium-tosf-sc-t2a--base.tfm) \
tex(NotoSerif-Medium-tosf-sc-t2a.tfm) \
tex(NotoSerif-Medium-tosf-sc-t2a.vf) \
tex(NotoSerif-Medium-tosf-sc-t2b--base.tfm) \
tex(NotoSerif-Medium-tosf-sc-t2b.tfm) \
tex(NotoSerif-Medium-tosf-sc-t2b.vf) \
tex(NotoSerif-Medium-tosf-sc-t2c--base.tfm) \
tex(NotoSerif-Medium-tosf-sc-t2c.tfm) \
tex(NotoSerif-Medium-tosf-sc-t2c.vf) \
tex(NotoSerif-Medium-tosf-t1--base.tfm) \
tex(NotoSerif-Medium-tosf-t1.tfm) \
tex(NotoSerif-Medium-tosf-t1.vf) \
tex(NotoSerif-Medium-tosf-t2a.tfm) \
tex(NotoSerif-Medium-tosf-t2b.tfm) \
tex(NotoSerif-Medium-tosf-t2c.tfm) \
tex(NotoSerif-Medium-tosf-ts1--base.tfm) \
tex(NotoSerif-Medium-tosf-ts1.tfm) \
tex(NotoSerif-Medium-tosf-ts1.vf) \
tex(NotoSerif-MediumItalic-lf-lgr.tfm) \
tex(NotoSerif-MediumItalic-lf-ly1.tfm) \
tex(NotoSerif-MediumItalic-lf-ot1.tfm) \
tex(NotoSerif-MediumItalic-lf-sc-lgr.tfm) \
tex(NotoSerif-MediumItalic-lf-sc-ly1--base.tfm) \
tex(NotoSerif-MediumItalic-lf-sc-ly1.tfm) \
tex(NotoSerif-MediumItalic-lf-sc-ly1.vf) \
tex(NotoSerif-MediumItalic-lf-sc-ot1--base.tfm) \
tex(NotoSerif-MediumItalic-lf-sc-ot1.tfm) \
tex(NotoSerif-MediumItalic-lf-sc-ot1.vf) \
tex(NotoSerif-MediumItalic-lf-sc-t1--base.tfm) \
tex(NotoSerif-MediumItalic-lf-sc-t1.tfm) \
tex(NotoSerif-MediumItalic-lf-sc-t1.vf) \
tex(NotoSerif-MediumItalic-lf-sc-t2a--base.tfm) \
tex(NotoSerif-MediumItalic-lf-sc-t2a.tfm) \
tex(NotoSerif-MediumItalic-lf-sc-t2a.vf) \
tex(NotoSerif-MediumItalic-lf-sc-t2b--base.tfm) \
tex(NotoSerif-MediumItalic-lf-sc-t2b.tfm) \
tex(NotoSerif-MediumItalic-lf-sc-t2b.vf) \
tex(NotoSerif-MediumItalic-lf-sc-t2c--base.tfm) \
tex(NotoSerif-MediumItalic-lf-sc-t2c.tfm) \
tex(NotoSerif-MediumItalic-lf-sc-t2c.vf) \
tex(NotoSerif-MediumItalic-lf-t1--base.tfm) \
tex(NotoSerif-MediumItalic-lf-t1.tfm) \
tex(NotoSerif-MediumItalic-lf-t1.vf) \
tex(NotoSerif-MediumItalic-lf-t2a.tfm) \
tex(NotoSerif-MediumItalic-lf-t2b.tfm) \
tex(NotoSerif-MediumItalic-lf-t2c.tfm) \
tex(NotoSerif-MediumItalic-lf-ts1--base.tfm) \
tex(NotoSerif-MediumItalic-lf-ts1.tfm) \
tex(NotoSerif-MediumItalic-lf-ts1.vf) \
tex(NotoSerif-MediumItalic-osf-lgr.tfm) \
tex(NotoSerif-MediumItalic-osf-ly1.tfm) \
tex(NotoSerif-MediumItalic-osf-ot1.tfm) \
tex(NotoSerif-MediumItalic-osf-sc-lgr.tfm) \
tex(NotoSerif-MediumItalic-osf-sc-ly1--base.tfm) \
tex(NotoSerif-MediumItalic-osf-sc-ly1.tfm) \
tex(NotoSerif-MediumItalic-osf-sc-ly1.vf) \
tex(NotoSerif-MediumItalic-osf-sc-ot1--base.tfm) \
tex(NotoSerif-MediumItalic-osf-sc-ot1.tfm) \
tex(NotoSerif-MediumItalic-osf-sc-ot1.vf) \
tex(NotoSerif-MediumItalic-osf-sc-t1--base.tfm) \
tex(NotoSerif-MediumItalic-osf-sc-t1.tfm) \
tex(NotoSerif-MediumItalic-osf-sc-t1.vf) \
tex(NotoSerif-MediumItalic-osf-sc-t2a--base.tfm) \
tex(NotoSerif-MediumItalic-osf-sc-t2a.tfm) \
tex(NotoSerif-MediumItalic-osf-sc-t2a.vf) \
tex(NotoSerif-MediumItalic-osf-sc-t2b--base.tfm) \
tex(NotoSerif-MediumItalic-osf-sc-t2b.tfm) \
tex(NotoSerif-MediumItalic-osf-sc-t2b.vf) \
tex(NotoSerif-MediumItalic-osf-sc-t2c--base.tfm) \
tex(NotoSerif-MediumItalic-osf-sc-t2c.tfm) \
tex(NotoSerif-MediumItalic-osf-sc-t2c.vf) \
tex(NotoSerif-MediumItalic-osf-t1--base.tfm) \
tex(NotoSerif-MediumItalic-osf-t1.tfm) \
tex(NotoSerif-MediumItalic-osf-t1.vf) \
tex(NotoSerif-MediumItalic-osf-t2a.tfm) \
tex(NotoSerif-MediumItalic-osf-t2b.tfm) \
tex(NotoSerif-MediumItalic-osf-t2c.tfm) \
tex(NotoSerif-MediumItalic-osf-ts1--base.tfm) \
tex(NotoSerif-MediumItalic-osf-ts1.tfm) \
tex(NotoSerif-MediumItalic-osf-ts1.vf) \
tex(NotoSerif-MediumItalic-sup-lgr.tfm) \
tex(NotoSerif-MediumItalic-sup-ly1.tfm) \
tex(NotoSerif-MediumItalic-sup-ot1.tfm) \
tex(NotoSerif-MediumItalic-sup-t1--base.tfm) \
tex(NotoSerif-MediumItalic-sup-t1.tfm) \
tex(NotoSerif-MediumItalic-sup-t1.vf) \
tex(NotoSerif-MediumItalic-sup-t2a.tfm) \
tex(NotoSerif-MediumItalic-sup-t2b.tfm) \
tex(NotoSerif-MediumItalic-sup-t2c.tfm) \
tex(NotoSerif-MediumItalic-tlf-lgr.tfm) \
tex(NotoSerif-MediumItalic-tlf-ly1.tfm) \
tex(NotoSerif-MediumItalic-tlf-ot1.tfm) \
tex(NotoSerif-MediumItalic-tlf-sc-lgr.tfm) \
tex(NotoSerif-MediumItalic-tlf-sc-ly1--base.tfm) \
tex(NotoSerif-MediumItalic-tlf-sc-ly1.tfm) \
tex(NotoSerif-MediumItalic-tlf-sc-ly1.vf) \
tex(NotoSerif-MediumItalic-tlf-sc-ot1--base.tfm) \
tex(NotoSerif-MediumItalic-tlf-sc-ot1.tfm) \
tex(NotoSerif-MediumItalic-tlf-sc-ot1.vf) \
tex(NotoSerif-MediumItalic-tlf-sc-t1--base.tfm) \
tex(NotoSerif-MediumItalic-tlf-sc-t1.tfm) \
tex(NotoSerif-MediumItalic-tlf-sc-t1.vf) \
tex(NotoSerif-MediumItalic-tlf-sc-t2a--base.tfm) \
tex(NotoSerif-MediumItalic-tlf-sc-t2a.tfm) \
tex(NotoSerif-MediumItalic-tlf-sc-t2a.vf) \
tex(NotoSerif-MediumItalic-tlf-sc-t2b--base.tfm) \
tex(NotoSerif-MediumItalic-tlf-sc-t2b.tfm) \
tex(NotoSerif-MediumItalic-tlf-sc-t2b.vf) \
tex(NotoSerif-MediumItalic-tlf-sc-t2c--base.tfm) \
tex(NotoSerif-MediumItalic-tlf-sc-t2c.tfm) \
tex(NotoSerif-MediumItalic-tlf-sc-t2c.vf) \
tex(NotoSerif-MediumItalic-tlf-t1--base.tfm) \
tex(NotoSerif-MediumItalic-tlf-t1.tfm) \
tex(NotoSerif-MediumItalic-tlf-t1.vf) \
tex(NotoSerif-MediumItalic-tlf-t2a.tfm) \
tex(NotoSerif-MediumItalic-tlf-t2b.tfm) \
tex(NotoSerif-MediumItalic-tlf-t2c.tfm) \
tex(NotoSerif-MediumItalic-tlf-ts1--base.tfm) \
tex(NotoSerif-MediumItalic-tlf-ts1.tfm) \
tex(NotoSerif-MediumItalic-tlf-ts1.vf) \
tex(NotoSerif-MediumItalic-tosf-lgr.tfm) \
tex(NotoSerif-MediumItalic-tosf-ly1.tfm) \
tex(NotoSerif-MediumItalic-tosf-ot1.tfm) \
tex(NotoSerif-MediumItalic-tosf-sc-lgr.tfm) \
tex(NotoSerif-MediumItalic-tosf-sc-ly1--base.tfm) \
tex(NotoSerif-MediumItalic-tosf-sc-ly1.tfm) \
tex(NotoSerif-MediumItalic-tosf-sc-ly1.vf) \
tex(NotoSerif-MediumItalic-tosf-sc-ot1--base.tfm) \
tex(NotoSerif-MediumItalic-tosf-sc-ot1.tfm) \
tex(NotoSerif-MediumItalic-tosf-sc-ot1.vf) \
tex(NotoSerif-MediumItalic-tosf-sc-t1--base.tfm) \
tex(NotoSerif-MediumItalic-tosf-sc-t1.tfm) \
tex(NotoSerif-MediumItalic-tosf-sc-t1.vf) \
tex(NotoSerif-MediumItalic-tosf-sc-t2a--base.tfm) \
tex(NotoSerif-MediumItalic-tosf-sc-t2a.tfm) \
tex(NotoSerif-MediumItalic-tosf-sc-t2a.vf) \
tex(NotoSerif-MediumItalic-tosf-sc-t2b--base.tfm) \
tex(NotoSerif-MediumItalic-tosf-sc-t2b.tfm) \
tex(NotoSerif-MediumItalic-tosf-sc-t2b.vf) \
tex(NotoSerif-MediumItalic-tosf-sc-t2c--base.tfm) \
tex(NotoSerif-MediumItalic-tosf-sc-t2c.tfm) \
tex(NotoSerif-MediumItalic-tosf-sc-t2c.vf) \
tex(NotoSerif-MediumItalic-tosf-t1--base.tfm) \
tex(NotoSerif-MediumItalic-tosf-t1.tfm) \
tex(NotoSerif-MediumItalic-tosf-t1.vf) \
tex(NotoSerif-MediumItalic-tosf-t2a.tfm) \
tex(NotoSerif-MediumItalic-tosf-t2b.tfm) \
tex(NotoSerif-MediumItalic-tosf-t2c.tfm) \
tex(NotoSerif-MediumItalic-tosf-ts1--base.tfm) \
tex(NotoSerif-MediumItalic-tosf-ts1.tfm) \
tex(NotoSerif-MediumItalic-tosf-ts1.vf) \
tex(NotoSerif-Regular-lf-lgr.tfm) \
tex(NotoSerif-Regular-lf-ly1.tfm) \
tex(NotoSerif-Regular-lf-ot1.tfm) \
tex(NotoSerif-Regular-lf-sc-lgr.tfm) \
tex(NotoSerif-Regular-lf-sc-ly1--base.tfm) \
tex(NotoSerif-Regular-lf-sc-ly1.tfm) \
tex(NotoSerif-Regular-lf-sc-ly1.vf) \
tex(NotoSerif-Regular-lf-sc-ot1--base.tfm) \
tex(NotoSerif-Regular-lf-sc-ot1.tfm) \
tex(NotoSerif-Regular-lf-sc-ot1.vf) \
tex(NotoSerif-Regular-lf-sc-t1--base.tfm) \
tex(NotoSerif-Regular-lf-sc-t1.tfm) \
tex(NotoSerif-Regular-lf-sc-t1.vf) \
tex(NotoSerif-Regular-lf-sc-t2a--base.tfm) \
tex(NotoSerif-Regular-lf-sc-t2a.tfm) \
tex(NotoSerif-Regular-lf-sc-t2a.vf) \
tex(NotoSerif-Regular-lf-sc-t2b--base.tfm) \
tex(NotoSerif-Regular-lf-sc-t2b.tfm) \
tex(NotoSerif-Regular-lf-sc-t2b.vf) \
tex(NotoSerif-Regular-lf-sc-t2c--base.tfm) \
tex(NotoSerif-Regular-lf-sc-t2c.tfm) \
tex(NotoSerif-Regular-lf-sc-t2c.vf) \
tex(NotoSerif-Regular-lf-t1--base.tfm) \
tex(NotoSerif-Regular-lf-t1.tfm) \
tex(NotoSerif-Regular-lf-t1.vf) \
tex(NotoSerif-Regular-lf-t2a.tfm) \
tex(NotoSerif-Regular-lf-t2b.tfm) \
tex(NotoSerif-Regular-lf-t2c.tfm) \
tex(NotoSerif-Regular-lf-ts1--base.tfm) \
tex(NotoSerif-Regular-lf-ts1.tfm) \
tex(NotoSerif-Regular-lf-ts1.vf) \
tex(NotoSerif-Regular-osf-lgr.tfm) \
tex(NotoSerif-Regular-osf-ly1.tfm) \
tex(NotoSerif-Regular-osf-ot1.tfm) \
tex(NotoSerif-Regular-osf-sc-lgr.tfm) \
tex(NotoSerif-Regular-osf-sc-ly1--base.tfm) \
tex(NotoSerif-Regular-osf-sc-ly1.tfm) \
tex(NotoSerif-Regular-osf-sc-ly1.vf) \
tex(NotoSerif-Regular-osf-sc-ot1--base.tfm) \
tex(NotoSerif-Regular-osf-sc-ot1.tfm) \
tex(NotoSerif-Regular-osf-sc-ot1.vf) \
tex(NotoSerif-Regular-osf-sc-t1--base.tfm) \
tex(NotoSerif-Regular-osf-sc-t1.tfm) \
tex(NotoSerif-Regular-osf-sc-t1.vf) \
tex(NotoSerif-Regular-osf-sc-t2a--base.tfm) \
tex(NotoSerif-Regular-osf-sc-t2a.tfm) \
tex(NotoSerif-Regular-osf-sc-t2a.vf) \
tex(NotoSerif-Regular-osf-sc-t2b--base.tfm) \
tex(NotoSerif-Regular-osf-sc-t2b.tfm) \
tex(NotoSerif-Regular-osf-sc-t2b.vf) \
tex(NotoSerif-Regular-osf-sc-t2c--base.tfm) \
tex(NotoSerif-Regular-osf-sc-t2c.tfm) \
tex(NotoSerif-Regular-osf-sc-t2c.vf) \
tex(NotoSerif-Regular-osf-t1--base.tfm) \
tex(NotoSerif-Regular-osf-t1.tfm) \
tex(NotoSerif-Regular-osf-t1.vf) \
tex(NotoSerif-Regular-osf-t2a.tfm) \
tex(NotoSerif-Regular-osf-t2b.tfm) \
tex(NotoSerif-Regular-osf-t2c.tfm) \
tex(NotoSerif-Regular-osf-ts1--base.tfm) \
tex(NotoSerif-Regular-osf-ts1.tfm) \
tex(NotoSerif-Regular-osf-ts1.vf) \
tex(NotoSerif-Regular-sup-lgr.tfm) \
tex(NotoSerif-Regular-sup-ly1.tfm) \
tex(NotoSerif-Regular-sup-ot1.tfm) \
tex(NotoSerif-Regular-sup-t1--base.tfm) \
tex(NotoSerif-Regular-sup-t1.tfm) \
tex(NotoSerif-Regular-sup-t1.vf) \
tex(NotoSerif-Regular-sup-t2a.tfm) \
tex(NotoSerif-Regular-sup-t2b.tfm) \
tex(NotoSerif-Regular-sup-t2c.tfm) \
tex(NotoSerif-Regular-tlf-lgr.tfm) \
tex(NotoSerif-Regular-tlf-ly1.tfm) \
tex(NotoSerif-Regular-tlf-ot1.tfm) \
tex(NotoSerif-Regular-tlf-sc-lgr.tfm) \
tex(NotoSerif-Regular-tlf-sc-ly1--base.tfm) \
tex(NotoSerif-Regular-tlf-sc-ly1.tfm) \
tex(NotoSerif-Regular-tlf-sc-ly1.vf) \
tex(NotoSerif-Regular-tlf-sc-ot1--base.tfm) \
tex(NotoSerif-Regular-tlf-sc-ot1.tfm) \
tex(NotoSerif-Regular-tlf-sc-ot1.vf) \
tex(NotoSerif-Regular-tlf-sc-t1--base.tfm) \
tex(NotoSerif-Regular-tlf-sc-t1.tfm) \
tex(NotoSerif-Regular-tlf-sc-t1.vf) \
tex(NotoSerif-Regular-tlf-sc-t2a--base.tfm) \
tex(NotoSerif-Regular-tlf-sc-t2a.tfm) \
tex(NotoSerif-Regular-tlf-sc-t2a.vf) \
tex(NotoSerif-Regular-tlf-sc-t2b--base.tfm) \
tex(NotoSerif-Regular-tlf-sc-t2b.tfm) \
tex(NotoSerif-Regular-tlf-sc-t2b.vf) \
tex(NotoSerif-Regular-tlf-sc-t2c--base.tfm) \
tex(NotoSerif-Regular-tlf-sc-t2c.tfm) \
tex(NotoSerif-Regular-tlf-sc-t2c.vf) \
tex(NotoSerif-Regular-tlf-t1--base.tfm) \
tex(NotoSerif-Regular-tlf-t1.tfm) \
tex(NotoSerif-Regular-tlf-t1.vf) \
tex(NotoSerif-Regular-tlf-t2a.tfm) \
tex(NotoSerif-Regular-tlf-t2b.tfm) \
tex(NotoSerif-Regular-tlf-t2c.tfm) \
tex(NotoSerif-Regular-tlf-ts1--base.tfm) \
tex(NotoSerif-Regular-tlf-ts1.tfm) \
tex(NotoSerif-Regular-tlf-ts1.vf) \
tex(NotoSerif-Regular-tosf-lgr.tfm) \
tex(NotoSerif-Regular-tosf-ly1.tfm) \
tex(NotoSerif-Regular-tosf-ot1.tfm) \
tex(NotoSerif-Regular-tosf-sc-lgr.tfm) \
tex(NotoSerif-Regular-tosf-sc-ly1--base.tfm) \
tex(NotoSerif-Regular-tosf-sc-ly1.tfm) \
tex(NotoSerif-Regular-tosf-sc-ly1.vf) \
tex(NotoSerif-Regular-tosf-sc-ot1--base.tfm) \
tex(NotoSerif-Regular-tosf-sc-ot1.tfm) \
tex(NotoSerif-Regular-tosf-sc-ot1.vf) \
tex(NotoSerif-Regular-tosf-sc-t1--base.tfm) \
tex(NotoSerif-Regular-tosf-sc-t1.tfm) \
tex(NotoSerif-Regular-tosf-sc-t1.vf) \
tex(NotoSerif-Regular-tosf-sc-t2a--base.tfm) \
tex(NotoSerif-Regular-tosf-sc-t2a.tfm) \
tex(NotoSerif-Regular-tosf-sc-t2a.vf) \
tex(NotoSerif-Regular-tosf-sc-t2b--base.tfm) \
tex(NotoSerif-Regular-tosf-sc-t2b.tfm) \
tex(NotoSerif-Regular-tosf-sc-t2b.vf) \
tex(NotoSerif-Regular-tosf-sc-t2c--base.tfm) \
tex(NotoSerif-Regular-tosf-sc-t2c.tfm) \
tex(NotoSerif-Regular-tosf-sc-t2c.vf) \
tex(NotoSerif-Regular-tosf-t1--base.tfm) \
tex(NotoSerif-Regular-tosf-t1.tfm) \
tex(NotoSerif-Regular-tosf-t1.vf) \
tex(NotoSerif-Regular-tosf-t2a.tfm) \
tex(NotoSerif-Regular-tosf-t2b.tfm) \
tex(NotoSerif-Regular-tosf-t2c.tfm) \
tex(NotoSerif-Regular-tosf-ts1--base.tfm) \
tex(NotoSerif-Regular-tosf-ts1.tfm) \
tex(NotoSerif-Regular-tosf-ts1.vf) \
tex(NotoSerif-SemiBold-lf-lgr.tfm) \
tex(NotoSerif-SemiBold-lf-ly1.tfm) \
tex(NotoSerif-SemiBold-lf-ot1.tfm) \
tex(NotoSerif-SemiBold-lf-sc-lgr.tfm) \
tex(NotoSerif-SemiBold-lf-sc-ly1--base.tfm) \
tex(NotoSerif-SemiBold-lf-sc-ly1.tfm) \
tex(NotoSerif-SemiBold-lf-sc-ly1.vf) \
tex(NotoSerif-SemiBold-lf-sc-ot1--base.tfm) \
tex(NotoSerif-SemiBold-lf-sc-ot1.tfm) \
tex(NotoSerif-SemiBold-lf-sc-ot1.vf) \
tex(NotoSerif-SemiBold-lf-sc-t1--base.tfm) \
tex(NotoSerif-SemiBold-lf-sc-t1.tfm) \
tex(NotoSerif-SemiBold-lf-sc-t1.vf) \
tex(NotoSerif-SemiBold-lf-sc-t2a--base.tfm) \
tex(NotoSerif-SemiBold-lf-sc-t2a.tfm) \
tex(NotoSerif-SemiBold-lf-sc-t2a.vf) \
tex(NotoSerif-SemiBold-lf-sc-t2b--base.tfm) \
tex(NotoSerif-SemiBold-lf-sc-t2b.tfm) \
tex(NotoSerif-SemiBold-lf-sc-t2b.vf) \
tex(NotoSerif-SemiBold-lf-sc-t2c--base.tfm) \
tex(NotoSerif-SemiBold-lf-sc-t2c.tfm) \
tex(NotoSerif-SemiBold-lf-sc-t2c.vf) \
tex(NotoSerif-SemiBold-lf-t1--base.tfm) \
tex(NotoSerif-SemiBold-lf-t1.tfm) \
tex(NotoSerif-SemiBold-lf-t1.vf) \
tex(NotoSerif-SemiBold-lf-t2a.tfm) \
tex(NotoSerif-SemiBold-lf-t2b.tfm) \
tex(NotoSerif-SemiBold-lf-t2c.tfm) \
tex(NotoSerif-SemiBold-lf-ts1--base.tfm) \
tex(NotoSerif-SemiBold-lf-ts1.tfm) \
tex(NotoSerif-SemiBold-lf-ts1.vf) \
tex(NotoSerif-SemiBold-osf-lgr.tfm) \
tex(NotoSerif-SemiBold-osf-ly1.tfm) \
tex(NotoSerif-SemiBold-osf-ot1.tfm) \
tex(NotoSerif-SemiBold-osf-sc-lgr.tfm) \
tex(NotoSerif-SemiBold-osf-sc-ly1--base.tfm) \
tex(NotoSerif-SemiBold-osf-sc-ly1.tfm) \
tex(NotoSerif-SemiBold-osf-sc-ly1.vf) \
tex(NotoSerif-SemiBold-osf-sc-ot1--base.tfm) \
tex(NotoSerif-SemiBold-osf-sc-ot1.tfm) \
tex(NotoSerif-SemiBold-osf-sc-ot1.vf) \
tex(NotoSerif-SemiBold-osf-sc-t1--base.tfm) \
tex(NotoSerif-SemiBold-osf-sc-t1.tfm) \
tex(NotoSerif-SemiBold-osf-sc-t1.vf) \
tex(NotoSerif-SemiBold-osf-sc-t2a--base.tfm) \
tex(NotoSerif-SemiBold-osf-sc-t2a.tfm) \
tex(NotoSerif-SemiBold-osf-sc-t2a.vf) \
tex(NotoSerif-SemiBold-osf-sc-t2b--base.tfm) \
tex(NotoSerif-SemiBold-osf-sc-t2b.tfm) \
tex(NotoSerif-SemiBold-osf-sc-t2b.vf) \
tex(NotoSerif-SemiBold-osf-sc-t2c--base.tfm) \
tex(NotoSerif-SemiBold-osf-sc-t2c.tfm) \
tex(NotoSerif-SemiBold-osf-sc-t2c.vf) \
tex(NotoSerif-SemiBold-osf-t1--base.tfm) \
tex(NotoSerif-SemiBold-osf-t1.tfm) \
tex(NotoSerif-SemiBold-osf-t1.vf) \
tex(NotoSerif-SemiBold-osf-t2a.tfm) \
tex(NotoSerif-SemiBold-osf-t2b.tfm) \
tex(NotoSerif-SemiBold-osf-t2c.tfm) \
tex(NotoSerif-SemiBold-osf-ts1--base.tfm) \
tex(NotoSerif-SemiBold-osf-ts1.tfm) \
tex(NotoSerif-SemiBold-osf-ts1.vf) \
tex(NotoSerif-SemiBold-sup-lgr.tfm) \
tex(NotoSerif-SemiBold-sup-ly1.tfm) \
tex(NotoSerif-SemiBold-sup-ot1.tfm) \
tex(NotoSerif-SemiBold-sup-t1--base.tfm) \
tex(NotoSerif-SemiBold-sup-t1.tfm) \
tex(NotoSerif-SemiBold-sup-t1.vf) \
tex(NotoSerif-SemiBold-sup-t2a.tfm) \
tex(NotoSerif-SemiBold-sup-t2b.tfm) \
tex(NotoSerif-SemiBold-sup-t2c.tfm) \
tex(NotoSerif-SemiBold-tlf-lgr.tfm) \
tex(NotoSerif-SemiBold-tlf-ly1.tfm) \
tex(NotoSerif-SemiBold-tlf-ot1.tfm) \
tex(NotoSerif-SemiBold-tlf-sc-lgr.tfm) \
tex(NotoSerif-SemiBold-tlf-sc-ly1--base.tfm) \
tex(NotoSerif-SemiBold-tlf-sc-ly1.tfm) \
tex(NotoSerif-SemiBold-tlf-sc-ly1.vf) \
tex(NotoSerif-SemiBold-tlf-sc-ot1--base.tfm) \
tex(NotoSerif-SemiBold-tlf-sc-ot1.tfm) \
tex(NotoSerif-SemiBold-tlf-sc-ot1.vf) \
tex(NotoSerif-SemiBold-tlf-sc-t1--base.tfm) \
tex(NotoSerif-SemiBold-tlf-sc-t1.tfm) \
tex(NotoSerif-SemiBold-tlf-sc-t1.vf) \
tex(NotoSerif-SemiBold-tlf-sc-t2a--base.tfm) \
tex(NotoSerif-SemiBold-tlf-sc-t2a.tfm) \
tex(NotoSerif-SemiBold-tlf-sc-t2a.vf) \
tex(NotoSerif-SemiBold-tlf-sc-t2b--base.tfm) \
tex(NotoSerif-SemiBold-tlf-sc-t2b.tfm) \
tex(NotoSerif-SemiBold-tlf-sc-t2b.vf) \
tex(NotoSerif-SemiBold-tlf-sc-t2c--base.tfm) \
tex(NotoSerif-SemiBold-tlf-sc-t2c.tfm) \
tex(NotoSerif-SemiBold-tlf-sc-t2c.vf) \
tex(NotoSerif-SemiBold-tlf-t1--base.tfm) \
tex(NotoSerif-SemiBold-tlf-t1.tfm) \
tex(NotoSerif-SemiBold-tlf-t1.vf) \
tex(NotoSerif-SemiBold-tlf-t2a.tfm) \
tex(NotoSerif-SemiBold-tlf-t2b.tfm) \
tex(NotoSerif-SemiBold-tlf-t2c.tfm) \
tex(NotoSerif-SemiBold-tlf-ts1--base.tfm) \
tex(NotoSerif-SemiBold-tlf-ts1.tfm) \
tex(NotoSerif-SemiBold-tlf-ts1.vf) \
tex(NotoSerif-SemiBold-tosf-lgr.tfm) \
tex(NotoSerif-SemiBold-tosf-ly1.tfm) \
tex(NotoSerif-SemiBold-tosf-ot1.tfm) \
tex(NotoSerif-SemiBold-tosf-sc-lgr.tfm) \
tex(NotoSerif-SemiBold-tosf-sc-ly1--base.tfm) \
tex(NotoSerif-SemiBold-tosf-sc-ly1.tfm) \
tex(NotoSerif-SemiBold-tosf-sc-ly1.vf) \
tex(NotoSerif-SemiBold-tosf-sc-ot1--base.tfm) \
tex(NotoSerif-SemiBold-tosf-sc-ot1.tfm) \
tex(NotoSerif-SemiBold-tosf-sc-ot1.vf) \
tex(NotoSerif-SemiBold-tosf-sc-t1--base.tfm) \
tex(NotoSerif-SemiBold-tosf-sc-t1.tfm) \
tex(NotoSerif-SemiBold-tosf-sc-t1.vf) \
tex(NotoSerif-SemiBold-tosf-sc-t2a--base.tfm) \
tex(NotoSerif-SemiBold-tosf-sc-t2a.tfm) \
tex(NotoSerif-SemiBold-tosf-sc-t2a.vf) \
tex(NotoSerif-SemiBold-tosf-sc-t2b--base.tfm) \
tex(NotoSerif-SemiBold-tosf-sc-t2b.tfm) \
tex(NotoSerif-SemiBold-tosf-sc-t2b.vf) \
tex(NotoSerif-SemiBold-tosf-sc-t2c--base.tfm) \
tex(NotoSerif-SemiBold-tosf-sc-t2c.tfm) \
tex(NotoSerif-SemiBold-tosf-sc-t2c.vf) \
tex(NotoSerif-SemiBold-tosf-t1--base.tfm) \
tex(NotoSerif-SemiBold-tosf-t1.tfm) \
tex(NotoSerif-SemiBold-tosf-t1.vf) \
tex(NotoSerif-SemiBold-tosf-t2a.tfm) \
tex(NotoSerif-SemiBold-tosf-t2b.tfm) \
tex(NotoSerif-SemiBold-tosf-t2c.tfm) \
tex(NotoSerif-SemiBold-tosf-ts1--base.tfm) \
tex(NotoSerif-SemiBold-tosf-ts1.tfm) \
tex(NotoSerif-SemiBold-tosf-ts1.vf) \
tex(NotoSerif-SemiBoldItalic-lf-lgr.tfm) \
tex(NotoSerif-SemiBoldItalic-lf-ly1.tfm) \
tex(NotoSerif-SemiBoldItalic-lf-ot1.tfm) \
tex(NotoSerif-SemiBoldItalic-lf-sc-lgr.tfm) \
tex(NotoSerif-SemiBoldItalic-lf-sc-ly1--base.tfm) \
tex(NotoSerif-SemiBoldItalic-lf-sc-ly1.tfm) \
tex(NotoSerif-SemiBoldItalic-lf-sc-ly1.vf) \
tex(NotoSerif-SemiBoldItalic-lf-sc-ot1--base.tfm) \
tex(NotoSerif-SemiBoldItalic-lf-sc-ot1.tfm) \
tex(NotoSerif-SemiBoldItalic-lf-sc-ot1.vf) \
tex(NotoSerif-SemiBoldItalic-lf-sc-t1--base.tfm) \
tex(NotoSerif-SemiBoldItalic-lf-sc-t1.tfm) \
tex(NotoSerif-SemiBoldItalic-lf-sc-t1.vf) \
tex(NotoSerif-SemiBoldItalic-lf-sc-t2a--base.tfm) \
tex(NotoSerif-SemiBoldItalic-lf-sc-t2a.tfm) \
tex(NotoSerif-SemiBoldItalic-lf-sc-t2a.vf) \
tex(NotoSerif-SemiBoldItalic-lf-sc-t2b--base.tfm) \
tex(NotoSerif-SemiBoldItalic-lf-sc-t2b.tfm) \
tex(NotoSerif-SemiBoldItalic-lf-sc-t2b.vf) \
tex(NotoSerif-SemiBoldItalic-lf-sc-t2c--base.tfm) \
tex(NotoSerif-SemiBoldItalic-lf-sc-t2c.tfm) \
tex(NotoSerif-SemiBoldItalic-lf-sc-t2c.vf) \
tex(NotoSerif-SemiBoldItalic-lf-t1--base.tfm) \
tex(NotoSerif-SemiBoldItalic-lf-t1.tfm) \
tex(NotoSerif-SemiBoldItalic-lf-t1.vf) \
tex(NotoSerif-SemiBoldItalic-lf-t2a.tfm) \
tex(NotoSerif-SemiBoldItalic-lf-t2b.tfm) \
tex(NotoSerif-SemiBoldItalic-lf-t2c.tfm) \
tex(NotoSerif-SemiBoldItalic-lf-ts1--base.tfm) \
tex(NotoSerif-SemiBoldItalic-lf-ts1.tfm) \
tex(NotoSerif-SemiBoldItalic-lf-ts1.vf) \
tex(NotoSerif-SemiBoldItalic-osf-lgr.tfm) \
tex(NotoSerif-SemiBoldItalic-osf-ly1.tfm) \
tex(NotoSerif-SemiBoldItalic-osf-ot1.tfm) \
tex(NotoSerif-SemiBoldItalic-osf-sc-lgr.tfm) \
tex(NotoSerif-SemiBoldItalic-osf-sc-ly1--base.tfm) \
tex(NotoSerif-SemiBoldItalic-osf-sc-ly1.tfm) \
tex(NotoSerif-SemiBoldItalic-osf-sc-ly1.vf) \
tex(NotoSerif-SemiBoldItalic-osf-sc-ot1--base.tfm) \
tex(NotoSerif-SemiBoldItalic-osf-sc-ot1.tfm) \
tex(NotoSerif-SemiBoldItalic-osf-sc-ot1.vf) \
tex(NotoSerif-SemiBoldItalic-osf-sc-t1--base.tfm) \
tex(NotoSerif-SemiBoldItalic-osf-sc-t1.tfm) \
tex(NotoSerif-SemiBoldItalic-osf-sc-t1.vf) \
tex(NotoSerif-SemiBoldItalic-osf-sc-t2a--base.tfm) \
tex(NotoSerif-SemiBoldItalic-osf-sc-t2a.tfm) \
tex(NotoSerif-SemiBoldItalic-osf-sc-t2a.vf) \
tex(NotoSerif-SemiBoldItalic-osf-sc-t2b--base.tfm) \
tex(NotoSerif-SemiBoldItalic-osf-sc-t2b.tfm) \
tex(NotoSerif-SemiBoldItalic-osf-sc-t2b.vf) \
tex(NotoSerif-SemiBoldItalic-osf-sc-t2c--base.tfm) \
tex(NotoSerif-SemiBoldItalic-osf-sc-t2c.tfm) \
tex(NotoSerif-SemiBoldItalic-osf-sc-t2c.vf) \
tex(NotoSerif-SemiBoldItalic-osf-t1--base.tfm) \
tex(NotoSerif-SemiBoldItalic-osf-t1.tfm) \
tex(NotoSerif-SemiBoldItalic-osf-t1.vf) \
tex(NotoSerif-SemiBoldItalic-osf-t2a.tfm) \
tex(NotoSerif-SemiBoldItalic-osf-t2b.tfm) \
tex(NotoSerif-SemiBoldItalic-osf-t2c.tfm) \
tex(NotoSerif-SemiBoldItalic-osf-ts1--base.tfm) \
tex(NotoSerif-SemiBoldItalic-osf-ts1.tfm) \
tex(NotoSerif-SemiBoldItalic-osf-ts1.vf) \
tex(NotoSerif-SemiBoldItalic-sup-lgr.tfm) \
tex(NotoSerif-SemiBoldItalic-sup-ly1.tfm) \
tex(NotoSerif-SemiBoldItalic-sup-ot1.tfm) \
tex(NotoSerif-SemiBoldItalic-sup-t1--base.tfm) \
tex(NotoSerif-SemiBoldItalic-sup-t1.tfm) \
tex(NotoSerif-SemiBoldItalic-sup-t1.vf) \
tex(NotoSerif-SemiBoldItalic-sup-t2a.tfm) \
tex(NotoSerif-SemiBoldItalic-sup-t2b.tfm) \
tex(NotoSerif-SemiBoldItalic-sup-t2c.tfm) \
tex(NotoSerif-SemiBoldItalic-tlf-lgr.tfm) \
tex(NotoSerif-SemiBoldItalic-tlf-ly1.tfm) \
tex(NotoSerif-SemiBoldItalic-tlf-ot1.tfm) \
tex(NotoSerif-SemiBoldItalic-tlf-sc-lgr.tfm) \
tex(NotoSerif-SemiBoldItalic-tlf-sc-ly1--base.tfm) \
tex(NotoSerif-SemiBoldItalic-tlf-sc-ly1.tfm) \
tex(NotoSerif-SemiBoldItalic-tlf-sc-ly1.vf) \
tex(NotoSerif-SemiBoldItalic-tlf-sc-ot1--base.tfm) \
tex(NotoSerif-SemiBoldItalic-tlf-sc-ot1.tfm) \
tex(NotoSerif-SemiBoldItalic-tlf-sc-ot1.vf) \
tex(NotoSerif-SemiBoldItalic-tlf-sc-t1--base.tfm) \
tex(NotoSerif-SemiBoldItalic-tlf-sc-t1.tfm) \
tex(NotoSerif-SemiBoldItalic-tlf-sc-t1.vf) \
tex(NotoSerif-SemiBoldItalic-tlf-sc-t2a--base.tfm) \
tex(NotoSerif-SemiBoldItalic-tlf-sc-t2a.tfm) \
tex(NotoSerif-SemiBoldItalic-tlf-sc-t2a.vf) \
tex(NotoSerif-SemiBoldItalic-tlf-sc-t2b--base.tfm) \
tex(NotoSerif-SemiBoldItalic-tlf-sc-t2b.tfm) \
tex(NotoSerif-SemiBoldItalic-tlf-sc-t2b.vf) \
tex(NotoSerif-SemiBoldItalic-tlf-sc-t2c--base.tfm) \
tex(NotoSerif-SemiBoldItalic-tlf-sc-t2c.tfm) \
tex(NotoSerif-SemiBoldItalic-tlf-sc-t2c.vf) \
tex(NotoSerif-SemiBoldItalic-tlf-t1--base.tfm) \
tex(NotoSerif-SemiBoldItalic-tlf-t1.tfm) \
tex(NotoSerif-SemiBoldItalic-tlf-t1.vf) \
tex(NotoSerif-SemiBoldItalic-tlf-t2a.tfm) \
tex(NotoSerif-SemiBoldItalic-tlf-t2b.tfm) \
tex(NotoSerif-SemiBoldItalic-tlf-t2c.tfm) \
tex(NotoSerif-SemiBoldItalic-tlf-ts1--base.tfm) \
tex(NotoSerif-SemiBoldItalic-tlf-ts1.tfm) \
tex(NotoSerif-SemiBoldItalic-tlf-ts1.vf) \
tex(NotoSerif-SemiBoldItalic-tosf-lgr.tfm) \
tex(NotoSerif-SemiBoldItalic-tosf-ly1.tfm) \
tex(NotoSerif-SemiBoldItalic-tosf-ot1.tfm) \
tex(NotoSerif-SemiBoldItalic-tosf-sc-lgr.tfm) \
tex(NotoSerif-SemiBoldItalic-tosf-sc-ly1--base.tfm) \
tex(NotoSerif-SemiBoldItalic-tosf-sc-ly1.tfm) \
tex(NotoSerif-SemiBoldItalic-tosf-sc-ly1.vf) \
tex(NotoSerif-SemiBoldItalic-tosf-sc-ot1--base.tfm) \
tex(NotoSerif-SemiBoldItalic-tosf-sc-ot1.tfm) \
tex(NotoSerif-SemiBoldItalic-tosf-sc-ot1.vf) \
tex(NotoSerif-SemiBoldItalic-tosf-sc-t1--base.tfm) \
tex(NotoSerif-SemiBoldItalic-tosf-sc-t1.tfm) \
tex(NotoSerif-SemiBoldItalic-tosf-sc-t1.vf) \
tex(NotoSerif-SemiBoldItalic-tosf-sc-t2a--base.tfm) \
tex(NotoSerif-SemiBoldItalic-tosf-sc-t2a.tfm) \
tex(NotoSerif-SemiBoldItalic-tosf-sc-t2a.vf) \
tex(NotoSerif-SemiBoldItalic-tosf-sc-t2b--base.tfm) \
tex(NotoSerif-SemiBoldItalic-tosf-sc-t2b.tfm) \
tex(NotoSerif-SemiBoldItalic-tosf-sc-t2b.vf) \
tex(NotoSerif-SemiBoldItalic-tosf-sc-t2c--base.tfm) \
tex(NotoSerif-SemiBoldItalic-tosf-sc-t2c.tfm) \
tex(NotoSerif-SemiBoldItalic-tosf-sc-t2c.vf) \
tex(NotoSerif-SemiBoldItalic-tosf-t1--base.tfm) \
tex(NotoSerif-SemiBoldItalic-tosf-t1.tfm) \
tex(NotoSerif-SemiBoldItalic-tosf-t1.vf) \
tex(NotoSerif-SemiBoldItalic-tosf-t2a.tfm) \
tex(NotoSerif-SemiBoldItalic-tosf-t2b.tfm) \
tex(NotoSerif-SemiBoldItalic-tosf-t2c.tfm) \
tex(NotoSerif-SemiBoldItalic-tosf-ts1--base.tfm) \
tex(NotoSerif-SemiBoldItalic-tosf-ts1.tfm) \
tex(NotoSerif-SemiBoldItalic-tosf-ts1.vf) \
tex(NotoSerif-Thin-lf-lgr.tfm) \
tex(NotoSerif-Thin-lf-ly1.tfm) \
tex(NotoSerif-Thin-lf-ot1.tfm) \
tex(NotoSerif-Thin-lf-sc-lgr.tfm) \
tex(NotoSerif-Thin-lf-sc-ly1--base.tfm) \
tex(NotoSerif-Thin-lf-sc-ly1.tfm) \
tex(NotoSerif-Thin-lf-sc-ly1.vf) \
tex(NotoSerif-Thin-lf-sc-ot1--base.tfm) \
tex(NotoSerif-Thin-lf-sc-ot1.tfm) \
tex(NotoSerif-Thin-lf-sc-ot1.vf) \
tex(NotoSerif-Thin-lf-sc-t1--base.tfm) \
tex(NotoSerif-Thin-lf-sc-t1.tfm) \
tex(NotoSerif-Thin-lf-sc-t1.vf) \
tex(NotoSerif-Thin-lf-sc-t2a--base.tfm) \
tex(NotoSerif-Thin-lf-sc-t2a.tfm) \
tex(NotoSerif-Thin-lf-sc-t2a.vf) \
tex(NotoSerif-Thin-lf-sc-t2b--base.tfm) \
tex(NotoSerif-Thin-lf-sc-t2b.tfm) \
tex(NotoSerif-Thin-lf-sc-t2b.vf) \
tex(NotoSerif-Thin-lf-sc-t2c--base.tfm) \
tex(NotoSerif-Thin-lf-sc-t2c.tfm) \
tex(NotoSerif-Thin-lf-sc-t2c.vf) \
tex(NotoSerif-Thin-lf-t1--base.tfm) \
tex(NotoSerif-Thin-lf-t1.tfm) \
tex(NotoSerif-Thin-lf-t1.vf) \
tex(NotoSerif-Thin-lf-t2a.tfm) \
tex(NotoSerif-Thin-lf-t2b.tfm) \
tex(NotoSerif-Thin-lf-t2c.tfm) \
tex(NotoSerif-Thin-lf-ts1--base.tfm) \
tex(NotoSerif-Thin-lf-ts1.tfm) \
tex(NotoSerif-Thin-lf-ts1.vf) \
tex(NotoSerif-Thin-osf-lgr.tfm) \
tex(NotoSerif-Thin-osf-ly1.tfm) \
tex(NotoSerif-Thin-osf-ot1.tfm) \
tex(NotoSerif-Thin-osf-sc-lgr.tfm) \
tex(NotoSerif-Thin-osf-sc-ly1--base.tfm) \
tex(NotoSerif-Thin-osf-sc-ly1.tfm) \
tex(NotoSerif-Thin-osf-sc-ly1.vf) \
tex(NotoSerif-Thin-osf-sc-ot1--base.tfm) \
tex(NotoSerif-Thin-osf-sc-ot1.tfm) \
tex(NotoSerif-Thin-osf-sc-ot1.vf) \
tex(NotoSerif-Thin-osf-sc-t1--base.tfm) \
tex(NotoSerif-Thin-osf-sc-t1.tfm) \
tex(NotoSerif-Thin-osf-sc-t1.vf) \
tex(NotoSerif-Thin-osf-sc-t2a--base.tfm) \
tex(NotoSerif-Thin-osf-sc-t2a.tfm) \
tex(NotoSerif-Thin-osf-sc-t2a.vf) \
tex(NotoSerif-Thin-osf-sc-t2b--base.tfm) \
tex(NotoSerif-Thin-osf-sc-t2b.tfm) \
tex(NotoSerif-Thin-osf-sc-t2b.vf) \
tex(NotoSerif-Thin-osf-sc-t2c--base.tfm) \
tex(NotoSerif-Thin-osf-sc-t2c.tfm) \
tex(NotoSerif-Thin-osf-sc-t2c.vf) \
tex(NotoSerif-Thin-osf-t1--base.tfm) \
tex(NotoSerif-Thin-osf-t1.tfm) \
tex(NotoSerif-Thin-osf-t1.vf) \
tex(NotoSerif-Thin-osf-t2a.tfm) \
tex(NotoSerif-Thin-osf-t2b.tfm) \
tex(NotoSerif-Thin-osf-t2c.tfm) \
tex(NotoSerif-Thin-osf-ts1--base.tfm) \
tex(NotoSerif-Thin-osf-ts1.tfm) \
tex(NotoSerif-Thin-osf-ts1.vf) \
tex(NotoSerif-Thin-sup-lgr.tfm) \
tex(NotoSerif-Thin-sup-ly1.tfm) \
tex(NotoSerif-Thin-sup-ot1.tfm) \
tex(NotoSerif-Thin-sup-t1--base.tfm) \
tex(NotoSerif-Thin-sup-t1.tfm) \
tex(NotoSerif-Thin-sup-t1.vf) \
tex(NotoSerif-Thin-sup-t2a.tfm) \
tex(NotoSerif-Thin-sup-t2b.tfm) \
tex(NotoSerif-Thin-sup-t2c.tfm) \
tex(NotoSerif-Thin-tlf-lgr.tfm) \
tex(NotoSerif-Thin-tlf-ly1.tfm) \
tex(NotoSerif-Thin-tlf-ot1.tfm) \
tex(NotoSerif-Thin-tlf-sc-lgr.tfm) \
tex(NotoSerif-Thin-tlf-sc-ly1--base.tfm) \
tex(NotoSerif-Thin-tlf-sc-ly1.tfm) \
tex(NotoSerif-Thin-tlf-sc-ly1.vf) \
tex(NotoSerif-Thin-tlf-sc-ot1--base.tfm) \
tex(NotoSerif-Thin-tlf-sc-ot1.tfm) \
tex(NotoSerif-Thin-tlf-sc-ot1.vf) \
tex(NotoSerif-Thin-tlf-sc-t1--base.tfm) \
tex(NotoSerif-Thin-tlf-sc-t1.tfm) \
tex(NotoSerif-Thin-tlf-sc-t1.vf) \
tex(NotoSerif-Thin-tlf-sc-t2a--base.tfm) \
tex(NotoSerif-Thin-tlf-sc-t2a.tfm) \
tex(NotoSerif-Thin-tlf-sc-t2a.vf) \
tex(NotoSerif-Thin-tlf-sc-t2b--base.tfm) \
tex(NotoSerif-Thin-tlf-sc-t2b.tfm) \
tex(NotoSerif-Thin-tlf-sc-t2b.vf) \
tex(NotoSerif-Thin-tlf-sc-t2c--base.tfm) \
tex(NotoSerif-Thin-tlf-sc-t2c.tfm) \
tex(NotoSerif-Thin-tlf-sc-t2c.vf) \
tex(NotoSerif-Thin-tlf-t1--base.tfm) \
tex(NotoSerif-Thin-tlf-t1.tfm) \
tex(NotoSerif-Thin-tlf-t1.vf) \
tex(NotoSerif-Thin-tlf-t2a.tfm) \
tex(NotoSerif-Thin-tlf-t2b.tfm) \
tex(NotoSerif-Thin-tlf-t2c.tfm) \
tex(NotoSerif-Thin-tlf-ts1--base.tfm) \
tex(NotoSerif-Thin-tlf-ts1.tfm) \
tex(NotoSerif-Thin-tlf-ts1.vf) \
tex(NotoSerif-Thin-tosf-lgr.tfm) \
tex(NotoSerif-Thin-tosf-ly1.tfm) \
tex(NotoSerif-Thin-tosf-ot1.tfm) \
tex(NotoSerif-Thin-tosf-sc-lgr.tfm) \
tex(NotoSerif-Thin-tosf-sc-ly1--base.tfm) \
tex(NotoSerif-Thin-tosf-sc-ly1.tfm) \
tex(NotoSerif-Thin-tosf-sc-ly1.vf) \
tex(NotoSerif-Thin-tosf-sc-ot1--base.tfm) \
tex(NotoSerif-Thin-tosf-sc-ot1.tfm) \
tex(NotoSerif-Thin-tosf-sc-ot1.vf) \
tex(NotoSerif-Thin-tosf-sc-t1--base.tfm) \
tex(NotoSerif-Thin-tosf-sc-t1.tfm) \
tex(NotoSerif-Thin-tosf-sc-t1.vf) \
tex(NotoSerif-Thin-tosf-sc-t2a--base.tfm) \
tex(NotoSerif-Thin-tosf-sc-t2a.tfm) \
tex(NotoSerif-Thin-tosf-sc-t2a.vf) \
tex(NotoSerif-Thin-tosf-sc-t2b--base.tfm) \
tex(NotoSerif-Thin-tosf-sc-t2b.tfm) \
tex(NotoSerif-Thin-tosf-sc-t2b.vf) \
tex(NotoSerif-Thin-tosf-sc-t2c--base.tfm) \
tex(NotoSerif-Thin-tosf-sc-t2c.tfm) \
tex(NotoSerif-Thin-tosf-sc-t2c.vf) \
tex(NotoSerif-Thin-tosf-t1--base.tfm) \
tex(NotoSerif-Thin-tosf-t1.tfm) \
tex(NotoSerif-Thin-tosf-t1.vf) \
tex(NotoSerif-Thin-tosf-t2a.tfm) \
tex(NotoSerif-Thin-tosf-t2b.tfm) \
tex(NotoSerif-Thin-tosf-t2c.tfm) \
tex(NotoSerif-Thin-tosf-ts1--base.tfm) \
tex(NotoSerif-Thin-tosf-ts1.tfm) \
tex(NotoSerif-Thin-tosf-ts1.vf) \
tex(NotoSerif-ThinItalic-lf-lgr.tfm) \
tex(NotoSerif-ThinItalic-lf-ly1.tfm) \
tex(NotoSerif-ThinItalic-lf-ot1.tfm) \
tex(NotoSerif-ThinItalic-lf-sc-lgr.tfm) \
tex(NotoSerif-ThinItalic-lf-sc-ly1--base.tfm) \
tex(NotoSerif-ThinItalic-lf-sc-ly1.tfm) \
tex(NotoSerif-ThinItalic-lf-sc-ly1.vf) \
tex(NotoSerif-ThinItalic-lf-sc-ot1--base.tfm) \
tex(NotoSerif-ThinItalic-lf-sc-ot1.tfm) \
tex(NotoSerif-ThinItalic-lf-sc-ot1.vf) \
tex(NotoSerif-ThinItalic-lf-sc-t1--base.tfm) \
tex(NotoSerif-ThinItalic-lf-sc-t1.tfm) \
tex(NotoSerif-ThinItalic-lf-sc-t1.vf) \
tex(NotoSerif-ThinItalic-lf-sc-t2a--base.tfm) \
tex(NotoSerif-ThinItalic-lf-sc-t2a.tfm) \
tex(NotoSerif-ThinItalic-lf-sc-t2a.vf) \
tex(NotoSerif-ThinItalic-lf-sc-t2b--base.tfm) \
tex(NotoSerif-ThinItalic-lf-sc-t2b.tfm) \
tex(NotoSerif-ThinItalic-lf-sc-t2b.vf) \
tex(NotoSerif-ThinItalic-lf-sc-t2c--base.tfm) \
tex(NotoSerif-ThinItalic-lf-sc-t2c.tfm) \
tex(NotoSerif-ThinItalic-lf-sc-t2c.vf) \
tex(NotoSerif-ThinItalic-lf-t1--base.tfm) \
tex(NotoSerif-ThinItalic-lf-t1.tfm) \
tex(NotoSerif-ThinItalic-lf-t1.vf) \
tex(NotoSerif-ThinItalic-lf-t2a.tfm) \
tex(NotoSerif-ThinItalic-lf-t2b.tfm) \
tex(NotoSerif-ThinItalic-lf-t2c.tfm) \
tex(NotoSerif-ThinItalic-lf-ts1--base.tfm) \
tex(NotoSerif-ThinItalic-lf-ts1.tfm) \
tex(NotoSerif-ThinItalic-lf-ts1.vf) \
tex(NotoSerif-ThinItalic-osf-lgr.tfm) \
tex(NotoSerif-ThinItalic-osf-ly1.tfm) \
tex(NotoSerif-ThinItalic-osf-ot1.tfm) \
tex(NotoSerif-ThinItalic-osf-sc-lgr.tfm) \
tex(NotoSerif-ThinItalic-osf-sc-ly1--base.tfm) \
tex(NotoSerif-ThinItalic-osf-sc-ly1.tfm) \
tex(NotoSerif-ThinItalic-osf-sc-ly1.vf) \
tex(NotoSerif-ThinItalic-osf-sc-ot1--base.tfm) \
tex(NotoSerif-ThinItalic-osf-sc-ot1.tfm) \
tex(NotoSerif-ThinItalic-osf-sc-ot1.vf) \
tex(NotoSerif-ThinItalic-osf-sc-t1--base.tfm) \
tex(NotoSerif-ThinItalic-osf-sc-t1.tfm) \
tex(NotoSerif-ThinItalic-osf-sc-t1.vf) \
tex(NotoSerif-ThinItalic-osf-sc-t2a--base.tfm) \
tex(NotoSerif-ThinItalic-osf-sc-t2a.tfm) \
tex(NotoSerif-ThinItalic-osf-sc-t2a.vf) \
tex(NotoSerif-ThinItalic-osf-sc-t2b--base.tfm) \
tex(NotoSerif-ThinItalic-osf-sc-t2b.tfm) \
tex(NotoSerif-ThinItalic-osf-sc-t2b.vf) \
tex(NotoSerif-ThinItalic-osf-sc-t2c--base.tfm) \
tex(NotoSerif-ThinItalic-osf-sc-t2c.tfm) \
tex(NotoSerif-ThinItalic-osf-sc-t2c.vf) \
tex(NotoSerif-ThinItalic-osf-t1--base.tfm) \
tex(NotoSerif-ThinItalic-osf-t1.tfm) \
tex(NotoSerif-ThinItalic-osf-t1.vf) \
tex(NotoSerif-ThinItalic-osf-t2a.tfm) \
tex(NotoSerif-ThinItalic-osf-t2b.tfm) \
tex(NotoSerif-ThinItalic-osf-t2c.tfm) \
tex(NotoSerif-ThinItalic-osf-ts1--base.tfm) \
tex(NotoSerif-ThinItalic-osf-ts1.tfm) \
tex(NotoSerif-ThinItalic-osf-ts1.vf) \
tex(NotoSerif-ThinItalic-sup-lgr.tfm) \
tex(NotoSerif-ThinItalic-sup-ly1.tfm) \
tex(NotoSerif-ThinItalic-sup-ot1.tfm) \
tex(NotoSerif-ThinItalic-sup-t1--base.tfm) \
tex(NotoSerif-ThinItalic-sup-t1.tfm) \
tex(NotoSerif-ThinItalic-sup-t1.vf) \
tex(NotoSerif-ThinItalic-sup-t2a.tfm) \
tex(NotoSerif-ThinItalic-sup-t2b.tfm) \
tex(NotoSerif-ThinItalic-sup-t2c.tfm) \
tex(NotoSerif-ThinItalic-tlf-lgr.tfm) \
tex(NotoSerif-ThinItalic-tlf-ly1.tfm) \
tex(NotoSerif-ThinItalic-tlf-ot1.tfm) \
tex(NotoSerif-ThinItalic-tlf-sc-lgr.tfm) \
tex(NotoSerif-ThinItalic-tlf-sc-ly1--base.tfm) \
tex(NotoSerif-ThinItalic-tlf-sc-ly1.tfm) \
tex(NotoSerif-ThinItalic-tlf-sc-ly1.vf) \
tex(NotoSerif-ThinItalic-tlf-sc-ot1--base.tfm) \
tex(NotoSerif-ThinItalic-tlf-sc-ot1.tfm) \
tex(NotoSerif-ThinItalic-tlf-sc-ot1.vf) \
tex(NotoSerif-ThinItalic-tlf-sc-t1--base.tfm) \
tex(NotoSerif-ThinItalic-tlf-sc-t1.tfm) \
tex(NotoSerif-ThinItalic-tlf-sc-t1.vf) \
tex(NotoSerif-ThinItalic-tlf-sc-t2a--base.tfm) \
tex(NotoSerif-ThinItalic-tlf-sc-t2a.tfm) \
tex(NotoSerif-ThinItalic-tlf-sc-t2a.vf) \
tex(NotoSerif-ThinItalic-tlf-sc-t2b--base.tfm) \
tex(NotoSerif-ThinItalic-tlf-sc-t2b.tfm) \
tex(NotoSerif-ThinItalic-tlf-sc-t2b.vf) \
tex(NotoSerif-ThinItalic-tlf-sc-t2c--base.tfm) \
tex(NotoSerif-ThinItalic-tlf-sc-t2c.tfm) \
tex(NotoSerif-ThinItalic-tlf-sc-t2c.vf) \
tex(NotoSerif-ThinItalic-tlf-t1--base.tfm) \
tex(NotoSerif-ThinItalic-tlf-t1.tfm) \
tex(NotoSerif-ThinItalic-tlf-t1.vf) \
tex(NotoSerif-ThinItalic-tlf-t2a.tfm) \
tex(NotoSerif-ThinItalic-tlf-t2b.tfm) \
tex(NotoSerif-ThinItalic-tlf-t2c.tfm) \
tex(NotoSerif-ThinItalic-tlf-ts1--base.tfm) \
tex(NotoSerif-ThinItalic-tlf-ts1.tfm) \
tex(NotoSerif-ThinItalic-tlf-ts1.vf) \
tex(NotoSerif-ThinItalic-tosf-lgr.tfm) \
tex(NotoSerif-ThinItalic-tosf-ly1.tfm) \
tex(NotoSerif-ThinItalic-tosf-ot1.tfm) \
tex(NotoSerif-ThinItalic-tosf-sc-lgr.tfm) \
tex(NotoSerif-ThinItalic-tosf-sc-ly1--base.tfm) \
tex(NotoSerif-ThinItalic-tosf-sc-ly1.tfm) \
tex(NotoSerif-ThinItalic-tosf-sc-ly1.vf) \
tex(NotoSerif-ThinItalic-tosf-sc-ot1--base.tfm) \
tex(NotoSerif-ThinItalic-tosf-sc-ot1.tfm) \
tex(NotoSerif-ThinItalic-tosf-sc-ot1.vf) \
tex(NotoSerif-ThinItalic-tosf-sc-t1--base.tfm) \
tex(NotoSerif-ThinItalic-tosf-sc-t1.tfm) \
tex(NotoSerif-ThinItalic-tosf-sc-t1.vf) \
tex(NotoSerif-ThinItalic-tosf-sc-t2a--base.tfm) \
tex(NotoSerif-ThinItalic-tosf-sc-t2a.tfm) \
tex(NotoSerif-ThinItalic-tosf-sc-t2a.vf) \
tex(NotoSerif-ThinItalic-tosf-sc-t2b--base.tfm) \
tex(NotoSerif-ThinItalic-tosf-sc-t2b.tfm) \
tex(NotoSerif-ThinItalic-tosf-sc-t2b.vf) \
tex(NotoSerif-ThinItalic-tosf-sc-t2c--base.tfm) \
tex(NotoSerif-ThinItalic-tosf-sc-t2c.tfm) \
tex(NotoSerif-ThinItalic-tosf-sc-t2c.vf) \
tex(NotoSerif-ThinItalic-tosf-t1--base.tfm) \
tex(NotoSerif-ThinItalic-tosf-t1.tfm) \
tex(NotoSerif-ThinItalic-tosf-t1.vf) \
tex(NotoSerif-ThinItalic-tosf-t2a.tfm) \
tex(NotoSerif-ThinItalic-tosf-t2b.tfm) \
tex(NotoSerif-ThinItalic-tosf-t2c.tfm) \
tex(NotoSerif-ThinItalic-tosf-ts1--base.tfm) \
tex(NotoSerif-ThinItalic-tosf-ts1.tfm) \
tex(NotoSerif-ThinItalic-tosf-ts1.vf) \
tex(OT1NotoSans-LF.fd) \
tex(OT1NotoSans-OsF.fd) \
tex(OT1NotoSans-Sup.fd) \
tex(OT1NotoSans-TLF.fd) \
tex(OT1NotoSans-TOsF.fd) \
tex(OT1NotoSansMono-Sup.fd) \
tex(OT1NotoSansMono-TLF.fd) \
tex(OT1NotoSansMono-TOsF.fd) \
tex(OT1NotoSerif-LF.fd) \
tex(OT1NotoSerif-OsF.fd) \
tex(OT1NotoSerif-Sup.fd) \
tex(OT1NotoSerif-TLF.fd) \
tex(OT1NotoSerif-TOsF.fd) \
tex(T1NotoSans-LF.fd) \
tex(T1NotoSans-OsF.fd) \
tex(T1NotoSans-Sup.fd) \
tex(T1NotoSans-TLF.fd) \
tex(T1NotoSans-TOsF.fd) \
tex(T1NotoSansMono-Sup.fd) \
tex(T1NotoSansMono-TLF.fd) \
tex(T1NotoSansMono-TOsF.fd) \
tex(T1NotoSerif-LF.fd) \
tex(T1NotoSerif-OsF.fd) \
tex(T1NotoSerif-Sup.fd) \
tex(T1NotoSerif-TLF.fd) \
tex(T1NotoSerif-TOsF.fd) \
tex(T2ANotoSans-LF.fd) \
tex(T2ANotoSans-OsF.fd) \
tex(T2ANotoSans-Sup.fd) \
tex(T2ANotoSans-TLF.fd) \
tex(T2ANotoSans-TOsF.fd) \
tex(T2ANotoSansMono-Sup.fd) \
tex(T2ANotoSansMono-TLF.fd) \
tex(T2ANotoSansMono-TOsF.fd) \
tex(T2ANotoSerif-LF.fd) \
tex(T2ANotoSerif-OsF.fd) \
tex(T2ANotoSerif-Sup.fd) \
tex(T2ANotoSerif-TLF.fd) \
tex(T2ANotoSerif-TOsF.fd) \
tex(T2BNotoSans-LF.fd) \
tex(T2BNotoSans-OsF.fd) \
tex(T2BNotoSans-Sup.fd) \
tex(T2BNotoSans-TLF.fd) \
tex(T2BNotoSans-TOsF.fd) \
tex(T2BNotoSansMono-Sup.fd) \
tex(T2BNotoSansMono-TLF.fd) \
tex(T2BNotoSansMono-TOsF.fd) \
tex(T2BNotoSerif-LF.fd) \
tex(T2BNotoSerif-OsF.fd) \
tex(T2BNotoSerif-Sup.fd) \
tex(T2BNotoSerif-TLF.fd) \
tex(T2BNotoSerif-TOsF.fd) \
tex(T2CNotoSans-LF.fd) \
tex(T2CNotoSans-OsF.fd) \
tex(T2CNotoSans-Sup.fd) \
tex(T2CNotoSans-TLF.fd) \
tex(T2CNotoSans-TOsF.fd) \
tex(T2CNotoSansMono-Sup.fd) \
tex(T2CNotoSansMono-TLF.fd) \
tex(T2CNotoSansMono-TOsF.fd) \
tex(T2CNotoSerif-LF.fd) \
tex(T2CNotoSerif-OsF.fd) \
tex(T2CNotoSerif-Sup.fd) \
tex(T2CNotoSerif-TLF.fd) \
tex(T2CNotoSerif-TOsF.fd) \
tex(TS1NotoSans-LF.fd) \
tex(TS1NotoSans-OsF.fd) \
tex(TS1NotoSans-TLF.fd) \
tex(TS1NotoSans-TOsF.fd) \
tex(TS1NotoSansMono-TLF.fd) \
tex(TS1NotoSansMono-TOsF.fd) \
tex(TS1NotoSerif-LF.fd) \
tex(TS1NotoSerif-OsF.fd) \
tex(TS1NotoSerif-TLF.fd) \
tex(TS1NotoSerif-TOsF.fd) \
tex(a_23t6v6.enc) \
tex(a_2gssks.enc) \
tex(a_3gh25n.enc) \
tex(a_3idd2i.enc) \
tex(a_3nh6de.enc) \
tex(a_3njtyh.enc) \
tex(a_3pvjsh.enc) \
tex(a_3qka2q.enc) \
tex(a_3utovq.enc) \
tex(a_47rvkj.enc) \
tex(a_4g272e.enc) \
tex(a_4hfkmi.enc) \
tex(a_4u4rqx.enc) \
tex(a_52qs4q.enc) \
tex(a_533fr4.enc) \
tex(a_57pcdw.enc) \
tex(a_5mzvu7.enc) \
tex(a_5pmcwb.enc) \
tex(a_5xwbon.enc) \
tex(a_623vws.enc) \
tex(a_63wp3v.enc) \
tex(a_6aka6h.enc) \
tex(a_6twv4d.enc) \
tex(a_772cjc.enc) \
tex(a_7bgfws.enc) \
tex(a_7ixzi4.enc) \
tex(a_7kfhbb.enc) \
tex(a_7nvxzr.enc) \
tex(a_7tyugd.enc) \
tex(a_a3ay2j.enc) \
tex(a_andblm.enc) \
tex(a_anmevl.enc) \
tex(a_bvwui6.enc) \
tex(a_bxhngq.enc) \
tex(a_c3bld5.enc) \
tex(a_c6wwr2.enc) \
tex(a_cjhu7y.enc) \
tex(a_clpsiq.enc) \
tex(a_cn5brv.enc) \
tex(a_cp3cte.enc) \
tex(a_cwvxtj.enc) \
tex(a_d2rsb5.enc) \
tex(a_d4qnfi.enc) \
tex(a_dadzwx.enc) \
tex(a_dbnhwa.enc) \
tex(a_ditypz.enc) \
tex(a_dov7os.enc) \
tex(a_dudwhc.enc) \
tex(a_e3kj7m.enc) \
tex(a_efce2n.enc) \
tex(a_eoogfy.enc) \
tex(a_eosscl.enc) \
tex(a_ez2y5p.enc) \
tex(a_ez4wts.enc) \
tex(a_ezjax5.enc) \
tex(a_fv2jeg.enc) \
tex(a_g4k3w3.enc) \
tex(a_gphhjx.enc) \
tex(a_gwevhp.enc) \
tex(a_gyb4rp.enc) \
tex(a_h2q3hr.enc) \
tex(a_h6fjyk.enc) \
tex(a_hc6tg2.enc) \
tex(a_hge7ml.enc) \
tex(a_hj5qan.enc) \
tex(a_honops.enc) \
tex(a_hvbi2c.enc) \
tex(a_ibmxvo.enc) \
tex(a_ilpfnc.enc) \
tex(a_jbt6o3.enc) \
tex(a_jde47l.enc) \
tex(a_jdknzu.enc) \
tex(a_jjjryc.enc) \
tex(a_jjkxah.enc) \
tex(a_kcvkxa.enc) \
tex(a_kejqxe.enc) \
tex(a_ky2jui.enc) \
tex(a_lavhrd.enc) \
tex(a_lefphz.enc) \
tex(a_lhny74.enc) \
tex(a_m5xrw6.enc) \
tex(a_mpi44v.enc) \
tex(a_mth4zs.enc) \
tex(a_mun6gy.enc) \
tex(a_mz6bs5.enc) \
tex(a_n3icpd.enc) \
tex(a_n43hoi.enc) \
tex(a_ob47l7.enc) \
tex(a_og6ksl.enc) \
tex(a_ombcnn.enc) \
tex(a_oprn5k.enc) \
tex(a_pboqxw.enc) \
tex(a_pbvxm5.enc) \
tex(a_pgzpov.enc) \
tex(a_pi22w6.enc) \
tex(a_pke5io.enc) \
tex(a_pqgg2n.enc) \
tex(a_qbvbpy.enc) \
tex(a_qhtgxt.enc) \
tex(a_qndmgf.enc) \
tex(a_r26tzy.enc) \
tex(a_rhblzr.enc) \
tex(a_rjgu3w.enc) \
tex(a_rrep23.enc) \
tex(a_rxdup2.enc) \
tex(a_sprqvi.enc) \
tex(a_sqptsk.enc) \
tex(a_sxundy.enc) \
tex(a_t2unpo.enc) \
tex(a_t3opuj.enc) \
tex(a_t6vbrd.enc) \
tex(a_tnyntu.enc) \
tex(a_u3fnjl.enc) \
tex(a_u5bewk.enc) \
tex(a_uhbuf6.enc) \
tex(a_vlry66.enc) \
tex(a_vyfymq.enc) \
tex(a_w67jv7.enc) \
tex(a_wcjgjy.enc) \
tex(a_wfibuq.enc) \
tex(a_wiy4e7.enc) \
tex(a_wsd2lr.enc) \
tex(a_x3b3qr.enc) \
tex(a_xdaab2.enc) \
tex(a_xjknry.enc) \
tex(a_xroyy4.enc) \
tex(a_xt7xsz.enc) \
tex(a_y2n3gg.enc) \
tex(a_z556xg.enc) \
tex(a_zmzdvf.enc) \
tex(a_zo23om.enc) \
tex(noto-mono.sty) \
tex(noto-sans.sty) \
tex(noto-serif.sty) \
tex(noto.map) \
tex(noto.sty) \
texlive-noto"
RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex(fontaxes.sty) \
tex(fontenc.sty) \
tex(fontspec.sty) \
tex(ifluatex.sty) \
tex(ifxetex.sty) \
tex(mweights.sty) \
tex(textcomp.sty) \
tex(updmap.cfg) \
tex(xkeyval.sty) \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-noto-fonts \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
