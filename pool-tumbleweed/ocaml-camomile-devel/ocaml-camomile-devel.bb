SUMMARY = "Development files for ocaml-camomile"
DESCRIPTION = "The ocaml-camomile-devel package contains libraries and signature files for \
developing applications that use ocaml-camomile."
LICENSE = "LGPL-2.0+"

PV = "1.0.2"

RPM_NAME = "ocaml-camomile-devel-1.0.2-3.25.aarch64.rpm"
RPM_HASH = "3964bd24375722ffaef274bcbee8890278479a5706286ae51b81573f055a8e24d1105b041920c779648771be883b007057fc3e6121b435b35bbcf228fc8a39ed"

RPROVIDES:${PN} += "ocaml-Camomile-do-not-use \
ocaml-CamomileDefaultConfig \
ocaml-CamomileDefaultConfig-- \
ocaml-CamomileDefaultConfig--InstallConfig \
ocaml-CamomileLibrary \
ocaml-CamomileLibrary-- \
ocaml-CamomileLibrary--AvlTree \
ocaml-CamomileLibrary--Bitsvect \
ocaml-CamomileLibrary--Byte-labeled-dag \
ocaml-CamomileLibrary--Bytesvect \
ocaml-CamomileLibrary--CaseMap \
ocaml-CamomileLibrary--CharEncoding \
ocaml-CamomileLibrary--Charmap \
ocaml-CamomileLibrary--ConfigInt \
ocaml-CamomileLibrary--Database \
ocaml-CamomileLibrary--Hangul \
ocaml-CamomileLibrary--IMap \
ocaml-CamomileLibrary--ISet \
ocaml-CamomileLibrary--Locale \
ocaml-CamomileLibrary--OOChannel \
ocaml-CamomileLibrary--StringPrep \
ocaml-CamomileLibrary--StringPrep-data \
ocaml-CamomileLibrary--SubText \
ocaml-CamomileLibrary--Tbl31 \
ocaml-CamomileLibrary--UCS4 \
ocaml-CamomileLibrary--UChar \
ocaml-CamomileLibrary--UCharInfo \
ocaml-CamomileLibrary--UCharTbl \
ocaml-CamomileLibrary--UCol \
ocaml-CamomileLibrary--ULine \
ocaml-CamomileLibrary--UMap \
ocaml-CamomileLibrary--UNF \
ocaml-CamomileLibrary--UPervasives \
ocaml-CamomileLibrary--URe \
ocaml-CamomileLibrary--UReStr \
ocaml-CamomileLibrary--UReStrLexer \
ocaml-CamomileLibrary--UReStrParser \
ocaml-CamomileLibrary--UReStrParserType \
ocaml-CamomileLibrary--USet \
ocaml-CamomileLibrary--UTF16 \
ocaml-CamomileLibrary--UTF8 \
ocaml-CamomileLibrary--UText \
ocaml-CamomileLibrary--UnicodeString \
ocaml-CamomileLibrary--Unidata \
ocaml-CamomileLibrary--Unimap \
ocaml-CamomileLibrary--XArray \
ocaml-CamomileLibrary--XString \
ocaml-CamomileLibraryDefault \
ocaml-CamomileLibraryDyn \
ocaml-camomile-devel \
ocamlfind-camomile \
ocamlfind-camomile.default-config \
ocamlfind-camomile.dyn \
ocamlfind-camomile.lib-default \
ocamlfind-camomile.library \
ocamlx-Camomile-do-not-use \
ocamlx-CamomileDefaultConfig \
ocamlx-CamomileDefaultConfig-- \
ocamlx-CamomileDefaultConfig--InstallConfig \
ocamlx-CamomileLibrary \
ocamlx-CamomileLibrary-- \
ocamlx-CamomileLibrary--AvlTree \
ocamlx-CamomileLibrary--Bitsvect \
ocamlx-CamomileLibrary--Byte-labeled-dag \
ocamlx-CamomileLibrary--Bytesvect \
ocamlx-CamomileLibrary--CaseMap \
ocamlx-CamomileLibrary--CharEncoding \
ocamlx-CamomileLibrary--Charmap \
ocamlx-CamomileLibrary--ConfigInt \
ocamlx-CamomileLibrary--Database \
ocamlx-CamomileLibrary--Hangul \
ocamlx-CamomileLibrary--IMap \
ocamlx-CamomileLibrary--ISet \
ocamlx-CamomileLibrary--Locale \
ocamlx-CamomileLibrary--OOChannel \
ocamlx-CamomileLibrary--StringPrep \
ocamlx-CamomileLibrary--StringPrep-data \
ocamlx-CamomileLibrary--SubText \
ocamlx-CamomileLibrary--Tbl31 \
ocamlx-CamomileLibrary--UCS4 \
ocamlx-CamomileLibrary--UChar \
ocamlx-CamomileLibrary--UCharInfo \
ocamlx-CamomileLibrary--UCharTbl \
ocamlx-CamomileLibrary--UCol \
ocamlx-CamomileLibrary--ULine \
ocamlx-CamomileLibrary--UMap \
ocamlx-CamomileLibrary--UNF \
ocamlx-CamomileLibrary--UPervasives \
ocamlx-CamomileLibrary--URe \
ocamlx-CamomileLibrary--UReStr \
ocamlx-CamomileLibrary--UReStrLexer \
ocamlx-CamomileLibrary--UReStrParser \
ocamlx-CamomileLibrary--UReStrParserType \
ocamlx-CamomileLibrary--USet \
ocamlx-CamomileLibrary--UTF16 \
ocamlx-CamomileLibrary--UTF8 \
ocamlx-CamomileLibrary--UText \
ocamlx-CamomileLibrary--UnicodeString \
ocamlx-CamomileLibrary--Unidata \
ocamlx-CamomileLibrary--Unimap \
ocamlx-CamomileLibrary--XArray \
ocamlx-CamomileLibrary--XString \
ocamlx-CamomileLibraryDefault \
ocamlx-CamomileLibraryDyn"

RDEPENDS:${PN} += "ocaml-CamlinternalFormatBasics \
ocaml-CamlinternalLazy \
ocaml-CamlinternalOO \
ocaml-Stdlib \
ocaml-Stdlib--Array \
ocaml-Stdlib--Bigarray \
ocaml-Stdlib--Buffer \
ocaml-Stdlib--Bytes \
ocaml-Stdlib--Char \
ocaml-Stdlib--Complex \
ocaml-Stdlib--Either \
ocaml-Stdlib--Filename \
ocaml-Stdlib--Format \
ocaml-Stdlib--Hashtbl \
ocaml-Stdlib--Int32 \
ocaml-Stdlib--Lazy \
ocaml-Stdlib--Lexing \
ocaml-Stdlib--List \
ocaml-Stdlib--Obj \
ocaml-Stdlib--Parsing \
ocaml-Stdlib--Pervasives \
ocaml-Stdlib--Printf \
ocaml-Stdlib--Queue \
ocaml-Stdlib--Seq \
ocaml-Stdlib--Stream \
ocaml-Stdlib--String \
ocaml-Stdlib--StringLabels \
ocaml-Stdlib--Sys \
ocaml-Stdlib--Uchar \
ocaml-Stdlib--Weak \
ocaml-camomile \
ocamlfind-bigarray \
ocamlx-CamlinternalLazy \
ocamlx-CamlinternalOO \
ocamlx-Stdlib \
ocamlx-Stdlib--Array \
ocamlx-Stdlib--Bigarray \
ocamlx-Stdlib--Buffer \
ocamlx-Stdlib--Bytes \
ocamlx-Stdlib--Char \
ocamlx-Stdlib--Filename \
ocamlx-Stdlib--Format \
ocamlx-Stdlib--Hashtbl \
ocamlx-Stdlib--Lexing \
ocamlx-Stdlib--List \
ocamlx-Stdlib--Parsing \
ocamlx-Stdlib--Printf \
ocamlx-Stdlib--Queue \
ocamlx-Stdlib--Stream \
ocamlx-Stdlib--String \
ocamlx-Stdlib--StringLabels \
ocamlx-Stdlib--Sys \
ocamlx-Stdlib--Weak"

inherit rpm
