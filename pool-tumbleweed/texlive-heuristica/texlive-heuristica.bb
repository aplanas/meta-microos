SUMMARY = "Fonts extending Utopia, with LaTeX support files"
DESCRIPTION = "The fonts extend the utopia set with Cyrillic glyphs, \
additional figure styles, ligatures and Small Caps in Regular \
style only. Macro support, and maths fonts that match the \
Utopia family, are provided by the Fourier and the Mathdesign \
font packages."
LICENSE = "OFL-1.1"

PV = "2023.209.1.092svn51362"

RPM_NAME = "texlive-heuristica-2023.209.1.092svn51362-54.1.noarch.rpm"
RPM_HASH = "47c6672e92784bb27690fee9b8b4094424ac960224ac1e523f21e28f032c8a5ac3e49372cdf14011c941d051cae17ab3794c58bc955be298b0f88b2c1b6c4845"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-Heuristica-Bold-inf-ly1.tfm \
tex-Heuristica-Bold-inf-t1--base.tfm \
tex-Heuristica-Bold-inf-t1.tfm \
tex-Heuristica-Bold-inf-t1.vf \
tex-Heuristica-Bold-inf-t2a.tfm \
tex-Heuristica-Bold-inf-t2b.tfm \
tex-Heuristica-Bold-inf-t2c.tfm \
tex-Heuristica-Bold-sup-ly1.tfm \
tex-Heuristica-Bold-sup-t1--base.tfm \
tex-Heuristica-Bold-sup-t1.tfm \
tex-Heuristica-Bold-sup-t1.vf \
tex-Heuristica-Bold-sup-t2a.tfm \
tex-Heuristica-Bold-sup-t2b.tfm \
tex-Heuristica-Bold-sup-t2c.tfm \
tex-Heuristica-Bold-tlf-ly1.tfm \
tex-Heuristica-Bold-tlf-t1--base.tfm \
tex-Heuristica-Bold-tlf-t1.tfm \
tex-Heuristica-Bold-tlf-t1.vf \
tex-Heuristica-Bold-tlf-t2a.tfm \
tex-Heuristica-Bold-tlf-t2b.tfm \
tex-Heuristica-Bold-tlf-t2c.tfm \
tex-Heuristica-Bold-tlf-ts1--base.tfm \
tex-Heuristica-Bold-tlf-ts1.tfm \
tex-Heuristica-Bold-tlf-ts1.vf \
tex-Heuristica-Bold-tosf-ly1.tfm \
tex-Heuristica-Bold-tosf-t1--base.tfm \
tex-Heuristica-Bold-tosf-t1.tfm \
tex-Heuristica-Bold-tosf-t1.vf \
tex-Heuristica-Bold-tosf-t2a.tfm \
tex-Heuristica-Bold-tosf-t2b.tfm \
tex-Heuristica-Bold-tosf-t2c.tfm \
tex-Heuristica-Bold-tosf-ts1--base.tfm \
tex-Heuristica-Bold-tosf-ts1.tfm \
tex-Heuristica-Bold-tosf-ts1.vf \
tex-Heuristica-BoldItalic-inf-ly1.tfm \
tex-Heuristica-BoldItalic-inf-t1--base.tfm \
tex-Heuristica-BoldItalic-inf-t1.tfm \
tex-Heuristica-BoldItalic-inf-t1.vf \
tex-Heuristica-BoldItalic-inf-t2a.tfm \
tex-Heuristica-BoldItalic-inf-t2b.tfm \
tex-Heuristica-BoldItalic-inf-t2c.tfm \
tex-Heuristica-BoldItalic-sup-ly1.tfm \
tex-Heuristica-BoldItalic-sup-t1--base.tfm \
tex-Heuristica-BoldItalic-sup-t1.tfm \
tex-Heuristica-BoldItalic-sup-t1.vf \
tex-Heuristica-BoldItalic-sup-t2a.tfm \
tex-Heuristica-BoldItalic-sup-t2b.tfm \
tex-Heuristica-BoldItalic-sup-t2c.tfm \
tex-Heuristica-BoldItalic-tlf-ly1.tfm \
tex-Heuristica-BoldItalic-tlf-t1--base.tfm \
tex-Heuristica-BoldItalic-tlf-t1.tfm \
tex-Heuristica-BoldItalic-tlf-t1.vf \
tex-Heuristica-BoldItalic-tlf-t2a.tfm \
tex-Heuristica-BoldItalic-tlf-t2b.tfm \
tex-Heuristica-BoldItalic-tlf-t2c.tfm \
tex-Heuristica-BoldItalic-tlf-ts1--base.tfm \
tex-Heuristica-BoldItalic-tlf-ts1.tfm \
tex-Heuristica-BoldItalic-tlf-ts1.vf \
tex-Heuristica-BoldItalic-tosf-ly1.tfm \
tex-Heuristica-BoldItalic-tosf-t1--base.tfm \
tex-Heuristica-BoldItalic-tosf-t1.tfm \
tex-Heuristica-BoldItalic-tosf-t1.vf \
tex-Heuristica-BoldItalic-tosf-t2a.tfm \
tex-Heuristica-BoldItalic-tosf-t2b.tfm \
tex-Heuristica-BoldItalic-tosf-t2c.tfm \
tex-Heuristica-BoldItalic-tosf-ts1--base.tfm \
tex-Heuristica-BoldItalic-tosf-ts1.tfm \
tex-Heuristica-BoldItalic-tosf-ts1.vf \
tex-Heuristica-Italic-inf-ly1.tfm \
tex-Heuristica-Italic-inf-t1--base.tfm \
tex-Heuristica-Italic-inf-t1.tfm \
tex-Heuristica-Italic-inf-t1.vf \
tex-Heuristica-Italic-inf-t2a.tfm \
tex-Heuristica-Italic-inf-t2b.tfm \
tex-Heuristica-Italic-inf-t2c.tfm \
tex-Heuristica-Italic-sup-ly1.tfm \
tex-Heuristica-Italic-sup-t1--base.tfm \
tex-Heuristica-Italic-sup-t1.tfm \
tex-Heuristica-Italic-sup-t1.vf \
tex-Heuristica-Italic-sup-t2a.tfm \
tex-Heuristica-Italic-sup-t2b.tfm \
tex-Heuristica-Italic-sup-t2c.tfm \
tex-Heuristica-Italic-tlf-ly1.tfm \
tex-Heuristica-Italic-tlf-t1--base.tfm \
tex-Heuristica-Italic-tlf-t1.tfm \
tex-Heuristica-Italic-tlf-t1.vf \
tex-Heuristica-Italic-tlf-t2a.tfm \
tex-Heuristica-Italic-tlf-t2b.tfm \
tex-Heuristica-Italic-tlf-t2c.tfm \
tex-Heuristica-Italic-tlf-ts1--base.tfm \
tex-Heuristica-Italic-tlf-ts1.tfm \
tex-Heuristica-Italic-tlf-ts1.vf \
tex-Heuristica-Italic-tosf-ly1.tfm \
tex-Heuristica-Italic-tosf-t1--base.tfm \
tex-Heuristica-Italic-tosf-t1.tfm \
tex-Heuristica-Italic-tosf-t1.vf \
tex-Heuristica-Italic-tosf-t2a.tfm \
tex-Heuristica-Italic-tosf-t2b.tfm \
tex-Heuristica-Italic-tosf-t2c.tfm \
tex-Heuristica-Italic-tosf-ts1--base.tfm \
tex-Heuristica-Italic-tosf-ts1.tfm \
tex-Heuristica-Italic-tosf-ts1.vf \
tex-Heuristica-Regular-inf-ly1.tfm \
tex-Heuristica-Regular-inf-t1--base.tfm \
tex-Heuristica-Regular-inf-t1.tfm \
tex-Heuristica-Regular-inf-t1.vf \
tex-Heuristica-Regular-inf-t2a.tfm \
tex-Heuristica-Regular-inf-t2b.tfm \
tex-Heuristica-Regular-inf-t2c.tfm \
tex-Heuristica-Regular-sup-ly1.tfm \
tex-Heuristica-Regular-sup-t1--base.tfm \
tex-Heuristica-Regular-sup-t1.tfm \
tex-Heuristica-Regular-sup-t1.vf \
tex-Heuristica-Regular-sup-t2a.tfm \
tex-Heuristica-Regular-sup-t2b.tfm \
tex-Heuristica-Regular-sup-t2c.tfm \
tex-Heuristica-Regular-tlf-ly1.tfm \
tex-Heuristica-Regular-tlf-sc-ly1--base.tfm \
tex-Heuristica-Regular-tlf-sc-ly1.tfm \
tex-Heuristica-Regular-tlf-sc-ly1.vf \
tex-Heuristica-Regular-tlf-sc-t1--base.tfm \
tex-Heuristica-Regular-tlf-sc-t1.tfm \
tex-Heuristica-Regular-tlf-sc-t1.vf \
tex-Heuristica-Regular-tlf-sc-t2a.tfm \
tex-Heuristica-Regular-tlf-sc-t2b.tfm \
tex-Heuristica-Regular-tlf-sc-t2c.tfm \
tex-Heuristica-Regular-tlf-t1--base.tfm \
tex-Heuristica-Regular-tlf-t1.tfm \
tex-Heuristica-Regular-tlf-t1.vf \
tex-Heuristica-Regular-tlf-t2a.tfm \
tex-Heuristica-Regular-tlf-t2b.tfm \
tex-Heuristica-Regular-tlf-t2c.tfm \
tex-Heuristica-Regular-tlf-ts1--base.tfm \
tex-Heuristica-Regular-tlf-ts1.tfm \
tex-Heuristica-Regular-tlf-ts1.vf \
tex-Heuristica-Regular-tosf-ly1.tfm \
tex-Heuristica-Regular-tosf-sc-ly1--base.tfm \
tex-Heuristica-Regular-tosf-sc-ly1.tfm \
tex-Heuristica-Regular-tosf-sc-ly1.vf \
tex-Heuristica-Regular-tosf-sc-t1--base.tfm \
tex-Heuristica-Regular-tosf-sc-t1.tfm \
tex-Heuristica-Regular-tosf-sc-t1.vf \
tex-Heuristica-Regular-tosf-sc-t2a.tfm \
tex-Heuristica-Regular-tosf-sc-t2b.tfm \
tex-Heuristica-Regular-tosf-sc-t2c.tfm \
tex-Heuristica-Regular-tosf-t1--base.tfm \
tex-Heuristica-Regular-tosf-t1.tfm \
tex-Heuristica-Regular-tosf-t1.vf \
tex-Heuristica-Regular-tosf-t2a.tfm \
tex-Heuristica-Regular-tosf-t2b.tfm \
tex-Heuristica-Regular-tosf-t2c.tfm \
tex-Heuristica-Regular-tosf-ts1--base.tfm \
tex-Heuristica-Regular-tosf-ts1.tfm \
tex-Heuristica-Regular-tosf-ts1.vf \
tex-Heuristica.map \
tex-LY1Heuristica-Inf.fd \
tex-LY1Heuristica-Sup.fd \
tex-LY1Heuristica-TLF.fd \
tex-LY1Heuristica-TOsF.fd \
tex-T1Heuristica-Inf.fd \
tex-T1Heuristica-Sup.fd \
tex-T1Heuristica-TLF.fd \
tex-T1Heuristica-TOsF.fd \
tex-T2AHeuristica-Inf.fd \
tex-T2AHeuristica-Sup.fd \
tex-T2AHeuristica-TLF.fd \
tex-T2AHeuristica-TOsF.fd \
tex-T2BHeuristica-Inf.fd \
tex-T2BHeuristica-Sup.fd \
tex-T2BHeuristica-TLF.fd \
tex-T2BHeuristica-TOsF.fd \
tex-T2CHeuristica-Inf.fd \
tex-T2CHeuristica-Sup.fd \
tex-T2CHeuristica-TLF.fd \
tex-T2CHeuristica-TOsF.fd \
tex-TS1Heuristica-TLF.fd \
tex-TS1Heuristica-TOsF.fd \
tex-heuristica.sty \
tex-zut-5b7xz5.enc \
tex-zut-bavnqe.enc \
tex-zut-ckaykl.enc \
tex-zut-cq6rqq.enc \
tex-zut-cvig5d.enc \
tex-zut-d3dvo4.enc \
tex-zut-dcwkkw.enc \
tex-zut-dhvb6d.enc \
tex-zut-dvh2xl.enc \
tex-zut-e7tlds.enc \
tex-zut-edf5gu.enc \
tex-zut-etrbro.enc \
tex-zut-evgarn.enc \
tex-zut-f5n2rf.enc \
tex-zut-fc3mov.enc \
tex-zut-flhghs.enc \
tex-zut-g4w54e.enc \
tex-zut-geqeyh.enc \
tex-zut-hbxdik.enc \
tex-zut-hln2hy.enc \
tex-zut-hvy566.enc \
tex-zut-ijw3px.enc \
tex-zut-it5nv3.enc \
tex-zut-j3hjx2.enc \
tex-zut-k42udk.enc \
tex-zut-n2gc2n.enc \
tex-zut-nvi5ys.enc \
tex-zut-qy67bk.enc \
tex-zut-rhmrtx.enc \
tex-zut-rutxxy.enc \
tex-zut-tfeu3y.enc \
tex-zut-thxlbm.enc \
tex-zut-tsvs4d.enc \
tex-zut-u7pc6m.enc \
tex-zut-ul3ofd.enc \
tex-zut-v7it2w.enc \
tex-zut-vaioc2.enc \
tex-zut-vtjod4.enc \
tex-zut-ysltpx.enc \
tex-zut-zk7stm.enc \
tex-zut-zl5g24.enc \
texlive-heuristica"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-etoolbox.sty \
tex-fontaxes.sty \
tex-fontenc.sty \
tex-ifthen.sty \
tex-mweights.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-filesystem \
texlive-heuristica-fonts \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
