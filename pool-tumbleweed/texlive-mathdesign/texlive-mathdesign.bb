SUMMARY = "Mathematical fonts to fit with particular text fonts"
DESCRIPTION = "The Math Design project offers free mathematical fonts that \
match with existing text fonts. To date, three free font \
families are available: Adobe Utopia, URW Garamond and \
Bitstream Charter. Three commercial fonts are also supported: \
Adobe Garamond Pro, Adobe UtopiaStd and ITC Charter. Mathdesign \
covers the whole LaTeX glyph set, including AMS symbols and \
some extra. Both roman and bold versions of these symbols can \
be used. Moreover you can choose between three greek fonts (two \
of them created by the Greek Font Society)."
LICENSE = "GPL-2.0-or-later"

PV = "2023.201.2.31svn31639"

RPM_NAME = "texlive-mathdesign-2023.201.2.31svn31639-52.1.noarch.rpm"
RPM_HASH = "e42c4831c724d6cf8474e3a02a5a4844679b239bc5fcf7ce1d1bb87e2041dd3f3f30e426c3b538e84d8d2f903da62efedf1ae7d67bb0de9fa5300d2064a73b14"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex(a_2dncez.enc) \
tex(a_2rwgaw.enc) \
tex(a_42s2zl.enc) \
tex(a_45o73x.enc) \
tex(a_4b5i6w.enc) \
tex(a_57soyv.enc) \
tex(a_csqf63.enc) \
tex(a_e65dz6.enc) \
tex(a_g2masa.enc) \
tex(a_g47ck7.enc) \
tex(a_ipzj2o.enc) \
tex(a_kld4uc.enc) \
tex(a_mdpn2k.enc) \
tex(a_n2elaj.enc) \
tex(a_oxfbe4.enc) \
tex(a_py5znv.enc) \
tex(a_qnfjtt.enc) \
tex(a_qzg4u4.enc) \
tex(a_r2nxhw.enc) \
tex(a_rl4tn2.enc) \
tex(a_rxz3ga.enc) \
tex(a_telfo7.enc) \
tex(a_uwwzqd.enc) \
tex(a_yezm6g.enc) \
tex(bchb8a.tfm) \
tex(bchbc8a.tfm) \
tex(bchbc8y.tfm) \
tex(bchbi8a.tfm) \
tex(bchr8a.tfm) \
tex(bchrc8a.tfm) \
tex(bchrc8y.tfm) \
tex(bchri8a.tfm) \
tex(mathdesign.sty) \
tex(md-chb7m.tfm) \
tex(md-chb7t.tfm) \
tex(md-chb7v.tfm) \
tex(md-chb7y.tfm) \
tex(md-chb8c.tfm) \
tex(md-chb8t.tfm) \
tex(md-chb8y.tfm) \
tex(md-chbc8y.tfm) \
tex(md-chbi7m.tfm) \
tex(md-chbi7t.tfm) \
tex(md-chbi8c.tfm) \
tex(md-chbi8t.tfm) \
tex(md-chbi8y.tfm) \
tex(md-chbma.tfm) \
tex(md-chbmb.tfm) \
tex(md-chbo7t.tfm) \
tex(md-chbo8c.tfm) \
tex(md-chbo8t.tfm) \
tex(md-chbo8y.tfm) \
tex(md-chboc8y.tfm) \
tex(md-chr7m.tfm) \
tex(md-chr7t.tfm) \
tex(md-chr7v.tfm) \
tex(md-chr7y.tfm) \
tex(md-chr8c.tfm) \
tex(md-chr8t.tfm) \
tex(md-chr8y.tfm) \
tex(md-chrc8y.tfm) \
tex(md-chree.tfm) \
tex(md-chri7m.tfm) \
tex(md-chri7t.tfm) \
tex(md-chri8c.tfm) \
tex(md-chri8t.tfm) \
tex(md-chri8y.tfm) \
tex(md-chrma.tfm) \
tex(md-chrmb.tfm) \
tex(md-chro7t.tfm) \
tex(md-chro8c.tfm) \
tex(md-chro8t.tfm) \
tex(md-chro8y.tfm) \
tex(md-chroc8y.tfm) \
tex(md-cib7m.tfm) \
tex(md-cib7t.tfm) \
tex(md-cib7v.tfm) \
tex(md-cib7y.tfm) \
tex(md-cib8c.tfm) \
tex(md-cib8t.tfm) \
tex(md-cibee.tfm) \
tex(md-cibi7m.tfm) \
tex(md-cibi7t.tfm) \
tex(md-cibi8c.tfm) \
tex(md-cibi8t.tfm) \
tex(md-cibma.tfm) \
tex(md-cibmb.tfm) \
tex(md-cir7m.tfm) \
tex(md-cir7t.tfm) \
tex(md-cir7v.tfm) \
tex(md-cir7y.tfm) \
tex(md-cir8c.tfm) \
tex(md-cir8t.tfm) \
tex(md-ciree.tfm) \
tex(md-ciri7m.tfm) \
tex(md-ciri7t.tfm) \
tex(md-ciri8c.tfm) \
tex(md-ciri8t.tfm) \
tex(md-cirma.tfm) \
tex(md-cirmb.tfm) \
tex(md-gdr7m.tfm) \
tex(md-gdr7t.tfm) \
tex(md-gdr7v.tfm) \
tex(md-gdr7y.tfm) \
tex(md-gdr8c.tfm) \
tex(md-gdr8t.tfm) \
tex(md-gdree.tfm) \
tex(md-gdri7m.tfm) \
tex(md-gdri7t.tfm) \
tex(md-gdri8c.tfm) \
tex(md-gdri8t.tfm) \
tex(md-gdrma.tfm) \
tex(md-gdrmb.tfm) \
tex(md-gds7m.tfm) \
tex(md-gds7t.tfm) \
tex(md-gds7v.tfm) \
tex(md-gds7y.tfm) \
tex(md-gds8c.tfm) \
tex(md-gds8t.tfm) \
tex(md-gdsi7m.tfm) \
tex(md-gdsi7t.tfm) \
tex(md-gdsi8c.tfm) \
tex(md-gdsi8t.tfm) \
tex(md-gdsma.tfm) \
tex(md-gdsmb.tfm) \
tex(md-gmm7m.tfm) \
tex(md-gmm7t.tfm) \
tex(md-gmm7v.tfm) \
tex(md-gmm7y.tfm) \
tex(md-gmm8c.tfm) \
tex(md-gmm8t.tfm) \
tex(md-gmm8y.tfm) \
tex(md-gmmi7m.tfm) \
tex(md-gmmi7t.tfm) \
tex(md-gmmi8c.tfm) \
tex(md-gmmi8t.tfm) \
tex(md-gmmi8y.tfm) \
tex(md-gmmma.tfm) \
tex(md-gmmmb.tfm) \
tex(md-gmmo7t.tfm) \
tex(md-gmmo8c.tfm) \
tex(md-gmmo8t.tfm) \
tex(md-gmmo8y.tfm) \
tex(md-gmr7m.tfm) \
tex(md-gmr7t.tfm) \
tex(md-gmr7v.tfm) \
tex(md-gmr7y.tfm) \
tex(md-gmr8c.tfm) \
tex(md-gmr8t.tfm) \
tex(md-gmr8y.tfm) \
tex(md-gmree.tfm) \
tex(md-gmri7m.tfm) \
tex(md-gmri7t.tfm) \
tex(md-gmri8c.tfm) \
tex(md-gmri8t.tfm) \
tex(md-gmri8y.tfm) \
tex(md-gmrma.tfm) \
tex(md-gmrmb.tfm) \
tex(md-gmro7t.tfm) \
tex(md-gmro8c.tfm) \
tex(md-gmro8t.tfm) \
tex(md-gmro8y.tfm) \
tex(md-grbb7m.tfm) \
tex(md-grbbi7m.tfm) \
tex(md-grbr7m.tfm) \
tex(md-grbri7m.tfm) \
tex(md-grdb7m.tfm) \
tex(md-grdbi7m.tfm) \
tex(md-grdr7m.tfm) \
tex(md-grdri7m.tfm) \
tex(md-usr7m.tfm) \
tex(md-usr7t.tfm) \
tex(md-usr7t5.tfm) \
tex(md-usr7t6.tfm) \
tex(md-usr7t7.tfm) \
tex(md-usr7t8.tfm) \
tex(md-usr7t9.tfm) \
tex(md-usr7v.tfm) \
tex(md-usr7y.tfm) \
tex(md-usr8c.tfm) \
tex(md-usr8t.tfm) \
tex(md-usree.tfm) \
tex(md-usri7m.tfm) \
tex(md-usri7t.tfm) \
tex(md-usri7t5.tfm) \
tex(md-usri7t6.tfm) \
tex(md-usri7t7.tfm) \
tex(md-usri7t8.tfm) \
tex(md-usri7t9.tfm) \
tex(md-usri8c.tfm) \
tex(md-usri8t.tfm) \
tex(md-usrma.tfm) \
tex(md-usrmb.tfm) \
tex(md-uss7m.tfm) \
tex(md-uss7t.tfm) \
tex(md-uss7v.tfm) \
tex(md-uss7y.tfm) \
tex(md-uss8c.tfm) \
tex(md-uss8t.tfm) \
tex(md-ussi7m.tfm) \
tex(md-ussi7t.tfm) \
tex(md-ussi8c.tfm) \
tex(md-ussi8t.tfm) \
tex(md-ussma.tfm) \
tex(md-ussmb.tfm) \
tex(md-utb7m.tfm) \
tex(md-utb7t.tfm) \
tex(md-utb7v.tfm) \
tex(md-utb7y.tfm) \
tex(md-utb8c.tfm) \
tex(md-utb8t.tfm) \
tex(md-utb8y.tfm) \
tex(md-utbee.tfm) \
tex(md-utbi7m.tfm) \
tex(md-utbi7t.tfm) \
tex(md-utbi8c.tfm) \
tex(md-utbi8t.tfm) \
tex(md-utbi8y.tfm) \
tex(md-utbma.tfm) \
tex(md-utbmb.tfm) \
tex(md-utbo7t.tfm) \
tex(md-utbo8c.tfm) \
tex(md-utbo8t.tfm) \
tex(md-utbo8y.tfm) \
tex(md-utr7m.tfm) \
tex(md-utr7t.tfm) \
tex(md-utr7v.tfm) \
tex(md-utr7y.tfm) \
tex(md-utr8c.tfm) \
tex(md-utr8t.tfm) \
tex(md-utr8y.tfm) \
tex(md-utree.tfm) \
tex(md-utri7m.tfm) \
tex(md-utri7t.tfm) \
tex(md-utri8c.tfm) \
tex(md-utri8t.tfm) \
tex(md-utri8y.tfm) \
tex(md-utrma.tfm) \
tex(md-utrmb.tfm) \
tex(md-utro7t.tfm) \
tex(md-utro8c.tfm) \
tex(md-utro8t.tfm) \
tex(md-utro8y.tfm) \
tex(md8x.enc) \
tex(mdacmr.fd) \
tex(mdamdbch.fd) \
tex(mdamdici.fd) \
tex(mdamdpgd.fd) \
tex(mdamdpus.fd) \
tex(mdamdput.fd) \
tex(mdamdugm.fd) \
tex(mdbch.cfg) \
tex(mdbch.map) \
tex(mdbch.sty) \
tex(mdbchb7m.tfm) \
tex(mdbchb7m.vf) \
tex(mdbchb7t.tfm) \
tex(mdbchb7t.vf) \
tex(mdbchb7v.tfm) \
tex(mdbchb7v.vf) \
tex(mdbchb7y.tfm) \
tex(mdbchb7y.vf) \
tex(mdbchb8c.tfm) \
tex(mdbchb8c.vf) \
tex(mdbchb8t.tfm) \
tex(mdbchb8t.vf) \
tex(mdbchbc8t.tfm) \
tex(mdbchbc8t.vf) \
tex(mdbchbfc8t.tfm) \
tex(mdbchbfc8t.vf) \
tex(mdbchbi7m.tfm) \
tex(mdbchbi7m.vf) \
tex(mdbchbi7t.tfm) \
tex(mdbchbi7t.vf) \
tex(mdbchbi8c.tfm) \
tex(mdbchbi8c.vf) \
tex(mdbchbi8t.tfm) \
tex(mdbchbi8t.vf) \
tex(mdbchbifc8t.tfm) \
tex(mdbchbifc8t.vf) \
tex(mdbchbma.tfm) \
tex(mdbchbma.vf) \
tex(mdbchbmb.tfm) \
tex(mdbchbmb.vf) \
tex(mdbchbo7t.tfm) \
tex(mdbchbo7t.vf) \
tex(mdbchbo8c.tfm) \
tex(mdbchbo8c.vf) \
tex(mdbchbo8t.tfm) \
tex(mdbchbo8t.vf) \
tex(mdbchbofc8t.tfm) \
tex(mdbchbofc8t.vf) \
tex(mdbchr7m.tfm) \
tex(mdbchr7m.vf) \
tex(mdbchr7t.tfm) \
tex(mdbchr7t.vf) \
tex(mdbchr7v.tfm) \
tex(mdbchr7v.vf) \
tex(mdbchr7y.tfm) \
tex(mdbchr7y.vf) \
tex(mdbchr8c.tfm) \
tex(mdbchr8c.vf) \
tex(mdbchr8t.tfm) \
tex(mdbchr8t.vf) \
tex(mdbchrc8t.tfm) \
tex(mdbchrc8t.vf) \
tex(mdbchrfc8t.tfm) \
tex(mdbchrfc8t.vf) \
tex(mdbchri7m.tfm) \
tex(mdbchri7m.vf) \
tex(mdbchri7t.tfm) \
tex(mdbchri7t.vf) \
tex(mdbchri8c.tfm) \
tex(mdbchri8c.vf) \
tex(mdbchri8t.tfm) \
tex(mdbchri8t.vf) \
tex(mdbchrifc8t.tfm) \
tex(mdbchrifc8t.vf) \
tex(mdbchrma.tfm) \
tex(mdbchrma.vf) \
tex(mdbchrmb.tfm) \
tex(mdbchrmb.vf) \
tex(mdbchro7t.tfm) \
tex(mdbchro7t.vf) \
tex(mdbchro8c.tfm) \
tex(mdbchro8c.vf) \
tex(mdbchro8t.tfm) \
tex(mdbchro8t.vf) \
tex(mdbchrofc8t.tfm) \
tex(mdbchrofc8t.vf) \
tex(mdbcmr.fd) \
tex(mdbmdbch.fd) \
tex(mdbmdici.fd) \
tex(mdbmdpgd.fd) \
tex(mdbmdpus.fd) \
tex(mdbmdput.fd) \
tex(mdbmdugm.fd) \
tex(mdfont.def) \
tex(mdgrbCb7m.tfm) \
tex(mdgrbCb7m.vf) \
tex(mdgrbCbi7m.tfm) \
tex(mdgrbCbi7m.vf) \
tex(mdgrbCr7m.tfm) \
tex(mdgrbCr7m.vf) \
tex(mdgrbCri7m.tfm) \
tex(mdgrbCri7m.vf) \
tex(mdgrbb7m.tfm) \
tex(mdgrbb7m.vf) \
tex(mdgrbbi7m.tfm) \
tex(mdgrbbi7m.vf) \
tex(mdgrbr7m.tfm) \
tex(mdgrbr7m.vf) \
tex(mdgrbri7m.tfm) \
tex(mdgrbri7m.vf) \
tex(mdgrdCb7m.tfm) \
tex(mdgrdCb7m.vf) \
tex(mdgrdCbi7m.tfm) \
tex(mdgrdCbi7m.vf) \
tex(mdgrdCri7m.tfm) \
tex(mdgrdCri7m.vf) \
tex(mdgrdb7m.tfm) \
tex(mdgrdb7m.vf) \
tex(mdgrdbi7m.tfm) \
tex(mdgrdbi7m.vf) \
tex(mdgrdr7m.tfm) \
tex(mdgrdr7m.vf) \
tex(mdgrdrC7m.tfm) \
tex(mdgrdrC7m.vf) \
tex(mdgrdri7m.tfm) \
tex(mdgrdri7m.vf) \
tex(mdgreek.map) \
tex(mdici.cfg) \
tex(mdici.map) \
tex(mdici.sty) \
tex(mdicib7m.tfm) \
tex(mdicib7m.vf) \
tex(mdicib7t.tfm) \
tex(mdicib7t.vf) \
tex(mdicib7v.tfm) \
tex(mdicib7v.vf) \
tex(mdicib7y.tfm) \
tex(mdicib7y.vf) \
tex(mdicib8c.tfm) \
tex(mdicib8c.vf) \
tex(mdicib8t.tfm) \
tex(mdicib8t.vf) \
tex(mdicibc8c.tfm) \
tex(mdicibc8c.vf) \
tex(mdicibc8t.tfm) \
tex(mdicibc8t.vf) \
tex(mdicibfc8t.tfm) \
tex(mdicibfc8t.vf) \
tex(mdicibi7m.tfm) \
tex(mdicibi7m.vf) \
tex(mdicibi7t.tfm) \
tex(mdicibi7t.vf) \
tex(mdicibi8c.tfm) \
tex(mdicibi8c.vf) \
tex(mdicibi8t.tfm) \
tex(mdicibi8t.vf) \
tex(mdicibic8c.tfm) \
tex(mdicibic8c.vf) \
tex(mdicibic8t.tfm) \
tex(mdicibic8t.vf) \
tex(mdicibifc8t.tfm) \
tex(mdicibifc8t.vf) \
tex(mdicibiu7m.vf) \
tex(mdicibma.tfm) \
tex(mdicibma.vf) \
tex(mdicibmb.tfm) \
tex(mdicibmb.vf) \
tex(mdicibui7m.vf) \
tex(mdicic8c.tfm) \
tex(mdicic8c.vf) \
tex(mdicic8t.tfm) \
tex(mdicic8t.vf) \
tex(mdicicc8c.tfm) \
tex(mdicicc8c.vf) \
tex(mdicicc8t.tfm) \
tex(mdicicc8t.vf) \
tex(mdicicfc8t.tfm) \
tex(mdicicfc8t.vf) \
tex(mdicici8c.tfm) \
tex(mdicici8c.vf) \
tex(mdicici8t.tfm) \
tex(mdicici8t.vf) \
tex(mdicicic8c.tfm) \
tex(mdicicic8c.vf) \
tex(mdicicic8t.tfm) \
tex(mdicicic8t.vf) \
tex(mdicicifc8t.tfm) \
tex(mdicicifc8t.vf) \
tex(mdicir7m.tfm) \
tex(mdicir7m.vf) \
tex(mdicir7t.tfm) \
tex(mdicir7t.vf) \
tex(mdicir7v.tfm) \
tex(mdicir7v.vf) \
tex(mdicir7y.tfm) \
tex(mdicir7y.vf) \
tex(mdicir8c.tfm) \
tex(mdicir8c.vf) \
tex(mdicir8t.tfm) \
tex(mdicir8t.vf) \
tex(mdicirc8c.tfm) \
tex(mdicirc8c.vf) \
tex(mdicirc8t.tfm) \
tex(mdicirc8t.vf) \
tex(mdicirfc8t.tfm) \
tex(mdicirfc8t.vf) \
tex(mdiciri7m.tfm) \
tex(mdiciri7m.vf) \
tex(mdiciri7t.tfm) \
tex(mdiciri7t.vf) \
tex(mdiciri8c.tfm) \
tex(mdiciri8c.vf) \
tex(mdiciri8t.tfm) \
tex(mdiciri8t.vf) \
tex(mdiciric8c.tfm) \
tex(mdiciric8c.vf) \
tex(mdiciric8t.tfm) \
tex(mdiciric8t.vf) \
tex(mdicirifc8t.tfm) \
tex(mdicirifc8t.vf) \
tex(mdiciriu7m.vf) \
tex(mdicirma.tfm) \
tex(mdicirma.vf) \
tex(mdicirmb.tfm) \
tex(mdicirmb.vf) \
tex(mdicirui7m.vf) \
tex(mdpgd.cfg) \
tex(mdpgd.map) \
tex(mdpgd.sty) \
tex(mdpgdb8c.tfm) \
tex(mdpgdb8c.vf) \
tex(mdpgdb8t.tfm) \
tex(mdpgdb8t.vf) \
tex(mdpgdbc8c.tfm) \
tex(mdpgdbc8c.vf) \
tex(mdpgdbc8t.tfm) \
tex(mdpgdbc8t.vf) \
tex(mdpgdbfc8t.tfm) \
tex(mdpgdbfc8t.vf) \
tex(mdpgdbi8c.tfm) \
tex(mdpgdbi8c.vf) \
tex(mdpgdbi8t.tfm) \
tex(mdpgdbi8t.vf) \
tex(mdpgdbic8c.tfm) \
tex(mdpgdbic8c.vf) \
tex(mdpgdbic8t.tfm) \
tex(mdpgdbic8t.vf) \
tex(mdpgdbifc8t.tfm) \
tex(mdpgdbifc8t.vf) \
tex(mdpgdr7m.tfm) \
tex(mdpgdr7m.vf) \
tex(mdpgdr7t.tfm) \
tex(mdpgdr7t.vf) \
tex(mdpgdr7v.tfm) \
tex(mdpgdr7v.vf) \
tex(mdpgdr7y.tfm) \
tex(mdpgdr7y.vf) \
tex(mdpgdr8c.tfm) \
tex(mdpgdr8c.vf) \
tex(mdpgdr8t.tfm) \
tex(mdpgdr8t.vf) \
tex(mdpgdrc8c.tfm) \
tex(mdpgdrc8c.vf) \
tex(mdpgdrc8t.tfm) \
tex(mdpgdrc8t.vf) \
tex(mdpgdrfc8t.tfm) \
tex(mdpgdrfc8t.vf) \
tex(mdpgdri7m.tfm) \
tex(mdpgdri7m.vf) \
tex(mdpgdri7t.tfm) \
tex(mdpgdri7t.vf) \
tex(mdpgdri8c.tfm) \
tex(mdpgdri8c.vf) \
tex(mdpgdri8t.tfm) \
tex(mdpgdri8t.vf) \
tex(mdpgdric8c.tfm) \
tex(mdpgdric8c.vf) \
tex(mdpgdric8t.tfm) \
tex(mdpgdric8t.vf) \
tex(mdpgdrifc8t.tfm) \
tex(mdpgdrifc8t.vf) \
tex(mdpgdrma.tfm) \
tex(mdpgdrma.vf) \
tex(mdpgdrmb.tfm) \
tex(mdpgdrmb.vf) \
tex(mdpgds7m.tfm) \
tex(mdpgds7m.vf) \
tex(mdpgds7t.tfm) \
tex(mdpgds7t.vf) \
tex(mdpgds7v.tfm) \
tex(mdpgds7v.vf) \
tex(mdpgds7y.tfm) \
tex(mdpgds7y.vf) \
tex(mdpgds8c.tfm) \
tex(mdpgds8c.vf) \
tex(mdpgds8t.tfm) \
tex(mdpgds8t.vf) \
tex(mdpgdsc8c.tfm) \
tex(mdpgdsc8c.vf) \
tex(mdpgdsc8t.tfm) \
tex(mdpgdsc8t.vf) \
tex(mdpgdsfc8t.tfm) \
tex(mdpgdsfc8t.vf) \
tex(mdpgdsi7m.tfm) \
tex(mdpgdsi7m.vf) \
tex(mdpgdsi7t.tfm) \
tex(mdpgdsi7t.vf) \
tex(mdpgdsi8c.tfm) \
tex(mdpgdsi8c.vf) \
tex(mdpgdsi8t.tfm) \
tex(mdpgdsi8t.vf) \
tex(mdpgdsic8c.tfm) \
tex(mdpgdsic8c.vf) \
tex(mdpgdsic8t.tfm) \
tex(mdpgdsic8t.vf) \
tex(mdpgdsifc8t.tfm) \
tex(mdpgdsifc8t.vf) \
tex(mdpgdsma.tfm) \
tex(mdpgdsma.vf) \
tex(mdpgdsmb.tfm) \
tex(mdpgdsmb.vf) \
tex(mdpus.cfg) \
tex(mdpus.map) \
tex(mdpus.sty) \
tex(mdpusb8c.tfm) \
tex(mdpusb8c.vf) \
tex(mdpusb8t.tfm) \
tex(mdpusb8t.vf) \
tex(mdpusbc8c.tfm) \
tex(mdpusbc8c.vf) \
tex(mdpusbc8t.tfm) \
tex(mdpusbc8t.vf) \
tex(mdpusbfc8t.tfm) \
tex(mdpusbfc8t.vf) \
tex(mdpusbi8c.tfm) \
tex(mdpusbi8c.vf) \
tex(mdpusbi8t.tfm) \
tex(mdpusbi8t.vf) \
tex(mdpusbic8c.tfm) \
tex(mdpusbic8c.vf) \
tex(mdpusbic8t.tfm) \
tex(mdpusbic8t.vf) \
tex(mdpusbifc8t.tfm) \
tex(mdpusbifc8t.vf) \
tex(mdpusr7m.tfm) \
tex(mdpusr7m.vf) \
tex(mdpusr7t.tfm) \
tex(mdpusr7t.vf) \
tex(mdpusr7v.tfm) \
tex(mdpusr7v.vf) \
tex(mdpusr7y.tfm) \
tex(mdpusr7y.vf) \
tex(mdpusr8c.tfm) \
tex(mdpusr8c.vf) \
tex(mdpusr8t.tfm) \
tex(mdpusr8t.vf) \
tex(mdpusrc8c.tfm) \
tex(mdpusrc8c.vf) \
tex(mdpusrc8t.tfm) \
tex(mdpusrc8t.vf) \
tex(mdpusrfc8t.tfm) \
tex(mdpusrfc8t.vf) \
tex(mdpusri7m.tfm) \
tex(mdpusri7m.vf) \
tex(mdpusri7t.tfm) \
tex(mdpusri7t.vf) \
tex(mdpusri8c.tfm) \
tex(mdpusri8c.vf) \
tex(mdpusri8t.tfm) \
tex(mdpusri8t.vf) \
tex(mdpusric8c.tfm) \
tex(mdpusric8c.vf) \
tex(mdpusric8t.tfm) \
tex(mdpusric8t.vf) \
tex(mdpusrifc8t.tfm) \
tex(mdpusrifc8t.vf) \
tex(mdpusrma.tfm) \
tex(mdpusrma.vf) \
tex(mdpusrmb.tfm) \
tex(mdpusrmb.vf) \
tex(mdpuss7m.tfm) \
tex(mdpuss7m.vf) \
tex(mdpuss7t.tfm) \
tex(mdpuss7t.vf) \
tex(mdpuss7v.tfm) \
tex(mdpuss7v.vf) \
tex(mdpuss7y.tfm) \
tex(mdpuss7y.vf) \
tex(mdpuss8c.tfm) \
tex(mdpuss8c.vf) \
tex(mdpuss8t.tfm) \
tex(mdpuss8t.vf) \
tex(mdpussc8c.tfm) \
tex(mdpussc8c.vf) \
tex(mdpussc8t.tfm) \
tex(mdpussc8t.vf) \
tex(mdpussfc8t.tfm) \
tex(mdpussfc8t.vf) \
tex(mdpussi7m.tfm) \
tex(mdpussi7m.vf) \
tex(mdpussi7t.tfm) \
tex(mdpussi7t.vf) \
tex(mdpussi8c.tfm) \
tex(mdpussi8c.vf) \
tex(mdpussi8t.tfm) \
tex(mdpussi8t.vf) \
tex(mdpussic8c.tfm) \
tex(mdpussic8c.vf) \
tex(mdpussic8t.tfm) \
tex(mdpussic8t.vf) \
tex(mdpussifc8t.tfm) \
tex(mdpussifc8t.vf) \
tex(mdpussma.tfm) \
tex(mdpussma.vf) \
tex(mdpussmb.tfm) \
tex(mdpussmb.vf) \
tex(mdput.cfg) \
tex(mdput.map) \
tex(mdput.sty) \
tex(mdputb7m.tfm) \
tex(mdputb7m.vf) \
tex(mdputb7t.tfm) \
tex(mdputb7t.vf) \
tex(mdputb7v.tfm) \
tex(mdputb7v.vf) \
tex(mdputb7y.tfm) \
tex(mdputb7y.vf) \
tex(mdputb8c.tfm) \
tex(mdputb8c.vf) \
tex(mdputb8t.tfm) \
tex(mdputb8t.vf) \
tex(mdputbc8t.tfm) \
tex(mdputbc8t.vf) \
tex(mdputbfc8t.tfm) \
tex(mdputbfc8t.vf) \
tex(mdputbi7m.tfm) \
tex(mdputbi7m.vf) \
tex(mdputbi7t.tfm) \
tex(mdputbi7t.vf) \
tex(mdputbi8c.tfm) \
tex(mdputbi8c.vf) \
tex(mdputbi8t.tfm) \
tex(mdputbi8t.vf) \
tex(mdputbifc8t.tfm) \
tex(mdputbifc8t.vf) \
tex(mdputbma.tfm) \
tex(mdputbma.vf) \
tex(mdputbmb.tfm) \
tex(mdputbmb.vf) \
tex(mdputbo7t.tfm) \
tex(mdputbo7t.vf) \
tex(mdputbo8c.tfm) \
tex(mdputbo8c.vf) \
tex(mdputbo8t.tfm) \
tex(mdputbo8t.vf) \
tex(mdputbofc8t.tfm) \
tex(mdputbofc8t.vf) \
tex(mdputr7m.tfm) \
tex(mdputr7m.vf) \
tex(mdputr7t.tfm) \
tex(mdputr7t.vf) \
tex(mdputr7v.tfm) \
tex(mdputr7v.vf) \
tex(mdputr7y.tfm) \
tex(mdputr7y.vf) \
tex(mdputr8c.tfm) \
tex(mdputr8c.vf) \
tex(mdputr8t.tfm) \
tex(mdputr8t.vf) \
tex(mdputrc8t.tfm) \
tex(mdputrc8t.vf) \
tex(mdputrfc8t.tfm) \
tex(mdputrfc8t.vf) \
tex(mdputri7m.tfm) \
tex(mdputri7m.vf) \
tex(mdputri7t.tfm) \
tex(mdputri7t.vf) \
tex(mdputri8c.tfm) \
tex(mdputri8c.vf) \
tex(mdputri8t.tfm) \
tex(mdputri8t.vf) \
tex(mdputrifc8t.tfm) \
tex(mdputrifc8t.vf) \
tex(mdputrma.tfm) \
tex(mdputrma.vf) \
tex(mdputrmb.tfm) \
tex(mdputrmb.vf) \
tex(mdputro7t.tfm) \
tex(mdputro7t.vf) \
tex(mdputro8c.tfm) \
tex(mdputro8c.vf) \
tex(mdputro8t.tfm) \
tex(mdputro8t.vf) \
tex(mdputrofc8t.tfm) \
tex(mdputrofc8t.vf) \
tex(mdsffont.def) \
tex(mdttfont.def) \
tex(mdugm.cfg) \
tex(mdugm.map) \
tex(mdugm.sty) \
tex(mdugmm7m.tfm) \
tex(mdugmm7m.vf) \
tex(mdugmm7t.tfm) \
tex(mdugmm7t.vf) \
tex(mdugmm7v.tfm) \
tex(mdugmm7v.vf) \
tex(mdugmm7y.tfm) \
tex(mdugmm7y.vf) \
tex(mdugmm8c.tfm) \
tex(mdugmm8c.vf) \
tex(mdugmm8t.tfm) \
tex(mdugmm8t.vf) \
tex(mdugmmfc8t.tfm) \
tex(mdugmmfc8t.vf) \
tex(mdugmmi7m.tfm) \
tex(mdugmmi7m.vf) \
tex(mdugmmi7t.tfm) \
tex(mdugmmi7t.vf) \
tex(mdugmmi8c.tfm) \
tex(mdugmmi8c.vf) \
tex(mdugmmi8t.tfm) \
tex(mdugmmi8t.vf) \
tex(mdugmmifc8t.tfm) \
tex(mdugmmifc8t.vf) \
tex(mdugmmma.tfm) \
tex(mdugmmma.vf) \
tex(mdugmmmb.tfm) \
tex(mdugmmmb.vf) \
tex(mdugmmo7t.tfm) \
tex(mdugmmo7t.vf) \
tex(mdugmmo8c.tfm) \
tex(mdugmmo8c.vf) \
tex(mdugmmo8t.tfm) \
tex(mdugmmo8t.vf) \
tex(mdugmmofc8t.tfm) \
tex(mdugmmofc8t.vf) \
tex(mdugmr7m.tfm) \
tex(mdugmr7m.vf) \
tex(mdugmr7t.tfm) \
tex(mdugmr7t.vf) \
tex(mdugmr7v.tfm) \
tex(mdugmr7v.vf) \
tex(mdugmr7y.tfm) \
tex(mdugmr7y.vf) \
tex(mdugmr8c.tfm) \
tex(mdugmr8c.vf) \
tex(mdugmr8t.tfm) \
tex(mdugmr8t.vf) \
tex(mdugmrfc8t.tfm) \
tex(mdugmrfc8t.vf) \
tex(mdugmri7m.tfm) \
tex(mdugmri7m.vf) \
tex(mdugmri7t.tfm) \
tex(mdugmri7t.vf) \
tex(mdugmri8c.tfm) \
tex(mdugmri8c.vf) \
tex(mdugmri8t.tfm) \
tex(mdugmri8t.vf) \
tex(mdugmrifc8t.tfm) \
tex(mdugmrifc8t.vf) \
tex(mdugmrma.tfm) \
tex(mdugmrma.vf) \
tex(mdugmrmb.tfm) \
tex(mdugmrmb.vf) \
tex(mdugmro7t.tfm) \
tex(mdugmro7t.vf) \
tex(mdugmro8c.tfm) \
tex(mdugmro8c.vf) \
tex(mdugmro8t.tfm) \
tex(mdugmro8t.vf) \
tex(mdugmrofc8t.tfm) \
tex(mdugmrofc8t.vf) \
tex(mdwcib7m.tfm) \
tex(mdwcib7y.tfm) \
tex(mdwcib8t.tfm) \
tex(mdwcibc8t.tfm) \
tex(mdwcibi7m.tfm) \
tex(mdwcibi7y.tfm) \
tex(mdwcibi8t.tfm) \
tex(mdwcibic8t.tfm) \
tex(mdwcic7m.tfm) \
tex(mdwcic7y.tfm) \
tex(mdwcic8t.tfm) \
tex(mdwcicc8t.tfm) \
tex(mdwcici7m.tfm) \
tex(mdwcici7y.tfm) \
tex(mdwcici8t.tfm) \
tex(mdwcicic8t.tfm) \
tex(mdwcir7m.tfm) \
tex(mdwcir7y.tfm) \
tex(mdwcir8t.tfm) \
tex(mdwcirc8t.tfm) \
tex(mdwciri7m.tfm) \
tex(mdwciri7y.tfm) \
tex(mdwciri8t.tfm) \
tex(mdwciric8t.tfm) \
tex(mdwgdb7m.tfm) \
tex(mdwgdb7y.tfm) \
tex(mdwgdb8t.tfm) \
tex(mdwgdbc8t.tfm) \
tex(mdwgdbi7m.tfm) \
tex(mdwgdbi7y.tfm) \
tex(mdwgdbi8t.tfm) \
tex(mdwgdbic8t.tfm) \
tex(mdwgdr7m.tfm) \
tex(mdwgdr7y.tfm) \
tex(mdwgdr8t.tfm) \
tex(mdwgdrc8t.tfm) \
tex(mdwgdri7m.tfm) \
tex(mdwgdri7y.tfm) \
tex(mdwgdri8t.tfm) \
tex(mdwgdric8t.tfm) \
tex(mdwgds7m.tfm) \
tex(mdwgds7y.tfm) \
tex(mdwgds8t.tfm) \
tex(mdwgdsc8t.tfm) \
tex(mdwgdsi7m.tfm) \
tex(mdwgdsi7y.tfm) \
tex(mdwgdsi8t.tfm) \
tex(mdwgdsic8t.tfm) \
tex(mdwusb7m.tfm) \
tex(mdwusb7y.tfm) \
tex(mdwusb8t.tfm) \
tex(mdwusbc8t.tfm) \
tex(mdwusbi7m.tfm) \
tex(mdwusbi7y.tfm) \
tex(mdwusbi8t.tfm) \
tex(mdwusbic8t.tfm) \
tex(mdwusr7m.tfm) \
tex(mdwusr7y.tfm) \
tex(mdwusr8t.tfm) \
tex(mdwusrc8t.tfm) \
tex(mdwusri7m.tfm) \
tex(mdwusri7y.tfm) \
tex(mdwusri8t.tfm) \
tex(mdwusric8t.tfm) \
tex(mdwuss7m.tfm) \
tex(mdwuss7y.tfm) \
tex(mdwuss8t.tfm) \
tex(mdwussc8t.tfm) \
tex(mdwussi7m.tfm) \
tex(mdwussi7y.tfm) \
tex(mdwussi8t.tfm) \
tex(mdwussic8t.tfm) \
tex(mdxcib7t.tfm) \
tex(mdxcib7y.tfm) \
tex(mdxcib7y.vf) \
tex(mdxcib8t.tfm) \
tex(mdxcib8t.vf) \
tex(mdxcibc8t.tfm) \
tex(mdxcibc8t.vf) \
tex(mdxcibi7t.tfm) \
tex(mdxcibi7y.tfm) \
tex(mdxcibi7y.vf) \
tex(mdxcibi8t.tfm) \
tex(mdxcibi8t.vf) \
tex(mdxcibic8t.tfm) \
tex(mdxcibic8t.vf) \
tex(mdxcic7t.tfm) \
tex(mdxcic7y.tfm) \
tex(mdxcic7y.vf) \
tex(mdxcic8t.tfm) \
tex(mdxcic8t.vf) \
tex(mdxcicc8t.tfm) \
tex(mdxcicc8t.vf) \
tex(mdxcici7t.tfm) \
tex(mdxcici7y.tfm) \
tex(mdxcici7y.vf) \
tex(mdxcici8t.tfm) \
tex(mdxcici8t.vf) \
tex(mdxcicic8t.tfm) \
tex(mdxcicic8t.vf) \
tex(mdxcir7t.tfm) \
tex(mdxcir7y.tfm) \
tex(mdxcir7y.vf) \
tex(mdxcir8t.tfm) \
tex(mdxcir8t.vf) \
tex(mdxcirc8t.tfm) \
tex(mdxcirc8t.vf) \
tex(mdxciri7t.tfm) \
tex(mdxciri7y.tfm) \
tex(mdxciri7y.vf) \
tex(mdxciri8t.tfm) \
tex(mdxciri8t.vf) \
tex(mdxciric8t.tfm) \
tex(mdxciric8t.vf) \
tex(mdxgdb7t.tfm) \
tex(mdxgdb7y.tfm) \
tex(mdxgdb7y.vf) \
tex(mdxgdb8t.tfm) \
tex(mdxgdb8t.vf) \
tex(mdxgdbc8t.tfm) \
tex(mdxgdbc8t.vf) \
tex(mdxgdbi7t.tfm) \
tex(mdxgdbi7y.tfm) \
tex(mdxgdbi7y.vf) \
tex(mdxgdbi8t.tfm) \
tex(mdxgdbi8t.vf) \
tex(mdxgdbic8t.tfm) \
tex(mdxgdbic8t.vf) \
tex(mdxgdr7t.tfm) \
tex(mdxgdr7y.tfm) \
tex(mdxgdr7y.vf) \
tex(mdxgdr8t.tfm) \
tex(mdxgdr8t.vf) \
tex(mdxgdrc8t.tfm) \
tex(mdxgdrc8t.vf) \
tex(mdxgdri7t.tfm) \
tex(mdxgdri7y.tfm) \
tex(mdxgdri7y.vf) \
tex(mdxgdri8t.tfm) \
tex(mdxgdri8t.vf) \
tex(mdxgdric8t.tfm) \
tex(mdxgdric8t.vf) \
tex(mdxgds7t.tfm) \
tex(mdxgds7y.tfm) \
tex(mdxgds7y.vf) \
tex(mdxgds8t.tfm) \
tex(mdxgds8t.vf) \
tex(mdxgdsc8t.tfm) \
tex(mdxgdsc8t.vf) \
tex(mdxgdsi7t.tfm) \
tex(mdxgdsi7y.tfm) \
tex(mdxgdsi7y.vf) \
tex(mdxgdsi8t.tfm) \
tex(mdxgdsi8t.vf) \
tex(mdxgdsic8t.tfm) \
tex(mdxgdsic8t.vf) \
tex(mdxusb7t.tfm) \
tex(mdxusb7y.tfm) \
tex(mdxusb7y.vf) \
tex(mdxusb8t.tfm) \
tex(mdxusb8t.vf) \
tex(mdxusbc8t.tfm) \
tex(mdxusbc8t.vf) \
tex(mdxusbi7t.tfm) \
tex(mdxusbi7y.tfm) \
tex(mdxusbi7y.vf) \
tex(mdxusbi8t.tfm) \
tex(mdxusbi8t.vf) \
tex(mdxusbic8t.tfm) \
tex(mdxusbic8t.vf) \
tex(mdxusr7t.tfm) \
tex(mdxusr7y.tfm) \
tex(mdxusr7y.vf) \
tex(mdxusr8t.tfm) \
tex(mdxusr8t.vf) \
tex(mdxusrc8t.tfm) \
tex(mdxusrc8t.vf) \
tex(mdxusri7t.tfm) \
tex(mdxusri7y.tfm) \
tex(mdxusri7y.vf) \
tex(mdxusri8t.tfm) \
tex(mdxusri8t.vf) \
tex(mdxusric8t.tfm) \
tex(mdxusric8t.vf) \
tex(mdxuss7t.tfm) \
tex(mdxuss7y.tfm) \
tex(mdxuss7y.vf) \
tex(mdxuss8t.tfm) \
tex(mdxuss8t.vf) \
tex(mdxussc8t.tfm) \
tex(mdxussc8t.vf) \
tex(mdxussi7t.tfm) \
tex(mdxussi7y.tfm) \
tex(mdxussi7y.vf) \
tex(mdxussi8t.tfm) \
tex(mdxussi8t.vf) \
tex(mdxussic8t.tfm) \
tex(mdxussic8t.vf) \
tex(omlmdbch.fd) \
tex(omlmdgrb.fd) \
tex(omlmdgrbc.fd) \
tex(omlmdgrd.fd) \
tex(omlmdgrdc.fd) \
tex(omlmdici.fd) \
tex(omlmdpgd.fd) \
tex(omlmdpus.fd) \
tex(omlmdput.fd) \
tex(omlmdugm.fd) \
tex(omsmdbch.fd) \
tex(omsmdici.fd) \
tex(omsmdpgd.fd) \
tex(omsmdpus.fd) \
tex(omsmdput.fd) \
tex(omsmdugm.fd) \
tex(omxmdbch.fd) \
tex(omxmdici.fd) \
tex(omxmdpgd.fd) \
tex(omxmdpus.fd) \
tex(omxmdput.fd) \
tex(omxmdugm.fd) \
tex(ot1mdbch.fd) \
tex(ot1mdici.fd) \
tex(ot1mdpgd.fd) \
tex(ot1mdpus.fd) \
tex(ot1mdput.fd) \
tex(ot1mdugm.fd) \
tex(putb8a.tfm) \
tex(putb8x.tfm) \
tex(putbi8a.tfm) \
tex(putr8a.tfm) \
tex(putr8x.tfm) \
tex(putri8a.tfm) \
tex(t1mdbch.fd) \
tex(t1mdici.fd) \
tex(t1mdpgd.fd) \
tex(t1mdpus.fd) \
tex(t1mdput.fd) \
tex(t1mdugm.fd) \
tex(ts1mdbch.fd) \
tex(ts1mdici.fd) \
tex(ts1mdpgd.fd) \
tex(ts1mdpus.fd) \
tex(ts1mdput.fd) \
tex(ts1mdugm.fd) \
tex(ugmm8a.tfm) \
tex(ugmmi8a.tfm) \
tex(ugmr8a.tfm) \
tex(ugmri8a.tfm) \
texlive-mathdesign"

RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex(fontenc.sty) \
tex(ifthen.sty) \
tex(keyval.sty) \
tex(texnansi.enc) \
tex(updmap.cfg) \
tex(xkeyval.sty) \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-mathdesign-fonts \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
