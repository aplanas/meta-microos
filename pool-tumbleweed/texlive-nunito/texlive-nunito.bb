SUMMARY = "The Nunito font face with support for LaTeX and pdfLaTeX"
DESCRIPTION = "This package provides LaTeX and pdfLaTeX support for the Nunito \
family of fonts, designed by Vernon Adams, Cyreal."
LICENSE = "OFL-1.1"

PV = "2023.209.0.0.0.1svn57429"

RPM_NAME = "texlive-nunito-2023.209.0.0.0.1svn57429-55.1.noarch.rpm"
RPM_HASH = "918ccc46c34349d6f995220a81cc65351dfa828638e1eb1577cfc16bafdb8288aac8abe5d3f1aab84fafe206d5bbfac6c89a3e46d3cb3be2f025b76d8c3de2ac"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-LY1Nunito-Sup.fd \
tex-LY1Nunito-TLF.fd \
tex-LY1Nunito-TOsF.fd \
tex-Nunito-Black-sup-ly1--base.tfm \
tex-Nunito-Black-sup-ly1.tfm \
tex-Nunito-Black-sup-ly1.vf \
tex-Nunito-Black-sup-ot1.tfm \
tex-Nunito-Black-sup-t1--base.tfm \
tex-Nunito-Black-sup-t1.tfm \
tex-Nunito-Black-sup-t1.vf \
tex-Nunito-Black-tlf-ly1--base.tfm \
tex-Nunito-Black-tlf-ly1.tfm \
tex-Nunito-Black-tlf-ly1.vf \
tex-Nunito-Black-tlf-ot1.tfm \
tex-Nunito-Black-tlf-t1--base.tfm \
tex-Nunito-Black-tlf-t1.tfm \
tex-Nunito-Black-tlf-t1.vf \
tex-Nunito-Black-tlf-ts1--base.tfm \
tex-Nunito-Black-tlf-ts1.tfm \
tex-Nunito-Black-tlf-ts1.vf \
tex-Nunito-Black-tosf-ly1--base.tfm \
tex-Nunito-Black-tosf-ly1.tfm \
tex-Nunito-Black-tosf-ly1.vf \
tex-Nunito-Black-tosf-ot1.tfm \
tex-Nunito-Black-tosf-t1--base.tfm \
tex-Nunito-Black-tosf-t1.tfm \
tex-Nunito-Black-tosf-t1.vf \
tex-Nunito-Black-tosf-ts1--base.tfm \
tex-Nunito-Black-tosf-ts1.tfm \
tex-Nunito-Black-tosf-ts1.vf \
tex-Nunito-BlackItalic-sup-ly1--base.tfm \
tex-Nunito-BlackItalic-sup-ly1.tfm \
tex-Nunito-BlackItalic-sup-ly1.vf \
tex-Nunito-BlackItalic-sup-ot1.tfm \
tex-Nunito-BlackItalic-sup-t1--base.tfm \
tex-Nunito-BlackItalic-sup-t1.tfm \
tex-Nunito-BlackItalic-sup-t1.vf \
tex-Nunito-BlackItalic-tlf-ly1--base.tfm \
tex-Nunito-BlackItalic-tlf-ly1.tfm \
tex-Nunito-BlackItalic-tlf-ly1.vf \
tex-Nunito-BlackItalic-tlf-ot1.tfm \
tex-Nunito-BlackItalic-tlf-t1--base.tfm \
tex-Nunito-BlackItalic-tlf-t1.tfm \
tex-Nunito-BlackItalic-tlf-t1.vf \
tex-Nunito-BlackItalic-tlf-ts1--base.tfm \
tex-Nunito-BlackItalic-tlf-ts1.tfm \
tex-Nunito-BlackItalic-tlf-ts1.vf \
tex-Nunito-BlackItalic-tosf-ly1--base.tfm \
tex-Nunito-BlackItalic-tosf-ly1.tfm \
tex-Nunito-BlackItalic-tosf-ly1.vf \
tex-Nunito-BlackItalic-tosf-ot1.tfm \
tex-Nunito-BlackItalic-tosf-t1--base.tfm \
tex-Nunito-BlackItalic-tosf-t1.tfm \
tex-Nunito-BlackItalic-tosf-t1.vf \
tex-Nunito-BlackItalic-tosf-ts1--base.tfm \
tex-Nunito-BlackItalic-tosf-ts1.tfm \
tex-Nunito-BlackItalic-tosf-ts1.vf \
tex-Nunito-Bold-sup-ly1--base.tfm \
tex-Nunito-Bold-sup-ly1.tfm \
tex-Nunito-Bold-sup-ly1.vf \
tex-Nunito-Bold-sup-ot1.tfm \
tex-Nunito-Bold-sup-t1--base.tfm \
tex-Nunito-Bold-sup-t1.tfm \
tex-Nunito-Bold-sup-t1.vf \
tex-Nunito-Bold-tlf-ly1--base.tfm \
tex-Nunito-Bold-tlf-ly1.tfm \
tex-Nunito-Bold-tlf-ly1.vf \
tex-Nunito-Bold-tlf-ot1.tfm \
tex-Nunito-Bold-tlf-t1--base.tfm \
tex-Nunito-Bold-tlf-t1.tfm \
tex-Nunito-Bold-tlf-t1.vf \
tex-Nunito-Bold-tlf-ts1--base.tfm \
tex-Nunito-Bold-tlf-ts1.tfm \
tex-Nunito-Bold-tlf-ts1.vf \
tex-Nunito-Bold-tosf-ly1--base.tfm \
tex-Nunito-Bold-tosf-ly1.tfm \
tex-Nunito-Bold-tosf-ly1.vf \
tex-Nunito-Bold-tosf-ot1.tfm \
tex-Nunito-Bold-tosf-t1--base.tfm \
tex-Nunito-Bold-tosf-t1.tfm \
tex-Nunito-Bold-tosf-t1.vf \
tex-Nunito-Bold-tosf-ts1--base.tfm \
tex-Nunito-Bold-tosf-ts1.tfm \
tex-Nunito-Bold-tosf-ts1.vf \
tex-Nunito-BoldItalic-sup-ly1--base.tfm \
tex-Nunito-BoldItalic-sup-ly1.tfm \
tex-Nunito-BoldItalic-sup-ly1.vf \
tex-Nunito-BoldItalic-sup-ot1.tfm \
tex-Nunito-BoldItalic-sup-t1--base.tfm \
tex-Nunito-BoldItalic-sup-t1.tfm \
tex-Nunito-BoldItalic-sup-t1.vf \
tex-Nunito-BoldItalic-tlf-ly1--base.tfm \
tex-Nunito-BoldItalic-tlf-ly1.tfm \
tex-Nunito-BoldItalic-tlf-ly1.vf \
tex-Nunito-BoldItalic-tlf-ot1.tfm \
tex-Nunito-BoldItalic-tlf-t1--base.tfm \
tex-Nunito-BoldItalic-tlf-t1.tfm \
tex-Nunito-BoldItalic-tlf-t1.vf \
tex-Nunito-BoldItalic-tlf-ts1--base.tfm \
tex-Nunito-BoldItalic-tlf-ts1.tfm \
tex-Nunito-BoldItalic-tlf-ts1.vf \
tex-Nunito-BoldItalic-tosf-ly1--base.tfm \
tex-Nunito-BoldItalic-tosf-ly1.tfm \
tex-Nunito-BoldItalic-tosf-ly1.vf \
tex-Nunito-BoldItalic-tosf-ot1.tfm \
tex-Nunito-BoldItalic-tosf-t1--base.tfm \
tex-Nunito-BoldItalic-tosf-t1.tfm \
tex-Nunito-BoldItalic-tosf-t1.vf \
tex-Nunito-BoldItalic-tosf-ts1--base.tfm \
tex-Nunito-BoldItalic-tosf-ts1.tfm \
tex-Nunito-BoldItalic-tosf-ts1.vf \
tex-Nunito-ExtraBold-sup-ly1--base.tfm \
tex-Nunito-ExtraBold-sup-ly1.tfm \
tex-Nunito-ExtraBold-sup-ly1.vf \
tex-Nunito-ExtraBold-sup-ot1.tfm \
tex-Nunito-ExtraBold-sup-t1--base.tfm \
tex-Nunito-ExtraBold-sup-t1.tfm \
tex-Nunito-ExtraBold-sup-t1.vf \
tex-Nunito-ExtraBold-tlf-ly1--base.tfm \
tex-Nunito-ExtraBold-tlf-ly1.tfm \
tex-Nunito-ExtraBold-tlf-ly1.vf \
tex-Nunito-ExtraBold-tlf-ot1.tfm \
tex-Nunito-ExtraBold-tlf-t1--base.tfm \
tex-Nunito-ExtraBold-tlf-t1.tfm \
tex-Nunito-ExtraBold-tlf-t1.vf \
tex-Nunito-ExtraBold-tlf-ts1--base.tfm \
tex-Nunito-ExtraBold-tlf-ts1.tfm \
tex-Nunito-ExtraBold-tlf-ts1.vf \
tex-Nunito-ExtraBold-tosf-ly1--base.tfm \
tex-Nunito-ExtraBold-tosf-ly1.tfm \
tex-Nunito-ExtraBold-tosf-ly1.vf \
tex-Nunito-ExtraBold-tosf-ot1.tfm \
tex-Nunito-ExtraBold-tosf-t1--base.tfm \
tex-Nunito-ExtraBold-tosf-t1.tfm \
tex-Nunito-ExtraBold-tosf-t1.vf \
tex-Nunito-ExtraBold-tosf-ts1--base.tfm \
tex-Nunito-ExtraBold-tosf-ts1.tfm \
tex-Nunito-ExtraBold-tosf-ts1.vf \
tex-Nunito-ExtraBoldItalic-sup-ly1--base.tfm \
tex-Nunito-ExtraBoldItalic-sup-ly1.tfm \
tex-Nunito-ExtraBoldItalic-sup-ly1.vf \
tex-Nunito-ExtraBoldItalic-sup-ot1.tfm \
tex-Nunito-ExtraBoldItalic-sup-t1--base.tfm \
tex-Nunito-ExtraBoldItalic-sup-t1.tfm \
tex-Nunito-ExtraBoldItalic-sup-t1.vf \
tex-Nunito-ExtraBoldItalic-tlf-ly1--base.tfm \
tex-Nunito-ExtraBoldItalic-tlf-ly1.tfm \
tex-Nunito-ExtraBoldItalic-tlf-ly1.vf \
tex-Nunito-ExtraBoldItalic-tlf-ot1.tfm \
tex-Nunito-ExtraBoldItalic-tlf-t1--base.tfm \
tex-Nunito-ExtraBoldItalic-tlf-t1.tfm \
tex-Nunito-ExtraBoldItalic-tlf-t1.vf \
tex-Nunito-ExtraBoldItalic-tlf-ts1--base.tfm \
tex-Nunito-ExtraBoldItalic-tlf-ts1.tfm \
tex-Nunito-ExtraBoldItalic-tlf-ts1.vf \
tex-Nunito-ExtraBoldItalic-tosf-ly1--base.tfm \
tex-Nunito-ExtraBoldItalic-tosf-ly1.tfm \
tex-Nunito-ExtraBoldItalic-tosf-ly1.vf \
tex-Nunito-ExtraBoldItalic-tosf-ot1.tfm \
tex-Nunito-ExtraBoldItalic-tosf-t1--base.tfm \
tex-Nunito-ExtraBoldItalic-tosf-t1.tfm \
tex-Nunito-ExtraBoldItalic-tosf-t1.vf \
tex-Nunito-ExtraBoldItalic-tosf-ts1--base.tfm \
tex-Nunito-ExtraBoldItalic-tosf-ts1.tfm \
tex-Nunito-ExtraBoldItalic-tosf-ts1.vf \
tex-Nunito-ExtraLight-sup-ly1--base.tfm \
tex-Nunito-ExtraLight-sup-ly1.tfm \
tex-Nunito-ExtraLight-sup-ly1.vf \
tex-Nunito-ExtraLight-sup-ot1.tfm \
tex-Nunito-ExtraLight-sup-t1--base.tfm \
tex-Nunito-ExtraLight-sup-t1.tfm \
tex-Nunito-ExtraLight-sup-t1.vf \
tex-Nunito-ExtraLight-tlf-ly1--base.tfm \
tex-Nunito-ExtraLight-tlf-ly1.tfm \
tex-Nunito-ExtraLight-tlf-ly1.vf \
tex-Nunito-ExtraLight-tlf-ot1.tfm \
tex-Nunito-ExtraLight-tlf-t1--base.tfm \
tex-Nunito-ExtraLight-tlf-t1.tfm \
tex-Nunito-ExtraLight-tlf-t1.vf \
tex-Nunito-ExtraLight-tlf-ts1--base.tfm \
tex-Nunito-ExtraLight-tlf-ts1.tfm \
tex-Nunito-ExtraLight-tlf-ts1.vf \
tex-Nunito-ExtraLight-tosf-ly1--base.tfm \
tex-Nunito-ExtraLight-tosf-ly1.tfm \
tex-Nunito-ExtraLight-tosf-ly1.vf \
tex-Nunito-ExtraLight-tosf-ot1.tfm \
tex-Nunito-ExtraLight-tosf-t1--base.tfm \
tex-Nunito-ExtraLight-tosf-t1.tfm \
tex-Nunito-ExtraLight-tosf-t1.vf \
tex-Nunito-ExtraLight-tosf-ts1--base.tfm \
tex-Nunito-ExtraLight-tosf-ts1.tfm \
tex-Nunito-ExtraLight-tosf-ts1.vf \
tex-Nunito-ExtraLightItalic-sup-ly1--base.tfm \
tex-Nunito-ExtraLightItalic-sup-ly1.tfm \
tex-Nunito-ExtraLightItalic-sup-ly1.vf \
tex-Nunito-ExtraLightItalic-sup-ot1.tfm \
tex-Nunito-ExtraLightItalic-sup-t1--base.tfm \
tex-Nunito-ExtraLightItalic-sup-t1.tfm \
tex-Nunito-ExtraLightItalic-sup-t1.vf \
tex-Nunito-ExtraLightItalic-tlf-ly1--base.tfm \
tex-Nunito-ExtraLightItalic-tlf-ly1.tfm \
tex-Nunito-ExtraLightItalic-tlf-ly1.vf \
tex-Nunito-ExtraLightItalic-tlf-ot1.tfm \
tex-Nunito-ExtraLightItalic-tlf-t1--base.tfm \
tex-Nunito-ExtraLightItalic-tlf-t1.tfm \
tex-Nunito-ExtraLightItalic-tlf-t1.vf \
tex-Nunito-ExtraLightItalic-tlf-ts1--base.tfm \
tex-Nunito-ExtraLightItalic-tlf-ts1.tfm \
tex-Nunito-ExtraLightItalic-tlf-ts1.vf \
tex-Nunito-ExtraLightItalic-tosf-ly1--base.tfm \
tex-Nunito-ExtraLightItalic-tosf-ly1.tfm \
tex-Nunito-ExtraLightItalic-tosf-ly1.vf \
tex-Nunito-ExtraLightItalic-tosf-ot1.tfm \
tex-Nunito-ExtraLightItalic-tosf-t1--base.tfm \
tex-Nunito-ExtraLightItalic-tosf-t1.tfm \
tex-Nunito-ExtraLightItalic-tosf-t1.vf \
tex-Nunito-ExtraLightItalic-tosf-ts1--base.tfm \
tex-Nunito-ExtraLightItalic-tosf-ts1.tfm \
tex-Nunito-ExtraLightItalic-tosf-ts1.vf \
tex-Nunito-Italic-sup-ly1--base.tfm \
tex-Nunito-Italic-sup-ly1.tfm \
tex-Nunito-Italic-sup-ly1.vf \
tex-Nunito-Italic-sup-ot1.tfm \
tex-Nunito-Italic-sup-t1--base.tfm \
tex-Nunito-Italic-sup-t1.tfm \
tex-Nunito-Italic-sup-t1.vf \
tex-Nunito-Italic-tlf-ly1--base.tfm \
tex-Nunito-Italic-tlf-ly1.tfm \
tex-Nunito-Italic-tlf-ly1.vf \
tex-Nunito-Italic-tlf-ot1.tfm \
tex-Nunito-Italic-tlf-t1--base.tfm \
tex-Nunito-Italic-tlf-t1.tfm \
tex-Nunito-Italic-tlf-t1.vf \
tex-Nunito-Italic-tlf-ts1--base.tfm \
tex-Nunito-Italic-tlf-ts1.tfm \
tex-Nunito-Italic-tlf-ts1.vf \
tex-Nunito-Italic-tosf-ly1--base.tfm \
tex-Nunito-Italic-tosf-ly1.tfm \
tex-Nunito-Italic-tosf-ly1.vf \
tex-Nunito-Italic-tosf-ot1.tfm \
tex-Nunito-Italic-tosf-t1--base.tfm \
tex-Nunito-Italic-tosf-t1.tfm \
tex-Nunito-Italic-tosf-t1.vf \
tex-Nunito-Italic-tosf-ts1--base.tfm \
tex-Nunito-Italic-tosf-ts1.tfm \
tex-Nunito-Italic-tosf-ts1.vf \
tex-Nunito-Light-sup-ly1--base.tfm \
tex-Nunito-Light-sup-ly1.tfm \
tex-Nunito-Light-sup-ly1.vf \
tex-Nunito-Light-sup-ot1.tfm \
tex-Nunito-Light-sup-t1--base.tfm \
tex-Nunito-Light-sup-t1.tfm \
tex-Nunito-Light-sup-t1.vf \
tex-Nunito-Light-tlf-ly1--base.tfm \
tex-Nunito-Light-tlf-ly1.tfm \
tex-Nunito-Light-tlf-ly1.vf \
tex-Nunito-Light-tlf-ot1.tfm \
tex-Nunito-Light-tlf-t1--base.tfm \
tex-Nunito-Light-tlf-t1.tfm \
tex-Nunito-Light-tlf-t1.vf \
tex-Nunito-Light-tlf-ts1--base.tfm \
tex-Nunito-Light-tlf-ts1.tfm \
tex-Nunito-Light-tlf-ts1.vf \
tex-Nunito-Light-tosf-ly1--base.tfm \
tex-Nunito-Light-tosf-ly1.tfm \
tex-Nunito-Light-tosf-ly1.vf \
tex-Nunito-Light-tosf-ot1.tfm \
tex-Nunito-Light-tosf-t1--base.tfm \
tex-Nunito-Light-tosf-t1.tfm \
tex-Nunito-Light-tosf-t1.vf \
tex-Nunito-Light-tosf-ts1--base.tfm \
tex-Nunito-Light-tosf-ts1.tfm \
tex-Nunito-Light-tosf-ts1.vf \
tex-Nunito-LightItalic-sup-ly1--base.tfm \
tex-Nunito-LightItalic-sup-ly1.tfm \
tex-Nunito-LightItalic-sup-ly1.vf \
tex-Nunito-LightItalic-sup-ot1.tfm \
tex-Nunito-LightItalic-sup-t1--base.tfm \
tex-Nunito-LightItalic-sup-t1.tfm \
tex-Nunito-LightItalic-sup-t1.vf \
tex-Nunito-LightItalic-tlf-ly1--base.tfm \
tex-Nunito-LightItalic-tlf-ly1.tfm \
tex-Nunito-LightItalic-tlf-ly1.vf \
tex-Nunito-LightItalic-tlf-ot1.tfm \
tex-Nunito-LightItalic-tlf-t1--base.tfm \
tex-Nunito-LightItalic-tlf-t1.tfm \
tex-Nunito-LightItalic-tlf-t1.vf \
tex-Nunito-LightItalic-tlf-ts1--base.tfm \
tex-Nunito-LightItalic-tlf-ts1.tfm \
tex-Nunito-LightItalic-tlf-ts1.vf \
tex-Nunito-LightItalic-tosf-ly1--base.tfm \
tex-Nunito-LightItalic-tosf-ly1.tfm \
tex-Nunito-LightItalic-tosf-ly1.vf \
tex-Nunito-LightItalic-tosf-ot1.tfm \
tex-Nunito-LightItalic-tosf-t1--base.tfm \
tex-Nunito-LightItalic-tosf-t1.tfm \
tex-Nunito-LightItalic-tosf-t1.vf \
tex-Nunito-LightItalic-tosf-ts1--base.tfm \
tex-Nunito-LightItalic-tosf-ts1.tfm \
tex-Nunito-LightItalic-tosf-ts1.vf \
tex-Nunito-Regular-sup-ly1--base.tfm \
tex-Nunito-Regular-sup-ly1.tfm \
tex-Nunito-Regular-sup-ly1.vf \
tex-Nunito-Regular-sup-ot1.tfm \
tex-Nunito-Regular-sup-t1--base.tfm \
tex-Nunito-Regular-sup-t1.tfm \
tex-Nunito-Regular-sup-t1.vf \
tex-Nunito-Regular-tlf-ly1--base.tfm \
tex-Nunito-Regular-tlf-ly1.tfm \
tex-Nunito-Regular-tlf-ly1.vf \
tex-Nunito-Regular-tlf-ot1.tfm \
tex-Nunito-Regular-tlf-t1--base.tfm \
tex-Nunito-Regular-tlf-t1.tfm \
tex-Nunito-Regular-tlf-t1.vf \
tex-Nunito-Regular-tlf-ts1--base.tfm \
tex-Nunito-Regular-tlf-ts1.tfm \
tex-Nunito-Regular-tlf-ts1.vf \
tex-Nunito-Regular-tosf-ly1--base.tfm \
tex-Nunito-Regular-tosf-ly1.tfm \
tex-Nunito-Regular-tosf-ly1.vf \
tex-Nunito-Regular-tosf-ot1.tfm \
tex-Nunito-Regular-tosf-t1--base.tfm \
tex-Nunito-Regular-tosf-t1.tfm \
tex-Nunito-Regular-tosf-t1.vf \
tex-Nunito-Regular-tosf-ts1--base.tfm \
tex-Nunito-Regular-tosf-ts1.tfm \
tex-Nunito-Regular-tosf-ts1.vf \
tex-Nunito-SemiBold-sup-ly1--base.tfm \
tex-Nunito-SemiBold-sup-ly1.tfm \
tex-Nunito-SemiBold-sup-ly1.vf \
tex-Nunito-SemiBold-sup-ot1.tfm \
tex-Nunito-SemiBold-sup-t1--base.tfm \
tex-Nunito-SemiBold-sup-t1.tfm \
tex-Nunito-SemiBold-sup-t1.vf \
tex-Nunito-SemiBold-tlf-ly1--base.tfm \
tex-Nunito-SemiBold-tlf-ly1.tfm \
tex-Nunito-SemiBold-tlf-ly1.vf \
tex-Nunito-SemiBold-tlf-ot1.tfm \
tex-Nunito-SemiBold-tlf-t1--base.tfm \
tex-Nunito-SemiBold-tlf-t1.tfm \
tex-Nunito-SemiBold-tlf-t1.vf \
tex-Nunito-SemiBold-tlf-ts1--base.tfm \
tex-Nunito-SemiBold-tlf-ts1.tfm \
tex-Nunito-SemiBold-tlf-ts1.vf \
tex-Nunito-SemiBold-tosf-ly1--base.tfm \
tex-Nunito-SemiBold-tosf-ly1.tfm \
tex-Nunito-SemiBold-tosf-ly1.vf \
tex-Nunito-SemiBold-tosf-ot1.tfm \
tex-Nunito-SemiBold-tosf-t1--base.tfm \
tex-Nunito-SemiBold-tosf-t1.tfm \
tex-Nunito-SemiBold-tosf-t1.vf \
tex-Nunito-SemiBold-tosf-ts1--base.tfm \
tex-Nunito-SemiBold-tosf-ts1.tfm \
tex-Nunito-SemiBold-tosf-ts1.vf \
tex-Nunito-SemiBoldItalic-sup-ly1--base.tfm \
tex-Nunito-SemiBoldItalic-sup-ly1.tfm \
tex-Nunito-SemiBoldItalic-sup-ly1.vf \
tex-Nunito-SemiBoldItalic-sup-ot1.tfm \
tex-Nunito-SemiBoldItalic-sup-t1--base.tfm \
tex-Nunito-SemiBoldItalic-sup-t1.tfm \
tex-Nunito-SemiBoldItalic-sup-t1.vf \
tex-Nunito-SemiBoldItalic-tlf-ly1--base.tfm \
tex-Nunito-SemiBoldItalic-tlf-ly1.tfm \
tex-Nunito-SemiBoldItalic-tlf-ly1.vf \
tex-Nunito-SemiBoldItalic-tlf-ot1.tfm \
tex-Nunito-SemiBoldItalic-tlf-t1--base.tfm \
tex-Nunito-SemiBoldItalic-tlf-t1.tfm \
tex-Nunito-SemiBoldItalic-tlf-t1.vf \
tex-Nunito-SemiBoldItalic-tlf-ts1--base.tfm \
tex-Nunito-SemiBoldItalic-tlf-ts1.tfm \
tex-Nunito-SemiBoldItalic-tlf-ts1.vf \
tex-Nunito-SemiBoldItalic-tosf-ly1--base.tfm \
tex-Nunito-SemiBoldItalic-tosf-ly1.tfm \
tex-Nunito-SemiBoldItalic-tosf-ly1.vf \
tex-Nunito-SemiBoldItalic-tosf-ot1.tfm \
tex-Nunito-SemiBoldItalic-tosf-t1--base.tfm \
tex-Nunito-SemiBoldItalic-tosf-t1.tfm \
tex-Nunito-SemiBoldItalic-tosf-t1.vf \
tex-Nunito-SemiBoldItalic-tosf-ts1--base.tfm \
tex-Nunito-SemiBoldItalic-tosf-ts1.tfm \
tex-Nunito-SemiBoldItalic-tosf-ts1.vf \
tex-Nunito.map \
tex-OT1Nunito-Sup.fd \
tex-OT1Nunito-TLF.fd \
tex-OT1Nunito-TOsF.fd \
tex-T1Nunito-Sup.fd \
tex-T1Nunito-TLF.fd \
tex-T1Nunito-TOsF.fd \
tex-TS1Nunito-TLF.fd \
tex-TS1Nunito-TOsF.fd \
tex-a-2owfxx.enc \
tex-a-35ovjx.enc \
tex-a-g4f2r6.enc \
tex-a-hxzdi6.enc \
tex-a-lzhlbi.enc \
tex-a-nr4mc7.enc \
tex-a-wslvgt.enc \
tex-a-xcjjqo.enc \
tex-a-xv7ze7.enc \
tex-a-xzgqel.enc \
tex-nunito.sty \
texlive-nunito"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontaxes.sty \
tex-fontenc.sty \
tex-ifthen.sty \
tex-mweights.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-nunito-fonts \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
