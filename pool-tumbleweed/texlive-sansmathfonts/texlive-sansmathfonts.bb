SUMMARY = "Extended Computer Modern sans serif fonts"
DESCRIPTION = "Sans serif small caps and math fonts for use with Computer \
Modern."
LICENSE = "LPPL-1.0"

PV = "2023.201.svn64661"

RPM_NAME = "texlive-sansmathfonts-2023.201.svn64661-53.1.noarch.rpm"
RPM_HASH = "d0876311b84ee79b8c7b6d7d6bba665b197ad40bc481e4019eee5b89ead144b6d1a047677d079aa38ceaf731fa1d91b221e76596d29da31d2e04a92eca2c9cab"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex(cmsmf10.tfm) \
tex(cmsmf10.vf) \
tex(cmsmf12.tfm) \
tex(cmsmf12.vf) \
tex(cmsmf17.tfm) \
tex(cmsmf17.vf) \
tex(cmsmf8.tfm) \
tex(cmsmf8.vf) \
tex(cmsmf9.tfm) \
tex(cmsmf9.vf) \
tex(cmsmfIPiXi10.tfm) \
tex(cmsmfIPiXi12.tfm) \
tex(cmsmfIPiXi17.tfm) \
tex(cmsmfIPiXi8.tfm) \
tex(cmsmfIPiXi9.tfm) \
tex(cmsmfIPiXibx10.tfm) \
tex(cmsmfIPiXibx12.tfm) \
tex(cmsmfIPiXibx17.tfm) \
tex(cmsmfIPiXibx8.tfm) \
tex(cmsmfIPiXibx9.tfm) \
tex(cmsmfIPiXibxcsc10.tfm) \
tex(cmsmfIPiXicsc10.tfm) \
tex(cmsmfIPiXicsc8.tfm) \
tex(cmsmfIPiXicsc9.tfm) \
tex(cmsmfIPiXicsci10.tfm) \
tex(cmsmfIPiXicsci8.tfm) \
tex(cmsmfIPiXicsci9.tfm) \
tex(cmsmfIPiXii10.tfm) \
tex(cmsmfIPiXii12.tfm) \
tex(cmsmfIPiXii17.tfm) \
tex(cmsmfIPiXii8.tfm) \
tex(cmsmfIPiXii9.tfm) \
tex(cmsmfIPiXixi10.tfm) \
tex(cmsmfIPiXixi12.tfm) \
tex(cmsmfIPiXixi17.tfm) \
tex(cmsmfIPiXixi8.tfm) \
tex(cmsmfIPiXixi9.tfm) \
tex(cmsmfIPiXixicsc10.tfm) \
tex(cmsmfbx10.tfm) \
tex(cmsmfbx10.vf) \
tex(cmsmfbx12.tfm) \
tex(cmsmfbx12.vf) \
tex(cmsmfbx17.tfm) \
tex(cmsmfbx17.vf) \
tex(cmsmfbx8.tfm) \
tex(cmsmfbx8.vf) \
tex(cmsmfbx9.tfm) \
tex(cmsmfbx9.vf) \
tex(cmsmfbxcsc10.tfm) \
tex(cmsmfbxcsc10.vf) \
tex(cmsmfcsc10.tfm) \
tex(cmsmfcsc10.vf) \
tex(cmsmfcsc8.tfm) \
tex(cmsmfcsc8.vf) \
tex(cmsmfcsc9.tfm) \
tex(cmsmfcsc9.vf) \
tex(cmsmfcsci10.tfm) \
tex(cmsmfcsci10.vf) \
tex(cmsmfcsci8.tfm) \
tex(cmsmfcsci8.vf) \
tex(cmsmfcsci9.tfm) \
tex(cmsmfcsci9.vf) \
tex(cmsmfi10.tfm) \
tex(cmsmfi10.vf) \
tex(cmsmfi12.tfm) \
tex(cmsmfi12.vf) \
tex(cmsmfi17.tfm) \
tex(cmsmfi17.vf) \
tex(cmsmfi8.tfm) \
tex(cmsmfi8.vf) \
tex(cmsmfi9.tfm) \
tex(cmsmfi9.vf) \
tex(cmsmfxi10.tfm) \
tex(cmsmfxi10.vf) \
tex(cmsmfxi12.tfm) \
tex(cmsmfxi12.vf) \
tex(cmsmfxi17.tfm) \
tex(cmsmfxi17.vf) \
tex(cmsmfxi8.tfm) \
tex(cmsmfxi8.vf) \
tex(cmsmfxi9.tfm) \
tex(cmsmfxi9.vf) \
tex(cmsmfxicsc10.tfm) \
tex(cmsmfxicsc10.vf) \
tex(cmssbsy10.tfm) \
tex(cmssbsy5.tfm) \
tex(cmssbsy6.tfm) \
tex(cmssbsy7.tfm) \
tex(cmssbsy8.tfm) \
tex(cmssbsy9.tfm) \
tex(cmssbxcsc10.tfm) \
tex(cmsscsc10.tfm) \
tex(cmsscsc8.tfm) \
tex(cmsscsc9.tfm) \
tex(cmsscsci10.tfm) \
tex(cmsscsci8.tfm) \
tex(cmsscsci9.tfm) \
tex(cmssex10.tfm) \
tex(cmssex7.tfm) \
tex(cmssex8.tfm) \
tex(cmssex9.tfm) \
tex(cmssmi10.tfm) \
tex(cmssmi5.tfm) \
tex(cmssmi6.tfm) \
tex(cmssmi7.tfm) \
tex(cmssmi8.tfm) \
tex(cmssmi9.tfm) \
tex(cmssmib10.tfm) \
tex(cmssmib5.tfm) \
tex(cmssmib6.tfm) \
tex(cmssmib7.tfm) \
tex(cmssmib8.tfm) \
tex(cmssmib9.tfm) \
tex(cmsssy10.tfm) \
tex(cmsssy5.tfm) \
tex(cmsssy6.tfm) \
tex(cmsssy7.tfm) \
tex(cmsssy8.tfm) \
tex(cmsssy9.tfm) \
tex(cmssu10.tfm) \
tex(cmssxicsc10.tfm) \
tex(eczi0500.tfm) \
tex(eczi0600.tfm) \
tex(eczi0700.tfm) \
tex(eczi0800.tfm) \
tex(eczi0900.tfm) \
tex(eczi1000.tfm) \
tex(eczi1095.tfm) \
tex(eczi1200.tfm) \
tex(eczi1440.tfm) \
tex(eczi1728.tfm) \
tex(eczi2074.tfm) \
tex(eczi2488.tfm) \
tex(eczi2986.tfm) \
tex(eczi3583.tfm) \
tex(eczo0500.tfm) \
tex(eczo0600.tfm) \
tex(eczo0700.tfm) \
tex(eczo0800.tfm) \
tex(eczo0900.tfm) \
tex(eczo1000.tfm) \
tex(eczo1095.tfm) \
tex(eczo1200.tfm) \
tex(eczo1440.tfm) \
tex(eczo1728.tfm) \
tex(eczo2074.tfm) \
tex(eczo2488.tfm) \
tex(eczo2986.tfm) \
tex(eczo3583.tfm) \
tex(eczx0500.tfm) \
tex(eczx0600.tfm) \
tex(eczx0700.tfm) \
tex(eczx0800.tfm) \
tex(eczx0900.tfm) \
tex(eczx1000.tfm) \
tex(eczx1095.tfm) \
tex(eczx1200.tfm) \
tex(eczx1440.tfm) \
tex(eczx1728.tfm) \
tex(eczx2074.tfm) \
tex(eczx2488.tfm) \
tex(eczx2986.tfm) \
tex(eczx3583.tfm) \
tex(eczz0500.tfm) \
tex(eczz0600.tfm) \
tex(eczz0700.tfm) \
tex(eczz0800.tfm) \
tex(eczz0900.tfm) \
tex(eczz1000.tfm) \
tex(eczz1095.tfm) \
tex(eczz1200.tfm) \
tex(eczz1440.tfm) \
tex(eczz1728.tfm) \
tex(eczz2074.tfm) \
tex(eczz2488.tfm) \
tex(eczz2986.tfm) \
tex(eczz3583.tfm) \
tex(omlcmssm.fd) \
tex(omscmsssy.fd) \
tex(omxcmssex.fd) \
tex(ot1cmsmf.fd) \
tex(ot1xcmss.fd) \
tex(sansmathfonts.map) \
tex(sansmathfonts.sty) \
tex(ssesint10.tfm) \
tex(ssesint7.tfm) \
tex(ssesint8.tfm) \
tex(ssesint9.tfm) \
tex(ssmsam10.tfm) \
tex(ssmsam5.tfm) \
tex(ssmsam6.tfm) \
tex(ssmsam7.tfm) \
tex(ssmsam8.tfm) \
tex(ssmsam9.tfm) \
tex(ssmsbm10.tfm) \
tex(ssmsbm5.tfm) \
tex(ssmsbm6.tfm) \
tex(ssmsbm7.tfm) \
tex(ssmsbm8.tfm) \
tex(ssmsbm9.tfm) \
tex(t1xcmss.fd) \
tex(ucmsmf.fd) \
tex(ussesint.fd) \
tex(ussmsa.fd) \
tex(ussmsb.fd) \
tex(uxcmss.fd) \
texlive-sansmathfonts"

RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex(cmss10.tfm) \
tex(cmss12.tfm) \
tex(cmss17.tfm) \
tex(cmss8.tfm) \
tex(cmss9.tfm) \
tex(cmssbx10.tfm) \
tex(cmssi10.tfm) \
tex(cmssi12.tfm) \
tex(cmssi17.tfm) \
tex(cmssi8.tfm) \
tex(cmssi9.tfm) \
tex(updmap.cfg) \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-sansmathfonts-fonts \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
