SUMMARY = "Extension of Bitstream Charter fonts"
DESCRIPTION = "The package presents an extension of Bitstream Charter, which \
provides small caps, oldstyle figures and superior figures in \
all four styles, accompanied by LaTeX font support files. The \
fonts themselves are provided in both Adobe Type 1 and OTF \
formats, with supporting files as necessary."
LICENSE = "LPPL-1.0"

PV = "2023.201.1.24svn63057"

RPM_NAME = "texlive-xcharter-2023.201.1.24svn63057-52.2.noarch.rpm"
RPM_HASH = "f24a381c18ccc45b2fa56124aba0ec29eb47ef5d7d98137bbe8674724135fe41412dab56aa3db7e8e57ca21ef378a64de0d2a5c14c9f5f6bb272aef0c6b95e19"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-LY1XCharter-Dnom.fd \
tex-LY1XCharter-Inf.fd \
tex-LY1XCharter-LF.fd \
tex-LY1XCharter-Numr.fd \
tex-LY1XCharter-OsF.fd \
tex-LY1XCharter-Sup.fd \
tex-LY1XCharter-TLF.fd \
tex-LY1XCharter-TOsF.fd \
tex-LY1XCharterTH-osf.fd \
tex-LY1XCharterTH-tlf.fd \
tex-OT1XCharter-Dnom.fd \
tex-OT1XCharter-Inf.fd \
tex-OT1XCharter-LF.fd \
tex-OT1XCharter-Numr.fd \
tex-OT1XCharter-OsF.fd \
tex-OT1XCharter-Sup.fd \
tex-OT1XCharter-TLF.fd \
tex-OT1XCharter-TOsF.fd \
tex-OT1XCharterTH-osf.fd \
tex-OT1XCharterTH-tlf.fd \
tex-OT2XCharter-TLF.fd \
tex-T1XCharter-Dnom.fd \
tex-T1XCharter-Inf.fd \
tex-T1XCharter-LF.fd \
tex-T1XCharter-Numr.fd \
tex-T1XCharter-OsF.fd \
tex-T1XCharter-Sup.fd \
tex-T1XCharter-TLF.fd \
tex-T1XCharter-TOsF.fd \
tex-T1XCharterTH-osf.fd \
tex-T1XCharterTH-tlf.fd \
tex-T2ASRBXCharter-LF.fd \
tex-T2ASRBXCharter-OsF.fd \
tex-T2ASRBXCharter-Sup.fd \
tex-T2ASRBXCharter-TLF.fd \
tex-T2ASRBXCharter-TOsF.fd \
tex-T2AXCharter-LF.fd \
tex-T2AXCharter-OsF.fd \
tex-T2AXCharter-Sup.fd \
tex-T2AXCharter-TLF.fd \
tex-T2AXCharter-TOsF.fd \
tex-TS1XCharter-LF.fd \
tex-TS1XCharter-OsF.fd \
tex-TS1XCharter-TLF.fd \
tex-TS1XCharter-TOsF.fd \
tex-XCharter-Bol-osf.tfm \
tex-XCharter-BolIta-alph.tfm \
tex-XCharter-Bold-dnom-ly1--base.tfm \
tex-XCharter-Bold-dnom-ly1.tfm \
tex-XCharter-Bold-dnom-ly1.vf \
tex-XCharter-Bold-dnom-ot1.tfm \
tex-XCharter-Bold-dnom-t1--base.tfm \
tex-XCharter-Bold-dnom-t1.tfm \
tex-XCharter-Bold-dnom-t1.vf \
tex-XCharter-Bold-inf-ly1--base.tfm \
tex-XCharter-Bold-inf-ly1.tfm \
tex-XCharter-Bold-inf-ly1.vf \
tex-XCharter-Bold-inf-ot1.tfm \
tex-XCharter-Bold-inf-t1--base.tfm \
tex-XCharter-Bold-inf-t1.tfm \
tex-XCharter-Bold-inf-t1.vf \
tex-XCharter-Bold-lf-ly1--base.tfm \
tex-XCharter-Bold-lf-ly1.tfm \
tex-XCharter-Bold-lf-ly1.vf \
tex-XCharter-Bold-lf-ot1.tfm \
tex-XCharter-Bold-lf-sc-ly1--base.tfm \
tex-XCharter-Bold-lf-sc-ly1.tfm \
tex-XCharter-Bold-lf-sc-ly1.vf \
tex-XCharter-Bold-lf-sc-ot1--base.tfm \
tex-XCharter-Bold-lf-sc-ot1.tfm \
tex-XCharter-Bold-lf-sc-ot1.vf \
tex-XCharter-Bold-lf-sc-t1--base.tfm \
tex-XCharter-Bold-lf-sc-t1.tfm \
tex-XCharter-Bold-lf-sc-t1.vf \
tex-XCharter-Bold-lf-sc-t2a--base.tfm \
tex-XCharter-Bold-lf-sc-t2a.tfm \
tex-XCharter-Bold-lf-sc-t2a.vf \
tex-XCharter-Bold-lf-sc-t2asrb--base.tfm \
tex-XCharter-Bold-lf-sc-t2asrb.tfm \
tex-XCharter-Bold-lf-sc-t2asrb.vf \
tex-XCharter-Bold-lf-t1--base.tfm \
tex-XCharter-Bold-lf-t1.tfm \
tex-XCharter-Bold-lf-t1.vf \
tex-XCharter-Bold-lf-t2a.tfm \
tex-XCharter-Bold-lf-t2asrb.tfm \
tex-XCharter-Bold-numr-ly1--base.tfm \
tex-XCharter-Bold-numr-ly1.tfm \
tex-XCharter-Bold-numr-ly1.vf \
tex-XCharter-Bold-numr-ot1.tfm \
tex-XCharter-Bold-numr-t1--base.tfm \
tex-XCharter-Bold-numr-t1.tfm \
tex-XCharter-Bold-numr-t1.vf \
tex-XCharter-Bold-osf-ly1--base.tfm \
tex-XCharter-Bold-osf-ly1.tfm \
tex-XCharter-Bold-osf-ly1.vf \
tex-XCharter-Bold-osf-ot1.tfm \
tex-XCharter-Bold-osf-sc-ly1--base.tfm \
tex-XCharter-Bold-osf-sc-ly1.tfm \
tex-XCharter-Bold-osf-sc-ly1.vf \
tex-XCharter-Bold-osf-sc-ot1--base.tfm \
tex-XCharter-Bold-osf-sc-ot1.tfm \
tex-XCharter-Bold-osf-sc-ot1.vf \
tex-XCharter-Bold-osf-sc-t1--base.tfm \
tex-XCharter-Bold-osf-sc-t1.tfm \
tex-XCharter-Bold-osf-sc-t1.vf \
tex-XCharter-Bold-osf-sc-t2a--base.tfm \
tex-XCharter-Bold-osf-sc-t2a.tfm \
tex-XCharter-Bold-osf-sc-t2a.vf \
tex-XCharter-Bold-osf-sc-t2asrb--base.tfm \
tex-XCharter-Bold-osf-sc-t2asrb.tfm \
tex-XCharter-Bold-osf-sc-t2asrb.vf \
tex-XCharter-Bold-osf-t1--base.tfm \
tex-XCharter-Bold-osf-t1.tfm \
tex-XCharter-Bold-osf-t1.vf \
tex-XCharter-Bold-osf-t2a.tfm \
tex-XCharter-Bold-osf-t2asrb.tfm \
tex-XCharter-Bold-sup-ly1--base.tfm \
tex-XCharter-Bold-sup-ly1.tfm \
tex-XCharter-Bold-sup-ly1.vf \
tex-XCharter-Bold-sup-ot1.tfm \
tex-XCharter-Bold-sup-t1--base.tfm \
tex-XCharter-Bold-sup-t1.tfm \
tex-XCharter-Bold-sup-t1.vf \
tex-XCharter-Bold-sup-t2a.tfm \
tex-XCharter-Bold-sup-t2asrb.tfm \
tex-XCharter-Bold-tlf-ly1--base.tfm \
tex-XCharter-Bold-tlf-ly1.tfm \
tex-XCharter-Bold-tlf-ly1.vf \
tex-XCharter-Bold-tlf-ot1.tfm \
tex-XCharter-Bold-tlf-ot1G.tfm \
tex-XCharter-Bold-tlf-ot1G.vf \
tex-XCharter-Bold-tlf-ot2.tfm \
tex-XCharter-Bold-tlf-sc-ly1--base.tfm \
tex-XCharter-Bold-tlf-sc-ly1.tfm \
tex-XCharter-Bold-tlf-sc-ly1.vf \
tex-XCharter-Bold-tlf-sc-ot1--base.tfm \
tex-XCharter-Bold-tlf-sc-ot1.tfm \
tex-XCharter-Bold-tlf-sc-ot1.vf \
tex-XCharter-Bold-tlf-sc-t1--base.tfm \
tex-XCharter-Bold-tlf-sc-t1.tfm \
tex-XCharter-Bold-tlf-sc-t1.vf \
tex-XCharter-Bold-tlf-sc-t2a--base.tfm \
tex-XCharter-Bold-tlf-sc-t2a.tfm \
tex-XCharter-Bold-tlf-sc-t2a.vf \
tex-XCharter-Bold-tlf-sc-t2asrb--base.tfm \
tex-XCharter-Bold-tlf-sc-t2asrb.tfm \
tex-XCharter-Bold-tlf-sc-t2asrb.vf \
tex-XCharter-Bold-tlf-t1--base.tfm \
tex-XCharter-Bold-tlf-t1.tfm \
tex-XCharter-Bold-tlf-t1.vf \
tex-XCharter-Bold-tlf-t2a.tfm \
tex-XCharter-Bold-tlf-t2asrb.tfm \
tex-XCharter-Bold-tosf-ly1--base.tfm \
tex-XCharter-Bold-tosf-ly1.tfm \
tex-XCharter-Bold-tosf-ly1.vf \
tex-XCharter-Bold-tosf-ot1.tfm \
tex-XCharter-Bold-tosf-sc-ly1--base.tfm \
tex-XCharter-Bold-tosf-sc-ly1.tfm \
tex-XCharter-Bold-tosf-sc-ly1.vf \
tex-XCharter-Bold-tosf-sc-ot1--base.tfm \
tex-XCharter-Bold-tosf-sc-ot1.tfm \
tex-XCharter-Bold-tosf-sc-ot1.vf \
tex-XCharter-Bold-tosf-sc-t1--base.tfm \
tex-XCharter-Bold-tosf-sc-t1.tfm \
tex-XCharter-Bold-tosf-sc-t1.vf \
tex-XCharter-Bold-tosf-sc-t2a--base.tfm \
tex-XCharter-Bold-tosf-sc-t2a.tfm \
tex-XCharter-Bold-tosf-sc-t2a.vf \
tex-XCharter-Bold-tosf-sc-t2asrb--base.tfm \
tex-XCharter-Bold-tosf-sc-t2asrb.tfm \
tex-XCharter-Bold-tosf-sc-t2asrb.vf \
tex-XCharter-Bold-tosf-t1--base.tfm \
tex-XCharter-Bold-tosf-t1.tfm \
tex-XCharter-Bold-tosf-t1.vf \
tex-XCharter-Bold-tosf-t2a.tfm \
tex-XCharter-Bold-tosf-t2asrb.tfm \
tex-XCharter-Bold-ts1--base.tfm \
tex-XCharter-Bold-ts1.tfm \
tex-XCharter-Bold-ts1.vf \
tex-XCharter-BoldItalic-dnom-ly1--base.tfm \
tex-XCharter-BoldItalic-dnom-ly1.tfm \
tex-XCharter-BoldItalic-dnom-ly1.vf \
tex-XCharter-BoldItalic-dnom-ot1.tfm \
tex-XCharter-BoldItalic-dnom-t1--base.tfm \
tex-XCharter-BoldItalic-dnom-t1.tfm \
tex-XCharter-BoldItalic-dnom-t1.vf \
tex-XCharter-BoldItalic-inf-ly1--base.tfm \
tex-XCharter-BoldItalic-inf-ly1.tfm \
tex-XCharter-BoldItalic-inf-ly1.vf \
tex-XCharter-BoldItalic-inf-ot1.tfm \
tex-XCharter-BoldItalic-inf-t1--base.tfm \
tex-XCharter-BoldItalic-inf-t1.tfm \
tex-XCharter-BoldItalic-inf-t1.vf \
tex-XCharter-BoldItalic-lf-ly1--base.tfm \
tex-XCharter-BoldItalic-lf-ly1.tfm \
tex-XCharter-BoldItalic-lf-ly1.vf \
tex-XCharter-BoldItalic-lf-ot1.tfm \
tex-XCharter-BoldItalic-lf-sc-ly1--base.tfm \
tex-XCharter-BoldItalic-lf-sc-ly1.tfm \
tex-XCharter-BoldItalic-lf-sc-ly1.vf \
tex-XCharter-BoldItalic-lf-sc-ot1--base.tfm \
tex-XCharter-BoldItalic-lf-sc-ot1.tfm \
tex-XCharter-BoldItalic-lf-sc-ot1.vf \
tex-XCharter-BoldItalic-lf-sc-t1--base.tfm \
tex-XCharter-BoldItalic-lf-sc-t1.tfm \
tex-XCharter-BoldItalic-lf-sc-t1.vf \
tex-XCharter-BoldItalic-lf-sc-t2a--base.tfm \
tex-XCharter-BoldItalic-lf-sc-t2a.tfm \
tex-XCharter-BoldItalic-lf-sc-t2a.vf \
tex-XCharter-BoldItalic-lf-sc-t2asrb--base.tfm \
tex-XCharter-BoldItalic-lf-sc-t2asrb.tfm \
tex-XCharter-BoldItalic-lf-sc-t2asrb.vf \
tex-XCharter-BoldItalic-lf-t1--base.tfm \
tex-XCharter-BoldItalic-lf-t1.tfm \
tex-XCharter-BoldItalic-lf-t1.vf \
tex-XCharter-BoldItalic-lf-t2a.tfm \
tex-XCharter-BoldItalic-lf-t2asrb.tfm \
tex-XCharter-BoldItalic-numr-ly1--base.tfm \
tex-XCharter-BoldItalic-numr-ly1.tfm \
tex-XCharter-BoldItalic-numr-ly1.vf \
tex-XCharter-BoldItalic-numr-ot1.tfm \
tex-XCharter-BoldItalic-numr-t1--base.tfm \
tex-XCharter-BoldItalic-numr-t1.tfm \
tex-XCharter-BoldItalic-numr-t1.vf \
tex-XCharter-BoldItalic-osf-ly1--base.tfm \
tex-XCharter-BoldItalic-osf-ly1.tfm \
tex-XCharter-BoldItalic-osf-ly1.vf \
tex-XCharter-BoldItalic-osf-ot1.tfm \
tex-XCharter-BoldItalic-osf-sc-ly1--base.tfm \
tex-XCharter-BoldItalic-osf-sc-ly1.tfm \
tex-XCharter-BoldItalic-osf-sc-ly1.vf \
tex-XCharter-BoldItalic-osf-sc-ot1--base.tfm \
tex-XCharter-BoldItalic-osf-sc-ot1.tfm \
tex-XCharter-BoldItalic-osf-sc-ot1.vf \
tex-XCharter-BoldItalic-osf-sc-t1--base.tfm \
tex-XCharter-BoldItalic-osf-sc-t1.tfm \
tex-XCharter-BoldItalic-osf-sc-t1.vf \
tex-XCharter-BoldItalic-osf-sc-t2a--base.tfm \
tex-XCharter-BoldItalic-osf-sc-t2a.tfm \
tex-XCharter-BoldItalic-osf-sc-t2a.vf \
tex-XCharter-BoldItalic-osf-sc-t2asrb--base.tfm \
tex-XCharter-BoldItalic-osf-sc-t2asrb.tfm \
tex-XCharter-BoldItalic-osf-sc-t2asrb.vf \
tex-XCharter-BoldItalic-osf-t1--base.tfm \
tex-XCharter-BoldItalic-osf-t1.tfm \
tex-XCharter-BoldItalic-osf-t1.vf \
tex-XCharter-BoldItalic-osf-t2a.tfm \
tex-XCharter-BoldItalic-osf-t2asrb.tfm \
tex-XCharter-BoldItalic-sup-ly1--base.tfm \
tex-XCharter-BoldItalic-sup-ly1.tfm \
tex-XCharter-BoldItalic-sup-ly1.vf \
tex-XCharter-BoldItalic-sup-ot1.tfm \
tex-XCharter-BoldItalic-sup-t1--base.tfm \
tex-XCharter-BoldItalic-sup-t1.tfm \
tex-XCharter-BoldItalic-sup-t1.vf \
tex-XCharter-BoldItalic-sup-t2a.tfm \
tex-XCharter-BoldItalic-sup-t2asrb.tfm \
tex-XCharter-BoldItalic-tlf-ly1--base.tfm \
tex-XCharter-BoldItalic-tlf-ly1.tfm \
tex-XCharter-BoldItalic-tlf-ly1.vf \
tex-XCharter-BoldItalic-tlf-ot1.tfm \
tex-XCharter-BoldItalic-tlf-ot1G.tfm \
tex-XCharter-BoldItalic-tlf-ot1G.vf \
tex-XCharter-BoldItalic-tlf-ot2.tfm \
tex-XCharter-BoldItalic-tlf-sc-ly1--base.tfm \
tex-XCharter-BoldItalic-tlf-sc-ly1.tfm \
tex-XCharter-BoldItalic-tlf-sc-ly1.vf \
tex-XCharter-BoldItalic-tlf-sc-ot1--base.tfm \
tex-XCharter-BoldItalic-tlf-sc-ot1.tfm \
tex-XCharter-BoldItalic-tlf-sc-ot1.vf \
tex-XCharter-BoldItalic-tlf-sc-t1--base.tfm \
tex-XCharter-BoldItalic-tlf-sc-t1.tfm \
tex-XCharter-BoldItalic-tlf-sc-t1.vf \
tex-XCharter-BoldItalic-tlf-sc-t2a--base.tfm \
tex-XCharter-BoldItalic-tlf-sc-t2a.tfm \
tex-XCharter-BoldItalic-tlf-sc-t2a.vf \
tex-XCharter-BoldItalic-tlf-sc-t2asrb--base.tfm \
tex-XCharter-BoldItalic-tlf-sc-t2asrb.tfm \
tex-XCharter-BoldItalic-tlf-sc-t2asrb.vf \
tex-XCharter-BoldItalic-tlf-t1--base.tfm \
tex-XCharter-BoldItalic-tlf-t1.tfm \
tex-XCharter-BoldItalic-tlf-t1.vf \
tex-XCharter-BoldItalic-tlf-t2a.tfm \
tex-XCharter-BoldItalic-tlf-t2asrb.tfm \
tex-XCharter-BoldItalic-tosf-ly1--base.tfm \
tex-XCharter-BoldItalic-tosf-ly1.tfm \
tex-XCharter-BoldItalic-tosf-ly1.vf \
tex-XCharter-BoldItalic-tosf-ot1.tfm \
tex-XCharter-BoldItalic-tosf-sc-ly1--base.tfm \
tex-XCharter-BoldItalic-tosf-sc-ly1.tfm \
tex-XCharter-BoldItalic-tosf-sc-ly1.vf \
tex-XCharter-BoldItalic-tosf-sc-ot1--base.tfm \
tex-XCharter-BoldItalic-tosf-sc-ot1.tfm \
tex-XCharter-BoldItalic-tosf-sc-ot1.vf \
tex-XCharter-BoldItalic-tosf-sc-t1--base.tfm \
tex-XCharter-BoldItalic-tosf-sc-t1.tfm \
tex-XCharter-BoldItalic-tosf-sc-t1.vf \
tex-XCharter-BoldItalic-tosf-sc-t2a--base.tfm \
tex-XCharter-BoldItalic-tosf-sc-t2a.tfm \
tex-XCharter-BoldItalic-tosf-sc-t2a.vf \
tex-XCharter-BoldItalic-tosf-sc-t2asrb--base.tfm \
tex-XCharter-BoldItalic-tosf-sc-t2asrb.tfm \
tex-XCharter-BoldItalic-tosf-sc-t2asrb.vf \
tex-XCharter-BoldItalic-tosf-t1--base.tfm \
tex-XCharter-BoldItalic-tosf-t1.tfm \
tex-XCharter-BoldItalic-tosf-t1.vf \
tex-XCharter-BoldItalic-tosf-t2a.tfm \
tex-XCharter-BoldItalic-tosf-t2asrb.tfm \
tex-XCharter-BoldItalic-ts1--base.tfm \
tex-XCharter-BoldItalic-ts1.tfm \
tex-XCharter-BoldItalic-ts1.vf \
tex-XCharter-BoldSlanted-dnom-ly1--base.tfm \
tex-XCharter-BoldSlanted-dnom-ly1.tfm \
tex-XCharter-BoldSlanted-dnom-ly1.vf \
tex-XCharter-BoldSlanted-dnom-ot1.tfm \
tex-XCharter-BoldSlanted-dnom-t1--base.tfm \
tex-XCharter-BoldSlanted-dnom-t1.tfm \
tex-XCharter-BoldSlanted-dnom-t1.vf \
tex-XCharter-BoldSlanted-inf-ly1--base.tfm \
tex-XCharter-BoldSlanted-inf-ly1.tfm \
tex-XCharter-BoldSlanted-inf-ly1.vf \
tex-XCharter-BoldSlanted-inf-ot1.tfm \
tex-XCharter-BoldSlanted-inf-t1--base.tfm \
tex-XCharter-BoldSlanted-inf-t1.tfm \
tex-XCharter-BoldSlanted-inf-t1.vf \
tex-XCharter-BoldSlanted-lf-ly1--base.tfm \
tex-XCharter-BoldSlanted-lf-ly1.tfm \
tex-XCharter-BoldSlanted-lf-ly1.vf \
tex-XCharter-BoldSlanted-lf-ot1.tfm \
tex-XCharter-BoldSlanted-lf-sc-ly1--base.tfm \
tex-XCharter-BoldSlanted-lf-sc-ly1.tfm \
tex-XCharter-BoldSlanted-lf-sc-ly1.vf \
tex-XCharter-BoldSlanted-lf-sc-ot1--base.tfm \
tex-XCharter-BoldSlanted-lf-sc-ot1.tfm \
tex-XCharter-BoldSlanted-lf-sc-ot1.vf \
tex-XCharter-BoldSlanted-lf-sc-t1--base.tfm \
tex-XCharter-BoldSlanted-lf-sc-t1.tfm \
tex-XCharter-BoldSlanted-lf-sc-t1.vf \
tex-XCharter-BoldSlanted-lf-sc-t2a--base.tfm \
tex-XCharter-BoldSlanted-lf-sc-t2a.tfm \
tex-XCharter-BoldSlanted-lf-sc-t2a.vf \
tex-XCharter-BoldSlanted-lf-sc-t2asrb--base.tfm \
tex-XCharter-BoldSlanted-lf-sc-t2asrb.tfm \
tex-XCharter-BoldSlanted-lf-sc-t2asrb.vf \
tex-XCharter-BoldSlanted-lf-t1--base.tfm \
tex-XCharter-BoldSlanted-lf-t1.tfm \
tex-XCharter-BoldSlanted-lf-t1.vf \
tex-XCharter-BoldSlanted-lf-t2a.tfm \
tex-XCharter-BoldSlanted-lf-t2asrb.tfm \
tex-XCharter-BoldSlanted-numr-ly1--base.tfm \
tex-XCharter-BoldSlanted-numr-ly1.tfm \
tex-XCharter-BoldSlanted-numr-ly1.vf \
tex-XCharter-BoldSlanted-numr-ot1.tfm \
tex-XCharter-BoldSlanted-numr-t1--base.tfm \
tex-XCharter-BoldSlanted-numr-t1.tfm \
tex-XCharter-BoldSlanted-numr-t1.vf \
tex-XCharter-BoldSlanted-osf-ly1--base.tfm \
tex-XCharter-BoldSlanted-osf-ly1.tfm \
tex-XCharter-BoldSlanted-osf-ly1.vf \
tex-XCharter-BoldSlanted-osf-ot1.tfm \
tex-XCharter-BoldSlanted-osf-sc-ly1--base.tfm \
tex-XCharter-BoldSlanted-osf-sc-ly1.tfm \
tex-XCharter-BoldSlanted-osf-sc-ly1.vf \
tex-XCharter-BoldSlanted-osf-sc-ot1--base.tfm \
tex-XCharter-BoldSlanted-osf-sc-ot1.tfm \
tex-XCharter-BoldSlanted-osf-sc-ot1.vf \
tex-XCharter-BoldSlanted-osf-sc-t1--base.tfm \
tex-XCharter-BoldSlanted-osf-sc-t1.tfm \
tex-XCharter-BoldSlanted-osf-sc-t1.vf \
tex-XCharter-BoldSlanted-osf-sc-t2a--base.tfm \
tex-XCharter-BoldSlanted-osf-sc-t2a.tfm \
tex-XCharter-BoldSlanted-osf-sc-t2a.vf \
tex-XCharter-BoldSlanted-osf-sc-t2asrb--base.tfm \
tex-XCharter-BoldSlanted-osf-sc-t2asrb.tfm \
tex-XCharter-BoldSlanted-osf-sc-t2asrb.vf \
tex-XCharter-BoldSlanted-osf-t1--base.tfm \
tex-XCharter-BoldSlanted-osf-t1.tfm \
tex-XCharter-BoldSlanted-osf-t1.vf \
tex-XCharter-BoldSlanted-osf-t2a.tfm \
tex-XCharter-BoldSlanted-osf-t2asrb.tfm \
tex-XCharter-BoldSlanted-sup-ly1--base.tfm \
tex-XCharter-BoldSlanted-sup-ly1.tfm \
tex-XCharter-BoldSlanted-sup-ly1.vf \
tex-XCharter-BoldSlanted-sup-ot1.tfm \
tex-XCharter-BoldSlanted-sup-t1--base.tfm \
tex-XCharter-BoldSlanted-sup-t1.tfm \
tex-XCharter-BoldSlanted-sup-t1.vf \
tex-XCharter-BoldSlanted-sup-t2a.tfm \
tex-XCharter-BoldSlanted-sup-t2asrb.tfm \
tex-XCharter-BoldSlanted-tlf-ly1--base.tfm \
tex-XCharter-BoldSlanted-tlf-ly1.tfm \
tex-XCharter-BoldSlanted-tlf-ly1.vf \
tex-XCharter-BoldSlanted-tlf-ot1.tfm \
tex-XCharter-BoldSlanted-tlf-ot2.tfm \
tex-XCharter-BoldSlanted-tlf-sc-ly1--base.tfm \
tex-XCharter-BoldSlanted-tlf-sc-ly1.tfm \
tex-XCharter-BoldSlanted-tlf-sc-ly1.vf \
tex-XCharter-BoldSlanted-tlf-sc-ot1--base.tfm \
tex-XCharter-BoldSlanted-tlf-sc-ot1.tfm \
tex-XCharter-BoldSlanted-tlf-sc-ot1.vf \
tex-XCharter-BoldSlanted-tlf-sc-t1--base.tfm \
tex-XCharter-BoldSlanted-tlf-sc-t1.tfm \
tex-XCharter-BoldSlanted-tlf-sc-t1.vf \
tex-XCharter-BoldSlanted-tlf-sc-t2a--base.tfm \
tex-XCharter-BoldSlanted-tlf-sc-t2a.tfm \
tex-XCharter-BoldSlanted-tlf-sc-t2a.vf \
tex-XCharter-BoldSlanted-tlf-sc-t2asrb--base.tfm \
tex-XCharter-BoldSlanted-tlf-sc-t2asrb.tfm \
tex-XCharter-BoldSlanted-tlf-sc-t2asrb.vf \
tex-XCharter-BoldSlanted-tlf-t1--base.tfm \
tex-XCharter-BoldSlanted-tlf-t1.tfm \
tex-XCharter-BoldSlanted-tlf-t1.vf \
tex-XCharter-BoldSlanted-tlf-t2a.tfm \
tex-XCharter-BoldSlanted-tlf-t2asrb.tfm \
tex-XCharter-BoldSlanted-tosf-ly1--base.tfm \
tex-XCharter-BoldSlanted-tosf-ly1.tfm \
tex-XCharter-BoldSlanted-tosf-ly1.vf \
tex-XCharter-BoldSlanted-tosf-ot1.tfm \
tex-XCharter-BoldSlanted-tosf-sc-ly1--base.tfm \
tex-XCharter-BoldSlanted-tosf-sc-ly1.tfm \
tex-XCharter-BoldSlanted-tosf-sc-ly1.vf \
tex-XCharter-BoldSlanted-tosf-sc-ot1--base.tfm \
tex-XCharter-BoldSlanted-tosf-sc-ot1.tfm \
tex-XCharter-BoldSlanted-tosf-sc-ot1.vf \
tex-XCharter-BoldSlanted-tosf-sc-t1--base.tfm \
tex-XCharter-BoldSlanted-tosf-sc-t1.tfm \
tex-XCharter-BoldSlanted-tosf-sc-t1.vf \
tex-XCharter-BoldSlanted-tosf-sc-t2a--base.tfm \
tex-XCharter-BoldSlanted-tosf-sc-t2a.tfm \
tex-XCharter-BoldSlanted-tosf-sc-t2a.vf \
tex-XCharter-BoldSlanted-tosf-sc-t2asrb--base.tfm \
tex-XCharter-BoldSlanted-tosf-sc-t2asrb.tfm \
tex-XCharter-BoldSlanted-tosf-sc-t2asrb.vf \
tex-XCharter-BoldSlanted-tosf-t1--base.tfm \
tex-XCharter-BoldSlanted-tosf-t1.tfm \
tex-XCharter-BoldSlanted-tosf-t1.vf \
tex-XCharter-BoldSlanted-tosf-t2a.tfm \
tex-XCharter-BoldSlanted-tosf-t2asrb.tfm \
tex-XCharter-BoldSlanted-ts1--base.tfm \
tex-XCharter-BoldSlanted-ts1.tfm \
tex-XCharter-BoldSlanted-ts1.vf \
tex-XCharter-Ita-alph.tfm \
tex-XCharter-Italic-dnom-ly1--base.tfm \
tex-XCharter-Italic-dnom-ly1.tfm \
tex-XCharter-Italic-dnom-ly1.vf \
tex-XCharter-Italic-dnom-ot1.tfm \
tex-XCharter-Italic-dnom-t1--base.tfm \
tex-XCharter-Italic-dnom-t1.tfm \
tex-XCharter-Italic-dnom-t1.vf \
tex-XCharter-Italic-inf-ly1--base.tfm \
tex-XCharter-Italic-inf-ly1.tfm \
tex-XCharter-Italic-inf-ly1.vf \
tex-XCharter-Italic-inf-ot1.tfm \
tex-XCharter-Italic-inf-t1--base.tfm \
tex-XCharter-Italic-inf-t1.tfm \
tex-XCharter-Italic-inf-t1.vf \
tex-XCharter-Italic-lf-ly1--base.tfm \
tex-XCharter-Italic-lf-ly1.tfm \
tex-XCharter-Italic-lf-ly1.vf \
tex-XCharter-Italic-lf-ot1.tfm \
tex-XCharter-Italic-lf-sc-ly1--base.tfm \
tex-XCharter-Italic-lf-sc-ly1.tfm \
tex-XCharter-Italic-lf-sc-ly1.vf \
tex-XCharter-Italic-lf-sc-ot1--base.tfm \
tex-XCharter-Italic-lf-sc-ot1.tfm \
tex-XCharter-Italic-lf-sc-ot1.vf \
tex-XCharter-Italic-lf-sc-t1--base.tfm \
tex-XCharter-Italic-lf-sc-t1.tfm \
tex-XCharter-Italic-lf-sc-t1.vf \
tex-XCharter-Italic-lf-sc-t2a--base.tfm \
tex-XCharter-Italic-lf-sc-t2a.tfm \
tex-XCharter-Italic-lf-sc-t2a.vf \
tex-XCharter-Italic-lf-sc-t2asrb--base.tfm \
tex-XCharter-Italic-lf-sc-t2asrb.tfm \
tex-XCharter-Italic-lf-sc-t2asrb.vf \
tex-XCharter-Italic-lf-t1--base.tfm \
tex-XCharter-Italic-lf-t1.tfm \
tex-XCharter-Italic-lf-t1.vf \
tex-XCharter-Italic-lf-t2a.tfm \
tex-XCharter-Italic-lf-t2asrb.tfm \
tex-XCharter-Italic-numr-ly1--base.tfm \
tex-XCharter-Italic-numr-ly1.tfm \
tex-XCharter-Italic-numr-ly1.vf \
tex-XCharter-Italic-numr-ot1.tfm \
tex-XCharter-Italic-numr-t1--base.tfm \
tex-XCharter-Italic-numr-t1.tfm \
tex-XCharter-Italic-numr-t1.vf \
tex-XCharter-Italic-osf-ly1--base.tfm \
tex-XCharter-Italic-osf-ly1.tfm \
tex-XCharter-Italic-osf-ly1.vf \
tex-XCharter-Italic-osf-ot1.tfm \
tex-XCharter-Italic-osf-sc-ly1--base.tfm \
tex-XCharter-Italic-osf-sc-ly1.tfm \
tex-XCharter-Italic-osf-sc-ly1.vf \
tex-XCharter-Italic-osf-sc-ot1--base.tfm \
tex-XCharter-Italic-osf-sc-ot1.tfm \
tex-XCharter-Italic-osf-sc-ot1.vf \
tex-XCharter-Italic-osf-sc-t1--base.tfm \
tex-XCharter-Italic-osf-sc-t1.tfm \
tex-XCharter-Italic-osf-sc-t1.vf \
tex-XCharter-Italic-osf-sc-t2a--base.tfm \
tex-XCharter-Italic-osf-sc-t2a.tfm \
tex-XCharter-Italic-osf-sc-t2a.vf \
tex-XCharter-Italic-osf-sc-t2asrb--base.tfm \
tex-XCharter-Italic-osf-sc-t2asrb.tfm \
tex-XCharter-Italic-osf-sc-t2asrb.vf \
tex-XCharter-Italic-osf-t1--base.tfm \
tex-XCharter-Italic-osf-t1.tfm \
tex-XCharter-Italic-osf-t1.vf \
tex-XCharter-Italic-osf-t2a.tfm \
tex-XCharter-Italic-osf-t2asrb.tfm \
tex-XCharter-Italic-sup-ly1--base.tfm \
tex-XCharter-Italic-sup-ly1.tfm \
tex-XCharter-Italic-sup-ly1.vf \
tex-XCharter-Italic-sup-ot1.tfm \
tex-XCharter-Italic-sup-t1--base.tfm \
tex-XCharter-Italic-sup-t1.tfm \
tex-XCharter-Italic-sup-t1.vf \
tex-XCharter-Italic-sup-t2a.tfm \
tex-XCharter-Italic-sup-t2asrb.tfm \
tex-XCharter-Italic-tlf-ly1--base.tfm \
tex-XCharter-Italic-tlf-ly1.tfm \
tex-XCharter-Italic-tlf-ly1.vf \
tex-XCharter-Italic-tlf-ot1.tfm \
tex-XCharter-Italic-tlf-ot1G.tfm \
tex-XCharter-Italic-tlf-ot1G.vf \
tex-XCharter-Italic-tlf-ot2.tfm \
tex-XCharter-Italic-tlf-sc-ly1--base.tfm \
tex-XCharter-Italic-tlf-sc-ly1.tfm \
tex-XCharter-Italic-tlf-sc-ly1.vf \
tex-XCharter-Italic-tlf-sc-ot1--base.tfm \
tex-XCharter-Italic-tlf-sc-ot1.tfm \
tex-XCharter-Italic-tlf-sc-ot1.vf \
tex-XCharter-Italic-tlf-sc-t1--base.tfm \
tex-XCharter-Italic-tlf-sc-t1.tfm \
tex-XCharter-Italic-tlf-sc-t1.vf \
tex-XCharter-Italic-tlf-sc-t2a--base.tfm \
tex-XCharter-Italic-tlf-sc-t2a.tfm \
tex-XCharter-Italic-tlf-sc-t2a.vf \
tex-XCharter-Italic-tlf-sc-t2asrb--base.tfm \
tex-XCharter-Italic-tlf-sc-t2asrb.tfm \
tex-XCharter-Italic-tlf-sc-t2asrb.vf \
tex-XCharter-Italic-tlf-t1--base.tfm \
tex-XCharter-Italic-tlf-t1.tfm \
tex-XCharter-Italic-tlf-t1.vf \
tex-XCharter-Italic-tlf-t2a.tfm \
tex-XCharter-Italic-tlf-t2asrb.tfm \
tex-XCharter-Italic-tosf-ly1--base.tfm \
tex-XCharter-Italic-tosf-ly1.tfm \
tex-XCharter-Italic-tosf-ly1.vf \
tex-XCharter-Italic-tosf-ot1.tfm \
tex-XCharter-Italic-tosf-sc-ly1--base.tfm \
tex-XCharter-Italic-tosf-sc-ly1.tfm \
tex-XCharter-Italic-tosf-sc-ly1.vf \
tex-XCharter-Italic-tosf-sc-ot1--base.tfm \
tex-XCharter-Italic-tosf-sc-ot1.tfm \
tex-XCharter-Italic-tosf-sc-ot1.vf \
tex-XCharter-Italic-tosf-sc-t1--base.tfm \
tex-XCharter-Italic-tosf-sc-t1.tfm \
tex-XCharter-Italic-tosf-sc-t1.vf \
tex-XCharter-Italic-tosf-sc-t2a--base.tfm \
tex-XCharter-Italic-tosf-sc-t2a.tfm \
tex-XCharter-Italic-tosf-sc-t2a.vf \
tex-XCharter-Italic-tosf-sc-t2asrb--base.tfm \
tex-XCharter-Italic-tosf-sc-t2asrb.tfm \
tex-XCharter-Italic-tosf-sc-t2asrb.vf \
tex-XCharter-Italic-tosf-t1--base.tfm \
tex-XCharter-Italic-tosf-t1.tfm \
tex-XCharter-Italic-tosf-t1.vf \
tex-XCharter-Italic-tosf-t2a.tfm \
tex-XCharter-Italic-tosf-t2asrb.tfm \
tex-XCharter-Italic-ts1--base.tfm \
tex-XCharter-Italic-ts1.tfm \
tex-XCharter-Italic-ts1.vf \
tex-XCharter-Roman-dnom-ly1--base.tfm \
tex-XCharter-Roman-dnom-ly1.tfm \
tex-XCharter-Roman-dnom-ly1.vf \
tex-XCharter-Roman-dnom-ot1.tfm \
tex-XCharter-Roman-dnom-t1--base.tfm \
tex-XCharter-Roman-dnom-t1.tfm \
tex-XCharter-Roman-dnom-t1.vf \
tex-XCharter-Roman-inf-ly1--base.tfm \
tex-XCharter-Roman-inf-ly1.tfm \
tex-XCharter-Roman-inf-ly1.vf \
tex-XCharter-Roman-inf-ot1.tfm \
tex-XCharter-Roman-inf-t1--base.tfm \
tex-XCharter-Roman-inf-t1.tfm \
tex-XCharter-Roman-inf-t1.vf \
tex-XCharter-Roman-lf-ly1--base.tfm \
tex-XCharter-Roman-lf-ly1.tfm \
tex-XCharter-Roman-lf-ly1.vf \
tex-XCharter-Roman-lf-ot1.tfm \
tex-XCharter-Roman-lf-sc-ly1--base.tfm \
tex-XCharter-Roman-lf-sc-ly1.tfm \
tex-XCharter-Roman-lf-sc-ly1.vf \
tex-XCharter-Roman-lf-sc-ot1--base.tfm \
tex-XCharter-Roman-lf-sc-ot1.tfm \
tex-XCharter-Roman-lf-sc-ot1.vf \
tex-XCharter-Roman-lf-sc-t1--base.tfm \
tex-XCharter-Roman-lf-sc-t1.tfm \
tex-XCharter-Roman-lf-sc-t1.vf \
tex-XCharter-Roman-lf-sc-t2a--base.tfm \
tex-XCharter-Roman-lf-sc-t2a.tfm \
tex-XCharter-Roman-lf-sc-t2a.vf \
tex-XCharter-Roman-lf-sc-t2asrb--base.tfm \
tex-XCharter-Roman-lf-sc-t2asrb.tfm \
tex-XCharter-Roman-lf-sc-t2asrb.vf \
tex-XCharter-Roman-lf-t1--base.tfm \
tex-XCharter-Roman-lf-t1.tfm \
tex-XCharter-Roman-lf-t1.vf \
tex-XCharter-Roman-lf-t2a.tfm \
tex-XCharter-Roman-lf-t2asrb.tfm \
tex-XCharter-Roman-numr-ly1--base.tfm \
tex-XCharter-Roman-numr-ly1.tfm \
tex-XCharter-Roman-numr-ly1.vf \
tex-XCharter-Roman-numr-ot1.tfm \
tex-XCharter-Roman-numr-t1--base.tfm \
tex-XCharter-Roman-numr-t1.tfm \
tex-XCharter-Roman-numr-t1.vf \
tex-XCharter-Roman-osf-ly1--base.tfm \
tex-XCharter-Roman-osf-ly1.tfm \
tex-XCharter-Roman-osf-ly1.vf \
tex-XCharter-Roman-osf-ot1.tfm \
tex-XCharter-Roman-osf-sc-ly1--base.tfm \
tex-XCharter-Roman-osf-sc-ly1.tfm \
tex-XCharter-Roman-osf-sc-ly1.vf \
tex-XCharter-Roman-osf-sc-ot1--base.tfm \
tex-XCharter-Roman-osf-sc-ot1.tfm \
tex-XCharter-Roman-osf-sc-ot1.vf \
tex-XCharter-Roman-osf-sc-t1--base.tfm \
tex-XCharter-Roman-osf-sc-t1.tfm \
tex-XCharter-Roman-osf-sc-t1.vf \
tex-XCharter-Roman-osf-sc-t2a--base.tfm \
tex-XCharter-Roman-osf-sc-t2a.tfm \
tex-XCharter-Roman-osf-sc-t2a.vf \
tex-XCharter-Roman-osf-sc-t2asrb--base.tfm \
tex-XCharter-Roman-osf-sc-t2asrb.tfm \
tex-XCharter-Roman-osf-sc-t2asrb.vf \
tex-XCharter-Roman-osf-t1--base.tfm \
tex-XCharter-Roman-osf-t1.tfm \
tex-XCharter-Roman-osf-t1.vf \
tex-XCharter-Roman-osf-t2a.tfm \
tex-XCharter-Roman-osf-t2asrb.tfm \
tex-XCharter-Roman-sup-ly1--base.tfm \
tex-XCharter-Roman-sup-ly1.tfm \
tex-XCharter-Roman-sup-ly1.vf \
tex-XCharter-Roman-sup-ot1.tfm \
tex-XCharter-Roman-sup-t1--base.tfm \
tex-XCharter-Roman-sup-t1.tfm \
tex-XCharter-Roman-sup-t1.vf \
tex-XCharter-Roman-sup-t2a.tfm \
tex-XCharter-Roman-sup-t2asrb.tfm \
tex-XCharter-Roman-tlf-ly1--base.tfm \
tex-XCharter-Roman-tlf-ly1.tfm \
tex-XCharter-Roman-tlf-ly1.vf \
tex-XCharter-Roman-tlf-ot1.tfm \
tex-XCharter-Roman-tlf-ot1G.tfm \
tex-XCharter-Roman-tlf-ot1G.vf \
tex-XCharter-Roman-tlf-ot2.tfm \
tex-XCharter-Roman-tlf-sc-ly1--base.tfm \
tex-XCharter-Roman-tlf-sc-ly1.tfm \
tex-XCharter-Roman-tlf-sc-ly1.vf \
tex-XCharter-Roman-tlf-sc-ot1--base.tfm \
tex-XCharter-Roman-tlf-sc-ot1.tfm \
tex-XCharter-Roman-tlf-sc-ot1.vf \
tex-XCharter-Roman-tlf-sc-t1--base.tfm \
tex-XCharter-Roman-tlf-sc-t1.tfm \
tex-XCharter-Roman-tlf-sc-t1.vf \
tex-XCharter-Roman-tlf-sc-t2a--base.tfm \
tex-XCharter-Roman-tlf-sc-t2a.tfm \
tex-XCharter-Roman-tlf-sc-t2a.vf \
tex-XCharter-Roman-tlf-sc-t2asrb--base.tfm \
tex-XCharter-Roman-tlf-sc-t2asrb.tfm \
tex-XCharter-Roman-tlf-sc-t2asrb.vf \
tex-XCharter-Roman-tlf-t1--base.tfm \
tex-XCharter-Roman-tlf-t1.tfm \
tex-XCharter-Roman-tlf-t1.vf \
tex-XCharter-Roman-tlf-t2a.tfm \
tex-XCharter-Roman-tlf-t2asrb.tfm \
tex-XCharter-Roman-tosf-ly1--base.tfm \
tex-XCharter-Roman-tosf-ly1.tfm \
tex-XCharter-Roman-tosf-ly1.vf \
tex-XCharter-Roman-tosf-ot1.tfm \
tex-XCharter-Roman-tosf-sc-ly1--base.tfm \
tex-XCharter-Roman-tosf-sc-ly1.tfm \
tex-XCharter-Roman-tosf-sc-ly1.vf \
tex-XCharter-Roman-tosf-sc-ot1--base.tfm \
tex-XCharter-Roman-tosf-sc-ot1.tfm \
tex-XCharter-Roman-tosf-sc-ot1.vf \
tex-XCharter-Roman-tosf-sc-t1--base.tfm \
tex-XCharter-Roman-tosf-sc-t1.tfm \
tex-XCharter-Roman-tosf-sc-t1.vf \
tex-XCharter-Roman-tosf-sc-t2a--base.tfm \
tex-XCharter-Roman-tosf-sc-t2a.tfm \
tex-XCharter-Roman-tosf-sc-t2a.vf \
tex-XCharter-Roman-tosf-sc-t2asrb--base.tfm \
tex-XCharter-Roman-tosf-sc-t2asrb.tfm \
tex-XCharter-Roman-tosf-sc-t2asrb.vf \
tex-XCharter-Roman-tosf-t1--base.tfm \
tex-XCharter-Roman-tosf-t1.tfm \
tex-XCharter-Roman-tosf-t1.vf \
tex-XCharter-Roman-tosf-t2a.tfm \
tex-XCharter-Roman-tosf-t2asrb.tfm \
tex-XCharter-Roman-ts1--base.tfm \
tex-XCharter-Roman-ts1.tfm \
tex-XCharter-Roman-ts1.vf \
tex-XCharter-Slanted-dnom-ly1--base.tfm \
tex-XCharter-Slanted-dnom-ly1.tfm \
tex-XCharter-Slanted-dnom-ly1.vf \
tex-XCharter-Slanted-dnom-ot1.tfm \
tex-XCharter-Slanted-dnom-t1--base.tfm \
tex-XCharter-Slanted-dnom-t1.tfm \
tex-XCharter-Slanted-dnom-t1.vf \
tex-XCharter-Slanted-inf-ly1--base.tfm \
tex-XCharter-Slanted-inf-ly1.tfm \
tex-XCharter-Slanted-inf-ly1.vf \
tex-XCharter-Slanted-inf-ot1.tfm \
tex-XCharter-Slanted-inf-t1--base.tfm \
tex-XCharter-Slanted-inf-t1.tfm \
tex-XCharter-Slanted-inf-t1.vf \
tex-XCharter-Slanted-lf-ly1--base.tfm \
tex-XCharter-Slanted-lf-ly1.tfm \
tex-XCharter-Slanted-lf-ly1.vf \
tex-XCharter-Slanted-lf-ot1.tfm \
tex-XCharter-Slanted-lf-sc-ly1--base.tfm \
tex-XCharter-Slanted-lf-sc-ly1.tfm \
tex-XCharter-Slanted-lf-sc-ly1.vf \
tex-XCharter-Slanted-lf-sc-ot1--base.tfm \
tex-XCharter-Slanted-lf-sc-ot1.tfm \
tex-XCharter-Slanted-lf-sc-ot1.vf \
tex-XCharter-Slanted-lf-sc-t1--base.tfm \
tex-XCharter-Slanted-lf-sc-t1.tfm \
tex-XCharter-Slanted-lf-sc-t1.vf \
tex-XCharter-Slanted-lf-sc-t2a--base.tfm \
tex-XCharter-Slanted-lf-sc-t2a.tfm \
tex-XCharter-Slanted-lf-sc-t2a.vf \
tex-XCharter-Slanted-lf-sc-t2asrb--base.tfm \
tex-XCharter-Slanted-lf-sc-t2asrb.tfm \
tex-XCharter-Slanted-lf-sc-t2asrb.vf \
tex-XCharter-Slanted-lf-t1--base.tfm \
tex-XCharter-Slanted-lf-t1.tfm \
tex-XCharter-Slanted-lf-t1.vf \
tex-XCharter-Slanted-lf-t2a.tfm \
tex-XCharter-Slanted-lf-t2asrb.tfm \
tex-XCharter-Slanted-numr-ly1--base.tfm \
tex-XCharter-Slanted-numr-ly1.tfm \
tex-XCharter-Slanted-numr-ly1.vf \
tex-XCharter-Slanted-numr-ot1.tfm \
tex-XCharter-Slanted-numr-t1--base.tfm \
tex-XCharter-Slanted-numr-t1.tfm \
tex-XCharter-Slanted-numr-t1.vf \
tex-XCharter-Slanted-osf-ly1--base.tfm \
tex-XCharter-Slanted-osf-ly1.tfm \
tex-XCharter-Slanted-osf-ly1.vf \
tex-XCharter-Slanted-osf-ot1.tfm \
tex-XCharter-Slanted-osf-sc-ly1--base.tfm \
tex-XCharter-Slanted-osf-sc-ly1.tfm \
tex-XCharter-Slanted-osf-sc-ly1.vf \
tex-XCharter-Slanted-osf-sc-ot1--base.tfm \
tex-XCharter-Slanted-osf-sc-ot1.tfm \
tex-XCharter-Slanted-osf-sc-ot1.vf \
tex-XCharter-Slanted-osf-sc-t1--base.tfm \
tex-XCharter-Slanted-osf-sc-t1.tfm \
tex-XCharter-Slanted-osf-sc-t1.vf \
tex-XCharter-Slanted-osf-sc-t2a--base.tfm \
tex-XCharter-Slanted-osf-sc-t2a.tfm \
tex-XCharter-Slanted-osf-sc-t2a.vf \
tex-XCharter-Slanted-osf-sc-t2asrb--base.tfm \
tex-XCharter-Slanted-osf-sc-t2asrb.tfm \
tex-XCharter-Slanted-osf-sc-t2asrb.vf \
tex-XCharter-Slanted-osf-t1--base.tfm \
tex-XCharter-Slanted-osf-t1.tfm \
tex-XCharter-Slanted-osf-t1.vf \
tex-XCharter-Slanted-osf-t2a.tfm \
tex-XCharter-Slanted-osf-t2asrb.tfm \
tex-XCharter-Slanted-sup-ly1--base.tfm \
tex-XCharter-Slanted-sup-ly1.tfm \
tex-XCharter-Slanted-sup-ly1.vf \
tex-XCharter-Slanted-sup-ot1.tfm \
tex-XCharter-Slanted-sup-t1--base.tfm \
tex-XCharter-Slanted-sup-t1.tfm \
tex-XCharter-Slanted-sup-t1.vf \
tex-XCharter-Slanted-sup-t2a.tfm \
tex-XCharter-Slanted-sup-t2asrb.tfm \
tex-XCharter-Slanted-tlf-ly1--base.tfm \
tex-XCharter-Slanted-tlf-ly1.tfm \
tex-XCharter-Slanted-tlf-ly1.vf \
tex-XCharter-Slanted-tlf-ot1.tfm \
tex-XCharter-Slanted-tlf-ot2.tfm \
tex-XCharter-Slanted-tlf-sc-ly1--base.tfm \
tex-XCharter-Slanted-tlf-sc-ly1.tfm \
tex-XCharter-Slanted-tlf-sc-ly1.vf \
tex-XCharter-Slanted-tlf-sc-ot1--base.tfm \
tex-XCharter-Slanted-tlf-sc-ot1.tfm \
tex-XCharter-Slanted-tlf-sc-ot1.vf \
tex-XCharter-Slanted-tlf-sc-t1--base.tfm \
tex-XCharter-Slanted-tlf-sc-t1.tfm \
tex-XCharter-Slanted-tlf-sc-t1.vf \
tex-XCharter-Slanted-tlf-sc-t2a--base.tfm \
tex-XCharter-Slanted-tlf-sc-t2a.tfm \
tex-XCharter-Slanted-tlf-sc-t2a.vf \
tex-XCharter-Slanted-tlf-sc-t2asrb--base.tfm \
tex-XCharter-Slanted-tlf-sc-t2asrb.tfm \
tex-XCharter-Slanted-tlf-sc-t2asrb.vf \
tex-XCharter-Slanted-tlf-t1--base.tfm \
tex-XCharter-Slanted-tlf-t1.tfm \
tex-XCharter-Slanted-tlf-t1.vf \
tex-XCharter-Slanted-tlf-t2a.tfm \
tex-XCharter-Slanted-tlf-t2asrb.tfm \
tex-XCharter-Slanted-tosf-ly1--base.tfm \
tex-XCharter-Slanted-tosf-ly1.tfm \
tex-XCharter-Slanted-tosf-ly1.vf \
tex-XCharter-Slanted-tosf-ot1.tfm \
tex-XCharter-Slanted-tosf-sc-ly1--base.tfm \
tex-XCharter-Slanted-tosf-sc-ly1.tfm \
tex-XCharter-Slanted-tosf-sc-ly1.vf \
tex-XCharter-Slanted-tosf-sc-ot1--base.tfm \
tex-XCharter-Slanted-tosf-sc-ot1.tfm \
tex-XCharter-Slanted-tosf-sc-ot1.vf \
tex-XCharter-Slanted-tosf-sc-t1--base.tfm \
tex-XCharter-Slanted-tosf-sc-t1.tfm \
tex-XCharter-Slanted-tosf-sc-t1.vf \
tex-XCharter-Slanted-tosf-sc-t2a--base.tfm \
tex-XCharter-Slanted-tosf-sc-t2a.tfm \
tex-XCharter-Slanted-tosf-sc-t2a.vf \
tex-XCharter-Slanted-tosf-sc-t2asrb--base.tfm \
tex-XCharter-Slanted-tosf-sc-t2asrb.tfm \
tex-XCharter-Slanted-tosf-sc-t2asrb.vf \
tex-XCharter-Slanted-tosf-t1--base.tfm \
tex-XCharter-Slanted-tosf-t1.tfm \
tex-XCharter-Slanted-tosf-t1.vf \
tex-XCharter-Slanted-tosf-t2a.tfm \
tex-XCharter-Slanted-tosf-t2asrb.tfm \
tex-XCharter-Slanted-ts1--base.tfm \
tex-XCharter-Slanted-ts1.tfm \
tex-XCharter-Slanted-ts1.vf \
tex-XCharter-osf.tfm \
tex-XCharter.map \
tex-XCharter.sty \
tex-XCharter1-Bold-osf-ly1--base.tfm \
tex-XCharter1-Bold-osf-ly1.tfm \
tex-XCharter1-Bold-osf-ly1.vf \
tex-XCharter1-Bold-osf-ot1.tfm \
tex-XCharter1-Bold-osf-ot1.vf \
tex-XCharter1-Bold-osf-sc-ly1--base.tfm \
tex-XCharter1-Bold-osf-sc-ly1.tfm \
tex-XCharter1-Bold-osf-sc-ly1.vf \
tex-XCharter1-Bold-osf-sc-ot1--base.tfm \
tex-XCharter1-Bold-osf-sc-ot1.tfm \
tex-XCharter1-Bold-osf-sc-ot1.vf \
tex-XCharter1-Bold-osf-sc-t1--base.tfm \
tex-XCharter1-Bold-osf-sc-t1.tfm \
tex-XCharter1-Bold-osf-sc-t1.vf \
tex-XCharter1-Bold-osf-sc-t2a--base.tfm \
tex-XCharter1-Bold-osf-sc-t2a.tfm \
tex-XCharter1-Bold-osf-sc-t2a.vf \
tex-XCharter1-Bold-osf-sc-t2asrb--base.tfm \
tex-XCharter1-Bold-osf-sc-t2asrb.tfm \
tex-XCharter1-Bold-osf-sc-t2asrb.vf \
tex-XCharter1-Bold-osf-t1--base.tfm \
tex-XCharter1-Bold-osf-t1.tfm \
tex-XCharter1-Bold-osf-t1.vf \
tex-XCharter1-Bold-osf-t2a.tfm \
tex-XCharter1-Bold-osf-t2a.vf \
tex-XCharter1-Bold-osf-t2asrb.tfm \
tex-XCharter1-Bold-osf-t2asrb.vf \
tex-XCharter1-Bold-tosf-ly1--base.tfm \
tex-XCharter1-Bold-tosf-ly1.tfm \
tex-XCharter1-Bold-tosf-ly1.vf \
tex-XCharter1-Bold-tosf-ot1.tfm \
tex-XCharter1-Bold-tosf-ot1.vf \
tex-XCharter1-Bold-tosf-sc-ly1--base.tfm \
tex-XCharter1-Bold-tosf-sc-ly1.tfm \
tex-XCharter1-Bold-tosf-sc-ly1.vf \
tex-XCharter1-Bold-tosf-sc-ot1--base.tfm \
tex-XCharter1-Bold-tosf-sc-ot1.tfm \
tex-XCharter1-Bold-tosf-sc-ot1.vf \
tex-XCharter1-Bold-tosf-sc-t1--base.tfm \
tex-XCharter1-Bold-tosf-sc-t1.tfm \
tex-XCharter1-Bold-tosf-sc-t1.vf \
tex-XCharter1-Bold-tosf-sc-t2a--base.tfm \
tex-XCharter1-Bold-tosf-sc-t2a.tfm \
tex-XCharter1-Bold-tosf-sc-t2a.vf \
tex-XCharter1-Bold-tosf-sc-t2asrb--base.tfm \
tex-XCharter1-Bold-tosf-sc-t2asrb.tfm \
tex-XCharter1-Bold-tosf-sc-t2asrb.vf \
tex-XCharter1-Bold-tosf-t1--base.tfm \
tex-XCharter1-Bold-tosf-t1.tfm \
tex-XCharter1-Bold-tosf-t1.vf \
tex-XCharter1-Bold-tosf-t2a.tfm \
tex-XCharter1-Bold-tosf-t2a.vf \
tex-XCharter1-Bold-tosf-t2asrb.tfm \
tex-XCharter1-Bold-tosf-t2asrb.vf \
tex-XCharter1-Bold-ts1--base.tfm \
tex-XCharter1-Bold-ts1.tfm \
tex-XCharter1-Bold-ts1.vf \
tex-XCharter1-BoldItalic-osf-ly1--base.tfm \
tex-XCharter1-BoldItalic-osf-ly1.tfm \
tex-XCharter1-BoldItalic-osf-ly1.vf \
tex-XCharter1-BoldItalic-osf-ot1.tfm \
tex-XCharter1-BoldItalic-osf-ot1.vf \
tex-XCharter1-BoldItalic-osf-sc-ly1--base.tfm \
tex-XCharter1-BoldItalic-osf-sc-ly1.tfm \
tex-XCharter1-BoldItalic-osf-sc-ly1.vf \
tex-XCharter1-BoldItalic-osf-sc-ot1--base.tfm \
tex-XCharter1-BoldItalic-osf-sc-ot1.tfm \
tex-XCharter1-BoldItalic-osf-sc-ot1.vf \
tex-XCharter1-BoldItalic-osf-sc-t1--base.tfm \
tex-XCharter1-BoldItalic-osf-sc-t1.tfm \
tex-XCharter1-BoldItalic-osf-sc-t1.vf \
tex-XCharter1-BoldItalic-osf-sc-t2a--base.tfm \
tex-XCharter1-BoldItalic-osf-sc-t2a.tfm \
tex-XCharter1-BoldItalic-osf-sc-t2a.vf \
tex-XCharter1-BoldItalic-osf-sc-t2asrb--base.tfm \
tex-XCharter1-BoldItalic-osf-sc-t2asrb.tfm \
tex-XCharter1-BoldItalic-osf-sc-t2asrb.vf \
tex-XCharter1-BoldItalic-osf-t1--base.tfm \
tex-XCharter1-BoldItalic-osf-t1.tfm \
tex-XCharter1-BoldItalic-osf-t1.vf \
tex-XCharter1-BoldItalic-osf-t2a.tfm \
tex-XCharter1-BoldItalic-osf-t2a.vf \
tex-XCharter1-BoldItalic-osf-t2asrb.tfm \
tex-XCharter1-BoldItalic-osf-t2asrb.vf \
tex-XCharter1-BoldItalic-tosf-ly1--base.tfm \
tex-XCharter1-BoldItalic-tosf-ly1.tfm \
tex-XCharter1-BoldItalic-tosf-ly1.vf \
tex-XCharter1-BoldItalic-tosf-ot1.tfm \
tex-XCharter1-BoldItalic-tosf-ot1.vf \
tex-XCharter1-BoldItalic-tosf-sc-ly1--base.tfm \
tex-XCharter1-BoldItalic-tosf-sc-ly1.tfm \
tex-XCharter1-BoldItalic-tosf-sc-ly1.vf \
tex-XCharter1-BoldItalic-tosf-sc-ot1--base.tfm \
tex-XCharter1-BoldItalic-tosf-sc-ot1.tfm \
tex-XCharter1-BoldItalic-tosf-sc-ot1.vf \
tex-XCharter1-BoldItalic-tosf-sc-t1--base.tfm \
tex-XCharter1-BoldItalic-tosf-sc-t1.tfm \
tex-XCharter1-BoldItalic-tosf-sc-t1.vf \
tex-XCharter1-BoldItalic-tosf-sc-t2a--base.tfm \
tex-XCharter1-BoldItalic-tosf-sc-t2a.tfm \
tex-XCharter1-BoldItalic-tosf-sc-t2a.vf \
tex-XCharter1-BoldItalic-tosf-sc-t2asrb--base.tfm \
tex-XCharter1-BoldItalic-tosf-sc-t2asrb.tfm \
tex-XCharter1-BoldItalic-tosf-sc-t2asrb.vf \
tex-XCharter1-BoldItalic-tosf-t1--base.tfm \
tex-XCharter1-BoldItalic-tosf-t1.tfm \
tex-XCharter1-BoldItalic-tosf-t1.vf \
tex-XCharter1-BoldItalic-tosf-t2a.tfm \
tex-XCharter1-BoldItalic-tosf-t2a.vf \
tex-XCharter1-BoldItalic-tosf-t2asrb.tfm \
tex-XCharter1-BoldItalic-tosf-t2asrb.vf \
tex-XCharter1-BoldItalic-ts1--base.tfm \
tex-XCharter1-BoldItalic-ts1.tfm \
tex-XCharter1-BoldItalic-ts1.vf \
tex-XCharter1-BoldSlanted-osf-ly1--base.tfm \
tex-XCharter1-BoldSlanted-osf-ly1.tfm \
tex-XCharter1-BoldSlanted-osf-ly1.vf \
tex-XCharter1-BoldSlanted-osf-ot1.tfm \
tex-XCharter1-BoldSlanted-osf-ot1.vf \
tex-XCharter1-BoldSlanted-osf-sc-ly1--base.tfm \
tex-XCharter1-BoldSlanted-osf-sc-ly1.tfm \
tex-XCharter1-BoldSlanted-osf-sc-ly1.vf \
tex-XCharter1-BoldSlanted-osf-sc-ot1--base.tfm \
tex-XCharter1-BoldSlanted-osf-sc-ot1.tfm \
tex-XCharter1-BoldSlanted-osf-sc-ot1.vf \
tex-XCharter1-BoldSlanted-osf-sc-t1--base.tfm \
tex-XCharter1-BoldSlanted-osf-sc-t1.tfm \
tex-XCharter1-BoldSlanted-osf-sc-t1.vf \
tex-XCharter1-BoldSlanted-osf-sc-t2a--base.tfm \
tex-XCharter1-BoldSlanted-osf-sc-t2a.tfm \
tex-XCharter1-BoldSlanted-osf-sc-t2a.vf \
tex-XCharter1-BoldSlanted-osf-sc-t2asrb--base.tfm \
tex-XCharter1-BoldSlanted-osf-sc-t2asrb.tfm \
tex-XCharter1-BoldSlanted-osf-sc-t2asrb.vf \
tex-XCharter1-BoldSlanted-osf-t1--base.tfm \
tex-XCharter1-BoldSlanted-osf-t1.tfm \
tex-XCharter1-BoldSlanted-osf-t1.vf \
tex-XCharter1-BoldSlanted-osf-t2a.tfm \
tex-XCharter1-BoldSlanted-osf-t2a.vf \
tex-XCharter1-BoldSlanted-osf-t2asrb.tfm \
tex-XCharter1-BoldSlanted-osf-t2asrb.vf \
tex-XCharter1-BoldSlanted-tosf-ly1--base.tfm \
tex-XCharter1-BoldSlanted-tosf-ly1.tfm \
tex-XCharter1-BoldSlanted-tosf-ly1.vf \
tex-XCharter1-BoldSlanted-tosf-ot1.tfm \
tex-XCharter1-BoldSlanted-tosf-ot1.vf \
tex-XCharter1-BoldSlanted-tosf-sc-ly1--base.tfm \
tex-XCharter1-BoldSlanted-tosf-sc-ly1.tfm \
tex-XCharter1-BoldSlanted-tosf-sc-ly1.vf \
tex-XCharter1-BoldSlanted-tosf-sc-ot1--base.tfm \
tex-XCharter1-BoldSlanted-tosf-sc-ot1.tfm \
tex-XCharter1-BoldSlanted-tosf-sc-ot1.vf \
tex-XCharter1-BoldSlanted-tosf-sc-t1--base.tfm \
tex-XCharter1-BoldSlanted-tosf-sc-t1.tfm \
tex-XCharter1-BoldSlanted-tosf-sc-t1.vf \
tex-XCharter1-BoldSlanted-tosf-sc-t2a--base.tfm \
tex-XCharter1-BoldSlanted-tosf-sc-t2a.tfm \
tex-XCharter1-BoldSlanted-tosf-sc-t2a.vf \
tex-XCharter1-BoldSlanted-tosf-sc-t2asrb--base.tfm \
tex-XCharter1-BoldSlanted-tosf-sc-t2asrb.tfm \
tex-XCharter1-BoldSlanted-tosf-sc-t2asrb.vf \
tex-XCharter1-BoldSlanted-tosf-t1--base.tfm \
tex-XCharter1-BoldSlanted-tosf-t1.tfm \
tex-XCharter1-BoldSlanted-tosf-t1.vf \
tex-XCharter1-BoldSlanted-tosf-t2a.tfm \
tex-XCharter1-BoldSlanted-tosf-t2a.vf \
tex-XCharter1-BoldSlanted-tosf-t2asrb.tfm \
tex-XCharter1-BoldSlanted-tosf-t2asrb.vf \
tex-XCharter1-BoldSlanted-ts1--base.tfm \
tex-XCharter1-BoldSlanted-ts1.tfm \
tex-XCharter1-BoldSlanted-ts1.vf \
tex-XCharter1-Italic-osf-ly1--base.tfm \
tex-XCharter1-Italic-osf-ly1.tfm \
tex-XCharter1-Italic-osf-ly1.vf \
tex-XCharter1-Italic-osf-ot1.tfm \
tex-XCharter1-Italic-osf-ot1.vf \
tex-XCharter1-Italic-osf-sc-ly1--base.tfm \
tex-XCharter1-Italic-osf-sc-ly1.tfm \
tex-XCharter1-Italic-osf-sc-ly1.vf \
tex-XCharter1-Italic-osf-sc-ot1--base.tfm \
tex-XCharter1-Italic-osf-sc-ot1.tfm \
tex-XCharter1-Italic-osf-sc-ot1.vf \
tex-XCharter1-Italic-osf-sc-t1--base.tfm \
tex-XCharter1-Italic-osf-sc-t1.tfm \
tex-XCharter1-Italic-osf-sc-t1.vf \
tex-XCharter1-Italic-osf-sc-t2a--base.tfm \
tex-XCharter1-Italic-osf-sc-t2a.tfm \
tex-XCharter1-Italic-osf-sc-t2a.vf \
tex-XCharter1-Italic-osf-sc-t2asrb--base.tfm \
tex-XCharter1-Italic-osf-sc-t2asrb.tfm \
tex-XCharter1-Italic-osf-sc-t2asrb.vf \
tex-XCharter1-Italic-osf-t1--base.tfm \
tex-XCharter1-Italic-osf-t1.tfm \
tex-XCharter1-Italic-osf-t1.vf \
tex-XCharter1-Italic-osf-t2a.tfm \
tex-XCharter1-Italic-osf-t2a.vf \
tex-XCharter1-Italic-osf-t2asrb.tfm \
tex-XCharter1-Italic-osf-t2asrb.vf \
tex-XCharter1-Italic-tosf-ly1--base.tfm \
tex-XCharter1-Italic-tosf-ly1.tfm \
tex-XCharter1-Italic-tosf-ly1.vf \
tex-XCharter1-Italic-tosf-ot1.tfm \
tex-XCharter1-Italic-tosf-ot1.vf \
tex-XCharter1-Italic-tosf-sc-ly1--base.tfm \
tex-XCharter1-Italic-tosf-sc-ly1.tfm \
tex-XCharter1-Italic-tosf-sc-ly1.vf \
tex-XCharter1-Italic-tosf-sc-ot1--base.tfm \
tex-XCharter1-Italic-tosf-sc-ot1.tfm \
tex-XCharter1-Italic-tosf-sc-ot1.vf \
tex-XCharter1-Italic-tosf-sc-t1--base.tfm \
tex-XCharter1-Italic-tosf-sc-t1.tfm \
tex-XCharter1-Italic-tosf-sc-t1.vf \
tex-XCharter1-Italic-tosf-sc-t2a--base.tfm \
tex-XCharter1-Italic-tosf-sc-t2a.tfm \
tex-XCharter1-Italic-tosf-sc-t2a.vf \
tex-XCharter1-Italic-tosf-sc-t2asrb--base.tfm \
tex-XCharter1-Italic-tosf-sc-t2asrb.tfm \
tex-XCharter1-Italic-tosf-sc-t2asrb.vf \
tex-XCharter1-Italic-tosf-t1--base.tfm \
tex-XCharter1-Italic-tosf-t1.tfm \
tex-XCharter1-Italic-tosf-t1.vf \
tex-XCharter1-Italic-tosf-t2a.tfm \
tex-XCharter1-Italic-tosf-t2a.vf \
tex-XCharter1-Italic-tosf-t2asrb.tfm \
tex-XCharter1-Italic-tosf-t2asrb.vf \
tex-XCharter1-Italic-ts1--base.tfm \
tex-XCharter1-Italic-ts1.tfm \
tex-XCharter1-Italic-ts1.vf \
tex-XCharter1-Roman-osf-ly1--base.tfm \
tex-XCharter1-Roman-osf-ly1.tfm \
tex-XCharter1-Roman-osf-ly1.vf \
tex-XCharter1-Roman-osf-ot1.tfm \
tex-XCharter1-Roman-osf-ot1.vf \
tex-XCharter1-Roman-osf-sc-ly1--base.tfm \
tex-XCharter1-Roman-osf-sc-ly1.tfm \
tex-XCharter1-Roman-osf-sc-ly1.vf \
tex-XCharter1-Roman-osf-sc-ot1--base.tfm \
tex-XCharter1-Roman-osf-sc-ot1.tfm \
tex-XCharter1-Roman-osf-sc-ot1.vf \
tex-XCharter1-Roman-osf-sc-t1--base.tfm \
tex-XCharter1-Roman-osf-sc-t1.tfm \
tex-XCharter1-Roman-osf-sc-t1.vf \
tex-XCharter1-Roman-osf-sc-t2a--base.tfm \
tex-XCharter1-Roman-osf-sc-t2a.tfm \
tex-XCharter1-Roman-osf-sc-t2a.vf \
tex-XCharter1-Roman-osf-sc-t2asrb--base.tfm \
tex-XCharter1-Roman-osf-sc-t2asrb.tfm \
tex-XCharter1-Roman-osf-sc-t2asrb.vf \
tex-XCharter1-Roman-osf-t1--base.tfm \
tex-XCharter1-Roman-osf-t1.tfm \
tex-XCharter1-Roman-osf-t1.vf \
tex-XCharter1-Roman-osf-t2a.tfm \
tex-XCharter1-Roman-osf-t2a.vf \
tex-XCharter1-Roman-osf-t2asrb.tfm \
tex-XCharter1-Roman-osf-t2asrb.vf \
tex-XCharter1-Roman-tosf-ly1--base.tfm \
tex-XCharter1-Roman-tosf-ly1.tfm \
tex-XCharter1-Roman-tosf-ly1.vf \
tex-XCharter1-Roman-tosf-ot1.tfm \
tex-XCharter1-Roman-tosf-ot1.vf \
tex-XCharter1-Roman-tosf-sc-ly1--base.tfm \
tex-XCharter1-Roman-tosf-sc-ly1.tfm \
tex-XCharter1-Roman-tosf-sc-ly1.vf \
tex-XCharter1-Roman-tosf-sc-ot1--base.tfm \
tex-XCharter1-Roman-tosf-sc-ot1.tfm \
tex-XCharter1-Roman-tosf-sc-ot1.vf \
tex-XCharter1-Roman-tosf-sc-t1--base.tfm \
tex-XCharter1-Roman-tosf-sc-t1.tfm \
tex-XCharter1-Roman-tosf-sc-t1.vf \
tex-XCharter1-Roman-tosf-sc-t2a--base.tfm \
tex-XCharter1-Roman-tosf-sc-t2a.tfm \
tex-XCharter1-Roman-tosf-sc-t2a.vf \
tex-XCharter1-Roman-tosf-sc-t2asrb--base.tfm \
tex-XCharter1-Roman-tosf-sc-t2asrb.tfm \
tex-XCharter1-Roman-tosf-sc-t2asrb.vf \
tex-XCharter1-Roman-tosf-t1--base.tfm \
tex-XCharter1-Roman-tosf-t1.tfm \
tex-XCharter1-Roman-tosf-t1.vf \
tex-XCharter1-Roman-tosf-t2a.tfm \
tex-XCharter1-Roman-tosf-t2a.vf \
tex-XCharter1-Roman-tosf-t2asrb.tfm \
tex-XCharter1-Roman-tosf-t2asrb.vf \
tex-XCharter1-Roman-ts1--base.tfm \
tex-XCharter1-Roman-ts1.tfm \
tex-XCharter1-Roman-ts1.vf \
tex-XCharter1-Slanted-osf-ly1--base.tfm \
tex-XCharter1-Slanted-osf-ly1.tfm \
tex-XCharter1-Slanted-osf-ly1.vf \
tex-XCharter1-Slanted-osf-ot1.tfm \
tex-XCharter1-Slanted-osf-ot1.vf \
tex-XCharter1-Slanted-osf-sc-ly1--base.tfm \
tex-XCharter1-Slanted-osf-sc-ly1.tfm \
tex-XCharter1-Slanted-osf-sc-ly1.vf \
tex-XCharter1-Slanted-osf-sc-ot1--base.tfm \
tex-XCharter1-Slanted-osf-sc-ot1.tfm \
tex-XCharter1-Slanted-osf-sc-ot1.vf \
tex-XCharter1-Slanted-osf-sc-t1--base.tfm \
tex-XCharter1-Slanted-osf-sc-t1.tfm \
tex-XCharter1-Slanted-osf-sc-t1.vf \
tex-XCharter1-Slanted-osf-sc-t2a--base.tfm \
tex-XCharter1-Slanted-osf-sc-t2a.tfm \
tex-XCharter1-Slanted-osf-sc-t2a.vf \
tex-XCharter1-Slanted-osf-sc-t2asrb--base.tfm \
tex-XCharter1-Slanted-osf-sc-t2asrb.tfm \
tex-XCharter1-Slanted-osf-sc-t2asrb.vf \
tex-XCharter1-Slanted-osf-t1--base.tfm \
tex-XCharter1-Slanted-osf-t1.tfm \
tex-XCharter1-Slanted-osf-t1.vf \
tex-XCharter1-Slanted-osf-t2a.tfm \
tex-XCharter1-Slanted-osf-t2a.vf \
tex-XCharter1-Slanted-osf-t2asrb.tfm \
tex-XCharter1-Slanted-osf-t2asrb.vf \
tex-XCharter1-Slanted-tosf-ly1--base.tfm \
tex-XCharter1-Slanted-tosf-ly1.tfm \
tex-XCharter1-Slanted-tosf-ly1.vf \
tex-XCharter1-Slanted-tosf-ot1.tfm \
tex-XCharter1-Slanted-tosf-ot1.vf \
tex-XCharter1-Slanted-tosf-sc-ly1--base.tfm \
tex-XCharter1-Slanted-tosf-sc-ly1.tfm \
tex-XCharter1-Slanted-tosf-sc-ly1.vf \
tex-XCharter1-Slanted-tosf-sc-ot1--base.tfm \
tex-XCharter1-Slanted-tosf-sc-ot1.tfm \
tex-XCharter1-Slanted-tosf-sc-ot1.vf \
tex-XCharter1-Slanted-tosf-sc-t1--base.tfm \
tex-XCharter1-Slanted-tosf-sc-t1.tfm \
tex-XCharter1-Slanted-tosf-sc-t1.vf \
tex-XCharter1-Slanted-tosf-sc-t2a--base.tfm \
tex-XCharter1-Slanted-tosf-sc-t2a.tfm \
tex-XCharter1-Slanted-tosf-sc-t2a.vf \
tex-XCharter1-Slanted-tosf-sc-t2asrb--base.tfm \
tex-XCharter1-Slanted-tosf-sc-t2asrb.tfm \
tex-XCharter1-Slanted-tosf-sc-t2asrb.vf \
tex-XCharter1-Slanted-tosf-t1--base.tfm \
tex-XCharter1-Slanted-tosf-t1.tfm \
tex-XCharter1-Slanted-tosf-t1.vf \
tex-XCharter1-Slanted-tosf-t2a.tfm \
tex-XCharter1-Slanted-tosf-t2a.vf \
tex-XCharter1-Slanted-tosf-t2asrb.tfm \
tex-XCharter1-Slanted-tosf-t2asrb.vf \
tex-XCharter1-Slanted-ts1--base.tfm \
tex-XCharter1-Slanted-ts1.tfm \
tex-XCharter1-Slanted-ts1.vf \
tex-XCharter1TH-BoldItalic-osf-ly1.tfm \
tex-XCharter1TH-BoldItalic-osf-ot1.tfm \
tex-XCharter1TH-BoldItalic-osf-t1.tfm \
tex-XCharter1TH-Italic-osf-ly1.tfm \
tex-XCharter1TH-Italic-osf-ot1.tfm \
tex-XCharter1TH-Italic-osf-t1.tfm \
tex-XCharterMathBMI.tfm \
tex-XCharterMathBRM.tfm \
tex-XCharterMathMI.tfm \
tex-XCharterMathRM.tfm \
tex-XCharterTH-BoldItalic-osf-ly1.tfm \
tex-XCharterTH-BoldItalic-osf-ot1.tfm \
tex-XCharterTH-BoldItalic-osf-t1.tfm \
tex-XCharterTH-BoldItalic-tlf-ly1.tfm \
tex-XCharterTH-BoldItalic-tlf-ot1.tfm \
tex-XCharterTH-BoldItalic-tlf-t1.tfm \
tex-XCharterTH-Italic-osf-ly1.tfm \
tex-XCharterTH-Italic-osf-ot1.tfm \
tex-XCharterTH-Italic-osf-t1.tfm \
tex-XCharterTH-Italic-tlf-ly1.tfm \
tex-XCharterTH-Italic-tlf-ot1.tfm \
tex-XCharterTH-Italic-tlf-t1.tfm \
tex-chalph.enc \
tex-chtabosf.enc \
tex-ly1minxcharter.fd \
tex-newtx-xcharter-subs.tex \
tex-omlzchmi.fd \
tex-ot1minxcharter.fd \
tex-t1minxcharter.fd \
tex-t2asrbcmr.fd \
tex-t2asrbenc.def \
tex-xch-26pbhy.enc \
tex-xch-2itbay.enc \
tex-xch-2jcsfa.enc \
tex-xch-2ne5ra.enc \
tex-xch-2v3pxw.enc \
tex-xch-34ooqo.enc \
tex-xch-3qy4ma.enc \
tex-xch-4ba22z.enc \
tex-xch-4j4sw5.enc \
tex-xch-4nycuc.enc \
tex-xch-4sqimf.enc \
tex-xch-4zysyq.enc \
tex-xch-5wo36q.enc \
tex-xch-5x23ii.enc \
tex-xch-62bu45.enc \
tex-xch-62z5ot.enc \
tex-xch-6335sg.enc \
tex-xch-64qgug.enc \
tex-xch-65qaqc.enc \
tex-xch-6ckksa.enc \
tex-xch-6hzluo.enc \
tex-xch-6ir2ua.enc \
tex-xch-6mgzuz.enc \
tex-xch-6ramfp.enc \
tex-xch-6w7aji.enc \
tex-xch-6xwfqv.enc \
tex-xch-7aohvb.enc \
tex-xch-7cmdv6.enc \
tex-xch-a6eos7.enc \
tex-xch-acpec5.enc \
tex-xch-akeqbh.enc \
tex-xch-an6s6r.enc \
tex-xch-aw3wom.enc \
tex-xch-bjnaxa.enc \
tex-xch-blmpt7.enc \
tex-xch-c3yyfo.enc \
tex-xch-c54uym.enc \
tex-xch-ccfumi.enc \
tex-xch-cilcsm.enc \
tex-xch-cjimfy.enc \
tex-xch-ckugtc.enc \
tex-xch-co4ru4.enc \
tex-xch-cos7tu.enc \
tex-xch-cy5fc2.enc \
tex-xch-dp2hrq.enc \
tex-xch-dqjass.enc \
tex-xch-dynzsr.enc \
tex-xch-ei7atk.enc \
tex-xch-el7fqi.enc \
tex-xch-eldrzl.enc \
tex-xch-en7yt2.enc \
tex-xch-f5e46c.enc \
tex-xch-fiqldz.enc \
tex-xch-geqmur.enc \
tex-xch-glnwao.enc \
tex-xch-gspcih.enc \
tex-xch-guhmqj.enc \
tex-xch-hgvfee.enc \
tex-xch-hiviyg.enc \
tex-xch-hnm6t3.enc \
tex-xch-i2cund.enc \
tex-xch-i2fqhk.enc \
tex-xch-icytdu.enc \
tex-xch-iit6m7.enc \
tex-xch-ijhcpw.enc \
tex-xch-irqw25.enc \
tex-xch-kly36k.enc \
tex-xch-ksktz7.enc \
tex-xch-laqzs3.enc \
tex-xch-m2vrds.enc \
tex-xch-m4ry62.enc \
tex-xch-m6qb7y.enc \
tex-xch-mcqmfh.enc \
tex-xch-mgb5xg.enc \
tex-xch-mpbiom.enc \
tex-xch-naadkf.enc \
tex-xch-ng7me5.enc \
tex-xch-nhow2o.enc \
tex-xch-nii5is.enc \
tex-xch-o2mz2z.enc \
tex-xch-ocop3w.enc \
tex-xch-oeyavg.enc \
tex-xch-ph46id.enc \
tex-xch-pikjb7.enc \
tex-xch-plaupi.enc \
tex-xch-pqp4df.enc \
tex-xch-pz3lxg.enc \
tex-xch-q7fabp.enc \
tex-xch-qdw4m6.enc \
tex-xch-qfy5bi.enc \
tex-xch-qibaxb.enc \
tex-xch-qt227l.enc \
tex-xch-qxwrge.enc \
tex-xch-ruokxy.enc \
tex-xch-rvzpfm.enc \
tex-xch-rydp4l.enc \
tex-xch-s4eoyd.enc \
tex-xch-sczepj.enc \
tex-xch-swys7y.enc \
tex-xch-t5vgvk.enc \
tex-xch-tcksd3.enc \
tex-xch-tdjqi5.enc \
tex-xch-tipddl.enc \
tex-xch-tohekq.enc \
tex-xch-ttjfqt.enc \
tex-xch-txakzr.enc \
tex-xch-u5ytlb.enc \
tex-xch-u7hnxs.enc \
tex-xch-ufo3av.enc \
tex-xch-ukw3hq.enc \
tex-xch-usfr4u.enc \
tex-xch-v6llfb.enc \
tex-xch-vyhv3k.enc \
tex-xch-wbcur7.enc \
tex-xch-wd2dbe.enc \
tex-xch-wf67wi.enc \
tex-xch-wizqmm.enc \
tex-xch-wqeam3.enc \
tex-xch-wqjgnt.enc \
tex-xch-wuciy4.enc \
tex-xch-wz23kl.enc \
tex-xch-x36pxl.enc \
tex-xch-x6jczy.enc \
tex-xch-xqcxen.enc \
tex-xch-y642va.enc \
tex-xch-yelf2i.enc \
tex-xch-yr3lcc.enc \
tex-xch-z3wvjz.enc \
tex-xch-zqx27h.enc \
tex-xch1-2itbay.enc \
tex-xch1-2jcsfa.enc \
tex-xch1-3qy4ma.enc \
tex-xch1-4sqimf.enc \
tex-xch1-4zysyq.enc \
tex-xch1-5x23ii.enc \
tex-xch1-64qgug.enc \
tex-xch1-65qaqc.enc \
tex-xch1-6ir2ua.enc \
tex-xch1-6ramfp.enc \
tex-xch1-6xwfqv.enc \
tex-xch1-7aohvb.enc \
tex-xch1-acpec5.enc \
tex-xch1-an6s6r.enc \
tex-xch1-c3yyfo.enc \
tex-xch1-c54uym.enc \
tex-xch1-ccfumi.enc \
tex-xch1-cilcsm.enc \
tex-xch1-cjimfy.enc \
tex-xch1-co4ru4.enc \
tex-xch1-dp2hrq.enc \
tex-xch1-dynzsr.enc \
tex-xch1-eldrzl.enc \
tex-xch1-geqmur.enc \
tex-xch1-hgvfee.enc \
tex-xch1-i2cund.enc \
tex-xch1-i2fqhk.enc \
tex-xch1-icytdu.enc \
tex-xch1-iit6m7.enc \
tex-xch1-ksktz7.enc \
tex-xch1-laqzs3.enc \
tex-xch1-m6qb7y.enc \
tex-xch1-mpbiom.enc \
tex-xch1-ng7me5.enc \
tex-xch1-nhow2o.enc \
tex-xch1-ph46id.enc \
tex-xch1-pikjb7.enc \
tex-xch1-plaupi.enc \
tex-xch1-pqp4df.enc \
tex-xch1-q7fabp.enc \
tex-xch1-qfy5bi.enc \
tex-xch1-s4eoyd.enc \
tex-xch1-sczepj.enc \
tex-xch1-tipddl.enc \
tex-xch1-tohekq.enc \
tex-xch1-wd2dbe.enc \
tex-xch1-wf67wi.enc \
tex-xch1-wqeam3.enc \
tex-xch1-wqjgnt.enc \
tex-xch1-wuciy4.enc \
tex-xch1-x6jczy.enc \
tex-xch1-xqcxen.enc \
tex-xch1-yr3lcc.enc \
tex-xch1-z3wvjz.enc \
tex-xch1-zqx27h.enc \
tex-xch1TH-osf-ly1.enc \
tex-xch1TH-osf-ot1.enc \
tex-xch1TH-osf-t1.enc \
tex-xchTH-osf-ly1.enc \
tex-xchTH-osf-ot1.enc \
tex-xchTH-osf-t1.enc \
tex-xchTH-tlf-ly1.enc \
tex-xchTH-tlf-ot1.enc \
tex-xchTH-tlf-t1.enc \
tex-xcharter-ot2.enc \
tex-zchbmi.tfm \
tex-zchbmi.vf \
tex-zchbmi0.tfm \
tex-zchbmi0.vf \
tex-zchbmi2.tfm \
tex-zchbmi2.vf \
tex-zchbmi3.tfm \
tex-zchbmi3.vf \
tex-zchbmia.tfm \
tex-zchbmia.vf \
tex-zchmi.tfm \
tex-zchmi.vf \
tex-zchmi0.tfm \
tex-zchmi0.vf \
tex-zchmi2.tfm \
tex-zchmi2.vf \
tex-zchmi3.tfm \
tex-zchmi3.vf \
tex-zchmia-fromvf.tfm \
tex-zchmia-fromvf.vf \
tex-zchmia.tfm \
tex-zchmia.vf \
texlive-xcharter"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-etoolbox.sty \
tex-fontaxes.sty \
tex-fontenc.sty \
tex-fontspec.sty \
tex-iftex.sty \
tex-ifthen.sty \
tex-mweights.sty \
tex-realscripts.sty \
tex-rtxbmi-ut.tfm \
tex-scalefnt.sty \
tex-stxscr.tfm \
tex-textcomp.sty \
tex-txbmiaSTbb.tfm \
tex-txbmiaX.tfm \
tex-txmiaSTbb.tfm \
tex-txmiaX.tfm \
tex-updmap.cfg \
tex-xcharter-otf.sty \
tex-xkeyval.sty \
tex-xstring.sty \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin \
texlive-xcharter-fonts"

inherit rpm
