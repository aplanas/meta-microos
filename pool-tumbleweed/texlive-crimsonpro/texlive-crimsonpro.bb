SUMMARY = "CrimsonPro fonts with LaTeX support"
DESCRIPTION = "The CrimsonPro fonts are designed by Jacques Le Bailly and \
derived from the Crimson Text fonts designed by Sebastian \
Kosch. The family includes eight weights and italics for each \
weight."
LICENSE = "OFL-1.1"

PV = "2023.204.svn64565"

RPM_NAME = "texlive-crimsonpro-2023.204.svn64565-54.1.noarch.rpm"
RPM_HASH = "f7c7343665178a069b26342dc36ff47d342078f71d49ffcb26e8fe6ec0b45c0a9f0d252edb61afebb9e711f8106d76ee2c65ea3c55e9d76815efc33a25dbd9f0"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-CrimsonPro-Black-inf-ly1--base.tfm \
tex-CrimsonPro-Black-inf-ly1.tfm \
tex-CrimsonPro-Black-inf-ly1.vf \
tex-CrimsonPro-Black-inf-ot1.tfm \
tex-CrimsonPro-Black-inf-t1--base.tfm \
tex-CrimsonPro-Black-inf-t1.tfm \
tex-CrimsonPro-Black-inf-t1.vf \
tex-CrimsonPro-Black-lf-ly1--base.tfm \
tex-CrimsonPro-Black-lf-ly1.tfm \
tex-CrimsonPro-Black-lf-ly1.vf \
tex-CrimsonPro-Black-lf-ot1.tfm \
tex-CrimsonPro-Black-lf-t1--base.tfm \
tex-CrimsonPro-Black-lf-t1.tfm \
tex-CrimsonPro-Black-lf-t1.vf \
tex-CrimsonPro-Black-lf-ts1--base.tfm \
tex-CrimsonPro-Black-lf-ts1.tfm \
tex-CrimsonPro-Black-lf-ts1.vf \
tex-CrimsonPro-Black-osf-ly1--base.tfm \
tex-CrimsonPro-Black-osf-ly1.tfm \
tex-CrimsonPro-Black-osf-ly1.vf \
tex-CrimsonPro-Black-osf-ot1.tfm \
tex-CrimsonPro-Black-osf-t1--base.tfm \
tex-CrimsonPro-Black-osf-t1.tfm \
tex-CrimsonPro-Black-osf-t1.vf \
tex-CrimsonPro-Black-osf-ts1--base.tfm \
tex-CrimsonPro-Black-osf-ts1.tfm \
tex-CrimsonPro-Black-osf-ts1.vf \
tex-CrimsonPro-Black-sup-ly1--base.tfm \
tex-CrimsonPro-Black-sup-ly1.tfm \
tex-CrimsonPro-Black-sup-ly1.vf \
tex-CrimsonPro-Black-sup-ot1.tfm \
tex-CrimsonPro-Black-sup-t1--base.tfm \
tex-CrimsonPro-Black-sup-t1.tfm \
tex-CrimsonPro-Black-sup-t1.vf \
tex-CrimsonPro-Black-tlf-ly1--base.tfm \
tex-CrimsonPro-Black-tlf-ly1.tfm \
tex-CrimsonPro-Black-tlf-ly1.vf \
tex-CrimsonPro-Black-tlf-ot1.tfm \
tex-CrimsonPro-Black-tlf-t1--base.tfm \
tex-CrimsonPro-Black-tlf-t1.tfm \
tex-CrimsonPro-Black-tlf-t1.vf \
tex-CrimsonPro-Black-tlf-ts1--base.tfm \
tex-CrimsonPro-Black-tlf-ts1.tfm \
tex-CrimsonPro-Black-tlf-ts1.vf \
tex-CrimsonPro-Black-tosf-ly1--base.tfm \
tex-CrimsonPro-Black-tosf-ly1.tfm \
tex-CrimsonPro-Black-tosf-ly1.vf \
tex-CrimsonPro-Black-tosf-ot1.tfm \
tex-CrimsonPro-Black-tosf-t1--base.tfm \
tex-CrimsonPro-Black-tosf-t1.tfm \
tex-CrimsonPro-Black-tosf-t1.vf \
tex-CrimsonPro-Black-tosf-ts1--base.tfm \
tex-CrimsonPro-Black-tosf-ts1.tfm \
tex-CrimsonPro-Black-tosf-ts1.vf \
tex-CrimsonPro-BlackItalic-inf-ly1--base.tfm \
tex-CrimsonPro-BlackItalic-inf-ly1.tfm \
tex-CrimsonPro-BlackItalic-inf-ly1.vf \
tex-CrimsonPro-BlackItalic-inf-ot1.tfm \
tex-CrimsonPro-BlackItalic-inf-t1--base.tfm \
tex-CrimsonPro-BlackItalic-inf-t1.tfm \
tex-CrimsonPro-BlackItalic-inf-t1.vf \
tex-CrimsonPro-BlackItalic-lf-ly1--base.tfm \
tex-CrimsonPro-BlackItalic-lf-ly1.tfm \
tex-CrimsonPro-BlackItalic-lf-ly1.vf \
tex-CrimsonPro-BlackItalic-lf-ot1.tfm \
tex-CrimsonPro-BlackItalic-lf-t1--base.tfm \
tex-CrimsonPro-BlackItalic-lf-t1.tfm \
tex-CrimsonPro-BlackItalic-lf-t1.vf \
tex-CrimsonPro-BlackItalic-lf-ts1--base.tfm \
tex-CrimsonPro-BlackItalic-lf-ts1.tfm \
tex-CrimsonPro-BlackItalic-lf-ts1.vf \
tex-CrimsonPro-BlackItalic-osf-ly1--base.tfm \
tex-CrimsonPro-BlackItalic-osf-ly1.tfm \
tex-CrimsonPro-BlackItalic-osf-ly1.vf \
tex-CrimsonPro-BlackItalic-osf-ot1.tfm \
tex-CrimsonPro-BlackItalic-osf-t1--base.tfm \
tex-CrimsonPro-BlackItalic-osf-t1.tfm \
tex-CrimsonPro-BlackItalic-osf-t1.vf \
tex-CrimsonPro-BlackItalic-osf-ts1--base.tfm \
tex-CrimsonPro-BlackItalic-osf-ts1.tfm \
tex-CrimsonPro-BlackItalic-osf-ts1.vf \
tex-CrimsonPro-BlackItalic-sup-ly1--base.tfm \
tex-CrimsonPro-BlackItalic-sup-ly1.tfm \
tex-CrimsonPro-BlackItalic-sup-ly1.vf \
tex-CrimsonPro-BlackItalic-sup-ot1.tfm \
tex-CrimsonPro-BlackItalic-sup-t1--base.tfm \
tex-CrimsonPro-BlackItalic-sup-t1.tfm \
tex-CrimsonPro-BlackItalic-sup-t1.vf \
tex-CrimsonPro-BlackItalic-tlf-ly1--base.tfm \
tex-CrimsonPro-BlackItalic-tlf-ly1.tfm \
tex-CrimsonPro-BlackItalic-tlf-ly1.vf \
tex-CrimsonPro-BlackItalic-tlf-ot1.tfm \
tex-CrimsonPro-BlackItalic-tlf-t1--base.tfm \
tex-CrimsonPro-BlackItalic-tlf-t1.tfm \
tex-CrimsonPro-BlackItalic-tlf-t1.vf \
tex-CrimsonPro-BlackItalic-tlf-ts1--base.tfm \
tex-CrimsonPro-BlackItalic-tlf-ts1.tfm \
tex-CrimsonPro-BlackItalic-tlf-ts1.vf \
tex-CrimsonPro-BlackItalic-tosf-ly1--base.tfm \
tex-CrimsonPro-BlackItalic-tosf-ly1.tfm \
tex-CrimsonPro-BlackItalic-tosf-ly1.vf \
tex-CrimsonPro-BlackItalic-tosf-ot1.tfm \
tex-CrimsonPro-BlackItalic-tosf-t1--base.tfm \
tex-CrimsonPro-BlackItalic-tosf-t1.tfm \
tex-CrimsonPro-BlackItalic-tosf-t1.vf \
tex-CrimsonPro-BlackItalic-tosf-ts1--base.tfm \
tex-CrimsonPro-BlackItalic-tosf-ts1.tfm \
tex-CrimsonPro-BlackItalic-tosf-ts1.vf \
tex-CrimsonPro-Bold-inf-ly1--base.tfm \
tex-CrimsonPro-Bold-inf-ly1.tfm \
tex-CrimsonPro-Bold-inf-ly1.vf \
tex-CrimsonPro-Bold-inf-ot1.tfm \
tex-CrimsonPro-Bold-inf-t1--base.tfm \
tex-CrimsonPro-Bold-inf-t1.tfm \
tex-CrimsonPro-Bold-inf-t1.vf \
tex-CrimsonPro-Bold-lf-ly1--base.tfm \
tex-CrimsonPro-Bold-lf-ly1.tfm \
tex-CrimsonPro-Bold-lf-ly1.vf \
tex-CrimsonPro-Bold-lf-ot1.tfm \
tex-CrimsonPro-Bold-lf-t1--base.tfm \
tex-CrimsonPro-Bold-lf-t1.tfm \
tex-CrimsonPro-Bold-lf-t1.vf \
tex-CrimsonPro-Bold-lf-ts1--base.tfm \
tex-CrimsonPro-Bold-lf-ts1.tfm \
tex-CrimsonPro-Bold-lf-ts1.vf \
tex-CrimsonPro-Bold-osf-ly1--base.tfm \
tex-CrimsonPro-Bold-osf-ly1.tfm \
tex-CrimsonPro-Bold-osf-ly1.vf \
tex-CrimsonPro-Bold-osf-ot1.tfm \
tex-CrimsonPro-Bold-osf-t1--base.tfm \
tex-CrimsonPro-Bold-osf-t1.tfm \
tex-CrimsonPro-Bold-osf-t1.vf \
tex-CrimsonPro-Bold-osf-ts1--base.tfm \
tex-CrimsonPro-Bold-osf-ts1.tfm \
tex-CrimsonPro-Bold-osf-ts1.vf \
tex-CrimsonPro-Bold-sup-ly1--base.tfm \
tex-CrimsonPro-Bold-sup-ly1.tfm \
tex-CrimsonPro-Bold-sup-ly1.vf \
tex-CrimsonPro-Bold-sup-ot1.tfm \
tex-CrimsonPro-Bold-sup-t1--base.tfm \
tex-CrimsonPro-Bold-sup-t1.tfm \
tex-CrimsonPro-Bold-sup-t1.vf \
tex-CrimsonPro-Bold-tlf-ly1--base.tfm \
tex-CrimsonPro-Bold-tlf-ly1.tfm \
tex-CrimsonPro-Bold-tlf-ly1.vf \
tex-CrimsonPro-Bold-tlf-ot1.tfm \
tex-CrimsonPro-Bold-tlf-t1--base.tfm \
tex-CrimsonPro-Bold-tlf-t1.tfm \
tex-CrimsonPro-Bold-tlf-t1.vf \
tex-CrimsonPro-Bold-tlf-ts1--base.tfm \
tex-CrimsonPro-Bold-tlf-ts1.tfm \
tex-CrimsonPro-Bold-tlf-ts1.vf \
tex-CrimsonPro-Bold-tosf-ly1--base.tfm \
tex-CrimsonPro-Bold-tosf-ly1.tfm \
tex-CrimsonPro-Bold-tosf-ly1.vf \
tex-CrimsonPro-Bold-tosf-ot1.tfm \
tex-CrimsonPro-Bold-tosf-t1--base.tfm \
tex-CrimsonPro-Bold-tosf-t1.tfm \
tex-CrimsonPro-Bold-tosf-t1.vf \
tex-CrimsonPro-Bold-tosf-ts1--base.tfm \
tex-CrimsonPro-Bold-tosf-ts1.tfm \
tex-CrimsonPro-Bold-tosf-ts1.vf \
tex-CrimsonPro-BoldItalic-inf-ly1--base.tfm \
tex-CrimsonPro-BoldItalic-inf-ly1.tfm \
tex-CrimsonPro-BoldItalic-inf-ly1.vf \
tex-CrimsonPro-BoldItalic-inf-ot1.tfm \
tex-CrimsonPro-BoldItalic-inf-t1--base.tfm \
tex-CrimsonPro-BoldItalic-inf-t1.tfm \
tex-CrimsonPro-BoldItalic-inf-t1.vf \
tex-CrimsonPro-BoldItalic-lf-ly1--base.tfm \
tex-CrimsonPro-BoldItalic-lf-ly1.tfm \
tex-CrimsonPro-BoldItalic-lf-ly1.vf \
tex-CrimsonPro-BoldItalic-lf-ot1.tfm \
tex-CrimsonPro-BoldItalic-lf-t1--base.tfm \
tex-CrimsonPro-BoldItalic-lf-t1.tfm \
tex-CrimsonPro-BoldItalic-lf-t1.vf \
tex-CrimsonPro-BoldItalic-lf-ts1--base.tfm \
tex-CrimsonPro-BoldItalic-lf-ts1.tfm \
tex-CrimsonPro-BoldItalic-lf-ts1.vf \
tex-CrimsonPro-BoldItalic-osf-ly1--base.tfm \
tex-CrimsonPro-BoldItalic-osf-ly1.tfm \
tex-CrimsonPro-BoldItalic-osf-ly1.vf \
tex-CrimsonPro-BoldItalic-osf-ot1.tfm \
tex-CrimsonPro-BoldItalic-osf-t1--base.tfm \
tex-CrimsonPro-BoldItalic-osf-t1.tfm \
tex-CrimsonPro-BoldItalic-osf-t1.vf \
tex-CrimsonPro-BoldItalic-osf-ts1--base.tfm \
tex-CrimsonPro-BoldItalic-osf-ts1.tfm \
tex-CrimsonPro-BoldItalic-osf-ts1.vf \
tex-CrimsonPro-BoldItalic-sup-ly1--base.tfm \
tex-CrimsonPro-BoldItalic-sup-ly1.tfm \
tex-CrimsonPro-BoldItalic-sup-ly1.vf \
tex-CrimsonPro-BoldItalic-sup-ot1.tfm \
tex-CrimsonPro-BoldItalic-sup-t1--base.tfm \
tex-CrimsonPro-BoldItalic-sup-t1.tfm \
tex-CrimsonPro-BoldItalic-sup-t1.vf \
tex-CrimsonPro-BoldItalic-tlf-ly1--base.tfm \
tex-CrimsonPro-BoldItalic-tlf-ly1.tfm \
tex-CrimsonPro-BoldItalic-tlf-ly1.vf \
tex-CrimsonPro-BoldItalic-tlf-ot1.tfm \
tex-CrimsonPro-BoldItalic-tlf-t1--base.tfm \
tex-CrimsonPro-BoldItalic-tlf-t1.tfm \
tex-CrimsonPro-BoldItalic-tlf-t1.vf \
tex-CrimsonPro-BoldItalic-tlf-ts1--base.tfm \
tex-CrimsonPro-BoldItalic-tlf-ts1.tfm \
tex-CrimsonPro-BoldItalic-tlf-ts1.vf \
tex-CrimsonPro-BoldItalic-tosf-ly1--base.tfm \
tex-CrimsonPro-BoldItalic-tosf-ly1.tfm \
tex-CrimsonPro-BoldItalic-tosf-ly1.vf \
tex-CrimsonPro-BoldItalic-tosf-ot1.tfm \
tex-CrimsonPro-BoldItalic-tosf-t1--base.tfm \
tex-CrimsonPro-BoldItalic-tosf-t1.tfm \
tex-CrimsonPro-BoldItalic-tosf-t1.vf \
tex-CrimsonPro-BoldItalic-tosf-ts1--base.tfm \
tex-CrimsonPro-BoldItalic-tosf-ts1.tfm \
tex-CrimsonPro-BoldItalic-tosf-ts1.vf \
tex-CrimsonPro-ExtraBold-inf-ly1--base.tfm \
tex-CrimsonPro-ExtraBold-inf-ly1.tfm \
tex-CrimsonPro-ExtraBold-inf-ly1.vf \
tex-CrimsonPro-ExtraBold-inf-ot1.tfm \
tex-CrimsonPro-ExtraBold-inf-t1--base.tfm \
tex-CrimsonPro-ExtraBold-inf-t1.tfm \
tex-CrimsonPro-ExtraBold-inf-t1.vf \
tex-CrimsonPro-ExtraBold-lf-ly1--base.tfm \
tex-CrimsonPro-ExtraBold-lf-ly1.tfm \
tex-CrimsonPro-ExtraBold-lf-ly1.vf \
tex-CrimsonPro-ExtraBold-lf-ot1.tfm \
tex-CrimsonPro-ExtraBold-lf-t1--base.tfm \
tex-CrimsonPro-ExtraBold-lf-t1.tfm \
tex-CrimsonPro-ExtraBold-lf-t1.vf \
tex-CrimsonPro-ExtraBold-lf-ts1--base.tfm \
tex-CrimsonPro-ExtraBold-lf-ts1.tfm \
tex-CrimsonPro-ExtraBold-lf-ts1.vf \
tex-CrimsonPro-ExtraBold-osf-ly1--base.tfm \
tex-CrimsonPro-ExtraBold-osf-ly1.tfm \
tex-CrimsonPro-ExtraBold-osf-ly1.vf \
tex-CrimsonPro-ExtraBold-osf-ot1.tfm \
tex-CrimsonPro-ExtraBold-osf-t1--base.tfm \
tex-CrimsonPro-ExtraBold-osf-t1.tfm \
tex-CrimsonPro-ExtraBold-osf-t1.vf \
tex-CrimsonPro-ExtraBold-osf-ts1--base.tfm \
tex-CrimsonPro-ExtraBold-osf-ts1.tfm \
tex-CrimsonPro-ExtraBold-osf-ts1.vf \
tex-CrimsonPro-ExtraBold-sup-ly1--base.tfm \
tex-CrimsonPro-ExtraBold-sup-ly1.tfm \
tex-CrimsonPro-ExtraBold-sup-ly1.vf \
tex-CrimsonPro-ExtraBold-sup-ot1.tfm \
tex-CrimsonPro-ExtraBold-sup-t1--base.tfm \
tex-CrimsonPro-ExtraBold-sup-t1.tfm \
tex-CrimsonPro-ExtraBold-sup-t1.vf \
tex-CrimsonPro-ExtraBold-tlf-ly1--base.tfm \
tex-CrimsonPro-ExtraBold-tlf-ly1.tfm \
tex-CrimsonPro-ExtraBold-tlf-ly1.vf \
tex-CrimsonPro-ExtraBold-tlf-ot1.tfm \
tex-CrimsonPro-ExtraBold-tlf-t1--base.tfm \
tex-CrimsonPro-ExtraBold-tlf-t1.tfm \
tex-CrimsonPro-ExtraBold-tlf-t1.vf \
tex-CrimsonPro-ExtraBold-tlf-ts1--base.tfm \
tex-CrimsonPro-ExtraBold-tlf-ts1.tfm \
tex-CrimsonPro-ExtraBold-tlf-ts1.vf \
tex-CrimsonPro-ExtraBold-tosf-ly1--base.tfm \
tex-CrimsonPro-ExtraBold-tosf-ly1.tfm \
tex-CrimsonPro-ExtraBold-tosf-ly1.vf \
tex-CrimsonPro-ExtraBold-tosf-ot1.tfm \
tex-CrimsonPro-ExtraBold-tosf-t1--base.tfm \
tex-CrimsonPro-ExtraBold-tosf-t1.tfm \
tex-CrimsonPro-ExtraBold-tosf-t1.vf \
tex-CrimsonPro-ExtraBold-tosf-ts1--base.tfm \
tex-CrimsonPro-ExtraBold-tosf-ts1.tfm \
tex-CrimsonPro-ExtraBold-tosf-ts1.vf \
tex-CrimsonPro-ExtraBoldItalic-inf-ly1--base.tfm \
tex-CrimsonPro-ExtraBoldItalic-inf-ly1.tfm \
tex-CrimsonPro-ExtraBoldItalic-inf-ly1.vf \
tex-CrimsonPro-ExtraBoldItalic-inf-ot1.tfm \
tex-CrimsonPro-ExtraBoldItalic-inf-t1--base.tfm \
tex-CrimsonPro-ExtraBoldItalic-inf-t1.tfm \
tex-CrimsonPro-ExtraBoldItalic-inf-t1.vf \
tex-CrimsonPro-ExtraBoldItalic-lf-ly1--base.tfm \
tex-CrimsonPro-ExtraBoldItalic-lf-ly1.tfm \
tex-CrimsonPro-ExtraBoldItalic-lf-ly1.vf \
tex-CrimsonPro-ExtraBoldItalic-lf-ot1.tfm \
tex-CrimsonPro-ExtraBoldItalic-lf-t1--base.tfm \
tex-CrimsonPro-ExtraBoldItalic-lf-t1.tfm \
tex-CrimsonPro-ExtraBoldItalic-lf-t1.vf \
tex-CrimsonPro-ExtraBoldItalic-lf-ts1--base.tfm \
tex-CrimsonPro-ExtraBoldItalic-lf-ts1.tfm \
tex-CrimsonPro-ExtraBoldItalic-lf-ts1.vf \
tex-CrimsonPro-ExtraBoldItalic-osf-ly1--base.tfm \
tex-CrimsonPro-ExtraBoldItalic-osf-ly1.tfm \
tex-CrimsonPro-ExtraBoldItalic-osf-ly1.vf \
tex-CrimsonPro-ExtraBoldItalic-osf-ot1.tfm \
tex-CrimsonPro-ExtraBoldItalic-osf-t1--base.tfm \
tex-CrimsonPro-ExtraBoldItalic-osf-t1.tfm \
tex-CrimsonPro-ExtraBoldItalic-osf-t1.vf \
tex-CrimsonPro-ExtraBoldItalic-osf-ts1--base.tfm \
tex-CrimsonPro-ExtraBoldItalic-osf-ts1.tfm \
tex-CrimsonPro-ExtraBoldItalic-osf-ts1.vf \
tex-CrimsonPro-ExtraBoldItalic-sup-ly1--base.tfm \
tex-CrimsonPro-ExtraBoldItalic-sup-ly1.tfm \
tex-CrimsonPro-ExtraBoldItalic-sup-ly1.vf \
tex-CrimsonPro-ExtraBoldItalic-sup-ot1.tfm \
tex-CrimsonPro-ExtraBoldItalic-sup-t1--base.tfm \
tex-CrimsonPro-ExtraBoldItalic-sup-t1.tfm \
tex-CrimsonPro-ExtraBoldItalic-sup-t1.vf \
tex-CrimsonPro-ExtraBoldItalic-tlf-ly1--base.tfm \
tex-CrimsonPro-ExtraBoldItalic-tlf-ly1.tfm \
tex-CrimsonPro-ExtraBoldItalic-tlf-ly1.vf \
tex-CrimsonPro-ExtraBoldItalic-tlf-ot1.tfm \
tex-CrimsonPro-ExtraBoldItalic-tlf-t1--base.tfm \
tex-CrimsonPro-ExtraBoldItalic-tlf-t1.tfm \
tex-CrimsonPro-ExtraBoldItalic-tlf-t1.vf \
tex-CrimsonPro-ExtraBoldItalic-tlf-ts1--base.tfm \
tex-CrimsonPro-ExtraBoldItalic-tlf-ts1.tfm \
tex-CrimsonPro-ExtraBoldItalic-tlf-ts1.vf \
tex-CrimsonPro-ExtraBoldItalic-tosf-ly1--base.tfm \
tex-CrimsonPro-ExtraBoldItalic-tosf-ly1.tfm \
tex-CrimsonPro-ExtraBoldItalic-tosf-ly1.vf \
tex-CrimsonPro-ExtraBoldItalic-tosf-ot1.tfm \
tex-CrimsonPro-ExtraBoldItalic-tosf-t1--base.tfm \
tex-CrimsonPro-ExtraBoldItalic-tosf-t1.tfm \
tex-CrimsonPro-ExtraBoldItalic-tosf-t1.vf \
tex-CrimsonPro-ExtraBoldItalic-tosf-ts1--base.tfm \
tex-CrimsonPro-ExtraBoldItalic-tosf-ts1.tfm \
tex-CrimsonPro-ExtraBoldItalic-tosf-ts1.vf \
tex-CrimsonPro-ExtraLight-inf-ly1--base.tfm \
tex-CrimsonPro-ExtraLight-inf-ly1.tfm \
tex-CrimsonPro-ExtraLight-inf-ly1.vf \
tex-CrimsonPro-ExtraLight-inf-ot1.tfm \
tex-CrimsonPro-ExtraLight-inf-t1--base.tfm \
tex-CrimsonPro-ExtraLight-inf-t1.tfm \
tex-CrimsonPro-ExtraLight-inf-t1.vf \
tex-CrimsonPro-ExtraLight-lf-ly1--base.tfm \
tex-CrimsonPro-ExtraLight-lf-ly1.tfm \
tex-CrimsonPro-ExtraLight-lf-ly1.vf \
tex-CrimsonPro-ExtraLight-lf-ot1.tfm \
tex-CrimsonPro-ExtraLight-lf-t1--base.tfm \
tex-CrimsonPro-ExtraLight-lf-t1.tfm \
tex-CrimsonPro-ExtraLight-lf-t1.vf \
tex-CrimsonPro-ExtraLight-lf-ts1--base.tfm \
tex-CrimsonPro-ExtraLight-lf-ts1.tfm \
tex-CrimsonPro-ExtraLight-lf-ts1.vf \
tex-CrimsonPro-ExtraLight-osf-ly1--base.tfm \
tex-CrimsonPro-ExtraLight-osf-ly1.tfm \
tex-CrimsonPro-ExtraLight-osf-ly1.vf \
tex-CrimsonPro-ExtraLight-osf-ot1.tfm \
tex-CrimsonPro-ExtraLight-osf-t1--base.tfm \
tex-CrimsonPro-ExtraLight-osf-t1.tfm \
tex-CrimsonPro-ExtraLight-osf-t1.vf \
tex-CrimsonPro-ExtraLight-osf-ts1--base.tfm \
tex-CrimsonPro-ExtraLight-osf-ts1.tfm \
tex-CrimsonPro-ExtraLight-osf-ts1.vf \
tex-CrimsonPro-ExtraLight-sup-ly1--base.tfm \
tex-CrimsonPro-ExtraLight-sup-ly1.tfm \
tex-CrimsonPro-ExtraLight-sup-ly1.vf \
tex-CrimsonPro-ExtraLight-sup-ot1.tfm \
tex-CrimsonPro-ExtraLight-sup-t1--base.tfm \
tex-CrimsonPro-ExtraLight-sup-t1.tfm \
tex-CrimsonPro-ExtraLight-sup-t1.vf \
tex-CrimsonPro-ExtraLight-tlf-ly1--base.tfm \
tex-CrimsonPro-ExtraLight-tlf-ly1.tfm \
tex-CrimsonPro-ExtraLight-tlf-ly1.vf \
tex-CrimsonPro-ExtraLight-tlf-ot1.tfm \
tex-CrimsonPro-ExtraLight-tlf-t1--base.tfm \
tex-CrimsonPro-ExtraLight-tlf-t1.tfm \
tex-CrimsonPro-ExtraLight-tlf-t1.vf \
tex-CrimsonPro-ExtraLight-tlf-ts1--base.tfm \
tex-CrimsonPro-ExtraLight-tlf-ts1.tfm \
tex-CrimsonPro-ExtraLight-tlf-ts1.vf \
tex-CrimsonPro-ExtraLight-tosf-ly1--base.tfm \
tex-CrimsonPro-ExtraLight-tosf-ly1.tfm \
tex-CrimsonPro-ExtraLight-tosf-ly1.vf \
tex-CrimsonPro-ExtraLight-tosf-ot1.tfm \
tex-CrimsonPro-ExtraLight-tosf-t1--base.tfm \
tex-CrimsonPro-ExtraLight-tosf-t1.tfm \
tex-CrimsonPro-ExtraLight-tosf-t1.vf \
tex-CrimsonPro-ExtraLight-tosf-ts1--base.tfm \
tex-CrimsonPro-ExtraLight-tosf-ts1.tfm \
tex-CrimsonPro-ExtraLight-tosf-ts1.vf \
tex-CrimsonPro-ExtraLightItalic-inf-ly1--base.tfm \
tex-CrimsonPro-ExtraLightItalic-inf-ly1.tfm \
tex-CrimsonPro-ExtraLightItalic-inf-ly1.vf \
tex-CrimsonPro-ExtraLightItalic-inf-ot1.tfm \
tex-CrimsonPro-ExtraLightItalic-inf-t1--base.tfm \
tex-CrimsonPro-ExtraLightItalic-inf-t1.tfm \
tex-CrimsonPro-ExtraLightItalic-inf-t1.vf \
tex-CrimsonPro-ExtraLightItalic-lf-ly1--base.tfm \
tex-CrimsonPro-ExtraLightItalic-lf-ly1.tfm \
tex-CrimsonPro-ExtraLightItalic-lf-ly1.vf \
tex-CrimsonPro-ExtraLightItalic-lf-ot1.tfm \
tex-CrimsonPro-ExtraLightItalic-lf-t1--base.tfm \
tex-CrimsonPro-ExtraLightItalic-lf-t1.tfm \
tex-CrimsonPro-ExtraLightItalic-lf-t1.vf \
tex-CrimsonPro-ExtraLightItalic-lf-ts1--base.tfm \
tex-CrimsonPro-ExtraLightItalic-lf-ts1.tfm \
tex-CrimsonPro-ExtraLightItalic-lf-ts1.vf \
tex-CrimsonPro-ExtraLightItalic-osf-ly1--base.tfm \
tex-CrimsonPro-ExtraLightItalic-osf-ly1.tfm \
tex-CrimsonPro-ExtraLightItalic-osf-ly1.vf \
tex-CrimsonPro-ExtraLightItalic-osf-ot1.tfm \
tex-CrimsonPro-ExtraLightItalic-osf-t1--base.tfm \
tex-CrimsonPro-ExtraLightItalic-osf-t1.tfm \
tex-CrimsonPro-ExtraLightItalic-osf-t1.vf \
tex-CrimsonPro-ExtraLightItalic-osf-ts1--base.tfm \
tex-CrimsonPro-ExtraLightItalic-osf-ts1.tfm \
tex-CrimsonPro-ExtraLightItalic-osf-ts1.vf \
tex-CrimsonPro-ExtraLightItalic-sup-ly1--base.tfm \
tex-CrimsonPro-ExtraLightItalic-sup-ly1.tfm \
tex-CrimsonPro-ExtraLightItalic-sup-ly1.vf \
tex-CrimsonPro-ExtraLightItalic-sup-ot1.tfm \
tex-CrimsonPro-ExtraLightItalic-sup-t1--base.tfm \
tex-CrimsonPro-ExtraLightItalic-sup-t1.tfm \
tex-CrimsonPro-ExtraLightItalic-sup-t1.vf \
tex-CrimsonPro-ExtraLightItalic-tlf-ly1--base.tfm \
tex-CrimsonPro-ExtraLightItalic-tlf-ly1.tfm \
tex-CrimsonPro-ExtraLightItalic-tlf-ly1.vf \
tex-CrimsonPro-ExtraLightItalic-tlf-ot1.tfm \
tex-CrimsonPro-ExtraLightItalic-tlf-t1--base.tfm \
tex-CrimsonPro-ExtraLightItalic-tlf-t1.tfm \
tex-CrimsonPro-ExtraLightItalic-tlf-t1.vf \
tex-CrimsonPro-ExtraLightItalic-tlf-ts1--base.tfm \
tex-CrimsonPro-ExtraLightItalic-tlf-ts1.tfm \
tex-CrimsonPro-ExtraLightItalic-tlf-ts1.vf \
tex-CrimsonPro-ExtraLightItalic-tosf-ly1--base.tfm \
tex-CrimsonPro-ExtraLightItalic-tosf-ly1.tfm \
tex-CrimsonPro-ExtraLightItalic-tosf-ly1.vf \
tex-CrimsonPro-ExtraLightItalic-tosf-ot1.tfm \
tex-CrimsonPro-ExtraLightItalic-tosf-t1--base.tfm \
tex-CrimsonPro-ExtraLightItalic-tosf-t1.tfm \
tex-CrimsonPro-ExtraLightItalic-tosf-t1.vf \
tex-CrimsonPro-ExtraLightItalic-tosf-ts1--base.tfm \
tex-CrimsonPro-ExtraLightItalic-tosf-ts1.tfm \
tex-CrimsonPro-ExtraLightItalic-tosf-ts1.vf \
tex-CrimsonPro-Italic-inf-ly1--base.tfm \
tex-CrimsonPro-Italic-inf-ly1.tfm \
tex-CrimsonPro-Italic-inf-ly1.vf \
tex-CrimsonPro-Italic-inf-ot1.tfm \
tex-CrimsonPro-Italic-inf-t1--base.tfm \
tex-CrimsonPro-Italic-inf-t1.tfm \
tex-CrimsonPro-Italic-inf-t1.vf \
tex-CrimsonPro-Italic-lf-ly1--base.tfm \
tex-CrimsonPro-Italic-lf-ly1.tfm \
tex-CrimsonPro-Italic-lf-ly1.vf \
tex-CrimsonPro-Italic-lf-ot1.tfm \
tex-CrimsonPro-Italic-lf-t1--base.tfm \
tex-CrimsonPro-Italic-lf-t1.tfm \
tex-CrimsonPro-Italic-lf-t1.vf \
tex-CrimsonPro-Italic-lf-ts1--base.tfm \
tex-CrimsonPro-Italic-lf-ts1.tfm \
tex-CrimsonPro-Italic-lf-ts1.vf \
tex-CrimsonPro-Italic-osf-ly1--base.tfm \
tex-CrimsonPro-Italic-osf-ly1.tfm \
tex-CrimsonPro-Italic-osf-ly1.vf \
tex-CrimsonPro-Italic-osf-ot1.tfm \
tex-CrimsonPro-Italic-osf-t1--base.tfm \
tex-CrimsonPro-Italic-osf-t1.tfm \
tex-CrimsonPro-Italic-osf-t1.vf \
tex-CrimsonPro-Italic-osf-ts1--base.tfm \
tex-CrimsonPro-Italic-osf-ts1.tfm \
tex-CrimsonPro-Italic-osf-ts1.vf \
tex-CrimsonPro-Italic-sup-ly1--base.tfm \
tex-CrimsonPro-Italic-sup-ly1.tfm \
tex-CrimsonPro-Italic-sup-ly1.vf \
tex-CrimsonPro-Italic-sup-ot1.tfm \
tex-CrimsonPro-Italic-sup-t1--base.tfm \
tex-CrimsonPro-Italic-sup-t1.tfm \
tex-CrimsonPro-Italic-sup-t1.vf \
tex-CrimsonPro-Italic-tlf-ly1--base.tfm \
tex-CrimsonPro-Italic-tlf-ly1.tfm \
tex-CrimsonPro-Italic-tlf-ly1.vf \
tex-CrimsonPro-Italic-tlf-ot1.tfm \
tex-CrimsonPro-Italic-tlf-t1--base.tfm \
tex-CrimsonPro-Italic-tlf-t1.tfm \
tex-CrimsonPro-Italic-tlf-t1.vf \
tex-CrimsonPro-Italic-tlf-ts1--base.tfm \
tex-CrimsonPro-Italic-tlf-ts1.tfm \
tex-CrimsonPro-Italic-tlf-ts1.vf \
tex-CrimsonPro-Italic-tosf-ly1--base.tfm \
tex-CrimsonPro-Italic-tosf-ly1.tfm \
tex-CrimsonPro-Italic-tosf-ly1.vf \
tex-CrimsonPro-Italic-tosf-ot1.tfm \
tex-CrimsonPro-Italic-tosf-t1--base.tfm \
tex-CrimsonPro-Italic-tosf-t1.tfm \
tex-CrimsonPro-Italic-tosf-t1.vf \
tex-CrimsonPro-Italic-tosf-ts1--base.tfm \
tex-CrimsonPro-Italic-tosf-ts1.tfm \
tex-CrimsonPro-Italic-tosf-ts1.vf \
tex-CrimsonPro-Light-inf-ly1--base.tfm \
tex-CrimsonPro-Light-inf-ly1.tfm \
tex-CrimsonPro-Light-inf-ly1.vf \
tex-CrimsonPro-Light-inf-ot1.tfm \
tex-CrimsonPro-Light-inf-t1--base.tfm \
tex-CrimsonPro-Light-inf-t1.tfm \
tex-CrimsonPro-Light-inf-t1.vf \
tex-CrimsonPro-Light-lf-ly1--base.tfm \
tex-CrimsonPro-Light-lf-ly1.tfm \
tex-CrimsonPro-Light-lf-ly1.vf \
tex-CrimsonPro-Light-lf-ot1.tfm \
tex-CrimsonPro-Light-lf-t1--base.tfm \
tex-CrimsonPro-Light-lf-t1.tfm \
tex-CrimsonPro-Light-lf-t1.vf \
tex-CrimsonPro-Light-lf-ts1--base.tfm \
tex-CrimsonPro-Light-lf-ts1.tfm \
tex-CrimsonPro-Light-lf-ts1.vf \
tex-CrimsonPro-Light-osf-ly1--base.tfm \
tex-CrimsonPro-Light-osf-ly1.tfm \
tex-CrimsonPro-Light-osf-ly1.vf \
tex-CrimsonPro-Light-osf-ot1.tfm \
tex-CrimsonPro-Light-osf-t1--base.tfm \
tex-CrimsonPro-Light-osf-t1.tfm \
tex-CrimsonPro-Light-osf-t1.vf \
tex-CrimsonPro-Light-osf-ts1--base.tfm \
tex-CrimsonPro-Light-osf-ts1.tfm \
tex-CrimsonPro-Light-osf-ts1.vf \
tex-CrimsonPro-Light-sup-ly1--base.tfm \
tex-CrimsonPro-Light-sup-ly1.tfm \
tex-CrimsonPro-Light-sup-ly1.vf \
tex-CrimsonPro-Light-sup-ot1.tfm \
tex-CrimsonPro-Light-sup-t1--base.tfm \
tex-CrimsonPro-Light-sup-t1.tfm \
tex-CrimsonPro-Light-sup-t1.vf \
tex-CrimsonPro-Light-tlf-ly1--base.tfm \
tex-CrimsonPro-Light-tlf-ly1.tfm \
tex-CrimsonPro-Light-tlf-ly1.vf \
tex-CrimsonPro-Light-tlf-ot1.tfm \
tex-CrimsonPro-Light-tlf-t1--base.tfm \
tex-CrimsonPro-Light-tlf-t1.tfm \
tex-CrimsonPro-Light-tlf-t1.vf \
tex-CrimsonPro-Light-tlf-ts1--base.tfm \
tex-CrimsonPro-Light-tlf-ts1.tfm \
tex-CrimsonPro-Light-tlf-ts1.vf \
tex-CrimsonPro-Light-tosf-ly1--base.tfm \
tex-CrimsonPro-Light-tosf-ly1.tfm \
tex-CrimsonPro-Light-tosf-ly1.vf \
tex-CrimsonPro-Light-tosf-ot1.tfm \
tex-CrimsonPro-Light-tosf-t1--base.tfm \
tex-CrimsonPro-Light-tosf-t1.tfm \
tex-CrimsonPro-Light-tosf-t1.vf \
tex-CrimsonPro-Light-tosf-ts1--base.tfm \
tex-CrimsonPro-Light-tosf-ts1.tfm \
tex-CrimsonPro-Light-tosf-ts1.vf \
tex-CrimsonPro-LightItalic-inf-ly1--base.tfm \
tex-CrimsonPro-LightItalic-inf-ly1.tfm \
tex-CrimsonPro-LightItalic-inf-ly1.vf \
tex-CrimsonPro-LightItalic-inf-ot1.tfm \
tex-CrimsonPro-LightItalic-inf-t1--base.tfm \
tex-CrimsonPro-LightItalic-inf-t1.tfm \
tex-CrimsonPro-LightItalic-inf-t1.vf \
tex-CrimsonPro-LightItalic-lf-ly1--base.tfm \
tex-CrimsonPro-LightItalic-lf-ly1.tfm \
tex-CrimsonPro-LightItalic-lf-ly1.vf \
tex-CrimsonPro-LightItalic-lf-ot1.tfm \
tex-CrimsonPro-LightItalic-lf-t1--base.tfm \
tex-CrimsonPro-LightItalic-lf-t1.tfm \
tex-CrimsonPro-LightItalic-lf-t1.vf \
tex-CrimsonPro-LightItalic-lf-ts1--base.tfm \
tex-CrimsonPro-LightItalic-lf-ts1.tfm \
tex-CrimsonPro-LightItalic-lf-ts1.vf \
tex-CrimsonPro-LightItalic-osf-ly1--base.tfm \
tex-CrimsonPro-LightItalic-osf-ly1.tfm \
tex-CrimsonPro-LightItalic-osf-ly1.vf \
tex-CrimsonPro-LightItalic-osf-ot1.tfm \
tex-CrimsonPro-LightItalic-osf-t1--base.tfm \
tex-CrimsonPro-LightItalic-osf-t1.tfm \
tex-CrimsonPro-LightItalic-osf-t1.vf \
tex-CrimsonPro-LightItalic-osf-ts1--base.tfm \
tex-CrimsonPro-LightItalic-osf-ts1.tfm \
tex-CrimsonPro-LightItalic-osf-ts1.vf \
tex-CrimsonPro-LightItalic-sup-ly1--base.tfm \
tex-CrimsonPro-LightItalic-sup-ly1.tfm \
tex-CrimsonPro-LightItalic-sup-ly1.vf \
tex-CrimsonPro-LightItalic-sup-ot1.tfm \
tex-CrimsonPro-LightItalic-sup-t1--base.tfm \
tex-CrimsonPro-LightItalic-sup-t1.tfm \
tex-CrimsonPro-LightItalic-sup-t1.vf \
tex-CrimsonPro-LightItalic-tlf-ly1--base.tfm \
tex-CrimsonPro-LightItalic-tlf-ly1.tfm \
tex-CrimsonPro-LightItalic-tlf-ly1.vf \
tex-CrimsonPro-LightItalic-tlf-ot1.tfm \
tex-CrimsonPro-LightItalic-tlf-t1--base.tfm \
tex-CrimsonPro-LightItalic-tlf-t1.tfm \
tex-CrimsonPro-LightItalic-tlf-t1.vf \
tex-CrimsonPro-LightItalic-tlf-ts1--base.tfm \
tex-CrimsonPro-LightItalic-tlf-ts1.tfm \
tex-CrimsonPro-LightItalic-tlf-ts1.vf \
tex-CrimsonPro-LightItalic-tosf-ly1--base.tfm \
tex-CrimsonPro-LightItalic-tosf-ly1.tfm \
tex-CrimsonPro-LightItalic-tosf-ly1.vf \
tex-CrimsonPro-LightItalic-tosf-ot1.tfm \
tex-CrimsonPro-LightItalic-tosf-t1--base.tfm \
tex-CrimsonPro-LightItalic-tosf-t1.tfm \
tex-CrimsonPro-LightItalic-tosf-t1.vf \
tex-CrimsonPro-LightItalic-tosf-ts1--base.tfm \
tex-CrimsonPro-LightItalic-tosf-ts1.tfm \
tex-CrimsonPro-LightItalic-tosf-ts1.vf \
tex-CrimsonPro-Medium-inf-ly1--base.tfm \
tex-CrimsonPro-Medium-inf-ly1.tfm \
tex-CrimsonPro-Medium-inf-ly1.vf \
tex-CrimsonPro-Medium-inf-ot1.tfm \
tex-CrimsonPro-Medium-inf-t1--base.tfm \
tex-CrimsonPro-Medium-inf-t1.tfm \
tex-CrimsonPro-Medium-inf-t1.vf \
tex-CrimsonPro-Medium-lf-ly1--base.tfm \
tex-CrimsonPro-Medium-lf-ly1.tfm \
tex-CrimsonPro-Medium-lf-ly1.vf \
tex-CrimsonPro-Medium-lf-ot1.tfm \
tex-CrimsonPro-Medium-lf-t1--base.tfm \
tex-CrimsonPro-Medium-lf-t1.tfm \
tex-CrimsonPro-Medium-lf-t1.vf \
tex-CrimsonPro-Medium-lf-ts1--base.tfm \
tex-CrimsonPro-Medium-lf-ts1.tfm \
tex-CrimsonPro-Medium-lf-ts1.vf \
tex-CrimsonPro-Medium-osf-ly1--base.tfm \
tex-CrimsonPro-Medium-osf-ly1.tfm \
tex-CrimsonPro-Medium-osf-ly1.vf \
tex-CrimsonPro-Medium-osf-ot1.tfm \
tex-CrimsonPro-Medium-osf-t1--base.tfm \
tex-CrimsonPro-Medium-osf-t1.tfm \
tex-CrimsonPro-Medium-osf-t1.vf \
tex-CrimsonPro-Medium-osf-ts1--base.tfm \
tex-CrimsonPro-Medium-osf-ts1.tfm \
tex-CrimsonPro-Medium-osf-ts1.vf \
tex-CrimsonPro-Medium-sup-ly1--base.tfm \
tex-CrimsonPro-Medium-sup-ly1.tfm \
tex-CrimsonPro-Medium-sup-ly1.vf \
tex-CrimsonPro-Medium-sup-ot1.tfm \
tex-CrimsonPro-Medium-sup-t1--base.tfm \
tex-CrimsonPro-Medium-sup-t1.tfm \
tex-CrimsonPro-Medium-sup-t1.vf \
tex-CrimsonPro-Medium-tlf-ly1--base.tfm \
tex-CrimsonPro-Medium-tlf-ly1.tfm \
tex-CrimsonPro-Medium-tlf-ly1.vf \
tex-CrimsonPro-Medium-tlf-ot1.tfm \
tex-CrimsonPro-Medium-tlf-t1--base.tfm \
tex-CrimsonPro-Medium-tlf-t1.tfm \
tex-CrimsonPro-Medium-tlf-t1.vf \
tex-CrimsonPro-Medium-tlf-ts1--base.tfm \
tex-CrimsonPro-Medium-tlf-ts1.tfm \
tex-CrimsonPro-Medium-tlf-ts1.vf \
tex-CrimsonPro-Medium-tosf-ly1--base.tfm \
tex-CrimsonPro-Medium-tosf-ly1.tfm \
tex-CrimsonPro-Medium-tosf-ly1.vf \
tex-CrimsonPro-Medium-tosf-ot1.tfm \
tex-CrimsonPro-Medium-tosf-t1--base.tfm \
tex-CrimsonPro-Medium-tosf-t1.tfm \
tex-CrimsonPro-Medium-tosf-t1.vf \
tex-CrimsonPro-Medium-tosf-ts1--base.tfm \
tex-CrimsonPro-Medium-tosf-ts1.tfm \
tex-CrimsonPro-Medium-tosf-ts1.vf \
tex-CrimsonPro-MediumItalic-inf-ly1--base.tfm \
tex-CrimsonPro-MediumItalic-inf-ly1.tfm \
tex-CrimsonPro-MediumItalic-inf-ly1.vf \
tex-CrimsonPro-MediumItalic-inf-ot1.tfm \
tex-CrimsonPro-MediumItalic-inf-t1--base.tfm \
tex-CrimsonPro-MediumItalic-inf-t1.tfm \
tex-CrimsonPro-MediumItalic-inf-t1.vf \
tex-CrimsonPro-MediumItalic-lf-ly1--base.tfm \
tex-CrimsonPro-MediumItalic-lf-ly1.tfm \
tex-CrimsonPro-MediumItalic-lf-ly1.vf \
tex-CrimsonPro-MediumItalic-lf-ot1.tfm \
tex-CrimsonPro-MediumItalic-lf-t1--base.tfm \
tex-CrimsonPro-MediumItalic-lf-t1.tfm \
tex-CrimsonPro-MediumItalic-lf-t1.vf \
tex-CrimsonPro-MediumItalic-lf-ts1--base.tfm \
tex-CrimsonPro-MediumItalic-lf-ts1.tfm \
tex-CrimsonPro-MediumItalic-lf-ts1.vf \
tex-CrimsonPro-MediumItalic-osf-ly1--base.tfm \
tex-CrimsonPro-MediumItalic-osf-ly1.tfm \
tex-CrimsonPro-MediumItalic-osf-ly1.vf \
tex-CrimsonPro-MediumItalic-osf-ot1.tfm \
tex-CrimsonPro-MediumItalic-osf-t1--base.tfm \
tex-CrimsonPro-MediumItalic-osf-t1.tfm \
tex-CrimsonPro-MediumItalic-osf-t1.vf \
tex-CrimsonPro-MediumItalic-osf-ts1--base.tfm \
tex-CrimsonPro-MediumItalic-osf-ts1.tfm \
tex-CrimsonPro-MediumItalic-osf-ts1.vf \
tex-CrimsonPro-MediumItalic-sup-ly1--base.tfm \
tex-CrimsonPro-MediumItalic-sup-ly1.tfm \
tex-CrimsonPro-MediumItalic-sup-ly1.vf \
tex-CrimsonPro-MediumItalic-sup-ot1.tfm \
tex-CrimsonPro-MediumItalic-sup-t1--base.tfm \
tex-CrimsonPro-MediumItalic-sup-t1.tfm \
tex-CrimsonPro-MediumItalic-sup-t1.vf \
tex-CrimsonPro-MediumItalic-tlf-ly1--base.tfm \
tex-CrimsonPro-MediumItalic-tlf-ly1.tfm \
tex-CrimsonPro-MediumItalic-tlf-ly1.vf \
tex-CrimsonPro-MediumItalic-tlf-ot1.tfm \
tex-CrimsonPro-MediumItalic-tlf-t1--base.tfm \
tex-CrimsonPro-MediumItalic-tlf-t1.tfm \
tex-CrimsonPro-MediumItalic-tlf-t1.vf \
tex-CrimsonPro-MediumItalic-tlf-ts1--base.tfm \
tex-CrimsonPro-MediumItalic-tlf-ts1.tfm \
tex-CrimsonPro-MediumItalic-tlf-ts1.vf \
tex-CrimsonPro-MediumItalic-tosf-ly1--base.tfm \
tex-CrimsonPro-MediumItalic-tosf-ly1.tfm \
tex-CrimsonPro-MediumItalic-tosf-ly1.vf \
tex-CrimsonPro-MediumItalic-tosf-ot1.tfm \
tex-CrimsonPro-MediumItalic-tosf-t1--base.tfm \
tex-CrimsonPro-MediumItalic-tosf-t1.tfm \
tex-CrimsonPro-MediumItalic-tosf-t1.vf \
tex-CrimsonPro-MediumItalic-tosf-ts1--base.tfm \
tex-CrimsonPro-MediumItalic-tosf-ts1.tfm \
tex-CrimsonPro-MediumItalic-tosf-ts1.vf \
tex-CrimsonPro-Regular-inf-ly1--base.tfm \
tex-CrimsonPro-Regular-inf-ly1.tfm \
tex-CrimsonPro-Regular-inf-ly1.vf \
tex-CrimsonPro-Regular-inf-ot1.tfm \
tex-CrimsonPro-Regular-inf-t1--base.tfm \
tex-CrimsonPro-Regular-inf-t1.tfm \
tex-CrimsonPro-Regular-inf-t1.vf \
tex-CrimsonPro-Regular-lf-ly1--base.tfm \
tex-CrimsonPro-Regular-lf-ly1.tfm \
tex-CrimsonPro-Regular-lf-ly1.vf \
tex-CrimsonPro-Regular-lf-ot1.tfm \
tex-CrimsonPro-Regular-lf-t1--base.tfm \
tex-CrimsonPro-Regular-lf-t1.tfm \
tex-CrimsonPro-Regular-lf-t1.vf \
tex-CrimsonPro-Regular-lf-ts1--base.tfm \
tex-CrimsonPro-Regular-lf-ts1.tfm \
tex-CrimsonPro-Regular-lf-ts1.vf \
tex-CrimsonPro-Regular-osf-ly1--base.tfm \
tex-CrimsonPro-Regular-osf-ly1.tfm \
tex-CrimsonPro-Regular-osf-ly1.vf \
tex-CrimsonPro-Regular-osf-ot1.tfm \
tex-CrimsonPro-Regular-osf-t1--base.tfm \
tex-CrimsonPro-Regular-osf-t1.tfm \
tex-CrimsonPro-Regular-osf-t1.vf \
tex-CrimsonPro-Regular-osf-ts1--base.tfm \
tex-CrimsonPro-Regular-osf-ts1.tfm \
tex-CrimsonPro-Regular-osf-ts1.vf \
tex-CrimsonPro-Regular-sup-ly1--base.tfm \
tex-CrimsonPro-Regular-sup-ly1.tfm \
tex-CrimsonPro-Regular-sup-ly1.vf \
tex-CrimsonPro-Regular-sup-ot1.tfm \
tex-CrimsonPro-Regular-sup-t1--base.tfm \
tex-CrimsonPro-Regular-sup-t1.tfm \
tex-CrimsonPro-Regular-sup-t1.vf \
tex-CrimsonPro-Regular-tlf-ly1--base.tfm \
tex-CrimsonPro-Regular-tlf-ly1.tfm \
tex-CrimsonPro-Regular-tlf-ly1.vf \
tex-CrimsonPro-Regular-tlf-ot1.tfm \
tex-CrimsonPro-Regular-tlf-t1--base.tfm \
tex-CrimsonPro-Regular-tlf-t1.tfm \
tex-CrimsonPro-Regular-tlf-t1.vf \
tex-CrimsonPro-Regular-tlf-ts1--base.tfm \
tex-CrimsonPro-Regular-tlf-ts1.tfm \
tex-CrimsonPro-Regular-tlf-ts1.vf \
tex-CrimsonPro-Regular-tosf-ly1--base.tfm \
tex-CrimsonPro-Regular-tosf-ly1.tfm \
tex-CrimsonPro-Regular-tosf-ly1.vf \
tex-CrimsonPro-Regular-tosf-ot1.tfm \
tex-CrimsonPro-Regular-tosf-t1--base.tfm \
tex-CrimsonPro-Regular-tosf-t1.tfm \
tex-CrimsonPro-Regular-tosf-t1.vf \
tex-CrimsonPro-Regular-tosf-ts1--base.tfm \
tex-CrimsonPro-Regular-tosf-ts1.tfm \
tex-CrimsonPro-Regular-tosf-ts1.vf \
tex-CrimsonPro-SemiBold-inf-ly1--base.tfm \
tex-CrimsonPro-SemiBold-inf-ly1.tfm \
tex-CrimsonPro-SemiBold-inf-ly1.vf \
tex-CrimsonPro-SemiBold-inf-ot1.tfm \
tex-CrimsonPro-SemiBold-inf-t1--base.tfm \
tex-CrimsonPro-SemiBold-inf-t1.tfm \
tex-CrimsonPro-SemiBold-inf-t1.vf \
tex-CrimsonPro-SemiBold-lf-ly1--base.tfm \
tex-CrimsonPro-SemiBold-lf-ly1.tfm \
tex-CrimsonPro-SemiBold-lf-ly1.vf \
tex-CrimsonPro-SemiBold-lf-ot1.tfm \
tex-CrimsonPro-SemiBold-lf-t1--base.tfm \
tex-CrimsonPro-SemiBold-lf-t1.tfm \
tex-CrimsonPro-SemiBold-lf-t1.vf \
tex-CrimsonPro-SemiBold-lf-ts1--base.tfm \
tex-CrimsonPro-SemiBold-lf-ts1.tfm \
tex-CrimsonPro-SemiBold-lf-ts1.vf \
tex-CrimsonPro-SemiBold-osf-ly1--base.tfm \
tex-CrimsonPro-SemiBold-osf-ly1.tfm \
tex-CrimsonPro-SemiBold-osf-ly1.vf \
tex-CrimsonPro-SemiBold-osf-ot1.tfm \
tex-CrimsonPro-SemiBold-osf-t1--base.tfm \
tex-CrimsonPro-SemiBold-osf-t1.tfm \
tex-CrimsonPro-SemiBold-osf-t1.vf \
tex-CrimsonPro-SemiBold-osf-ts1--base.tfm \
tex-CrimsonPro-SemiBold-osf-ts1.tfm \
tex-CrimsonPro-SemiBold-osf-ts1.vf \
tex-CrimsonPro-SemiBold-sup-ly1--base.tfm \
tex-CrimsonPro-SemiBold-sup-ly1.tfm \
tex-CrimsonPro-SemiBold-sup-ly1.vf \
tex-CrimsonPro-SemiBold-sup-ot1.tfm \
tex-CrimsonPro-SemiBold-sup-t1--base.tfm \
tex-CrimsonPro-SemiBold-sup-t1.tfm \
tex-CrimsonPro-SemiBold-sup-t1.vf \
tex-CrimsonPro-SemiBold-tlf-ly1--base.tfm \
tex-CrimsonPro-SemiBold-tlf-ly1.tfm \
tex-CrimsonPro-SemiBold-tlf-ly1.vf \
tex-CrimsonPro-SemiBold-tlf-ot1.tfm \
tex-CrimsonPro-SemiBold-tlf-t1--base.tfm \
tex-CrimsonPro-SemiBold-tlf-t1.tfm \
tex-CrimsonPro-SemiBold-tlf-t1.vf \
tex-CrimsonPro-SemiBold-tlf-ts1--base.tfm \
tex-CrimsonPro-SemiBold-tlf-ts1.tfm \
tex-CrimsonPro-SemiBold-tlf-ts1.vf \
tex-CrimsonPro-SemiBold-tosf-ly1--base.tfm \
tex-CrimsonPro-SemiBold-tosf-ly1.tfm \
tex-CrimsonPro-SemiBold-tosf-ly1.vf \
tex-CrimsonPro-SemiBold-tosf-ot1.tfm \
tex-CrimsonPro-SemiBold-tosf-t1--base.tfm \
tex-CrimsonPro-SemiBold-tosf-t1.tfm \
tex-CrimsonPro-SemiBold-tosf-t1.vf \
tex-CrimsonPro-SemiBold-tosf-ts1--base.tfm \
tex-CrimsonPro-SemiBold-tosf-ts1.tfm \
tex-CrimsonPro-SemiBold-tosf-ts1.vf \
tex-CrimsonPro-SemiBoldItalic-inf-ly1--base.tfm \
tex-CrimsonPro-SemiBoldItalic-inf-ly1.tfm \
tex-CrimsonPro-SemiBoldItalic-inf-ly1.vf \
tex-CrimsonPro-SemiBoldItalic-inf-ot1.tfm \
tex-CrimsonPro-SemiBoldItalic-inf-t1--base.tfm \
tex-CrimsonPro-SemiBoldItalic-inf-t1.tfm \
tex-CrimsonPro-SemiBoldItalic-inf-t1.vf \
tex-CrimsonPro-SemiBoldItalic-lf-ly1--base.tfm \
tex-CrimsonPro-SemiBoldItalic-lf-ly1.tfm \
tex-CrimsonPro-SemiBoldItalic-lf-ly1.vf \
tex-CrimsonPro-SemiBoldItalic-lf-ot1.tfm \
tex-CrimsonPro-SemiBoldItalic-lf-t1--base.tfm \
tex-CrimsonPro-SemiBoldItalic-lf-t1.tfm \
tex-CrimsonPro-SemiBoldItalic-lf-t1.vf \
tex-CrimsonPro-SemiBoldItalic-lf-ts1--base.tfm \
tex-CrimsonPro-SemiBoldItalic-lf-ts1.tfm \
tex-CrimsonPro-SemiBoldItalic-lf-ts1.vf \
tex-CrimsonPro-SemiBoldItalic-osf-ly1--base.tfm \
tex-CrimsonPro-SemiBoldItalic-osf-ly1.tfm \
tex-CrimsonPro-SemiBoldItalic-osf-ly1.vf \
tex-CrimsonPro-SemiBoldItalic-osf-ot1.tfm \
tex-CrimsonPro-SemiBoldItalic-osf-t1--base.tfm \
tex-CrimsonPro-SemiBoldItalic-osf-t1.tfm \
tex-CrimsonPro-SemiBoldItalic-osf-t1.vf \
tex-CrimsonPro-SemiBoldItalic-osf-ts1--base.tfm \
tex-CrimsonPro-SemiBoldItalic-osf-ts1.tfm \
tex-CrimsonPro-SemiBoldItalic-osf-ts1.vf \
tex-CrimsonPro-SemiBoldItalic-sup-ly1--base.tfm \
tex-CrimsonPro-SemiBoldItalic-sup-ly1.tfm \
tex-CrimsonPro-SemiBoldItalic-sup-ly1.vf \
tex-CrimsonPro-SemiBoldItalic-sup-ot1.tfm \
tex-CrimsonPro-SemiBoldItalic-sup-t1--base.tfm \
tex-CrimsonPro-SemiBoldItalic-sup-t1.tfm \
tex-CrimsonPro-SemiBoldItalic-sup-t1.vf \
tex-CrimsonPro-SemiBoldItalic-tlf-ly1--base.tfm \
tex-CrimsonPro-SemiBoldItalic-tlf-ly1.tfm \
tex-CrimsonPro-SemiBoldItalic-tlf-ly1.vf \
tex-CrimsonPro-SemiBoldItalic-tlf-ot1.tfm \
tex-CrimsonPro-SemiBoldItalic-tlf-t1--base.tfm \
tex-CrimsonPro-SemiBoldItalic-tlf-t1.tfm \
tex-CrimsonPro-SemiBoldItalic-tlf-t1.vf \
tex-CrimsonPro-SemiBoldItalic-tlf-ts1--base.tfm \
tex-CrimsonPro-SemiBoldItalic-tlf-ts1.tfm \
tex-CrimsonPro-SemiBoldItalic-tlf-ts1.vf \
tex-CrimsonPro-SemiBoldItalic-tosf-ly1--base.tfm \
tex-CrimsonPro-SemiBoldItalic-tosf-ly1.tfm \
tex-CrimsonPro-SemiBoldItalic-tosf-ly1.vf \
tex-CrimsonPro-SemiBoldItalic-tosf-ot1.tfm \
tex-CrimsonPro-SemiBoldItalic-tosf-t1--base.tfm \
tex-CrimsonPro-SemiBoldItalic-tosf-t1.tfm \
tex-CrimsonPro-SemiBoldItalic-tosf-t1.vf \
tex-CrimsonPro-SemiBoldItalic-tosf-ts1--base.tfm \
tex-CrimsonPro-SemiBoldItalic-tosf-ts1.tfm \
tex-CrimsonPro-SemiBoldItalic-tosf-ts1.vf \
tex-CrimsonPro.map \
tex-CrimsonPro.sty \
tex-LY1CrimsonPro-Inf.fd \
tex-LY1CrimsonPro-LF.fd \
tex-LY1CrimsonPro-OsF.fd \
tex-LY1CrimsonPro-Sup.fd \
tex-LY1CrimsonPro-TLF.fd \
tex-LY1CrimsonPro-TOsF.fd \
tex-OT1CrimsonPro-Inf.fd \
tex-OT1CrimsonPro-LF.fd \
tex-OT1CrimsonPro-OsF.fd \
tex-OT1CrimsonPro-Sup.fd \
tex-OT1CrimsonPro-TLF.fd \
tex-OT1CrimsonPro-TOsF.fd \
tex-T1CrimsonPro-Inf.fd \
tex-T1CrimsonPro-LF.fd \
tex-T1CrimsonPro-OsF.fd \
tex-T1CrimsonPro-Sup.fd \
tex-T1CrimsonPro-TLF.fd \
tex-T1CrimsonPro-TOsF.fd \
tex-TS1CrimsonPro-LF.fd \
tex-TS1CrimsonPro-OsF.fd \
tex-TS1CrimsonPro-TLF.fd \
tex-TS1CrimsonPro-TOsF.fd \
tex-crp-2sgwql.enc \
tex-crp-3lrgtj.enc \
tex-crp-b4nxop.enc \
tex-crp-bapnwu.enc \
tex-crp-hxzdi6.enc \
tex-crp-iqth5t.enc \
tex-crp-izapv7.enc \
tex-crp-jvsxek.enc \
tex-crp-kpggsy.enc \
tex-crp-krtxg6.enc \
tex-crp-ldjqep.enc \
tex-crp-q22ex3.enc \
tex-crp-qlkdbr.enc \
tex-crp-spbxfw.enc \
tex-crp-umrhwx.enc \
tex-crp-wslvgt.enc \
tex-crp-xsutkk.enc \
tex-crp-ylc3fo.enc \
tex-crp-yyrdtm.enc \
texlive-crimsonpro"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontaxes.sty \
tex-fontenc.sty \
tex-fontspec.sty \
tex-ifluatex.sty \
tex-ifxetex.sty \
tex-mweights.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-crimsonpro-fonts \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
