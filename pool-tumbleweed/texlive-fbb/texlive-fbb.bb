SUMMARY = "A free Bembo-like font"
DESCRIPTION = "The package provides a Bembo-like font package based on Cardo \
but with many modifications, adding Bold Italic, small caps in \
all styles, six figure choices in all styles, updated kerning \
tables, added figure tables and corrected f-ligatures. Both \
OpenType and Adobe Type 1 versions are provided; all necessary \
support files are provided. The font works well with \
newtxmath's libertine option."
LICENSE = "OFL-1.1"

PV = "2023.201.1.16svn55728"

RPM_NAME = "texlive-fbb-2023.201.1.16svn55728-52.1.noarch.rpm"
RPM_HASH = "128b418683077667c60d1d189112b30b3b234f284b52e448a1c843fe3f2dd7328ca91c580f393ea9bb477bc23aa80f3512d740762bf537ba4e00ab70b0f7a32e"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex(LY1fbb-Inf.fd) \
tex(LY1fbb-LF.fd) \
tex(LY1fbb-OsF.fd) \
tex(LY1fbb-Sup.fd) \
tex(LY1fbb-TLF.fd) \
tex(LY1fbb-TOsF.fd) \
tex(OT1fbb-Inf.fd) \
tex(OT1fbb-LF.fd) \
tex(OT1fbb-OsF.fd) \
tex(OT1fbb-Sup.fd) \
tex(OT1fbb-TLF.fd) \
tex(OT1fbb-TOsF.fd) \
tex(T1fbb-Inf.fd) \
tex(T1fbb-LF.fd) \
tex(T1fbb-OsF.fd) \
tex(T1fbb-Sup.fd) \
tex(T1fbb-TLF.fd) \
tex(T1fbb-TOsF.fd) \
tex(TS1fbb-LF.fd) \
tex(TS1fbb-OsF.fd) \
tex(TS1fbb-TLF.fd) \
tex(TS1fbb-TOsF.fd) \
tex(fbb-Bold-inf-ly1--base.tfm) \
tex(fbb-Bold-inf-ly1.tfm) \
tex(fbb-Bold-inf-ly1.vf) \
tex(fbb-Bold-inf-ot1.tfm) \
tex(fbb-Bold-inf-t1--base.tfm) \
tex(fbb-Bold-inf-t1.tfm) \
tex(fbb-Bold-inf-t1.vf) \
tex(fbb-Bold-lf-ly1--base.tfm) \
tex(fbb-Bold-lf-ly1.tfm) \
tex(fbb-Bold-lf-ly1.vf) \
tex(fbb-Bold-lf-ot1.tfm) \
tex(fbb-Bold-lf-sc-ly1--base.tfm) \
tex(fbb-Bold-lf-sc-ly1.tfm) \
tex(fbb-Bold-lf-sc-ly1.vf) \
tex(fbb-Bold-lf-sc-ot1--base.tfm) \
tex(fbb-Bold-lf-sc-ot1.tfm) \
tex(fbb-Bold-lf-sc-ot1.vf) \
tex(fbb-Bold-lf-sc-t1--base.tfm) \
tex(fbb-Bold-lf-sc-t1.tfm) \
tex(fbb-Bold-lf-sc-t1.vf) \
tex(fbb-Bold-lf-swash-ly1--base.tfm) \
tex(fbb-Bold-lf-swash-ly1.tfm) \
tex(fbb-Bold-lf-swash-ly1.vf) \
tex(fbb-Bold-lf-swash-ot1.tfm) \
tex(fbb-Bold-lf-swash-t1--base.tfm) \
tex(fbb-Bold-lf-swash-t1.tfm) \
tex(fbb-Bold-lf-swash-t1.vf) \
tex(fbb-Bold-lf-t1--base.tfm) \
tex(fbb-Bold-lf-t1.tfm) \
tex(fbb-Bold-lf-t1.vf) \
tex(fbb-Bold-lf-ts1--base.tfm) \
tex(fbb-Bold-lf-ts1.tfm) \
tex(fbb-Bold-lf-ts1.vf) \
tex(fbb-Bold-osf-ly1--base.tfm) \
tex(fbb-Bold-osf-ly1.tfm) \
tex(fbb-Bold-osf-ly1.vf) \
tex(fbb-Bold-osf-ot1.tfm) \
tex(fbb-Bold-osf-sc-ly1--base.tfm) \
tex(fbb-Bold-osf-sc-ly1.tfm) \
tex(fbb-Bold-osf-sc-ly1.vf) \
tex(fbb-Bold-osf-sc-ot1--base.tfm) \
tex(fbb-Bold-osf-sc-ot1.tfm) \
tex(fbb-Bold-osf-sc-ot1.vf) \
tex(fbb-Bold-osf-sc-t1--base.tfm) \
tex(fbb-Bold-osf-sc-t1.tfm) \
tex(fbb-Bold-osf-sc-t1.vf) \
tex(fbb-Bold-osf-swash-ly1--base.tfm) \
tex(fbb-Bold-osf-swash-ly1.tfm) \
tex(fbb-Bold-osf-swash-ly1.vf) \
tex(fbb-Bold-osf-swash-ot1.tfm) \
tex(fbb-Bold-osf-swash-t1--base.tfm) \
tex(fbb-Bold-osf-swash-t1.tfm) \
tex(fbb-Bold-osf-swash-t1.vf) \
tex(fbb-Bold-osf-t1--base.tfm) \
tex(fbb-Bold-osf-t1.tfm) \
tex(fbb-Bold-osf-t1.vf) \
tex(fbb-Bold-osf-ts1--base.tfm) \
tex(fbb-Bold-osf-ts1.tfm) \
tex(fbb-Bold-osf-ts1.vf) \
tex(fbb-Bold-sup-ly1--base.tfm) \
tex(fbb-Bold-sup-ly1.tfm) \
tex(fbb-Bold-sup-ly1.vf) \
tex(fbb-Bold-sup-ot1.tfm) \
tex(fbb-Bold-sup-t1--base.tfm) \
tex(fbb-Bold-sup-t1.tfm) \
tex(fbb-Bold-sup-t1.vf) \
tex(fbb-Bold-tlf-ly1--base.tfm) \
tex(fbb-Bold-tlf-ly1.tfm) \
tex(fbb-Bold-tlf-ly1.vf) \
tex(fbb-Bold-tlf-ot1.tfm) \
tex(fbb-Bold-tlf-sc-ly1--base.tfm) \
tex(fbb-Bold-tlf-sc-ly1.tfm) \
tex(fbb-Bold-tlf-sc-ly1.vf) \
tex(fbb-Bold-tlf-sc-ot1--base.tfm) \
tex(fbb-Bold-tlf-sc-ot1.tfm) \
tex(fbb-Bold-tlf-sc-ot1.vf) \
tex(fbb-Bold-tlf-sc-t1--base.tfm) \
tex(fbb-Bold-tlf-sc-t1.tfm) \
tex(fbb-Bold-tlf-sc-t1.vf) \
tex(fbb-Bold-tlf-swash-ly1--base.tfm) \
tex(fbb-Bold-tlf-swash-ly1.tfm) \
tex(fbb-Bold-tlf-swash-ly1.vf) \
tex(fbb-Bold-tlf-swash-ot1.tfm) \
tex(fbb-Bold-tlf-swash-t1--base.tfm) \
tex(fbb-Bold-tlf-swash-t1.tfm) \
tex(fbb-Bold-tlf-swash-t1.vf) \
tex(fbb-Bold-tlf-t1--base.tfm) \
tex(fbb-Bold-tlf-t1.tfm) \
tex(fbb-Bold-tlf-t1.vf) \
tex(fbb-Bold-tlf-ts1--base.tfm) \
tex(fbb-Bold-tlf-ts1.tfm) \
tex(fbb-Bold-tlf-ts1.vf) \
tex(fbb-Bold-tosf-ly1--base.tfm) \
tex(fbb-Bold-tosf-ly1.tfm) \
tex(fbb-Bold-tosf-ly1.vf) \
tex(fbb-Bold-tosf-ot1.tfm) \
tex(fbb-Bold-tosf-sc-ly1--base.tfm) \
tex(fbb-Bold-tosf-sc-ly1.tfm) \
tex(fbb-Bold-tosf-sc-ly1.vf) \
tex(fbb-Bold-tosf-sc-ot1--base.tfm) \
tex(fbb-Bold-tosf-sc-ot1.tfm) \
tex(fbb-Bold-tosf-sc-ot1.vf) \
tex(fbb-Bold-tosf-sc-t1--base.tfm) \
tex(fbb-Bold-tosf-sc-t1.tfm) \
tex(fbb-Bold-tosf-sc-t1.vf) \
tex(fbb-Bold-tosf-swash-ly1--base.tfm) \
tex(fbb-Bold-tosf-swash-ly1.tfm) \
tex(fbb-Bold-tosf-swash-ly1.vf) \
tex(fbb-Bold-tosf-swash-ot1.tfm) \
tex(fbb-Bold-tosf-swash-t1--base.tfm) \
tex(fbb-Bold-tosf-swash-t1.tfm) \
tex(fbb-Bold-tosf-swash-t1.vf) \
tex(fbb-Bold-tosf-t1--base.tfm) \
tex(fbb-Bold-tosf-t1.tfm) \
tex(fbb-Bold-tosf-t1.vf) \
tex(fbb-Bold-tosf-ts1--base.tfm) \
tex(fbb-Bold-tosf-ts1.tfm) \
tex(fbb-Bold-tosf-ts1.vf) \
tex(fbb-BoldItalic-inf-ly1--base.tfm) \
tex(fbb-BoldItalic-inf-ly1.tfm) \
tex(fbb-BoldItalic-inf-ly1.vf) \
tex(fbb-BoldItalic-inf-ot1.tfm) \
tex(fbb-BoldItalic-inf-t1--base.tfm) \
tex(fbb-BoldItalic-inf-t1.tfm) \
tex(fbb-BoldItalic-inf-t1.vf) \
tex(fbb-BoldItalic-lf-ly1--base.tfm) \
tex(fbb-BoldItalic-lf-ly1.tfm) \
tex(fbb-BoldItalic-lf-ly1.vf) \
tex(fbb-BoldItalic-lf-ot1.tfm) \
tex(fbb-BoldItalic-lf-sc-ly1--base.tfm) \
tex(fbb-BoldItalic-lf-sc-ly1.tfm) \
tex(fbb-BoldItalic-lf-sc-ly1.vf) \
tex(fbb-BoldItalic-lf-sc-ot1--base.tfm) \
tex(fbb-BoldItalic-lf-sc-ot1.tfm) \
tex(fbb-BoldItalic-lf-sc-ot1.vf) \
tex(fbb-BoldItalic-lf-sc-t1--base.tfm) \
tex(fbb-BoldItalic-lf-sc-t1.tfm) \
tex(fbb-BoldItalic-lf-sc-t1.vf) \
tex(fbb-BoldItalic-lf-swash-ly1--base.tfm) \
tex(fbb-BoldItalic-lf-swash-ly1.tfm) \
tex(fbb-BoldItalic-lf-swash-ly1.vf) \
tex(fbb-BoldItalic-lf-swash-ot1.tfm) \
tex(fbb-BoldItalic-lf-swash-t1--base.tfm) \
tex(fbb-BoldItalic-lf-swash-t1.tfm) \
tex(fbb-BoldItalic-lf-swash-t1.vf) \
tex(fbb-BoldItalic-lf-t1--base.tfm) \
tex(fbb-BoldItalic-lf-t1.tfm) \
tex(fbb-BoldItalic-lf-t1.vf) \
tex(fbb-BoldItalic-lf-ts1--base.tfm) \
tex(fbb-BoldItalic-lf-ts1.tfm) \
tex(fbb-BoldItalic-lf-ts1.vf) \
tex(fbb-BoldItalic-osf-ly1--base.tfm) \
tex(fbb-BoldItalic-osf-ly1.tfm) \
tex(fbb-BoldItalic-osf-ly1.vf) \
tex(fbb-BoldItalic-osf-ot1.tfm) \
tex(fbb-BoldItalic-osf-sc-ly1--base.tfm) \
tex(fbb-BoldItalic-osf-sc-ly1.tfm) \
tex(fbb-BoldItalic-osf-sc-ly1.vf) \
tex(fbb-BoldItalic-osf-sc-ot1--base.tfm) \
tex(fbb-BoldItalic-osf-sc-ot1.tfm) \
tex(fbb-BoldItalic-osf-sc-ot1.vf) \
tex(fbb-BoldItalic-osf-sc-t1--base.tfm) \
tex(fbb-BoldItalic-osf-sc-t1.tfm) \
tex(fbb-BoldItalic-osf-sc-t1.vf) \
tex(fbb-BoldItalic-osf-swash-ly1--base.tfm) \
tex(fbb-BoldItalic-osf-swash-ly1.tfm) \
tex(fbb-BoldItalic-osf-swash-ly1.vf) \
tex(fbb-BoldItalic-osf-swash-ot1.tfm) \
tex(fbb-BoldItalic-osf-swash-t1--base.tfm) \
tex(fbb-BoldItalic-osf-swash-t1.tfm) \
tex(fbb-BoldItalic-osf-swash-t1.vf) \
tex(fbb-BoldItalic-osf-t1--base.tfm) \
tex(fbb-BoldItalic-osf-t1.tfm) \
tex(fbb-BoldItalic-osf-t1.vf) \
tex(fbb-BoldItalic-osf-ts1--base.tfm) \
tex(fbb-BoldItalic-osf-ts1.tfm) \
tex(fbb-BoldItalic-osf-ts1.vf) \
tex(fbb-BoldItalic-sup-ly1--base.tfm) \
tex(fbb-BoldItalic-sup-ly1.tfm) \
tex(fbb-BoldItalic-sup-ly1.vf) \
tex(fbb-BoldItalic-sup-ot1.tfm) \
tex(fbb-BoldItalic-sup-t1--base.tfm) \
tex(fbb-BoldItalic-sup-t1.tfm) \
tex(fbb-BoldItalic-sup-t1.vf) \
tex(fbb-BoldItalic-tlf-ly1--base.tfm) \
tex(fbb-BoldItalic-tlf-ly1.tfm) \
tex(fbb-BoldItalic-tlf-ly1.vf) \
tex(fbb-BoldItalic-tlf-ot1.tfm) \
tex(fbb-BoldItalic-tlf-sc-ly1--base.tfm) \
tex(fbb-BoldItalic-tlf-sc-ly1.tfm) \
tex(fbb-BoldItalic-tlf-sc-ly1.vf) \
tex(fbb-BoldItalic-tlf-sc-ot1--base.tfm) \
tex(fbb-BoldItalic-tlf-sc-ot1.tfm) \
tex(fbb-BoldItalic-tlf-sc-ot1.vf) \
tex(fbb-BoldItalic-tlf-sc-t1--base.tfm) \
tex(fbb-BoldItalic-tlf-sc-t1.tfm) \
tex(fbb-BoldItalic-tlf-sc-t1.vf) \
tex(fbb-BoldItalic-tlf-swash-ly1--base.tfm) \
tex(fbb-BoldItalic-tlf-swash-ly1.tfm) \
tex(fbb-BoldItalic-tlf-swash-ly1.vf) \
tex(fbb-BoldItalic-tlf-swash-ot1.tfm) \
tex(fbb-BoldItalic-tlf-swash-t1--base.tfm) \
tex(fbb-BoldItalic-tlf-swash-t1.tfm) \
tex(fbb-BoldItalic-tlf-swash-t1.vf) \
tex(fbb-BoldItalic-tlf-t1--base.tfm) \
tex(fbb-BoldItalic-tlf-t1.tfm) \
tex(fbb-BoldItalic-tlf-t1.vf) \
tex(fbb-BoldItalic-tlf-ts1--base.tfm) \
tex(fbb-BoldItalic-tlf-ts1.tfm) \
tex(fbb-BoldItalic-tlf-ts1.vf) \
tex(fbb-BoldItalic-tosf-ly1--base.tfm) \
tex(fbb-BoldItalic-tosf-ly1.tfm) \
tex(fbb-BoldItalic-tosf-ly1.vf) \
tex(fbb-BoldItalic-tosf-ot1.tfm) \
tex(fbb-BoldItalic-tosf-sc-ly1--base.tfm) \
tex(fbb-BoldItalic-tosf-sc-ly1.tfm) \
tex(fbb-BoldItalic-tosf-sc-ly1.vf) \
tex(fbb-BoldItalic-tosf-sc-ot1--base.tfm) \
tex(fbb-BoldItalic-tosf-sc-ot1.tfm) \
tex(fbb-BoldItalic-tosf-sc-ot1.vf) \
tex(fbb-BoldItalic-tosf-sc-t1--base.tfm) \
tex(fbb-BoldItalic-tosf-sc-t1.tfm) \
tex(fbb-BoldItalic-tosf-sc-t1.vf) \
tex(fbb-BoldItalic-tosf-swash-ly1--base.tfm) \
tex(fbb-BoldItalic-tosf-swash-ly1.tfm) \
tex(fbb-BoldItalic-tosf-swash-ly1.vf) \
tex(fbb-BoldItalic-tosf-swash-ot1.tfm) \
tex(fbb-BoldItalic-tosf-swash-t1--base.tfm) \
tex(fbb-BoldItalic-tosf-swash-t1.tfm) \
tex(fbb-BoldItalic-tosf-swash-t1.vf) \
tex(fbb-BoldItalic-tosf-t1--base.tfm) \
tex(fbb-BoldItalic-tosf-t1.tfm) \
tex(fbb-BoldItalic-tosf-t1.vf) \
tex(fbb-BoldItalic-tosf-ts1--base.tfm) \
tex(fbb-BoldItalic-tosf-ts1.tfm) \
tex(fbb-BoldItalic-tosf-ts1.vf) \
tex(fbb-Italic-inf-ly1--base.tfm) \
tex(fbb-Italic-inf-ly1.tfm) \
tex(fbb-Italic-inf-ly1.vf) \
tex(fbb-Italic-inf-ot1.tfm) \
tex(fbb-Italic-inf-t1--base.tfm) \
tex(fbb-Italic-inf-t1.tfm) \
tex(fbb-Italic-inf-t1.vf) \
tex(fbb-Italic-lf-ly1--base.tfm) \
tex(fbb-Italic-lf-ly1.tfm) \
tex(fbb-Italic-lf-ly1.vf) \
tex(fbb-Italic-lf-ot1.tfm) \
tex(fbb-Italic-lf-sc-ly1--base.tfm) \
tex(fbb-Italic-lf-sc-ly1.tfm) \
tex(fbb-Italic-lf-sc-ly1.vf) \
tex(fbb-Italic-lf-sc-ot1--base.tfm) \
tex(fbb-Italic-lf-sc-ot1.tfm) \
tex(fbb-Italic-lf-sc-ot1.vf) \
tex(fbb-Italic-lf-sc-t1--base.tfm) \
tex(fbb-Italic-lf-sc-t1.tfm) \
tex(fbb-Italic-lf-sc-t1.vf) \
tex(fbb-Italic-lf-swash-ly1--base.tfm) \
tex(fbb-Italic-lf-swash-ly1.tfm) \
tex(fbb-Italic-lf-swash-ly1.vf) \
tex(fbb-Italic-lf-swash-ot1.tfm) \
tex(fbb-Italic-lf-swash-t1--base.tfm) \
tex(fbb-Italic-lf-swash-t1.tfm) \
tex(fbb-Italic-lf-swash-t1.vf) \
tex(fbb-Italic-lf-t1--base.tfm) \
tex(fbb-Italic-lf-t1.tfm) \
tex(fbb-Italic-lf-t1.vf) \
tex(fbb-Italic-lf-ts1--base.tfm) \
tex(fbb-Italic-lf-ts1.tfm) \
tex(fbb-Italic-lf-ts1.vf) \
tex(fbb-Italic-osf-ly1--base.tfm) \
tex(fbb-Italic-osf-ly1.tfm) \
tex(fbb-Italic-osf-ly1.vf) \
tex(fbb-Italic-osf-ot1.tfm) \
tex(fbb-Italic-osf-sc-ly1--base.tfm) \
tex(fbb-Italic-osf-sc-ly1.tfm) \
tex(fbb-Italic-osf-sc-ly1.vf) \
tex(fbb-Italic-osf-sc-ot1--base.tfm) \
tex(fbb-Italic-osf-sc-ot1.tfm) \
tex(fbb-Italic-osf-sc-ot1.vf) \
tex(fbb-Italic-osf-sc-t1--base.tfm) \
tex(fbb-Italic-osf-sc-t1.tfm) \
tex(fbb-Italic-osf-sc-t1.vf) \
tex(fbb-Italic-osf-swash-ly1--base.tfm) \
tex(fbb-Italic-osf-swash-ly1.tfm) \
tex(fbb-Italic-osf-swash-ly1.vf) \
tex(fbb-Italic-osf-swash-ot1.tfm) \
tex(fbb-Italic-osf-swash-t1--base.tfm) \
tex(fbb-Italic-osf-swash-t1.tfm) \
tex(fbb-Italic-osf-swash-t1.vf) \
tex(fbb-Italic-osf-t1--base.tfm) \
tex(fbb-Italic-osf-t1.tfm) \
tex(fbb-Italic-osf-t1.vf) \
tex(fbb-Italic-osf-ts1--base.tfm) \
tex(fbb-Italic-osf-ts1.tfm) \
tex(fbb-Italic-osf-ts1.vf) \
tex(fbb-Italic-sup-ly1--base.tfm) \
tex(fbb-Italic-sup-ly1.tfm) \
tex(fbb-Italic-sup-ly1.vf) \
tex(fbb-Italic-sup-ot1.tfm) \
tex(fbb-Italic-sup-t1--base.tfm) \
tex(fbb-Italic-sup-t1.tfm) \
tex(fbb-Italic-sup-t1.vf) \
tex(fbb-Italic-tlf-ly1--base.tfm) \
tex(fbb-Italic-tlf-ly1.tfm) \
tex(fbb-Italic-tlf-ly1.vf) \
tex(fbb-Italic-tlf-ot1.tfm) \
tex(fbb-Italic-tlf-sc-ly1--base.tfm) \
tex(fbb-Italic-tlf-sc-ly1.tfm) \
tex(fbb-Italic-tlf-sc-ly1.vf) \
tex(fbb-Italic-tlf-sc-ot1--base.tfm) \
tex(fbb-Italic-tlf-sc-ot1.tfm) \
tex(fbb-Italic-tlf-sc-ot1.vf) \
tex(fbb-Italic-tlf-sc-t1--base.tfm) \
tex(fbb-Italic-tlf-sc-t1.tfm) \
tex(fbb-Italic-tlf-sc-t1.vf) \
tex(fbb-Italic-tlf-swash-ly1--base.tfm) \
tex(fbb-Italic-tlf-swash-ly1.tfm) \
tex(fbb-Italic-tlf-swash-ly1.vf) \
tex(fbb-Italic-tlf-swash-ot1.tfm) \
tex(fbb-Italic-tlf-swash-t1--base.tfm) \
tex(fbb-Italic-tlf-swash-t1.tfm) \
tex(fbb-Italic-tlf-swash-t1.vf) \
tex(fbb-Italic-tlf-t1--base.tfm) \
tex(fbb-Italic-tlf-t1.tfm) \
tex(fbb-Italic-tlf-t1.vf) \
tex(fbb-Italic-tlf-ts1--base.tfm) \
tex(fbb-Italic-tlf-ts1.tfm) \
tex(fbb-Italic-tlf-ts1.vf) \
tex(fbb-Italic-tosf-ly1--base.tfm) \
tex(fbb-Italic-tosf-ly1.tfm) \
tex(fbb-Italic-tosf-ly1.vf) \
tex(fbb-Italic-tosf-ot1.tfm) \
tex(fbb-Italic-tosf-sc-ly1--base.tfm) \
tex(fbb-Italic-tosf-sc-ly1.tfm) \
tex(fbb-Italic-tosf-sc-ly1.vf) \
tex(fbb-Italic-tosf-sc-ot1--base.tfm) \
tex(fbb-Italic-tosf-sc-ot1.tfm) \
tex(fbb-Italic-tosf-sc-ot1.vf) \
tex(fbb-Italic-tosf-sc-t1--base.tfm) \
tex(fbb-Italic-tosf-sc-t1.tfm) \
tex(fbb-Italic-tosf-sc-t1.vf) \
tex(fbb-Italic-tosf-swash-ly1--base.tfm) \
tex(fbb-Italic-tosf-swash-ly1.tfm) \
tex(fbb-Italic-tosf-swash-ly1.vf) \
tex(fbb-Italic-tosf-swash-ot1.tfm) \
tex(fbb-Italic-tosf-swash-t1--base.tfm) \
tex(fbb-Italic-tosf-swash-t1.tfm) \
tex(fbb-Italic-tosf-swash-t1.vf) \
tex(fbb-Italic-tosf-t1--base.tfm) \
tex(fbb-Italic-tosf-t1.tfm) \
tex(fbb-Italic-tosf-t1.vf) \
tex(fbb-Italic-tosf-ts1--base.tfm) \
tex(fbb-Italic-tosf-ts1.tfm) \
tex(fbb-Italic-tosf-ts1.vf) \
tex(fbb-Regular-inf-ly1--base.tfm) \
tex(fbb-Regular-inf-ly1.tfm) \
tex(fbb-Regular-inf-ly1.vf) \
tex(fbb-Regular-inf-ot1.tfm) \
tex(fbb-Regular-inf-t1--base.tfm) \
tex(fbb-Regular-inf-t1.tfm) \
tex(fbb-Regular-inf-t1.vf) \
tex(fbb-Regular-lf-ly1--base.tfm) \
tex(fbb-Regular-lf-ly1.tfm) \
tex(fbb-Regular-lf-ly1.vf) \
tex(fbb-Regular-lf-ot1.tfm) \
tex(fbb-Regular-lf-sc-ly1--base.tfm) \
tex(fbb-Regular-lf-sc-ly1.tfm) \
tex(fbb-Regular-lf-sc-ly1.vf) \
tex(fbb-Regular-lf-sc-ot1--base.tfm) \
tex(fbb-Regular-lf-sc-ot1.tfm) \
tex(fbb-Regular-lf-sc-ot1.vf) \
tex(fbb-Regular-lf-sc-t1--base.tfm) \
tex(fbb-Regular-lf-sc-t1.tfm) \
tex(fbb-Regular-lf-sc-t1.vf) \
tex(fbb-Regular-lf-swash-ly1--base.tfm) \
tex(fbb-Regular-lf-swash-ly1.tfm) \
tex(fbb-Regular-lf-swash-ly1.vf) \
tex(fbb-Regular-lf-swash-ot1.tfm) \
tex(fbb-Regular-lf-swash-t1--base.tfm) \
tex(fbb-Regular-lf-swash-t1.tfm) \
tex(fbb-Regular-lf-swash-t1.vf) \
tex(fbb-Regular-lf-t1--base.tfm) \
tex(fbb-Regular-lf-t1.tfm) \
tex(fbb-Regular-lf-t1.vf) \
tex(fbb-Regular-lf-ts1--base.tfm) \
tex(fbb-Regular-lf-ts1.tfm) \
tex(fbb-Regular-lf-ts1.vf) \
tex(fbb-Regular-osf-ly1--base.tfm) \
tex(fbb-Regular-osf-ly1.tfm) \
tex(fbb-Regular-osf-ly1.vf) \
tex(fbb-Regular-osf-ot1.tfm) \
tex(fbb-Regular-osf-sc-ly1--base.tfm) \
tex(fbb-Regular-osf-sc-ly1.tfm) \
tex(fbb-Regular-osf-sc-ly1.vf) \
tex(fbb-Regular-osf-sc-ot1--base.tfm) \
tex(fbb-Regular-osf-sc-ot1.tfm) \
tex(fbb-Regular-osf-sc-ot1.vf) \
tex(fbb-Regular-osf-sc-t1--base.tfm) \
tex(fbb-Regular-osf-sc-t1.tfm) \
tex(fbb-Regular-osf-sc-t1.vf) \
tex(fbb-Regular-osf-swash-ly1--base.tfm) \
tex(fbb-Regular-osf-swash-ly1.tfm) \
tex(fbb-Regular-osf-swash-ly1.vf) \
tex(fbb-Regular-osf-swash-ot1.tfm) \
tex(fbb-Regular-osf-swash-t1--base.tfm) \
tex(fbb-Regular-osf-swash-t1.tfm) \
tex(fbb-Regular-osf-swash-t1.vf) \
tex(fbb-Regular-osf-t1--base.tfm) \
tex(fbb-Regular-osf-t1.tfm) \
tex(fbb-Regular-osf-t1.vf) \
tex(fbb-Regular-osf-ts1--base.tfm) \
tex(fbb-Regular-osf-ts1.tfm) \
tex(fbb-Regular-osf-ts1.vf) \
tex(fbb-Regular-sup-ly1--base.tfm) \
tex(fbb-Regular-sup-ly1.tfm) \
tex(fbb-Regular-sup-ly1.vf) \
tex(fbb-Regular-sup-ot1.tfm) \
tex(fbb-Regular-sup-t1--base.tfm) \
tex(fbb-Regular-sup-t1.tfm) \
tex(fbb-Regular-sup-t1.vf) \
tex(fbb-Regular-tlf-ly1--base.tfm) \
tex(fbb-Regular-tlf-ly1.tfm) \
tex(fbb-Regular-tlf-ly1.vf) \
tex(fbb-Regular-tlf-ot1.tfm) \
tex(fbb-Regular-tlf-sc-ly1--base.tfm) \
tex(fbb-Regular-tlf-sc-ly1.tfm) \
tex(fbb-Regular-tlf-sc-ly1.vf) \
tex(fbb-Regular-tlf-sc-ot1--base.tfm) \
tex(fbb-Regular-tlf-sc-ot1.tfm) \
tex(fbb-Regular-tlf-sc-ot1.vf) \
tex(fbb-Regular-tlf-sc-t1--base.tfm) \
tex(fbb-Regular-tlf-sc-t1.tfm) \
tex(fbb-Regular-tlf-sc-t1.vf) \
tex(fbb-Regular-tlf-swash-ly1--base.tfm) \
tex(fbb-Regular-tlf-swash-ly1.tfm) \
tex(fbb-Regular-tlf-swash-ly1.vf) \
tex(fbb-Regular-tlf-swash-ot1.tfm) \
tex(fbb-Regular-tlf-swash-t1--base.tfm) \
tex(fbb-Regular-tlf-swash-t1.tfm) \
tex(fbb-Regular-tlf-swash-t1.vf) \
tex(fbb-Regular-tlf-t1--base.tfm) \
tex(fbb-Regular-tlf-t1.tfm) \
tex(fbb-Regular-tlf-t1.vf) \
tex(fbb-Regular-tlf-ts1--base.tfm) \
tex(fbb-Regular-tlf-ts1.tfm) \
tex(fbb-Regular-tlf-ts1.vf) \
tex(fbb-Regular-tosf-ly1--base.tfm) \
tex(fbb-Regular-tosf-ly1.tfm) \
tex(fbb-Regular-tosf-ly1.vf) \
tex(fbb-Regular-tosf-ot1.tfm) \
tex(fbb-Regular-tosf-sc-ly1--base.tfm) \
tex(fbb-Regular-tosf-sc-ly1.tfm) \
tex(fbb-Regular-tosf-sc-ly1.vf) \
tex(fbb-Regular-tosf-sc-ot1--base.tfm) \
tex(fbb-Regular-tosf-sc-ot1.tfm) \
tex(fbb-Regular-tosf-sc-ot1.vf) \
tex(fbb-Regular-tosf-sc-t1--base.tfm) \
tex(fbb-Regular-tosf-sc-t1.tfm) \
tex(fbb-Regular-tosf-sc-t1.vf) \
tex(fbb-Regular-tosf-swash-ly1--base.tfm) \
tex(fbb-Regular-tosf-swash-ly1.tfm) \
tex(fbb-Regular-tosf-swash-ly1.vf) \
tex(fbb-Regular-tosf-swash-ot1.tfm) \
tex(fbb-Regular-tosf-swash-t1--base.tfm) \
tex(fbb-Regular-tosf-swash-t1.tfm) \
tex(fbb-Regular-tosf-swash-t1.vf) \
tex(fbb-Regular-tosf-t1--base.tfm) \
tex(fbb-Regular-tosf-t1.tfm) \
tex(fbb-Regular-tosf-t1.vf) \
tex(fbb-Regular-tosf-ts1--base.tfm) \
tex(fbb-Regular-tosf-ts1.tfm) \
tex(fbb-Regular-tosf-ts1.vf) \
tex(fbb.map) \
tex(fbb.sty) \
tex(fbbP-Bold-lf-ly1--base.tfm) \
tex(fbbP-Bold-lf-ly1.tfm) \
tex(fbbP-Bold-lf-ly1.vf) \
tex(fbbP-Bold-lf-ot1.tfm) \
tex(fbbP-Bold-lf-ot1.vf) \
tex(fbbP-Bold-lf-sc-ly1--base.tfm) \
tex(fbbP-Bold-lf-sc-ly1.tfm) \
tex(fbbP-Bold-lf-sc-ly1.vf) \
tex(fbbP-Bold-lf-sc-ot1--base.tfm) \
tex(fbbP-Bold-lf-sc-ot1.tfm) \
tex(fbbP-Bold-lf-sc-ot1.vf) \
tex(fbbP-Bold-lf-sc-t1--base.tfm) \
tex(fbbP-Bold-lf-sc-t1.tfm) \
tex(fbbP-Bold-lf-sc-t1.vf) \
tex(fbbP-Bold-lf-swash-ly1--base.tfm) \
tex(fbbP-Bold-lf-swash-ly1.tfm) \
tex(fbbP-Bold-lf-swash-ly1.vf) \
tex(fbbP-Bold-lf-swash-ot1.tfm) \
tex(fbbP-Bold-lf-swash-ot1.vf) \
tex(fbbP-Bold-lf-swash-t1--base.tfm) \
tex(fbbP-Bold-lf-swash-t1.tfm) \
tex(fbbP-Bold-lf-swash-t1.vf) \
tex(fbbP-Bold-lf-t1--base.tfm) \
tex(fbbP-Bold-lf-t1.tfm) \
tex(fbbP-Bold-lf-t1.vf) \
tex(fbbP-Bold-osf-ly1--base.tfm) \
tex(fbbP-Bold-osf-ly1.tfm) \
tex(fbbP-Bold-osf-ly1.vf) \
tex(fbbP-Bold-osf-ot1.tfm) \
tex(fbbP-Bold-osf-ot1.vf) \
tex(fbbP-Bold-osf-sc-ly1--base.tfm) \
tex(fbbP-Bold-osf-sc-ly1.tfm) \
tex(fbbP-Bold-osf-sc-ly1.vf) \
tex(fbbP-Bold-osf-sc-ot1--base.tfm) \
tex(fbbP-Bold-osf-sc-ot1.tfm) \
tex(fbbP-Bold-osf-sc-ot1.vf) \
tex(fbbP-Bold-osf-sc-t1--base.tfm) \
tex(fbbP-Bold-osf-sc-t1.tfm) \
tex(fbbP-Bold-osf-sc-t1.vf) \
tex(fbbP-Bold-osf-swash-ly1--base.tfm) \
tex(fbbP-Bold-osf-swash-ly1.tfm) \
tex(fbbP-Bold-osf-swash-ly1.vf) \
tex(fbbP-Bold-osf-swash-ot1.tfm) \
tex(fbbP-Bold-osf-swash-ot1.vf) \
tex(fbbP-Bold-osf-swash-t1--base.tfm) \
tex(fbbP-Bold-osf-swash-t1.tfm) \
tex(fbbP-Bold-osf-swash-t1.vf) \
tex(fbbP-Bold-osf-t1--base.tfm) \
tex(fbbP-Bold-osf-t1.tfm) \
tex(fbbP-Bold-osf-t1.vf) \
tex(fbbP-Bold-tlf-ly1--base.tfm) \
tex(fbbP-Bold-tlf-ly1.tfm) \
tex(fbbP-Bold-tlf-ly1.vf) \
tex(fbbP-Bold-tlf-ot1.tfm) \
tex(fbbP-Bold-tlf-ot1.vf) \
tex(fbbP-Bold-tlf-sc-ly1--base.tfm) \
tex(fbbP-Bold-tlf-sc-ly1.tfm) \
tex(fbbP-Bold-tlf-sc-ly1.vf) \
tex(fbbP-Bold-tlf-sc-ot1--base.tfm) \
tex(fbbP-Bold-tlf-sc-ot1.tfm) \
tex(fbbP-Bold-tlf-sc-ot1.vf) \
tex(fbbP-Bold-tlf-sc-t1--base.tfm) \
tex(fbbP-Bold-tlf-sc-t1.tfm) \
tex(fbbP-Bold-tlf-sc-t1.vf) \
tex(fbbP-Bold-tlf-swash-ly1--base.tfm) \
tex(fbbP-Bold-tlf-swash-ly1.tfm) \
tex(fbbP-Bold-tlf-swash-ly1.vf) \
tex(fbbP-Bold-tlf-swash-ot1.tfm) \
tex(fbbP-Bold-tlf-swash-ot1.vf) \
tex(fbbP-Bold-tlf-swash-t1--base.tfm) \
tex(fbbP-Bold-tlf-swash-t1.tfm) \
tex(fbbP-Bold-tlf-swash-t1.vf) \
tex(fbbP-Bold-tlf-t1--base.tfm) \
tex(fbbP-Bold-tlf-t1.tfm) \
tex(fbbP-Bold-tlf-t1.vf) \
tex(fbbP-Bold-tosf-ly1--base.tfm) \
tex(fbbP-Bold-tosf-ly1.tfm) \
tex(fbbP-Bold-tosf-ly1.vf) \
tex(fbbP-Bold-tosf-ot1.tfm) \
tex(fbbP-Bold-tosf-ot1.vf) \
tex(fbbP-Bold-tosf-sc-ly1--base.tfm) \
tex(fbbP-Bold-tosf-sc-ly1.tfm) \
tex(fbbP-Bold-tosf-sc-ly1.vf) \
tex(fbbP-Bold-tosf-sc-ot1--base.tfm) \
tex(fbbP-Bold-tosf-sc-ot1.tfm) \
tex(fbbP-Bold-tosf-sc-ot1.vf) \
tex(fbbP-Bold-tosf-sc-t1--base.tfm) \
tex(fbbP-Bold-tosf-sc-t1.tfm) \
tex(fbbP-Bold-tosf-sc-t1.vf) \
tex(fbbP-Bold-tosf-swash-ly1--base.tfm) \
tex(fbbP-Bold-tosf-swash-ly1.tfm) \
tex(fbbP-Bold-tosf-swash-ly1.vf) \
tex(fbbP-Bold-tosf-swash-ot1.tfm) \
tex(fbbP-Bold-tosf-swash-ot1.vf) \
tex(fbbP-Bold-tosf-swash-t1--base.tfm) \
tex(fbbP-Bold-tosf-swash-t1.tfm) \
tex(fbbP-Bold-tosf-swash-t1.vf) \
tex(fbbP-Bold-tosf-t1--base.tfm) \
tex(fbbP-Bold-tosf-t1.tfm) \
tex(fbbP-Bold-tosf-t1.vf) \
tex(fbbP-Regular-lf-ly1--base.tfm) \
tex(fbbP-Regular-lf-ly1.tfm) \
tex(fbbP-Regular-lf-ly1.vf) \
tex(fbbP-Regular-lf-ot1.tfm) \
tex(fbbP-Regular-lf-ot1.vf) \
tex(fbbP-Regular-lf-sc-ly1--base.tfm) \
tex(fbbP-Regular-lf-sc-ly1.tfm) \
tex(fbbP-Regular-lf-sc-ly1.vf) \
tex(fbbP-Regular-lf-sc-ot1--base.tfm) \
tex(fbbP-Regular-lf-sc-ot1.tfm) \
tex(fbbP-Regular-lf-sc-ot1.vf) \
tex(fbbP-Regular-lf-sc-t1--base.tfm) \
tex(fbbP-Regular-lf-sc-t1.tfm) \
tex(fbbP-Regular-lf-sc-t1.vf) \
tex(fbbP-Regular-lf-swash-ly1--base.tfm) \
tex(fbbP-Regular-lf-swash-ly1.tfm) \
tex(fbbP-Regular-lf-swash-ly1.vf) \
tex(fbbP-Regular-lf-swash-ot1.tfm) \
tex(fbbP-Regular-lf-swash-ot1.vf) \
tex(fbbP-Regular-lf-swash-t1--base.tfm) \
tex(fbbP-Regular-lf-swash-t1.tfm) \
tex(fbbP-Regular-lf-swash-t1.vf) \
tex(fbbP-Regular-lf-t1--base.tfm) \
tex(fbbP-Regular-lf-t1.tfm) \
tex(fbbP-Regular-lf-t1.vf) \
tex(fbbP-Regular-osf-ly1--base.tfm) \
tex(fbbP-Regular-osf-ly1.tfm) \
tex(fbbP-Regular-osf-ly1.vf) \
tex(fbbP-Regular-osf-ot1.tfm) \
tex(fbbP-Regular-osf-ot1.vf) \
tex(fbbP-Regular-osf-sc-ly1--base.tfm) \
tex(fbbP-Regular-osf-sc-ly1.tfm) \
tex(fbbP-Regular-osf-sc-ly1.vf) \
tex(fbbP-Regular-osf-sc-ot1--base.tfm) \
tex(fbbP-Regular-osf-sc-ot1.tfm) \
tex(fbbP-Regular-osf-sc-ot1.vf) \
tex(fbbP-Regular-osf-sc-t1--base.tfm) \
tex(fbbP-Regular-osf-sc-t1.tfm) \
tex(fbbP-Regular-osf-sc-t1.vf) \
tex(fbbP-Regular-osf-swash-ly1--base.tfm) \
tex(fbbP-Regular-osf-swash-ly1.tfm) \
tex(fbbP-Regular-osf-swash-ly1.vf) \
tex(fbbP-Regular-osf-swash-ot1.tfm) \
tex(fbbP-Regular-osf-swash-ot1.vf) \
tex(fbbP-Regular-osf-swash-t1--base.tfm) \
tex(fbbP-Regular-osf-swash-t1.tfm) \
tex(fbbP-Regular-osf-swash-t1.vf) \
tex(fbbP-Regular-osf-t1--base.tfm) \
tex(fbbP-Regular-osf-t1.tfm) \
tex(fbbP-Regular-osf-t1.vf) \
tex(fbbP-Regular-tlf-ly1--base.tfm) \
tex(fbbP-Regular-tlf-ly1.tfm) \
tex(fbbP-Regular-tlf-ly1.vf) \
tex(fbbP-Regular-tlf-ot1.tfm) \
tex(fbbP-Regular-tlf-ot1.vf) \
tex(fbbP-Regular-tlf-sc-ly1--base.tfm) \
tex(fbbP-Regular-tlf-sc-ly1.tfm) \
tex(fbbP-Regular-tlf-sc-ly1.vf) \
tex(fbbP-Regular-tlf-sc-ot1--base.tfm) \
tex(fbbP-Regular-tlf-sc-ot1.tfm) \
tex(fbbP-Regular-tlf-sc-ot1.vf) \
tex(fbbP-Regular-tlf-sc-t1--base.tfm) \
tex(fbbP-Regular-tlf-sc-t1.tfm) \
tex(fbbP-Regular-tlf-sc-t1.vf) \
tex(fbbP-Regular-tlf-swash-ly1--base.tfm) \
tex(fbbP-Regular-tlf-swash-ly1.tfm) \
tex(fbbP-Regular-tlf-swash-ly1.vf) \
tex(fbbP-Regular-tlf-swash-ot1.tfm) \
tex(fbbP-Regular-tlf-swash-ot1.vf) \
tex(fbbP-Regular-tlf-swash-t1--base.tfm) \
tex(fbbP-Regular-tlf-swash-t1.tfm) \
tex(fbbP-Regular-tlf-swash-t1.vf) \
tex(fbbP-Regular-tlf-t1--base.tfm) \
tex(fbbP-Regular-tlf-t1.tfm) \
tex(fbbP-Regular-tlf-t1.vf) \
tex(fbbP-Regular-tosf-ly1--base.tfm) \
tex(fbbP-Regular-tosf-ly1.tfm) \
tex(fbbP-Regular-tosf-ly1.vf) \
tex(fbbP-Regular-tosf-ot1.tfm) \
tex(fbbP-Regular-tosf-ot1.vf) \
tex(fbbP-Regular-tosf-sc-ly1--base.tfm) \
tex(fbbP-Regular-tosf-sc-ly1.tfm) \
tex(fbbP-Regular-tosf-sc-ly1.vf) \
tex(fbbP-Regular-tosf-sc-ot1--base.tfm) \
tex(fbbP-Regular-tosf-sc-ot1.tfm) \
tex(fbbP-Regular-tosf-sc-ot1.vf) \
tex(fbbP-Regular-tosf-sc-t1--base.tfm) \
tex(fbbP-Regular-tosf-sc-t1.tfm) \
tex(fbbP-Regular-tosf-sc-t1.vf) \
tex(fbbP-Regular-tosf-swash-ly1--base.tfm) \
tex(fbbP-Regular-tosf-swash-ly1.tfm) \
tex(fbbP-Regular-tosf-swash-ly1.vf) \
tex(fbbP-Regular-tosf-swash-ot1.tfm) \
tex(fbbP-Regular-tosf-swash-ot1.vf) \
tex(fbbP-Regular-tosf-swash-t1--base.tfm) \
tex(fbbP-Regular-tosf-swash-t1.tfm) \
tex(fbbP-Regular-tosf-swash-t1.vf) \
tex(fbbP-Regular-tosf-t1--base.tfm) \
tex(fbbP-Regular-tosf-t1.tfm) \
tex(fbbP-Regular-tosf-t1.vf) \
tex(fbbP_24put5.enc) \
tex(fbbP_2igduj.enc) \
tex(fbbP_2jnzza.enc) \
tex(fbbP_3duhfc.enc) \
tex(fbbP_3zscfd.enc) \
tex(fbbP_4mw2rr.enc) \
tex(fbbP_4wcgh5.enc) \
tex(fbbP_4zjlsx.enc) \
tex(fbbP_62speq.enc) \
tex(fbbP_6kt7zw.enc) \
tex(fbbP_6poto5.enc) \
tex(fbbP_6vkgd4.enc) \
tex(fbbP_6x3k7a.enc) \
tex(fbbP_73u7o6.enc) \
tex(fbbP_7uozom.enc) \
tex(fbbP_7zfhk4.enc) \
tex(fbbP_ba3tof.enc) \
tex(fbbP_bjh4if.enc) \
tex(fbbP_enzkw5.enc) \
tex(fbbP_f32ejw.enc) \
tex(fbbP_f7memx.enc) \
tex(fbbP_fmbb57.enc) \
tex(fbbP_ivhnor.enc) \
tex(fbbP_k3h4c5.enc) \
tex(fbbP_kc7qho.enc) \
tex(fbbP_lpkr6b.enc) \
tex(fbbP_mbwkti.enc) \
tex(fbbP_naynxa.enc) \
tex(fbbP_ned4xv.enc) \
tex(fbbP_nrlzkf.enc) \
tex(fbbP_oiqgfb.enc) \
tex(fbbP_orcs6b.enc) \
tex(fbbP_qfprdo.enc) \
tex(fbbP_qznuv4.enc) \
tex(fbbP_rkdrjp.enc) \
tex(fbbP_tu2qnw.enc) \
tex(fbbP_ub5jdu.enc) \
tex(fbbP_ulsnvv.enc) \
tex(fbbP_uscd66.enc) \
tex(fbbP_v6tazz.enc) \
tex(fbbP_vo3hij.enc) \
tex(fbbP_wblpum.enc) \
tex(fbbP_x5klbo.enc) \
tex(fbbP_xctm5z.enc) \
tex(fbbP_xp6hp3.enc) \
tex(fbbP_xyrmbw.enc) \
tex(fbbP_y2ahej.enc) \
tex(fbbP_yragzx.enc) \
tex(fbb_24fmi7.enc) \
tex(fbb_24put5.enc) \
tex(fbb_2b4mld.enc) \
tex(fbb_2igduj.enc) \
tex(fbb_2jnzza.enc) \
tex(fbb_2op7s3.enc) \
tex(fbb_2xprkz.enc) \
tex(fbb_3cnzgn.enc) \
tex(fbb_3duhfc.enc) \
tex(fbb_3gn25k.enc) \
tex(fbb_3xwxat.enc) \
tex(fbb_3zscfd.enc) \
tex(fbb_4ejvjt.enc) \
tex(fbb_4mw2rr.enc) \
tex(fbb_4qmemg.enc) \
tex(fbb_4qxxhr.enc) \
tex(fbb_4wcgh5.enc) \
tex(fbb_4zjlsx.enc) \
tex(fbb_54lzpc.enc) \
tex(fbb_62speq.enc) \
tex(fbb_6kt7zw.enc) \
tex(fbb_6poto5.enc) \
tex(fbb_6vkgd4.enc) \
tex(fbb_6x3k7a.enc) \
tex(fbb_6xtdz5.enc) \
tex(fbb_73u7o6.enc) \
tex(fbb_7uozom.enc) \
tex(fbb_7zfhk4.enc) \
tex(fbb_aeezmr.enc) \
tex(fbb_alifw3.enc) \
tex(fbb_anjsak.enc) \
tex(fbb_b4m333.enc) \
tex(fbb_ba3tof.enc) \
tex(fbb_bjh4if.enc) \
tex(fbb_bus4he.enc) \
tex(fbb_cocscg.enc) \
tex(fbb_dejuay.enc) \
tex(fbb_dvpyqt.enc) \
tex(fbb_dz2n6o.enc) \
tex(fbb_enzkw5.enc) \
tex(fbb_f32ejw.enc) \
tex(fbb_f7memx.enc) \
tex(fbb_fmbb57.enc) \
tex(fbb_fq2tsq.enc) \
tex(fbb_g53n3i.enc) \
tex(fbb_gebqxj.enc) \
tex(fbb_go7ogc.enc) \
tex(fbb_gspevp.enc) \
tex(fbb_hcrfa2.enc) \
tex(fbb_i5idwu.enc) \
tex(fbb_ihegxb.enc) \
tex(fbb_ivhnor.enc) \
tex(fbb_iygvdi.enc) \
tex(fbb_j5xf4u.enc) \
tex(fbb_jc4ywh.enc) \
tex(fbb_jssv6r.enc) \
tex(fbb_k3h4c5.enc) \
tex(fbb_kc7qho.enc) \
tex(fbb_l27jix.enc) \
tex(fbb_lbjzwe.enc) \
tex(fbb_lpkr6b.enc) \
tex(fbb_lulz6h.enc) \
tex(fbb_m5ynvh.enc) \
tex(fbb_m7ioki.enc) \
tex(fbb_mbwkti.enc) \
tex(fbb_mlvt4q.enc) \
tex(fbb_mpf4qq.enc) \
tex(fbb_naynxa.enc) \
tex(fbb_nc4uw4.enc) \
tex(fbb_nc5i6g.enc) \
tex(fbb_ned4xv.enc) \
tex(fbb_nrlzkf.enc) \
tex(fbb_o52cyd.enc) \
tex(fbb_oiqgfb.enc) \
tex(fbb_orcs6b.enc) \
tex(fbb_p5akwa.enc) \
tex(fbb_pwpiae.enc) \
tex(fbb_qfprdo.enc) \
tex(fbb_qznuv4.enc) \
tex(fbb_rdlb6f.enc) \
tex(fbb_rkdrjp.enc) \
tex(fbb_s5g7rn.enc) \
tex(fbb_tonehg.enc) \
tex(fbb_tu2qnw.enc) \
tex(fbb_ub5jdu.enc) \
tex(fbb_ulsnvv.enc) \
tex(fbb_uscd66.enc) \
tex(fbb_v6tazz.enc) \
tex(fbb_vk4up5.enc) \
tex(fbb_vo3hij.enc) \
tex(fbb_wblpum.enc) \
tex(fbb_wdb4p7.enc) \
tex(fbb_x5klbo.enc) \
tex(fbb_xctm5z.enc) \
tex(fbb_xp6hp3.enc) \
tex(fbb_xyrmbw.enc) \
tex(fbb_y2ahej.enc) \
tex(fbb_yragzx.enc) \
tex(fbb_ywg272.enc) \
tex(fbb_ywphh4.enc) \
tex(fbb_zbnzwf.enc) \
tex(fbb_zjfw7l.enc) \
texlive-fbb"

RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex(etoolbox.sty) \
tex(fontaxes.sty) \
tex(fontenc.sty) \
tex(ifetex.sty) \
tex(ifthen.sty) \
tex(mweights.sty) \
tex(textcomp.sty) \
tex(updmap.cfg) \
tex(xkeyval.sty) \
tex(xstring.sty) \
texlive \
texlive-fbb-fonts \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
