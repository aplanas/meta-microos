SUMMARY = "VLC without X dependencies"
DESCRIPTION = "This package of VLC contains the bare requirements you need to install. \
There is no graphical user interface included, thus it is also perfectly \
suitable for server installations, for example, to run a streaming server. \
 \
Should you decide to install the GUI modules, vlc-noX will stay \
installed as a dependency."
LICENSE = "GPL-2.0-or-later & LGPL-2.1-or-later"

PV = "3.0.18"

RPM_NAME = "vlc-noX-3.0.18-7.1.aarch64.rpm"
RPM_HASH = "17296b6d9b763c7eea4546a959b344319af95f9c07779dd0e578187b18905613859b20c766008e89436ffc3075b9542bba0a0956fef6b4d662ab47ad20a1854a"

RPROVIDES:${PN} += "liba52_plugin.so()(64bit) \
libaccess_alsa_plugin.so()(64bit) \
libaccess_concat_plugin.so()(64bit) \
libaccess_imem_plugin.so()(64bit) \
libaccess_mms_plugin.so()(64bit) \
libaccess_mtp_plugin.so()(64bit) \
libaccess_output_dummy_plugin.so()(64bit) \
libaccess_output_file_plugin.so()(64bit) \
libaccess_output_http_plugin.so()(64bit) \
libaccess_output_livehttp_plugin.so()(64bit) \
libaccess_output_rist_plugin.so()(64bit) \
libaccess_output_shout_plugin.so()(64bit) \
libaccess_output_srt_plugin.so()(64bit) \
libaccess_output_udp_plugin.so()(64bit) \
libaccess_realrtsp_plugin.so()(64bit) \
libaccess_srt_plugin.so()(64bit) \
libadaptive_plugin.so()(64bit) \
libaddonsfsstorage_plugin.so()(64bit) \
libaddonsvorepository_plugin.so()(64bit) \
libadf_plugin.so()(64bit) \
libadjust_plugin.so()(64bit) \
libadpcm_plugin.so()(64bit) \
libadummy_plugin.so()(64bit) \
libaes3_plugin.so()(64bit) \
libafile_plugin.so()(64bit) \
libaiff_plugin.so()(64bit) \
libalphamask_plugin.so()(64bit) \
libalsa_plugin.so()(64bit) \
libamem_plugin.so()(64bit) \
libanaglyph_plugin.so()(64bit) \
libantiflicker_plugin.so()(64bit) \
libaom_plugin.so()(64bit) \
libaraw_plugin.so()(64bit) \
libarchive_plugin.so()(64bit) \
libasf_plugin.so()(64bit) \
libattachment_plugin.so()(64bit) \
libau_plugin.so()(64bit) \
libaudio_format_plugin.so()(64bit) \
libaudiobargraph_a_plugin.so()(64bit) \
libaudiobargraph_v_plugin.so()(64bit) \
libaudioscrobbler_plugin.so()(64bit) \
libavahi_plugin.so()(64bit) \
libavi_plugin.so()(64bit) \
libball_plugin.so()(64bit) \
libblend_plugin.so()(64bit) \
libblendbench_plugin.so()(64bit) \
libbluescreen_plugin.so()(64bit) \
libcache_block_plugin.so()(64bit) \
libcache_read_plugin.so()(64bit) \
libcaf_plugin.so()(64bit) \
libcanvas_plugin.so()(64bit) \
libcc_plugin.so()(64bit) \
libcdda_plugin.so()(64bit) \
libcdg_plugin.so()(64bit) \
libchain_plugin.so()(64bit) \
libchorus_flanger_plugin.so()(64bit) \
libclone_plugin.so()(64bit) \
libcolorthres_plugin.so()(64bit) \
libcompressor_plugin.so()(64bit) \
libconsole_logger_plugin.so()(64bit) \
libcroppadd_plugin.so()(64bit) \
libcvdsub_plugin.so()(64bit) \
libdav1d_plugin.so()(64bit) \
libdbus_plugin.so()(64bit) \
libdbus_screensaver_plugin.so()(64bit) \
libdc1394_plugin.so()(64bit) \
libddummy_plugin.so()(64bit) \
libdecomp_plugin.so()(64bit) \
libdeinterlace_plugin.so()(64bit) \
libdemux_cdg_plugin.so()(64bit) \
libdemux_chromecast_plugin.so()(64bit) \
libdemux_stl_plugin.so()(64bit) \
libdemuxdump_plugin.so()(64bit) \
libdiracsys_plugin.so()(64bit) \
libdirectory_demux_plugin.so()(64bit) \
libdolby_surround_decoder_plugin.so()(64bit) \
libdtv_plugin.so()(64bit) \
libdummy_plugin.so()(64bit) \
libdv1394_plugin.so()(64bit) \
libdvb_plugin.so()(64bit) \
libdvbsub_plugin.so()(64bit) \
libdvdnav_plugin.so()(64bit) \
libdvdread_plugin.so()(64bit) \
libdynamicoverlay_plugin.so()(64bit) \
libedgedetection_plugin.so()(64bit) \
libedummy_plugin.so()(64bit) \
libequalizer_plugin.so()(64bit) \
liberase_plugin.so()(64bit) \
libes_plugin.so()(64bit) \
libexport_plugin.so()(64bit) \
libextract_plugin.so()(64bit) \
libfb_plugin.so()(64bit) \
libfile_keystore_plugin.so()(64bit) \
libfile_logger_plugin.so()(64bit) \
libfilesystem_plugin.so()(64bit) \
libfingerprinter_plugin.so()(64bit) \
libflac_plugin.so()(64bit) \
libflacsys_plugin.so()(64bit) \
libflaschen_plugin.so()(64bit) \
libfloat_mixer_plugin.so()(64bit) \
libfolder_plugin.so()(64bit) \
libfps_plugin.so()(64bit) \
libfreeze_plugin.so()(64bit) \
libftp_plugin.so()(64bit) \
libg711_plugin.so()(64bit) \
libgain_plugin.so()(64bit) \
libgaussianblur_plugin.so()(64bit) \
libgestures_plugin.so()(64bit) \
libgl_plugin.so()(64bit) \
libglconv_vaapi_drm_plugin.so()(64bit) \
libglconv_vaapi_x11_plugin.so()(64bit) \
libgme_plugin.so()(64bit) \
libgnutls_plugin.so()(64bit) \
libgradfun_plugin.so()(64bit) \
libgradient_plugin.so()(64bit) \
libgrain_plugin.so()(64bit) \
libgrey_yuv_plugin.so()(64bit) \
libh26x_plugin.so()(64bit) \
libhds_plugin.so()(64bit) \
libheadphone_channel_mixer_plugin.so()(64bit) \
libhotkeys_plugin.so()(64bit) \
libhqdn3d_plugin.so()(64bit) \
libhttp_plugin.so()(64bit) \
libhttps_plugin.so()(64bit) \
libi420_10_p010_plugin.so()(64bit) \
libi420_nv12_plugin.so()(64bit) \
libi420_rgb_plugin.so()(64bit) \
libi420_yuy2_plugin.so()(64bit) \
libi422_i420_plugin.so()(64bit) \
libi422_yuy2_plugin.so()(64bit) \
libidummy_plugin.so()(64bit) \
libimage_plugin.so()(64bit) \
libimem_plugin.so()(64bit) \
libinflate_plugin.so()(64bit) \
libinteger_mixer_plugin.so()(64bit) \
libinvert_plugin.so()(64bit) \
libjpeg_plugin.so()(64bit) \
libkaraoke_plugin.so()(64bit) \
libkate_plugin.so()(64bit) \
libkwallet_plugin.so()(64bit) \
liblibbluray_plugin.so()(64bit) \
liblibmpeg2_plugin.so()(64bit) \
liblinsys_hdsdi_plugin.so()(64bit) \
liblinsys_sdi_plugin.so()(64bit) \
liblirc_plugin.so()(64bit) \
liblive555_plugin.so()(64bit) \
liblogger_plugin.so()(64bit) \
liblogo_plugin.so()(64bit) \
liblpcm_plugin.so()(64bit) \
liblua_plugin.so()(64bit) \
libmad_plugin.so()(64bit) \
libmagnify_plugin.so()(64bit) \
libmarq_plugin.so()(64bit) \
libmediadirs_plugin.so()(64bit) \
libmemory_keystore_plugin.so()(64bit) \
libmirror_plugin.so()(64bit) \
libmjpeg_plugin.so()(64bit) \
libmkv_plugin.so()(64bit) \
libmono_plugin.so()(64bit) \
libmosaic_plugin.so()(64bit) \
libmotion_plugin.so()(64bit) \
libmotionblur_plugin.so()(64bit) \
libmotiondetect_plugin.so()(64bit) \
libmp4_plugin.so()(64bit) \
libmpg123_plugin.so()(64bit) \
libmpgv_plugin.so()(64bit) \
libmtp_plugin.so()(64bit) \
libmux_asf_plugin.so()(64bit) \
libmux_avi_plugin.so()(64bit) \
libmux_dummy_plugin.so()(64bit) \
libmux_mp4_plugin.so()(64bit) \
libmux_mpjpeg_plugin.so()(64bit) \
libmux_ogg_plugin.so()(64bit) \
libmux_ps_plugin.so()(64bit) \
libmux_ts_plugin.so()(64bit) \
libmux_wav_plugin.so()(64bit) \
libncurses_plugin.so()(64bit) \
libnetsync_plugin.so()(64bit) \
libnfs_plugin.so()(64bit) \
libnormvol_plugin.so()(64bit) \
libnoseek_plugin.so()(64bit) \
libnsc_plugin.so()(64bit) \
libnsv_plugin.so()(64bit) \
libnuv_plugin.so()(64bit) \
libogg_plugin.so()(64bit) \
liboggspots_plugin.so()(64bit) \
liboldmovie_plugin.so()(64bit) \
liboldrc_plugin.so()(64bit) \
libopus_plugin.so()(64bit) \
libpacketizer_a52_plugin.so()(64bit) \
libpacketizer_copy_plugin.so()(64bit) \
libpacketizer_dirac_plugin.so()(64bit) \
libpacketizer_dts_plugin.so()(64bit) \
libpacketizer_flac_plugin.so()(64bit) \
libpacketizer_h264_plugin.so()(64bit) \
libpacketizer_hevc_plugin.so()(64bit) \
libpacketizer_mlp_plugin.so()(64bit) \
libpacketizer_mpeg4audio_plugin.so()(64bit) \
libpacketizer_mpeg4video_plugin.so()(64bit) \
libpacketizer_mpegaudio_plugin.so()(64bit) \
libpacketizer_mpegvideo_plugin.so()(64bit) \
libpacketizer_vc1_plugin.so()(64bit) \
libparam_eq_plugin.so()(64bit) \
libplaylist_plugin.so()(64bit) \
libpng_plugin.so()(64bit) \
libpodcast_plugin.so()(64bit) \
libposterize_plugin.so()(64bit) \
libpostproc_plugin.so()(64bit) \
libprefetch_plugin.so()(64bit) \
libps_plugin.so()(64bit) \
libpsychedelic_plugin.so()(64bit) \
libpuzzle_plugin.so()(64bit) \
libpva_plugin.so()(64bit) \
librawaud_plugin.so()(64bit) \
librawdv_plugin.so()(64bit) \
librawvid_plugin.so()(64bit) \
librawvideo_plugin.so()(64bit) \
libreal_plugin.so()(64bit) \
librecord_plugin.so()(64bit) \
libremap_plugin.so()(64bit) \
libremoteosd_plugin.so()(64bit) \
libripple_plugin.so()(64bit) \
librist_plugin.so()(64bit) \
librotate_plugin.so()(64bit) \
librss_plugin.so()(64bit) \
librtp_plugin.so()(64bit) \
librtpvideo_plugin.so()(64bit) \
librv32_plugin.so()(64bit) \
libsamplerate_plugin.so()(64bit) \
libsap_plugin.so()(64bit) \
libsatip_plugin.so()(64bit) \
libscale_plugin.so()(64bit) \
libscaletempo_pitch_plugin.so()(64bit) \
libscaletempo_plugin.so()(64bit) \
libscene_plugin.so()(64bit) \
libschroedinger_plugin.so()(64bit) \
libscte18_plugin.so()(64bit) \
libscte27_plugin.so()(64bit) \
libsd_journal_plugin.so()(64bit) \
libsdp_plugin.so()(64bit) \
libsecret_plugin.so()(64bit) \
libsepia_plugin.so()(64bit) \
libsftp_plugin.so()(64bit) \
libsharpen_plugin.so()(64bit) \
libshm_plugin.so()(64bit) \
libsimple_channel_mixer_plugin.so()(64bit) \
libskiptags_plugin.so()(64bit) \
libsmb_plugin.so()(64bit) \
libsmf_plugin.so()(64bit) \
libsoxr_plugin.so()(64bit) \
libspatializer_plugin.so()(64bit) \
libspdif_plugin.so()(64bit) \
libspeex_plugin.so()(64bit) \
libspeex_resampler_plugin.so()(64bit) \
libspudec_plugin.so()(64bit) \
libstats_plugin.so()(64bit) \
libstereo_widen_plugin.so()(64bit) \
libstl_plugin.so()(64bit) \
libstream_out_autodel_plugin.so()(64bit) \
libstream_out_bridge_plugin.so()(64bit) \
libstream_out_chromecast_plugin.so()(64bit) \
libstream_out_cycle_plugin.so()(64bit) \
libstream_out_delay_plugin.so()(64bit) \
libstream_out_description_plugin.so()(64bit) \
libstream_out_display_plugin.so()(64bit) \
libstream_out_dummy_plugin.so()(64bit) \
libstream_out_duplicate_plugin.so()(64bit) \
libstream_out_es_plugin.so()(64bit) \
libstream_out_gather_plugin.so()(64bit) \
libstream_out_mosaic_bridge_plugin.so()(64bit) \
libstream_out_record_plugin.so()(64bit) \
libstream_out_rtp_plugin.so()(64bit) \
libstream_out_setid_plugin.so()(64bit) \
libstream_out_smem_plugin.so()(64bit) \
libstream_out_standard_plugin.so()(64bit) \
libstream_out_stats_plugin.so()(64bit) \
libstream_out_transcode_plugin.so()(64bit) \
libsubsdec_plugin.so()(64bit) \
libsubsdelay_plugin.so()(64bit) \
libsubstx3g_plugin.so()(64bit) \
libsubsusf_plugin.so()(64bit) \
libsubtitle_plugin.so()(64bit) \
libsvcdsub_plugin.so()(64bit) \
libsyslog_plugin.so()(64bit) \
libt140_plugin.so()(64bit) \
libtaglib_plugin.so()(64bit) \
libtcp_plugin.so()(64bit) \
libtdummy_plugin.so()(64bit) \
libtelx_plugin.so()(64bit) \
libtextst_plugin.so()(64bit) \
libtheora_plugin.so()(64bit) \
libtimecode_plugin.so()(64bit) \
libtospdif_plugin.so()(64bit) \
libtransform_plugin.so()(64bit) \
libtrivial_channel_mixer_plugin.so()(64bit) \
libts_plugin.so()(64bit) \
libtta_plugin.so()(64bit) \
libttml_plugin.so()(64bit) \
libtwolame_plugin.so()(64bit) \
libty_plugin.so()(64bit) \
libudev_plugin.so()(64bit) \
libudp_plugin.so()(64bit) \
libugly_resampler_plugin.so()(64bit) \
libuleaddvaudio_plugin.so()(64bit) \
libupnp_plugin.so()(64bit) \
libv4l2_plugin.so()(64bit) \
libvaapi_drm_plugin.so()(64bit) \
libvaapi_filters_plugin.so()(64bit) \
libvaapi_plugin.so()(64bit) \
libvc1_plugin.so()(64bit) \
libvcd_plugin.so()(64bit) \
libvdr_plugin.so()(64bit) \
libvdummy_plugin.so()(64bit) \
libvhs_plugin.so()(64bit) \
libvisual_plugin.so()(64bit) \
libvmem_plugin.so()(64bit) \
libvobsub_plugin.so()(64bit) \
libvoc_plugin.so()(64bit) \
libvod_rtsp_plugin.so()(64bit) \
libvorbis_plugin.so()(64bit) \
libvpx_plugin.so()(64bit) \
libwall_plugin.so()(64bit) \
libwav_plugin.so()(64bit) \
libwave_plugin.so()(64bit) \
libwebvtt_plugin.so()(64bit) \
libwl_shell_plugin.so()(64bit) \
libwl_shm_plugin.so()(64bit) \
libxa_plugin.so()(64bit) \
libxdg_screensaver_plugin.so()(64bit) \
libxdg_shell_plugin.so()(64bit) \
libxml_plugin.so()(64bit) \
libxwd_plugin.so()(64bit) \
libyuv_plugin.so()(64bit) \
libyuvp_plugin.so()(64bit) \
libyuy2_i420_plugin.so()(64bit) \
libyuy2_i422_plugin.so()(64bit) \
libzvbi_plugin.so()(64bit) \
vlc-noX \
vlc-noX(aarch-64)"
RDEPENDS:${PN} += "/bin/sh \
/sbin/ldconfig \
ld-linux-aarch64.so.1()(64bit) \
ld-linux-aarch64.so.1(GLIBC_2.17)(64bit) \
libBasicUsageEnvironment.so.2()(64bit) \
libFLAC.so.12()(64bit) \
libUsageEnvironment.so.3()(64bit) \
libX11.so.6()(64bit) \
liba52.so.0()(64bit) \
libaom.so.3()(64bit) \
libarchive.so.13()(64bit) \
libasound.so.2()(64bit) \
libasound.so.2(ALSA_0.9)(64bit) \
libasound.so.2(ALSA_0.9.0rc4)(64bit) \
libavahi-client.so.3()(64bit) \
libavahi-common.so.3()(64bit) \
libavc1394.so.0()(64bit) \
libbluray.so.2()(64bit) \
libc.so.6(GLIBC_2.34)(64bit) \
libcddb.so.2()(64bit) \
libdav1d.so.6()(64bit) \
libdbus-1.so.3()(64bit) \
libdbus-1.so.3(LIBDBUS_1_3)(64bit) \
libdc1394.so.25()(64bit) \
libdvbpsi.so.10()(64bit) \
libdvdnav.so.4()(64bit) \
libdvdread.so.8()(64bit) \
libebml.so.5()(64bit) \
libgcc_s.so.1()(64bit) \
libgcc_s.so.1(GCC_3.0)(64bit) \
libgcc_s.so.1(GCC_3.3.1)(64bit) \
libgcrypt.so.20()(64bit) \
libgcrypt.so.20(GCRYPT_1.6)(64bit) \
libgio-2.0.so.0()(64bit) \
libglib-2.0.so.0()(64bit) \
libgme.so.0()(64bit) \
libgnutls.so.30()(64bit) \
libgnutls.so.30(GNUTLS_3_4)(64bit) \
libgobject-2.0.so.0()(64bit) \
libgpg-error.so.0()(64bit) \
libgpg-error.so.0(GPG_ERROR_1.0)(64bit) \
libgroupsock.so.30()(64bit) \
libixml.so.11()(64bit) \
libjpeg.so.8()(64bit) \
libjpeg.so.8(LIBJPEG_8.0)(64bit) \
libkate.so.1()(64bit) \
liblirc_client.so.0()(64bit) \
libliveMedia.so.107()(64bit) \
liblua5.3.so.5()(64bit) \
libm.so.6()(64bit) \
libm.so.6(GLIBC_2.17)(64bit) \
libm.so.6(GLIBC_2.27)(64bit) \
libm.so.6(GLIBC_2.29)(64bit) \
libmad.so.0()(64bit) \
libmatroska.so.7()(64bit) \
libmatroska.so.7(V_1.7.0)(64bit) \
libmpeg2.so.0()(64bit) \
libmpg123.so.0()(64bit) \
libmtp.so.9()(64bit) \
libncursesw.so.6()(64bit) \
libncursesw.so.6(NCURSESTW6_5.7.20081102)(64bit) \
libnfs.so.14()(64bit) \
libogg.so.0()(64bit) \
libopus.so.0()(64bit) \
libplacebo.so.264()(64bit) \
libpng16.so.16()(64bit) \
libpng16.so.16(PNG16_0)(64bit) \
libpostproc.so.55.9()(64bit) \
libpostproc.so.55.9(LIBPOSTPROC_55)(64bit) \
libprotobuf-lite-3.21.12.so()(64bit) \
libraw1394.so.11()(64bit) \
librom1394.so.0()(64bit) \
libsamplerate.so.0()(64bit) \
libsamplerate.so.0(libsamplerate.so.0.0)(64bit) \
libschroedinger-1.0.so.0()(64bit) \
libsecret-1.so.0()(64bit) \
libshout.so.3()(64bit) \
libsmbclient.so.0()(64bit) \
libsmbclient.so.0(SMBCLIENT_0.1.0)(64bit) \
libsoxr.so.0()(64bit) \
libspeex.so.1()(64bit) \
libspeexdsp.so.1()(64bit) \
libsrt.so.1.5()(64bit) \
libssh2.so.1()(64bit) \
libstdc++.so.6()(64bit) \
libstdc++.so.6(CXXABI_1.3)(64bit) \
libstdc++.so.6(CXXABI_1.3.9)(64bit) \
libstdc++.so.6(GLIBCXX_3.4)(64bit) \
libstdc++.so.6(GLIBCXX_3.4.11)(64bit) \
libstdc++.so.6(GLIBCXX_3.4.15)(64bit) \
libstdc++.so.6(GLIBCXX_3.4.20)(64bit) \
libstdc++.so.6(GLIBCXX_3.4.21)(64bit) \
libstdc++.so.6(GLIBCXX_3.4.26)(64bit) \
libstdc++.so.6(GLIBCXX_3.4.29)(64bit) \
libstdc++.so.6(GLIBCXX_3.4.5)(64bit) \
libstdc++.so.6(GLIBCXX_3.4.9)(64bit) \
libsystemd.so.0()(64bit) \
libsystemd.so.0(LIBSYSTEMD_209)(64bit) \
libtag.so.1()(64bit) \
libtheoradec.so.1()(64bit) \
libtheoradec.so.1(libtheoradec_1.0)(64bit) \
libtheoraenc.so.1()(64bit) \
libtheoraenc.so.1(libtheoraenc_1.0)(64bit) \
libtinfo.so.6()(64bit) \
libtinfo.so.6(NCURSES6_TINFO_5.0.19991023)(64bit) \
libtinfo.so.6(NCURSES6_TINFO_5.7.20081102)(64bit) \
libtwolame.so.0()(64bit) \
libudev.so.1()(64bit) \
libudev.so.1(LIBUDEV_183)(64bit) \
libupnp.so.17()(64bit) \
libva-drm.so.2()(64bit) \
libva-x11.so.2()(64bit) \
libva.so.2()(64bit) \
libva.so.2(VA_API_0.33.0)(64bit) \
libvlc.so.5()(64bit) \
libvlc5 \
libvlccore.so.9()(64bit) \
libvlccore9 \
libvorbis.so.0()(64bit) \
libvorbisenc.so.2()(64bit) \
libvpx.so.8()(64bit) \
libwayland-client.so.0()(64bit) \
libxml2.so.2()(64bit) \
libxml2.so.2(LIBXML2_2.4.30)(64bit) \
libxml2.so.2(LIBXML2_2.5.0)(64bit) \
libxml2.so.2(LIBXML2_2.5.2)(64bit) \
libxml2.so.2(LIBXML2_2.6.0)(64bit) \
libxml2.so.2(LIBXML2_2.6.21)(64bit) \
libz.so.1()(64bit) \
libzvbi.so.0()(64bit)"

inherit rpm
