SUMMARY = "Support for the Roboto family of fonts"
DESCRIPTION = "This package provides LaTeX, pdfLaTeX, XeLaTeX and LuaLaTeX \
support for the Roboto Sans, Roboto Condensed, Roboto Mono, \
Roboto Slab and Roboto Serif families of fonts, designed by \
Christian Robertson and Greg Gazdowicz for Google."
LICENSE = "Apache-1.0"

PV = "2023.201.svn64350"

RPM_NAME = "texlive-roboto-2023.201.svn64350-53.1.noarch.rpm"
RPM_HASH = "264bbb675101b5d7e61e8e097aff8c6f240db667adf6ae6e01dccf404e701aaa05113b5c2b73c74172b2dacc7f1addc638be91d00c87005839e801a606ff64e3"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-LGRRoboto-LF.fd \
tex-LGRRoboto-OsF.fd \
tex-LGRRoboto-TLF.fd \
tex-LGRRoboto-TOsF.fd \
tex-LGRRobotoMono-TLF.fd \
tex-LGRRobotoSerif-LF.fd \
tex-LGRRobotoSerif-OsF.fd \
tex-LGRRobotoSerif-Sup.fd \
tex-LGRRobotoSerif-TLF.fd \
tex-LGRRobotoSerif-TOsF.fd \
tex-LGRRobotoSlab-TLF.fd \
tex-LY1Roboto-LF.fd \
tex-LY1Roboto-OsF.fd \
tex-LY1Roboto-TLF.fd \
tex-LY1Roboto-TOsF.fd \
tex-LY1RobotoMono-TLF.fd \
tex-LY1RobotoSerif-LF.fd \
tex-LY1RobotoSerif-OsF.fd \
tex-LY1RobotoSerif-Sup.fd \
tex-LY1RobotoSerif-TLF.fd \
tex-LY1RobotoSerif-TOsF.fd \
tex-LY1RobotoSlab-TLF.fd \
tex-OT1Roboto-LF.fd \
tex-OT1Roboto-OsF.fd \
tex-OT1Roboto-TLF.fd \
tex-OT1Roboto-TOsF.fd \
tex-OT1RobotoMono-TLF.fd \
tex-OT1RobotoSerif-LF.fd \
tex-OT1RobotoSerif-OsF.fd \
tex-OT1RobotoSerif-Sup.fd \
tex-OT1RobotoSerif-TLF.fd \
tex-OT1RobotoSerif-TOsF.fd \
tex-OT1RobotoSlab-TLF.fd \
tex-Roboto-Black-lf-lgr--base.tfm \
tex-Roboto-Black-lf-lgr.tfm \
tex-Roboto-Black-lf-lgr.vf \
tex-Roboto-Black-lf-ly1--base.tfm \
tex-Roboto-Black-lf-ly1.tfm \
tex-Roboto-Black-lf-ly1.vf \
tex-Roboto-Black-lf-ot1.tfm \
tex-Roboto-Black-lf-sc-lgr--base.tfm \
tex-Roboto-Black-lf-sc-lgr.tfm \
tex-Roboto-Black-lf-sc-lgr.vf \
tex-Roboto-Black-lf-sc-ly1--base.tfm \
tex-Roboto-Black-lf-sc-ly1.tfm \
tex-Roboto-Black-lf-sc-ly1.vf \
tex-Roboto-Black-lf-sc-ot1--base.tfm \
tex-Roboto-Black-lf-sc-ot1.tfm \
tex-Roboto-Black-lf-sc-ot1.vf \
tex-Roboto-Black-lf-sc-t1--base.tfm \
tex-Roboto-Black-lf-sc-t1.tfm \
tex-Roboto-Black-lf-sc-t1.vf \
tex-Roboto-Black-lf-t1--base.tfm \
tex-Roboto-Black-lf-t1.tfm \
tex-Roboto-Black-lf-t1.vf \
tex-Roboto-Black-lf-ts1--base.tfm \
tex-Roboto-Black-lf-ts1.tfm \
tex-Roboto-Black-lf-ts1.vf \
tex-Roboto-Black-osf-lgr--base.tfm \
tex-Roboto-Black-osf-lgr.tfm \
tex-Roboto-Black-osf-lgr.vf \
tex-Roboto-Black-osf-ly1--base.tfm \
tex-Roboto-Black-osf-ly1.tfm \
tex-Roboto-Black-osf-ly1.vf \
tex-Roboto-Black-osf-ot1.tfm \
tex-Roboto-Black-osf-sc-lgr--base.tfm \
tex-Roboto-Black-osf-sc-lgr.tfm \
tex-Roboto-Black-osf-sc-lgr.vf \
tex-Roboto-Black-osf-sc-ly1--base.tfm \
tex-Roboto-Black-osf-sc-ly1.tfm \
tex-Roboto-Black-osf-sc-ly1.vf \
tex-Roboto-Black-osf-sc-ot1--base.tfm \
tex-Roboto-Black-osf-sc-ot1.tfm \
tex-Roboto-Black-osf-sc-ot1.vf \
tex-Roboto-Black-osf-sc-t1--base.tfm \
tex-Roboto-Black-osf-sc-t1.tfm \
tex-Roboto-Black-osf-sc-t1.vf \
tex-Roboto-Black-osf-t1--base.tfm \
tex-Roboto-Black-osf-t1.tfm \
tex-Roboto-Black-osf-t1.vf \
tex-Roboto-Black-osf-ts1--base.tfm \
tex-Roboto-Black-osf-ts1.tfm \
tex-Roboto-Black-osf-ts1.vf \
tex-Roboto-Black-tlf-lgr--base.tfm \
tex-Roboto-Black-tlf-lgr.tfm \
tex-Roboto-Black-tlf-lgr.vf \
tex-Roboto-Black-tlf-ly1--base.tfm \
tex-Roboto-Black-tlf-ly1.tfm \
tex-Roboto-Black-tlf-ly1.vf \
tex-Roboto-Black-tlf-ot1.tfm \
tex-Roboto-Black-tlf-sc-lgr--base.tfm \
tex-Roboto-Black-tlf-sc-lgr.tfm \
tex-Roboto-Black-tlf-sc-lgr.vf \
tex-Roboto-Black-tlf-sc-ly1--base.tfm \
tex-Roboto-Black-tlf-sc-ly1.tfm \
tex-Roboto-Black-tlf-sc-ly1.vf \
tex-Roboto-Black-tlf-sc-ot1--base.tfm \
tex-Roboto-Black-tlf-sc-ot1.tfm \
tex-Roboto-Black-tlf-sc-ot1.vf \
tex-Roboto-Black-tlf-sc-t1--base.tfm \
tex-Roboto-Black-tlf-sc-t1.tfm \
tex-Roboto-Black-tlf-sc-t1.vf \
tex-Roboto-Black-tlf-t1--base.tfm \
tex-Roboto-Black-tlf-t1.tfm \
tex-Roboto-Black-tlf-t1.vf \
tex-Roboto-Black-tlf-ts1--base.tfm \
tex-Roboto-Black-tlf-ts1.tfm \
tex-Roboto-Black-tlf-ts1.vf \
tex-Roboto-Black-tosf-lgr--base.tfm \
tex-Roboto-Black-tosf-lgr.tfm \
tex-Roboto-Black-tosf-lgr.vf \
tex-Roboto-Black-tosf-ly1--base.tfm \
tex-Roboto-Black-tosf-ly1.tfm \
tex-Roboto-Black-tosf-ly1.vf \
tex-Roboto-Black-tosf-ot1.tfm \
tex-Roboto-Black-tosf-sc-lgr--base.tfm \
tex-Roboto-Black-tosf-sc-lgr.tfm \
tex-Roboto-Black-tosf-sc-lgr.vf \
tex-Roboto-Black-tosf-sc-ly1--base.tfm \
tex-Roboto-Black-tosf-sc-ly1.tfm \
tex-Roboto-Black-tosf-sc-ly1.vf \
tex-Roboto-Black-tosf-sc-ot1--base.tfm \
tex-Roboto-Black-tosf-sc-ot1.tfm \
tex-Roboto-Black-tosf-sc-ot1.vf \
tex-Roboto-Black-tosf-sc-t1--base.tfm \
tex-Roboto-Black-tosf-sc-t1.tfm \
tex-Roboto-Black-tosf-sc-t1.vf \
tex-Roboto-Black-tosf-t1--base.tfm \
tex-Roboto-Black-tosf-t1.tfm \
tex-Roboto-Black-tosf-t1.vf \
tex-Roboto-Black-tosf-ts1--base.tfm \
tex-Roboto-Black-tosf-ts1.tfm \
tex-Roboto-Black-tosf-ts1.vf \
tex-Roboto-BlackItalic-lf-lgr--base.tfm \
tex-Roboto-BlackItalic-lf-lgr.tfm \
tex-Roboto-BlackItalic-lf-lgr.vf \
tex-Roboto-BlackItalic-lf-ly1--base.tfm \
tex-Roboto-BlackItalic-lf-ly1.tfm \
tex-Roboto-BlackItalic-lf-ly1.vf \
tex-Roboto-BlackItalic-lf-ot1.tfm \
tex-Roboto-BlackItalic-lf-sc-lgr--base.tfm \
tex-Roboto-BlackItalic-lf-sc-lgr.tfm \
tex-Roboto-BlackItalic-lf-sc-lgr.vf \
tex-Roboto-BlackItalic-lf-sc-ly1--base.tfm \
tex-Roboto-BlackItalic-lf-sc-ly1.tfm \
tex-Roboto-BlackItalic-lf-sc-ly1.vf \
tex-Roboto-BlackItalic-lf-sc-ot1--base.tfm \
tex-Roboto-BlackItalic-lf-sc-ot1.tfm \
tex-Roboto-BlackItalic-lf-sc-ot1.vf \
tex-Roboto-BlackItalic-lf-sc-t1--base.tfm \
tex-Roboto-BlackItalic-lf-sc-t1.tfm \
tex-Roboto-BlackItalic-lf-sc-t1.vf \
tex-Roboto-BlackItalic-lf-t1--base.tfm \
tex-Roboto-BlackItalic-lf-t1.tfm \
tex-Roboto-BlackItalic-lf-t1.vf \
tex-Roboto-BlackItalic-lf-ts1--base.tfm \
tex-Roboto-BlackItalic-lf-ts1.tfm \
tex-Roboto-BlackItalic-lf-ts1.vf \
tex-Roboto-BlackItalic-osf-lgr--base.tfm \
tex-Roboto-BlackItalic-osf-lgr.tfm \
tex-Roboto-BlackItalic-osf-lgr.vf \
tex-Roboto-BlackItalic-osf-ly1--base.tfm \
tex-Roboto-BlackItalic-osf-ly1.tfm \
tex-Roboto-BlackItalic-osf-ly1.vf \
tex-Roboto-BlackItalic-osf-ot1.tfm \
tex-Roboto-BlackItalic-osf-sc-lgr--base.tfm \
tex-Roboto-BlackItalic-osf-sc-lgr.tfm \
tex-Roboto-BlackItalic-osf-sc-lgr.vf \
tex-Roboto-BlackItalic-osf-sc-ly1--base.tfm \
tex-Roboto-BlackItalic-osf-sc-ly1.tfm \
tex-Roboto-BlackItalic-osf-sc-ly1.vf \
tex-Roboto-BlackItalic-osf-sc-ot1--base.tfm \
tex-Roboto-BlackItalic-osf-sc-ot1.tfm \
tex-Roboto-BlackItalic-osf-sc-ot1.vf \
tex-Roboto-BlackItalic-osf-sc-t1--base.tfm \
tex-Roboto-BlackItalic-osf-sc-t1.tfm \
tex-Roboto-BlackItalic-osf-sc-t1.vf \
tex-Roboto-BlackItalic-osf-t1--base.tfm \
tex-Roboto-BlackItalic-osf-t1.tfm \
tex-Roboto-BlackItalic-osf-t1.vf \
tex-Roboto-BlackItalic-osf-ts1--base.tfm \
tex-Roboto-BlackItalic-osf-ts1.tfm \
tex-Roboto-BlackItalic-osf-ts1.vf \
tex-Roboto-BlackItalic-tlf-lgr--base.tfm \
tex-Roboto-BlackItalic-tlf-lgr.tfm \
tex-Roboto-BlackItalic-tlf-lgr.vf \
tex-Roboto-BlackItalic-tlf-ly1--base.tfm \
tex-Roboto-BlackItalic-tlf-ly1.tfm \
tex-Roboto-BlackItalic-tlf-ly1.vf \
tex-Roboto-BlackItalic-tlf-ot1.tfm \
tex-Roboto-BlackItalic-tlf-sc-lgr--base.tfm \
tex-Roboto-BlackItalic-tlf-sc-lgr.tfm \
tex-Roboto-BlackItalic-tlf-sc-lgr.vf \
tex-Roboto-BlackItalic-tlf-sc-ly1--base.tfm \
tex-Roboto-BlackItalic-tlf-sc-ly1.tfm \
tex-Roboto-BlackItalic-tlf-sc-ly1.vf \
tex-Roboto-BlackItalic-tlf-sc-ot1--base.tfm \
tex-Roboto-BlackItalic-tlf-sc-ot1.tfm \
tex-Roboto-BlackItalic-tlf-sc-ot1.vf \
tex-Roboto-BlackItalic-tlf-sc-t1--base.tfm \
tex-Roboto-BlackItalic-tlf-sc-t1.tfm \
tex-Roboto-BlackItalic-tlf-sc-t1.vf \
tex-Roboto-BlackItalic-tlf-t1--base.tfm \
tex-Roboto-BlackItalic-tlf-t1.tfm \
tex-Roboto-BlackItalic-tlf-t1.vf \
tex-Roboto-BlackItalic-tlf-ts1--base.tfm \
tex-Roboto-BlackItalic-tlf-ts1.tfm \
tex-Roboto-BlackItalic-tlf-ts1.vf \
tex-Roboto-BlackItalic-tosf-lgr--base.tfm \
tex-Roboto-BlackItalic-tosf-lgr.tfm \
tex-Roboto-BlackItalic-tosf-lgr.vf \
tex-Roboto-BlackItalic-tosf-ly1--base.tfm \
tex-Roboto-BlackItalic-tosf-ly1.tfm \
tex-Roboto-BlackItalic-tosf-ly1.vf \
tex-Roboto-BlackItalic-tosf-ot1.tfm \
tex-Roboto-BlackItalic-tosf-sc-lgr--base.tfm \
tex-Roboto-BlackItalic-tosf-sc-lgr.tfm \
tex-Roboto-BlackItalic-tosf-sc-lgr.vf \
tex-Roboto-BlackItalic-tosf-sc-ly1--base.tfm \
tex-Roboto-BlackItalic-tosf-sc-ly1.tfm \
tex-Roboto-BlackItalic-tosf-sc-ly1.vf \
tex-Roboto-BlackItalic-tosf-sc-ot1--base.tfm \
tex-Roboto-BlackItalic-tosf-sc-ot1.tfm \
tex-Roboto-BlackItalic-tosf-sc-ot1.vf \
tex-Roboto-BlackItalic-tosf-sc-t1--base.tfm \
tex-Roboto-BlackItalic-tosf-sc-t1.tfm \
tex-Roboto-BlackItalic-tosf-sc-t1.vf \
tex-Roboto-BlackItalic-tosf-t1--base.tfm \
tex-Roboto-BlackItalic-tosf-t1.tfm \
tex-Roboto-BlackItalic-tosf-t1.vf \
tex-Roboto-BlackItalic-tosf-ts1--base.tfm \
tex-Roboto-BlackItalic-tosf-ts1.tfm \
tex-Roboto-BlackItalic-tosf-ts1.vf \
tex-Roboto-Bold-lf-lgr--base.tfm \
tex-Roboto-Bold-lf-lgr.tfm \
tex-Roboto-Bold-lf-lgr.vf \
tex-Roboto-Bold-lf-ly1--base.tfm \
tex-Roboto-Bold-lf-ly1.tfm \
tex-Roboto-Bold-lf-ly1.vf \
tex-Roboto-Bold-lf-ot1.tfm \
tex-Roboto-Bold-lf-sc-lgr--base.tfm \
tex-Roboto-Bold-lf-sc-lgr.tfm \
tex-Roboto-Bold-lf-sc-lgr.vf \
tex-Roboto-Bold-lf-sc-ly1--base.tfm \
tex-Roboto-Bold-lf-sc-ly1.tfm \
tex-Roboto-Bold-lf-sc-ly1.vf \
tex-Roboto-Bold-lf-sc-ot1--base.tfm \
tex-Roboto-Bold-lf-sc-ot1.tfm \
tex-Roboto-Bold-lf-sc-ot1.vf \
tex-Roboto-Bold-lf-sc-t1--base.tfm \
tex-Roboto-Bold-lf-sc-t1.tfm \
tex-Roboto-Bold-lf-sc-t1.vf \
tex-Roboto-Bold-lf-t1--base.tfm \
tex-Roboto-Bold-lf-t1.tfm \
tex-Roboto-Bold-lf-t1.vf \
tex-Roboto-Bold-lf-ts1--base.tfm \
tex-Roboto-Bold-lf-ts1.tfm \
tex-Roboto-Bold-lf-ts1.vf \
tex-Roboto-Bold-osf-lgr--base.tfm \
tex-Roboto-Bold-osf-lgr.tfm \
tex-Roboto-Bold-osf-lgr.vf \
tex-Roboto-Bold-osf-ly1--base.tfm \
tex-Roboto-Bold-osf-ly1.tfm \
tex-Roboto-Bold-osf-ly1.vf \
tex-Roboto-Bold-osf-ot1.tfm \
tex-Roboto-Bold-osf-sc-lgr--base.tfm \
tex-Roboto-Bold-osf-sc-lgr.tfm \
tex-Roboto-Bold-osf-sc-lgr.vf \
tex-Roboto-Bold-osf-sc-ly1--base.tfm \
tex-Roboto-Bold-osf-sc-ly1.tfm \
tex-Roboto-Bold-osf-sc-ly1.vf \
tex-Roboto-Bold-osf-sc-ot1--base.tfm \
tex-Roboto-Bold-osf-sc-ot1.tfm \
tex-Roboto-Bold-osf-sc-ot1.vf \
tex-Roboto-Bold-osf-sc-t1--base.tfm \
tex-Roboto-Bold-osf-sc-t1.tfm \
tex-Roboto-Bold-osf-sc-t1.vf \
tex-Roboto-Bold-osf-t1--base.tfm \
tex-Roboto-Bold-osf-t1.tfm \
tex-Roboto-Bold-osf-t1.vf \
tex-Roboto-Bold-osf-ts1--base.tfm \
tex-Roboto-Bold-osf-ts1.tfm \
tex-Roboto-Bold-osf-ts1.vf \
tex-Roboto-Bold-tlf-lgr--base.tfm \
tex-Roboto-Bold-tlf-lgr.tfm \
tex-Roboto-Bold-tlf-lgr.vf \
tex-Roboto-Bold-tlf-ly1--base.tfm \
tex-Roboto-Bold-tlf-ly1.tfm \
tex-Roboto-Bold-tlf-ly1.vf \
tex-Roboto-Bold-tlf-ot1.tfm \
tex-Roboto-Bold-tlf-sc-lgr--base.tfm \
tex-Roboto-Bold-tlf-sc-lgr.tfm \
tex-Roboto-Bold-tlf-sc-lgr.vf \
tex-Roboto-Bold-tlf-sc-ly1--base.tfm \
tex-Roboto-Bold-tlf-sc-ly1.tfm \
tex-Roboto-Bold-tlf-sc-ly1.vf \
tex-Roboto-Bold-tlf-sc-ot1--base.tfm \
tex-Roboto-Bold-tlf-sc-ot1.tfm \
tex-Roboto-Bold-tlf-sc-ot1.vf \
tex-Roboto-Bold-tlf-sc-t1--base.tfm \
tex-Roboto-Bold-tlf-sc-t1.tfm \
tex-Roboto-Bold-tlf-sc-t1.vf \
tex-Roboto-Bold-tlf-t1--base.tfm \
tex-Roboto-Bold-tlf-t1.tfm \
tex-Roboto-Bold-tlf-t1.vf \
tex-Roboto-Bold-tlf-ts1--base.tfm \
tex-Roboto-Bold-tlf-ts1.tfm \
tex-Roboto-Bold-tlf-ts1.vf \
tex-Roboto-Bold-tosf-lgr--base.tfm \
tex-Roboto-Bold-tosf-lgr.tfm \
tex-Roboto-Bold-tosf-lgr.vf \
tex-Roboto-Bold-tosf-ly1--base.tfm \
tex-Roboto-Bold-tosf-ly1.tfm \
tex-Roboto-Bold-tosf-ly1.vf \
tex-Roboto-Bold-tosf-ot1.tfm \
tex-Roboto-Bold-tosf-sc-lgr--base.tfm \
tex-Roboto-Bold-tosf-sc-lgr.tfm \
tex-Roboto-Bold-tosf-sc-lgr.vf \
tex-Roboto-Bold-tosf-sc-ly1--base.tfm \
tex-Roboto-Bold-tosf-sc-ly1.tfm \
tex-Roboto-Bold-tosf-sc-ly1.vf \
tex-Roboto-Bold-tosf-sc-ot1--base.tfm \
tex-Roboto-Bold-tosf-sc-ot1.tfm \
tex-Roboto-Bold-tosf-sc-ot1.vf \
tex-Roboto-Bold-tosf-sc-t1--base.tfm \
tex-Roboto-Bold-tosf-sc-t1.tfm \
tex-Roboto-Bold-tosf-sc-t1.vf \
tex-Roboto-Bold-tosf-t1--base.tfm \
tex-Roboto-Bold-tosf-t1.tfm \
tex-Roboto-Bold-tosf-t1.vf \
tex-Roboto-Bold-tosf-ts1--base.tfm \
tex-Roboto-Bold-tosf-ts1.tfm \
tex-Roboto-Bold-tosf-ts1.vf \
tex-Roboto-BoldItalic-lf-lgr--base.tfm \
tex-Roboto-BoldItalic-lf-lgr.tfm \
tex-Roboto-BoldItalic-lf-lgr.vf \
tex-Roboto-BoldItalic-lf-ly1--base.tfm \
tex-Roboto-BoldItalic-lf-ly1.tfm \
tex-Roboto-BoldItalic-lf-ly1.vf \
tex-Roboto-BoldItalic-lf-ot1.tfm \
tex-Roboto-BoldItalic-lf-sc-lgr--base.tfm \
tex-Roboto-BoldItalic-lf-sc-lgr.tfm \
tex-Roboto-BoldItalic-lf-sc-lgr.vf \
tex-Roboto-BoldItalic-lf-sc-ly1--base.tfm \
tex-Roboto-BoldItalic-lf-sc-ly1.tfm \
tex-Roboto-BoldItalic-lf-sc-ly1.vf \
tex-Roboto-BoldItalic-lf-sc-ot1--base.tfm \
tex-Roboto-BoldItalic-lf-sc-ot1.tfm \
tex-Roboto-BoldItalic-lf-sc-ot1.vf \
tex-Roboto-BoldItalic-lf-sc-t1--base.tfm \
tex-Roboto-BoldItalic-lf-sc-t1.tfm \
tex-Roboto-BoldItalic-lf-sc-t1.vf \
tex-Roboto-BoldItalic-lf-t1--base.tfm \
tex-Roboto-BoldItalic-lf-t1.tfm \
tex-Roboto-BoldItalic-lf-t1.vf \
tex-Roboto-BoldItalic-lf-ts1--base.tfm \
tex-Roboto-BoldItalic-lf-ts1.tfm \
tex-Roboto-BoldItalic-lf-ts1.vf \
tex-Roboto-BoldItalic-osf-lgr--base.tfm \
tex-Roboto-BoldItalic-osf-lgr.tfm \
tex-Roboto-BoldItalic-osf-lgr.vf \
tex-Roboto-BoldItalic-osf-ly1--base.tfm \
tex-Roboto-BoldItalic-osf-ly1.tfm \
tex-Roboto-BoldItalic-osf-ly1.vf \
tex-Roboto-BoldItalic-osf-ot1.tfm \
tex-Roboto-BoldItalic-osf-sc-lgr--base.tfm \
tex-Roboto-BoldItalic-osf-sc-lgr.tfm \
tex-Roboto-BoldItalic-osf-sc-lgr.vf \
tex-Roboto-BoldItalic-osf-sc-ly1--base.tfm \
tex-Roboto-BoldItalic-osf-sc-ly1.tfm \
tex-Roboto-BoldItalic-osf-sc-ly1.vf \
tex-Roboto-BoldItalic-osf-sc-ot1--base.tfm \
tex-Roboto-BoldItalic-osf-sc-ot1.tfm \
tex-Roboto-BoldItalic-osf-sc-ot1.vf \
tex-Roboto-BoldItalic-osf-sc-t1--base.tfm \
tex-Roboto-BoldItalic-osf-sc-t1.tfm \
tex-Roboto-BoldItalic-osf-sc-t1.vf \
tex-Roboto-BoldItalic-osf-t1--base.tfm \
tex-Roboto-BoldItalic-osf-t1.tfm \
tex-Roboto-BoldItalic-osf-t1.vf \
tex-Roboto-BoldItalic-osf-ts1--base.tfm \
tex-Roboto-BoldItalic-osf-ts1.tfm \
tex-Roboto-BoldItalic-osf-ts1.vf \
tex-Roboto-BoldItalic-tlf-lgr--base.tfm \
tex-Roboto-BoldItalic-tlf-lgr.tfm \
tex-Roboto-BoldItalic-tlf-lgr.vf \
tex-Roboto-BoldItalic-tlf-ly1--base.tfm \
tex-Roboto-BoldItalic-tlf-ly1.tfm \
tex-Roboto-BoldItalic-tlf-ly1.vf \
tex-Roboto-BoldItalic-tlf-ot1.tfm \
tex-Roboto-BoldItalic-tlf-sc-lgr--base.tfm \
tex-Roboto-BoldItalic-tlf-sc-lgr.tfm \
tex-Roboto-BoldItalic-tlf-sc-lgr.vf \
tex-Roboto-BoldItalic-tlf-sc-ly1--base.tfm \
tex-Roboto-BoldItalic-tlf-sc-ly1.tfm \
tex-Roboto-BoldItalic-tlf-sc-ly1.vf \
tex-Roboto-BoldItalic-tlf-sc-ot1--base.tfm \
tex-Roboto-BoldItalic-tlf-sc-ot1.tfm \
tex-Roboto-BoldItalic-tlf-sc-ot1.vf \
tex-Roboto-BoldItalic-tlf-sc-t1--base.tfm \
tex-Roboto-BoldItalic-tlf-sc-t1.tfm \
tex-Roboto-BoldItalic-tlf-sc-t1.vf \
tex-Roboto-BoldItalic-tlf-t1--base.tfm \
tex-Roboto-BoldItalic-tlf-t1.tfm \
tex-Roboto-BoldItalic-tlf-t1.vf \
tex-Roboto-BoldItalic-tlf-ts1--base.tfm \
tex-Roboto-BoldItalic-tlf-ts1.tfm \
tex-Roboto-BoldItalic-tlf-ts1.vf \
tex-Roboto-BoldItalic-tosf-lgr--base.tfm \
tex-Roboto-BoldItalic-tosf-lgr.tfm \
tex-Roboto-BoldItalic-tosf-lgr.vf \
tex-Roboto-BoldItalic-tosf-ly1--base.tfm \
tex-Roboto-BoldItalic-tosf-ly1.tfm \
tex-Roboto-BoldItalic-tosf-ly1.vf \
tex-Roboto-BoldItalic-tosf-ot1.tfm \
tex-Roboto-BoldItalic-tosf-sc-lgr--base.tfm \
tex-Roboto-BoldItalic-tosf-sc-lgr.tfm \
tex-Roboto-BoldItalic-tosf-sc-lgr.vf \
tex-Roboto-BoldItalic-tosf-sc-ly1--base.tfm \
tex-Roboto-BoldItalic-tosf-sc-ly1.tfm \
tex-Roboto-BoldItalic-tosf-sc-ly1.vf \
tex-Roboto-BoldItalic-tosf-sc-ot1--base.tfm \
tex-Roboto-BoldItalic-tosf-sc-ot1.tfm \
tex-Roboto-BoldItalic-tosf-sc-ot1.vf \
tex-Roboto-BoldItalic-tosf-sc-t1--base.tfm \
tex-Roboto-BoldItalic-tosf-sc-t1.tfm \
tex-Roboto-BoldItalic-tosf-sc-t1.vf \
tex-Roboto-BoldItalic-tosf-t1--base.tfm \
tex-Roboto-BoldItalic-tosf-t1.tfm \
tex-Roboto-BoldItalic-tosf-t1.vf \
tex-Roboto-BoldItalic-tosf-ts1--base.tfm \
tex-Roboto-BoldItalic-tosf-ts1.tfm \
tex-Roboto-BoldItalic-tosf-ts1.vf \
tex-Roboto-Italic-lf-lgr--base.tfm \
tex-Roboto-Italic-lf-lgr.tfm \
tex-Roboto-Italic-lf-lgr.vf \
tex-Roboto-Italic-lf-ly1--base.tfm \
tex-Roboto-Italic-lf-ly1.tfm \
tex-Roboto-Italic-lf-ly1.vf \
tex-Roboto-Italic-lf-ot1.tfm \
tex-Roboto-Italic-lf-sc-lgr--base.tfm \
tex-Roboto-Italic-lf-sc-lgr.tfm \
tex-Roboto-Italic-lf-sc-lgr.vf \
tex-Roboto-Italic-lf-sc-ly1--base.tfm \
tex-Roboto-Italic-lf-sc-ly1.tfm \
tex-Roboto-Italic-lf-sc-ly1.vf \
tex-Roboto-Italic-lf-sc-ot1--base.tfm \
tex-Roboto-Italic-lf-sc-ot1.tfm \
tex-Roboto-Italic-lf-sc-ot1.vf \
tex-Roboto-Italic-lf-sc-t1--base.tfm \
tex-Roboto-Italic-lf-sc-t1.tfm \
tex-Roboto-Italic-lf-sc-t1.vf \
tex-Roboto-Italic-lf-t1--base.tfm \
tex-Roboto-Italic-lf-t1.tfm \
tex-Roboto-Italic-lf-t1.vf \
tex-Roboto-Italic-lf-ts1--base.tfm \
tex-Roboto-Italic-lf-ts1.tfm \
tex-Roboto-Italic-lf-ts1.vf \
tex-Roboto-Italic-osf-lgr--base.tfm \
tex-Roboto-Italic-osf-lgr.tfm \
tex-Roboto-Italic-osf-lgr.vf \
tex-Roboto-Italic-osf-ly1--base.tfm \
tex-Roboto-Italic-osf-ly1.tfm \
tex-Roboto-Italic-osf-ly1.vf \
tex-Roboto-Italic-osf-ot1.tfm \
tex-Roboto-Italic-osf-sc-lgr--base.tfm \
tex-Roboto-Italic-osf-sc-lgr.tfm \
tex-Roboto-Italic-osf-sc-lgr.vf \
tex-Roboto-Italic-osf-sc-ly1--base.tfm \
tex-Roboto-Italic-osf-sc-ly1.tfm \
tex-Roboto-Italic-osf-sc-ly1.vf \
tex-Roboto-Italic-osf-sc-ot1--base.tfm \
tex-Roboto-Italic-osf-sc-ot1.tfm \
tex-Roboto-Italic-osf-sc-ot1.vf \
tex-Roboto-Italic-osf-sc-t1--base.tfm \
tex-Roboto-Italic-osf-sc-t1.tfm \
tex-Roboto-Italic-osf-sc-t1.vf \
tex-Roboto-Italic-osf-t1--base.tfm \
tex-Roboto-Italic-osf-t1.tfm \
tex-Roboto-Italic-osf-t1.vf \
tex-Roboto-Italic-osf-ts1--base.tfm \
tex-Roboto-Italic-osf-ts1.tfm \
tex-Roboto-Italic-osf-ts1.vf \
tex-Roboto-Italic-tlf-lgr--base.tfm \
tex-Roboto-Italic-tlf-lgr.tfm \
tex-Roboto-Italic-tlf-lgr.vf \
tex-Roboto-Italic-tlf-ly1--base.tfm \
tex-Roboto-Italic-tlf-ly1.tfm \
tex-Roboto-Italic-tlf-ly1.vf \
tex-Roboto-Italic-tlf-ot1.tfm \
tex-Roboto-Italic-tlf-sc-lgr--base.tfm \
tex-Roboto-Italic-tlf-sc-lgr.tfm \
tex-Roboto-Italic-tlf-sc-lgr.vf \
tex-Roboto-Italic-tlf-sc-ly1--base.tfm \
tex-Roboto-Italic-tlf-sc-ly1.tfm \
tex-Roboto-Italic-tlf-sc-ly1.vf \
tex-Roboto-Italic-tlf-sc-ot1--base.tfm \
tex-Roboto-Italic-tlf-sc-ot1.tfm \
tex-Roboto-Italic-tlf-sc-ot1.vf \
tex-Roboto-Italic-tlf-sc-t1--base.tfm \
tex-Roboto-Italic-tlf-sc-t1.tfm \
tex-Roboto-Italic-tlf-sc-t1.vf \
tex-Roboto-Italic-tlf-t1--base.tfm \
tex-Roboto-Italic-tlf-t1.tfm \
tex-Roboto-Italic-tlf-t1.vf \
tex-Roboto-Italic-tlf-ts1--base.tfm \
tex-Roboto-Italic-tlf-ts1.tfm \
tex-Roboto-Italic-tlf-ts1.vf \
tex-Roboto-Italic-tosf-lgr--base.tfm \
tex-Roboto-Italic-tosf-lgr.tfm \
tex-Roboto-Italic-tosf-lgr.vf \
tex-Roboto-Italic-tosf-ly1--base.tfm \
tex-Roboto-Italic-tosf-ly1.tfm \
tex-Roboto-Italic-tosf-ly1.vf \
tex-Roboto-Italic-tosf-ot1.tfm \
tex-Roboto-Italic-tosf-sc-lgr--base.tfm \
tex-Roboto-Italic-tosf-sc-lgr.tfm \
tex-Roboto-Italic-tosf-sc-lgr.vf \
tex-Roboto-Italic-tosf-sc-ly1--base.tfm \
tex-Roboto-Italic-tosf-sc-ly1.tfm \
tex-Roboto-Italic-tosf-sc-ly1.vf \
tex-Roboto-Italic-tosf-sc-ot1--base.tfm \
tex-Roboto-Italic-tosf-sc-ot1.tfm \
tex-Roboto-Italic-tosf-sc-ot1.vf \
tex-Roboto-Italic-tosf-sc-t1--base.tfm \
tex-Roboto-Italic-tosf-sc-t1.tfm \
tex-Roboto-Italic-tosf-sc-t1.vf \
tex-Roboto-Italic-tosf-t1--base.tfm \
tex-Roboto-Italic-tosf-t1.tfm \
tex-Roboto-Italic-tosf-t1.vf \
tex-Roboto-Italic-tosf-ts1--base.tfm \
tex-Roboto-Italic-tosf-ts1.tfm \
tex-Roboto-Italic-tosf-ts1.vf \
tex-Roboto-Light-lf-lgr--base.tfm \
tex-Roboto-Light-lf-lgr.tfm \
tex-Roboto-Light-lf-lgr.vf \
tex-Roboto-Light-lf-ly1--base.tfm \
tex-Roboto-Light-lf-ly1.tfm \
tex-Roboto-Light-lf-ly1.vf \
tex-Roboto-Light-lf-ot1.tfm \
tex-Roboto-Light-lf-sc-lgr--base.tfm \
tex-Roboto-Light-lf-sc-lgr.tfm \
tex-Roboto-Light-lf-sc-lgr.vf \
tex-Roboto-Light-lf-sc-ly1--base.tfm \
tex-Roboto-Light-lf-sc-ly1.tfm \
tex-Roboto-Light-lf-sc-ly1.vf \
tex-Roboto-Light-lf-sc-ot1--base.tfm \
tex-Roboto-Light-lf-sc-ot1.tfm \
tex-Roboto-Light-lf-sc-ot1.vf \
tex-Roboto-Light-lf-sc-t1--base.tfm \
tex-Roboto-Light-lf-sc-t1.tfm \
tex-Roboto-Light-lf-sc-t1.vf \
tex-Roboto-Light-lf-t1--base.tfm \
tex-Roboto-Light-lf-t1.tfm \
tex-Roboto-Light-lf-t1.vf \
tex-Roboto-Light-lf-ts1--base.tfm \
tex-Roboto-Light-lf-ts1.tfm \
tex-Roboto-Light-lf-ts1.vf \
tex-Roboto-Light-osf-lgr--base.tfm \
tex-Roboto-Light-osf-lgr.tfm \
tex-Roboto-Light-osf-lgr.vf \
tex-Roboto-Light-osf-ly1--base.tfm \
tex-Roboto-Light-osf-ly1.tfm \
tex-Roboto-Light-osf-ly1.vf \
tex-Roboto-Light-osf-ot1.tfm \
tex-Roboto-Light-osf-sc-lgr--base.tfm \
tex-Roboto-Light-osf-sc-lgr.tfm \
tex-Roboto-Light-osf-sc-lgr.vf \
tex-Roboto-Light-osf-sc-ly1--base.tfm \
tex-Roboto-Light-osf-sc-ly1.tfm \
tex-Roboto-Light-osf-sc-ly1.vf \
tex-Roboto-Light-osf-sc-ot1--base.tfm \
tex-Roboto-Light-osf-sc-ot1.tfm \
tex-Roboto-Light-osf-sc-ot1.vf \
tex-Roboto-Light-osf-sc-t1--base.tfm \
tex-Roboto-Light-osf-sc-t1.tfm \
tex-Roboto-Light-osf-sc-t1.vf \
tex-Roboto-Light-osf-t1--base.tfm \
tex-Roboto-Light-osf-t1.tfm \
tex-Roboto-Light-osf-t1.vf \
tex-Roboto-Light-osf-ts1--base.tfm \
tex-Roboto-Light-osf-ts1.tfm \
tex-Roboto-Light-osf-ts1.vf \
tex-Roboto-Light-tlf-lgr--base.tfm \
tex-Roboto-Light-tlf-lgr.tfm \
tex-Roboto-Light-tlf-lgr.vf \
tex-Roboto-Light-tlf-ly1--base.tfm \
tex-Roboto-Light-tlf-ly1.tfm \
tex-Roboto-Light-tlf-ly1.vf \
tex-Roboto-Light-tlf-ot1.tfm \
tex-Roboto-Light-tlf-sc-lgr--base.tfm \
tex-Roboto-Light-tlf-sc-lgr.tfm \
tex-Roboto-Light-tlf-sc-lgr.vf \
tex-Roboto-Light-tlf-sc-ly1--base.tfm \
tex-Roboto-Light-tlf-sc-ly1.tfm \
tex-Roboto-Light-tlf-sc-ly1.vf \
tex-Roboto-Light-tlf-sc-ot1--base.tfm \
tex-Roboto-Light-tlf-sc-ot1.tfm \
tex-Roboto-Light-tlf-sc-ot1.vf \
tex-Roboto-Light-tlf-sc-t1--base.tfm \
tex-Roboto-Light-tlf-sc-t1.tfm \
tex-Roboto-Light-tlf-sc-t1.vf \
tex-Roboto-Light-tlf-t1--base.tfm \
tex-Roboto-Light-tlf-t1.tfm \
tex-Roboto-Light-tlf-t1.vf \
tex-Roboto-Light-tlf-ts1--base.tfm \
tex-Roboto-Light-tlf-ts1.tfm \
tex-Roboto-Light-tlf-ts1.vf \
tex-Roboto-Light-tosf-lgr--base.tfm \
tex-Roboto-Light-tosf-lgr.tfm \
tex-Roboto-Light-tosf-lgr.vf \
tex-Roboto-Light-tosf-ly1--base.tfm \
tex-Roboto-Light-tosf-ly1.tfm \
tex-Roboto-Light-tosf-ly1.vf \
tex-Roboto-Light-tosf-ot1.tfm \
tex-Roboto-Light-tosf-sc-lgr--base.tfm \
tex-Roboto-Light-tosf-sc-lgr.tfm \
tex-Roboto-Light-tosf-sc-lgr.vf \
tex-Roboto-Light-tosf-sc-ly1--base.tfm \
tex-Roboto-Light-tosf-sc-ly1.tfm \
tex-Roboto-Light-tosf-sc-ly1.vf \
tex-Roboto-Light-tosf-sc-ot1--base.tfm \
tex-Roboto-Light-tosf-sc-ot1.tfm \
tex-Roboto-Light-tosf-sc-ot1.vf \
tex-Roboto-Light-tosf-sc-t1--base.tfm \
tex-Roboto-Light-tosf-sc-t1.tfm \
tex-Roboto-Light-tosf-sc-t1.vf \
tex-Roboto-Light-tosf-t1--base.tfm \
tex-Roboto-Light-tosf-t1.tfm \
tex-Roboto-Light-tosf-t1.vf \
tex-Roboto-Light-tosf-ts1--base.tfm \
tex-Roboto-Light-tosf-ts1.tfm \
tex-Roboto-Light-tosf-ts1.vf \
tex-Roboto-LightItalic-lf-lgr--base.tfm \
tex-Roboto-LightItalic-lf-lgr.tfm \
tex-Roboto-LightItalic-lf-lgr.vf \
tex-Roboto-LightItalic-lf-ly1--base.tfm \
tex-Roboto-LightItalic-lf-ly1.tfm \
tex-Roboto-LightItalic-lf-ly1.vf \
tex-Roboto-LightItalic-lf-ot1.tfm \
tex-Roboto-LightItalic-lf-sc-lgr--base.tfm \
tex-Roboto-LightItalic-lf-sc-lgr.tfm \
tex-Roboto-LightItalic-lf-sc-lgr.vf \
tex-Roboto-LightItalic-lf-sc-ly1--base.tfm \
tex-Roboto-LightItalic-lf-sc-ly1.tfm \
tex-Roboto-LightItalic-lf-sc-ly1.vf \
tex-Roboto-LightItalic-lf-sc-ot1--base.tfm \
tex-Roboto-LightItalic-lf-sc-ot1.tfm \
tex-Roboto-LightItalic-lf-sc-ot1.vf \
tex-Roboto-LightItalic-lf-sc-t1--base.tfm \
tex-Roboto-LightItalic-lf-sc-t1.tfm \
tex-Roboto-LightItalic-lf-sc-t1.vf \
tex-Roboto-LightItalic-lf-t1--base.tfm \
tex-Roboto-LightItalic-lf-t1.tfm \
tex-Roboto-LightItalic-lf-t1.vf \
tex-Roboto-LightItalic-lf-ts1--base.tfm \
tex-Roboto-LightItalic-lf-ts1.tfm \
tex-Roboto-LightItalic-lf-ts1.vf \
tex-Roboto-LightItalic-osf-lgr--base.tfm \
tex-Roboto-LightItalic-osf-lgr.tfm \
tex-Roboto-LightItalic-osf-lgr.vf \
tex-Roboto-LightItalic-osf-ly1--base.tfm \
tex-Roboto-LightItalic-osf-ly1.tfm \
tex-Roboto-LightItalic-osf-ly1.vf \
tex-Roboto-LightItalic-osf-ot1.tfm \
tex-Roboto-LightItalic-osf-sc-lgr--base.tfm \
tex-Roboto-LightItalic-osf-sc-lgr.tfm \
tex-Roboto-LightItalic-osf-sc-lgr.vf \
tex-Roboto-LightItalic-osf-sc-ly1--base.tfm \
tex-Roboto-LightItalic-osf-sc-ly1.tfm \
tex-Roboto-LightItalic-osf-sc-ly1.vf \
tex-Roboto-LightItalic-osf-sc-ot1--base.tfm \
tex-Roboto-LightItalic-osf-sc-ot1.tfm \
tex-Roboto-LightItalic-osf-sc-ot1.vf \
tex-Roboto-LightItalic-osf-sc-t1--base.tfm \
tex-Roboto-LightItalic-osf-sc-t1.tfm \
tex-Roboto-LightItalic-osf-sc-t1.vf \
tex-Roboto-LightItalic-osf-t1--base.tfm \
tex-Roboto-LightItalic-osf-t1.tfm \
tex-Roboto-LightItalic-osf-t1.vf \
tex-Roboto-LightItalic-osf-ts1--base.tfm \
tex-Roboto-LightItalic-osf-ts1.tfm \
tex-Roboto-LightItalic-osf-ts1.vf \
tex-Roboto-LightItalic-tlf-lgr--base.tfm \
tex-Roboto-LightItalic-tlf-lgr.tfm \
tex-Roboto-LightItalic-tlf-lgr.vf \
tex-Roboto-LightItalic-tlf-ly1--base.tfm \
tex-Roboto-LightItalic-tlf-ly1.tfm \
tex-Roboto-LightItalic-tlf-ly1.vf \
tex-Roboto-LightItalic-tlf-ot1.tfm \
tex-Roboto-LightItalic-tlf-sc-lgr--base.tfm \
tex-Roboto-LightItalic-tlf-sc-lgr.tfm \
tex-Roboto-LightItalic-tlf-sc-lgr.vf \
tex-Roboto-LightItalic-tlf-sc-ly1--base.tfm \
tex-Roboto-LightItalic-tlf-sc-ly1.tfm \
tex-Roboto-LightItalic-tlf-sc-ly1.vf \
tex-Roboto-LightItalic-tlf-sc-ot1--base.tfm \
tex-Roboto-LightItalic-tlf-sc-ot1.tfm \
tex-Roboto-LightItalic-tlf-sc-ot1.vf \
tex-Roboto-LightItalic-tlf-sc-t1--base.tfm \
tex-Roboto-LightItalic-tlf-sc-t1.tfm \
tex-Roboto-LightItalic-tlf-sc-t1.vf \
tex-Roboto-LightItalic-tlf-t1--base.tfm \
tex-Roboto-LightItalic-tlf-t1.tfm \
tex-Roboto-LightItalic-tlf-t1.vf \
tex-Roboto-LightItalic-tlf-ts1--base.tfm \
tex-Roboto-LightItalic-tlf-ts1.tfm \
tex-Roboto-LightItalic-tlf-ts1.vf \
tex-Roboto-LightItalic-tosf-lgr--base.tfm \
tex-Roboto-LightItalic-tosf-lgr.tfm \
tex-Roboto-LightItalic-tosf-lgr.vf \
tex-Roboto-LightItalic-tosf-ly1--base.tfm \
tex-Roboto-LightItalic-tosf-ly1.tfm \
tex-Roboto-LightItalic-tosf-ly1.vf \
tex-Roboto-LightItalic-tosf-ot1.tfm \
tex-Roboto-LightItalic-tosf-sc-lgr--base.tfm \
tex-Roboto-LightItalic-tosf-sc-lgr.tfm \
tex-Roboto-LightItalic-tosf-sc-lgr.vf \
tex-Roboto-LightItalic-tosf-sc-ly1--base.tfm \
tex-Roboto-LightItalic-tosf-sc-ly1.tfm \
tex-Roboto-LightItalic-tosf-sc-ly1.vf \
tex-Roboto-LightItalic-tosf-sc-ot1--base.tfm \
tex-Roboto-LightItalic-tosf-sc-ot1.tfm \
tex-Roboto-LightItalic-tosf-sc-ot1.vf \
tex-Roboto-LightItalic-tosf-sc-t1--base.tfm \
tex-Roboto-LightItalic-tosf-sc-t1.tfm \
tex-Roboto-LightItalic-tosf-sc-t1.vf \
tex-Roboto-LightItalic-tosf-t1--base.tfm \
tex-Roboto-LightItalic-tosf-t1.tfm \
tex-Roboto-LightItalic-tosf-t1.vf \
tex-Roboto-LightItalic-tosf-ts1--base.tfm \
tex-Roboto-LightItalic-tosf-ts1.tfm \
tex-Roboto-LightItalic-tosf-ts1.vf \
tex-Roboto-Medium-lf-lgr--base.tfm \
tex-Roboto-Medium-lf-lgr.tfm \
tex-Roboto-Medium-lf-lgr.vf \
tex-Roboto-Medium-lf-ly1--base.tfm \
tex-Roboto-Medium-lf-ly1.tfm \
tex-Roboto-Medium-lf-ly1.vf \
tex-Roboto-Medium-lf-ot1.tfm \
tex-Roboto-Medium-lf-sc-lgr--base.tfm \
tex-Roboto-Medium-lf-sc-lgr.tfm \
tex-Roboto-Medium-lf-sc-lgr.vf \
tex-Roboto-Medium-lf-sc-ly1--base.tfm \
tex-Roboto-Medium-lf-sc-ly1.tfm \
tex-Roboto-Medium-lf-sc-ly1.vf \
tex-Roboto-Medium-lf-sc-ot1--base.tfm \
tex-Roboto-Medium-lf-sc-ot1.tfm \
tex-Roboto-Medium-lf-sc-ot1.vf \
tex-Roboto-Medium-lf-sc-t1--base.tfm \
tex-Roboto-Medium-lf-sc-t1.tfm \
tex-Roboto-Medium-lf-sc-t1.vf \
tex-Roboto-Medium-lf-t1--base.tfm \
tex-Roboto-Medium-lf-t1.tfm \
tex-Roboto-Medium-lf-t1.vf \
tex-Roboto-Medium-lf-ts1--base.tfm \
tex-Roboto-Medium-lf-ts1.tfm \
tex-Roboto-Medium-lf-ts1.vf \
tex-Roboto-Medium-osf-lgr--base.tfm \
tex-Roboto-Medium-osf-lgr.tfm \
tex-Roboto-Medium-osf-lgr.vf \
tex-Roboto-Medium-osf-ly1--base.tfm \
tex-Roboto-Medium-osf-ly1.tfm \
tex-Roboto-Medium-osf-ly1.vf \
tex-Roboto-Medium-osf-ot1.tfm \
tex-Roboto-Medium-osf-sc-lgr--base.tfm \
tex-Roboto-Medium-osf-sc-lgr.tfm \
tex-Roboto-Medium-osf-sc-lgr.vf \
tex-Roboto-Medium-osf-sc-ly1--base.tfm \
tex-Roboto-Medium-osf-sc-ly1.tfm \
tex-Roboto-Medium-osf-sc-ly1.vf \
tex-Roboto-Medium-osf-sc-ot1--base.tfm \
tex-Roboto-Medium-osf-sc-ot1.tfm \
tex-Roboto-Medium-osf-sc-ot1.vf \
tex-Roboto-Medium-osf-sc-t1--base.tfm \
tex-Roboto-Medium-osf-sc-t1.tfm \
tex-Roboto-Medium-osf-sc-t1.vf \
tex-Roboto-Medium-osf-t1--base.tfm \
tex-Roboto-Medium-osf-t1.tfm \
tex-Roboto-Medium-osf-t1.vf \
tex-Roboto-Medium-osf-ts1--base.tfm \
tex-Roboto-Medium-osf-ts1.tfm \
tex-Roboto-Medium-osf-ts1.vf \
tex-Roboto-Medium-tlf-lgr--base.tfm \
tex-Roboto-Medium-tlf-lgr.tfm \
tex-Roboto-Medium-tlf-lgr.vf \
tex-Roboto-Medium-tlf-ly1--base.tfm \
tex-Roboto-Medium-tlf-ly1.tfm \
tex-Roboto-Medium-tlf-ly1.vf \
tex-Roboto-Medium-tlf-ot1.tfm \
tex-Roboto-Medium-tlf-sc-lgr--base.tfm \
tex-Roboto-Medium-tlf-sc-lgr.tfm \
tex-Roboto-Medium-tlf-sc-lgr.vf \
tex-Roboto-Medium-tlf-sc-ly1--base.tfm \
tex-Roboto-Medium-tlf-sc-ly1.tfm \
tex-Roboto-Medium-tlf-sc-ly1.vf \
tex-Roboto-Medium-tlf-sc-ot1--base.tfm \
tex-Roboto-Medium-tlf-sc-ot1.tfm \
tex-Roboto-Medium-tlf-sc-ot1.vf \
tex-Roboto-Medium-tlf-sc-t1--base.tfm \
tex-Roboto-Medium-tlf-sc-t1.tfm \
tex-Roboto-Medium-tlf-sc-t1.vf \
tex-Roboto-Medium-tlf-t1--base.tfm \
tex-Roboto-Medium-tlf-t1.tfm \
tex-Roboto-Medium-tlf-t1.vf \
tex-Roboto-Medium-tlf-ts1--base.tfm \
tex-Roboto-Medium-tlf-ts1.tfm \
tex-Roboto-Medium-tlf-ts1.vf \
tex-Roboto-Medium-tosf-lgr--base.tfm \
tex-Roboto-Medium-tosf-lgr.tfm \
tex-Roboto-Medium-tosf-lgr.vf \
tex-Roboto-Medium-tosf-ly1--base.tfm \
tex-Roboto-Medium-tosf-ly1.tfm \
tex-Roboto-Medium-tosf-ly1.vf \
tex-Roboto-Medium-tosf-ot1.tfm \
tex-Roboto-Medium-tosf-sc-lgr--base.tfm \
tex-Roboto-Medium-tosf-sc-lgr.tfm \
tex-Roboto-Medium-tosf-sc-lgr.vf \
tex-Roboto-Medium-tosf-sc-ly1--base.tfm \
tex-Roboto-Medium-tosf-sc-ly1.tfm \
tex-Roboto-Medium-tosf-sc-ly1.vf \
tex-Roboto-Medium-tosf-sc-ot1--base.tfm \
tex-Roboto-Medium-tosf-sc-ot1.tfm \
tex-Roboto-Medium-tosf-sc-ot1.vf \
tex-Roboto-Medium-tosf-sc-t1--base.tfm \
tex-Roboto-Medium-tosf-sc-t1.tfm \
tex-Roboto-Medium-tosf-sc-t1.vf \
tex-Roboto-Medium-tosf-t1--base.tfm \
tex-Roboto-Medium-tosf-t1.tfm \
tex-Roboto-Medium-tosf-t1.vf \
tex-Roboto-Medium-tosf-ts1--base.tfm \
tex-Roboto-Medium-tosf-ts1.tfm \
tex-Roboto-Medium-tosf-ts1.vf \
tex-Roboto-MediumItalic-lf-lgr--base.tfm \
tex-Roboto-MediumItalic-lf-lgr.tfm \
tex-Roboto-MediumItalic-lf-lgr.vf \
tex-Roboto-MediumItalic-lf-ly1--base.tfm \
tex-Roboto-MediumItalic-lf-ly1.tfm \
tex-Roboto-MediumItalic-lf-ly1.vf \
tex-Roboto-MediumItalic-lf-ot1.tfm \
tex-Roboto-MediumItalic-lf-sc-lgr--base.tfm \
tex-Roboto-MediumItalic-lf-sc-lgr.tfm \
tex-Roboto-MediumItalic-lf-sc-lgr.vf \
tex-Roboto-MediumItalic-lf-sc-ly1--base.tfm \
tex-Roboto-MediumItalic-lf-sc-ly1.tfm \
tex-Roboto-MediumItalic-lf-sc-ly1.vf \
tex-Roboto-MediumItalic-lf-sc-ot1--base.tfm \
tex-Roboto-MediumItalic-lf-sc-ot1.tfm \
tex-Roboto-MediumItalic-lf-sc-ot1.vf \
tex-Roboto-MediumItalic-lf-sc-t1--base.tfm \
tex-Roboto-MediumItalic-lf-sc-t1.tfm \
tex-Roboto-MediumItalic-lf-sc-t1.vf \
tex-Roboto-MediumItalic-lf-t1--base.tfm \
tex-Roboto-MediumItalic-lf-t1.tfm \
tex-Roboto-MediumItalic-lf-t1.vf \
tex-Roboto-MediumItalic-lf-ts1--base.tfm \
tex-Roboto-MediumItalic-lf-ts1.tfm \
tex-Roboto-MediumItalic-lf-ts1.vf \
tex-Roboto-MediumItalic-osf-lgr--base.tfm \
tex-Roboto-MediumItalic-osf-lgr.tfm \
tex-Roboto-MediumItalic-osf-lgr.vf \
tex-Roboto-MediumItalic-osf-ly1--base.tfm \
tex-Roboto-MediumItalic-osf-ly1.tfm \
tex-Roboto-MediumItalic-osf-ly1.vf \
tex-Roboto-MediumItalic-osf-ot1.tfm \
tex-Roboto-MediumItalic-osf-sc-lgr--base.tfm \
tex-Roboto-MediumItalic-osf-sc-lgr.tfm \
tex-Roboto-MediumItalic-osf-sc-lgr.vf \
tex-Roboto-MediumItalic-osf-sc-ly1--base.tfm \
tex-Roboto-MediumItalic-osf-sc-ly1.tfm \
tex-Roboto-MediumItalic-osf-sc-ly1.vf \
tex-Roboto-MediumItalic-osf-sc-ot1--base.tfm \
tex-Roboto-MediumItalic-osf-sc-ot1.tfm \
tex-Roboto-MediumItalic-osf-sc-ot1.vf \
tex-Roboto-MediumItalic-osf-sc-t1--base.tfm \
tex-Roboto-MediumItalic-osf-sc-t1.tfm \
tex-Roboto-MediumItalic-osf-sc-t1.vf \
tex-Roboto-MediumItalic-osf-t1--base.tfm \
tex-Roboto-MediumItalic-osf-t1.tfm \
tex-Roboto-MediumItalic-osf-t1.vf \
tex-Roboto-MediumItalic-osf-ts1--base.tfm \
tex-Roboto-MediumItalic-osf-ts1.tfm \
tex-Roboto-MediumItalic-osf-ts1.vf \
tex-Roboto-MediumItalic-tlf-lgr--base.tfm \
tex-Roboto-MediumItalic-tlf-lgr.tfm \
tex-Roboto-MediumItalic-tlf-lgr.vf \
tex-Roboto-MediumItalic-tlf-ly1--base.tfm \
tex-Roboto-MediumItalic-tlf-ly1.tfm \
tex-Roboto-MediumItalic-tlf-ly1.vf \
tex-Roboto-MediumItalic-tlf-ot1.tfm \
tex-Roboto-MediumItalic-tlf-sc-lgr--base.tfm \
tex-Roboto-MediumItalic-tlf-sc-lgr.tfm \
tex-Roboto-MediumItalic-tlf-sc-lgr.vf \
tex-Roboto-MediumItalic-tlf-sc-ly1--base.tfm \
tex-Roboto-MediumItalic-tlf-sc-ly1.tfm \
tex-Roboto-MediumItalic-tlf-sc-ly1.vf \
tex-Roboto-MediumItalic-tlf-sc-ot1--base.tfm \
tex-Roboto-MediumItalic-tlf-sc-ot1.tfm \
tex-Roboto-MediumItalic-tlf-sc-ot1.vf \
tex-Roboto-MediumItalic-tlf-sc-t1--base.tfm \
tex-Roboto-MediumItalic-tlf-sc-t1.tfm \
tex-Roboto-MediumItalic-tlf-sc-t1.vf \
tex-Roboto-MediumItalic-tlf-t1--base.tfm \
tex-Roboto-MediumItalic-tlf-t1.tfm \
tex-Roboto-MediumItalic-tlf-t1.vf \
tex-Roboto-MediumItalic-tlf-ts1--base.tfm \
tex-Roboto-MediumItalic-tlf-ts1.tfm \
tex-Roboto-MediumItalic-tlf-ts1.vf \
tex-Roboto-MediumItalic-tosf-lgr--base.tfm \
tex-Roboto-MediumItalic-tosf-lgr.tfm \
tex-Roboto-MediumItalic-tosf-lgr.vf \
tex-Roboto-MediumItalic-tosf-ly1--base.tfm \
tex-Roboto-MediumItalic-tosf-ly1.tfm \
tex-Roboto-MediumItalic-tosf-ly1.vf \
tex-Roboto-MediumItalic-tosf-ot1.tfm \
tex-Roboto-MediumItalic-tosf-sc-lgr--base.tfm \
tex-Roboto-MediumItalic-tosf-sc-lgr.tfm \
tex-Roboto-MediumItalic-tosf-sc-lgr.vf \
tex-Roboto-MediumItalic-tosf-sc-ly1--base.tfm \
tex-Roboto-MediumItalic-tosf-sc-ly1.tfm \
tex-Roboto-MediumItalic-tosf-sc-ly1.vf \
tex-Roboto-MediumItalic-tosf-sc-ot1--base.tfm \
tex-Roboto-MediumItalic-tosf-sc-ot1.tfm \
tex-Roboto-MediumItalic-tosf-sc-ot1.vf \
tex-Roboto-MediumItalic-tosf-sc-t1--base.tfm \
tex-Roboto-MediumItalic-tosf-sc-t1.tfm \
tex-Roboto-MediumItalic-tosf-sc-t1.vf \
tex-Roboto-MediumItalic-tosf-t1--base.tfm \
tex-Roboto-MediumItalic-tosf-t1.tfm \
tex-Roboto-MediumItalic-tosf-t1.vf \
tex-Roboto-MediumItalic-tosf-ts1--base.tfm \
tex-Roboto-MediumItalic-tosf-ts1.tfm \
tex-Roboto-MediumItalic-tosf-ts1.vf \
tex-Roboto-Regular-lf-lgr--base.tfm \
tex-Roboto-Regular-lf-lgr.tfm \
tex-Roboto-Regular-lf-lgr.vf \
tex-Roboto-Regular-lf-ly1--base.tfm \
tex-Roboto-Regular-lf-ly1.tfm \
tex-Roboto-Regular-lf-ly1.vf \
tex-Roboto-Regular-lf-ot1.tfm \
tex-Roboto-Regular-lf-sc-lgr--base.tfm \
tex-Roboto-Regular-lf-sc-lgr.tfm \
tex-Roboto-Regular-lf-sc-lgr.vf \
tex-Roboto-Regular-lf-sc-ly1--base.tfm \
tex-Roboto-Regular-lf-sc-ly1.tfm \
tex-Roboto-Regular-lf-sc-ly1.vf \
tex-Roboto-Regular-lf-sc-ot1--base.tfm \
tex-Roboto-Regular-lf-sc-ot1.tfm \
tex-Roboto-Regular-lf-sc-ot1.vf \
tex-Roboto-Regular-lf-sc-t1--base.tfm \
tex-Roboto-Regular-lf-sc-t1.tfm \
tex-Roboto-Regular-lf-sc-t1.vf \
tex-Roboto-Regular-lf-t1--base.tfm \
tex-Roboto-Regular-lf-t1.tfm \
tex-Roboto-Regular-lf-t1.vf \
tex-Roboto-Regular-lf-ts1--base.tfm \
tex-Roboto-Regular-lf-ts1.tfm \
tex-Roboto-Regular-lf-ts1.vf \
tex-Roboto-Regular-osf-lgr--base.tfm \
tex-Roboto-Regular-osf-lgr.tfm \
tex-Roboto-Regular-osf-lgr.vf \
tex-Roboto-Regular-osf-ly1--base.tfm \
tex-Roboto-Regular-osf-ly1.tfm \
tex-Roboto-Regular-osf-ly1.vf \
tex-Roboto-Regular-osf-ot1.tfm \
tex-Roboto-Regular-osf-sc-lgr--base.tfm \
tex-Roboto-Regular-osf-sc-lgr.tfm \
tex-Roboto-Regular-osf-sc-lgr.vf \
tex-Roboto-Regular-osf-sc-ly1--base.tfm \
tex-Roboto-Regular-osf-sc-ly1.tfm \
tex-Roboto-Regular-osf-sc-ly1.vf \
tex-Roboto-Regular-osf-sc-ot1--base.tfm \
tex-Roboto-Regular-osf-sc-ot1.tfm \
tex-Roboto-Regular-osf-sc-ot1.vf \
tex-Roboto-Regular-osf-sc-t1--base.tfm \
tex-Roboto-Regular-osf-sc-t1.tfm \
tex-Roboto-Regular-osf-sc-t1.vf \
tex-Roboto-Regular-osf-t1--base.tfm \
tex-Roboto-Regular-osf-t1.tfm \
tex-Roboto-Regular-osf-t1.vf \
tex-Roboto-Regular-osf-ts1--base.tfm \
tex-Roboto-Regular-osf-ts1.tfm \
tex-Roboto-Regular-osf-ts1.vf \
tex-Roboto-Regular-tlf-lgr--base.tfm \
tex-Roboto-Regular-tlf-lgr.tfm \
tex-Roboto-Regular-tlf-lgr.vf \
tex-Roboto-Regular-tlf-ly1--base.tfm \
tex-Roboto-Regular-tlf-ly1.tfm \
tex-Roboto-Regular-tlf-ly1.vf \
tex-Roboto-Regular-tlf-ot1.tfm \
tex-Roboto-Regular-tlf-sc-lgr--base.tfm \
tex-Roboto-Regular-tlf-sc-lgr.tfm \
tex-Roboto-Regular-tlf-sc-lgr.vf \
tex-Roboto-Regular-tlf-sc-ly1--base.tfm \
tex-Roboto-Regular-tlf-sc-ly1.tfm \
tex-Roboto-Regular-tlf-sc-ly1.vf \
tex-Roboto-Regular-tlf-sc-ot1--base.tfm \
tex-Roboto-Regular-tlf-sc-ot1.tfm \
tex-Roboto-Regular-tlf-sc-ot1.vf \
tex-Roboto-Regular-tlf-sc-t1--base.tfm \
tex-Roboto-Regular-tlf-sc-t1.tfm \
tex-Roboto-Regular-tlf-sc-t1.vf \
tex-Roboto-Regular-tlf-t1--base.tfm \
tex-Roboto-Regular-tlf-t1.tfm \
tex-Roboto-Regular-tlf-t1.vf \
tex-Roboto-Regular-tlf-ts1--base.tfm \
tex-Roboto-Regular-tlf-ts1.tfm \
tex-Roboto-Regular-tlf-ts1.vf \
tex-Roboto-Regular-tosf-lgr--base.tfm \
tex-Roboto-Regular-tosf-lgr.tfm \
tex-Roboto-Regular-tosf-lgr.vf \
tex-Roboto-Regular-tosf-ly1--base.tfm \
tex-Roboto-Regular-tosf-ly1.tfm \
tex-Roboto-Regular-tosf-ly1.vf \
tex-Roboto-Regular-tosf-ot1.tfm \
tex-Roboto-Regular-tosf-sc-lgr--base.tfm \
tex-Roboto-Regular-tosf-sc-lgr.tfm \
tex-Roboto-Regular-tosf-sc-lgr.vf \
tex-Roboto-Regular-tosf-sc-ly1--base.tfm \
tex-Roboto-Regular-tosf-sc-ly1.tfm \
tex-Roboto-Regular-tosf-sc-ly1.vf \
tex-Roboto-Regular-tosf-sc-ot1--base.tfm \
tex-Roboto-Regular-tosf-sc-ot1.tfm \
tex-Roboto-Regular-tosf-sc-ot1.vf \
tex-Roboto-Regular-tosf-sc-t1--base.tfm \
tex-Roboto-Regular-tosf-sc-t1.tfm \
tex-Roboto-Regular-tosf-sc-t1.vf \
tex-Roboto-Regular-tosf-t1--base.tfm \
tex-Roboto-Regular-tosf-t1.tfm \
tex-Roboto-Regular-tosf-t1.vf \
tex-Roboto-Regular-tosf-ts1--base.tfm \
tex-Roboto-Regular-tosf-ts1.tfm \
tex-Roboto-Regular-tosf-ts1.vf \
tex-Roboto-Thin-lf-lgr--base.tfm \
tex-Roboto-Thin-lf-lgr.tfm \
tex-Roboto-Thin-lf-lgr.vf \
tex-Roboto-Thin-lf-ly1--base.tfm \
tex-Roboto-Thin-lf-ly1.tfm \
tex-Roboto-Thin-lf-ly1.vf \
tex-Roboto-Thin-lf-ot1.tfm \
tex-Roboto-Thin-lf-sc-lgr--base.tfm \
tex-Roboto-Thin-lf-sc-lgr.tfm \
tex-Roboto-Thin-lf-sc-lgr.vf \
tex-Roboto-Thin-lf-sc-ly1--base.tfm \
tex-Roboto-Thin-lf-sc-ly1.tfm \
tex-Roboto-Thin-lf-sc-ly1.vf \
tex-Roboto-Thin-lf-sc-ot1--base.tfm \
tex-Roboto-Thin-lf-sc-ot1.tfm \
tex-Roboto-Thin-lf-sc-ot1.vf \
tex-Roboto-Thin-lf-sc-t1--base.tfm \
tex-Roboto-Thin-lf-sc-t1.tfm \
tex-Roboto-Thin-lf-sc-t1.vf \
tex-Roboto-Thin-lf-t1--base.tfm \
tex-Roboto-Thin-lf-t1.tfm \
tex-Roboto-Thin-lf-t1.vf \
tex-Roboto-Thin-lf-ts1--base.tfm \
tex-Roboto-Thin-lf-ts1.tfm \
tex-Roboto-Thin-lf-ts1.vf \
tex-Roboto-Thin-osf-lgr--base.tfm \
tex-Roboto-Thin-osf-lgr.tfm \
tex-Roboto-Thin-osf-lgr.vf \
tex-Roboto-Thin-osf-ly1--base.tfm \
tex-Roboto-Thin-osf-ly1.tfm \
tex-Roboto-Thin-osf-ly1.vf \
tex-Roboto-Thin-osf-ot1.tfm \
tex-Roboto-Thin-osf-sc-lgr--base.tfm \
tex-Roboto-Thin-osf-sc-lgr.tfm \
tex-Roboto-Thin-osf-sc-lgr.vf \
tex-Roboto-Thin-osf-sc-ly1--base.tfm \
tex-Roboto-Thin-osf-sc-ly1.tfm \
tex-Roboto-Thin-osf-sc-ly1.vf \
tex-Roboto-Thin-osf-sc-ot1--base.tfm \
tex-Roboto-Thin-osf-sc-ot1.tfm \
tex-Roboto-Thin-osf-sc-ot1.vf \
tex-Roboto-Thin-osf-sc-t1--base.tfm \
tex-Roboto-Thin-osf-sc-t1.tfm \
tex-Roboto-Thin-osf-sc-t1.vf \
tex-Roboto-Thin-osf-t1--base.tfm \
tex-Roboto-Thin-osf-t1.tfm \
tex-Roboto-Thin-osf-t1.vf \
tex-Roboto-Thin-osf-ts1--base.tfm \
tex-Roboto-Thin-osf-ts1.tfm \
tex-Roboto-Thin-osf-ts1.vf \
tex-Roboto-Thin-tlf-lgr--base.tfm \
tex-Roboto-Thin-tlf-lgr.tfm \
tex-Roboto-Thin-tlf-lgr.vf \
tex-Roboto-Thin-tlf-ly1--base.tfm \
tex-Roboto-Thin-tlf-ly1.tfm \
tex-Roboto-Thin-tlf-ly1.vf \
tex-Roboto-Thin-tlf-ot1.tfm \
tex-Roboto-Thin-tlf-sc-lgr--base.tfm \
tex-Roboto-Thin-tlf-sc-lgr.tfm \
tex-Roboto-Thin-tlf-sc-lgr.vf \
tex-Roboto-Thin-tlf-sc-ly1--base.tfm \
tex-Roboto-Thin-tlf-sc-ly1.tfm \
tex-Roboto-Thin-tlf-sc-ly1.vf \
tex-Roboto-Thin-tlf-sc-ot1--base.tfm \
tex-Roboto-Thin-tlf-sc-ot1.tfm \
tex-Roboto-Thin-tlf-sc-ot1.vf \
tex-Roboto-Thin-tlf-sc-t1--base.tfm \
tex-Roboto-Thin-tlf-sc-t1.tfm \
tex-Roboto-Thin-tlf-sc-t1.vf \
tex-Roboto-Thin-tlf-t1--base.tfm \
tex-Roboto-Thin-tlf-t1.tfm \
tex-Roboto-Thin-tlf-t1.vf \
tex-Roboto-Thin-tlf-ts1--base.tfm \
tex-Roboto-Thin-tlf-ts1.tfm \
tex-Roboto-Thin-tlf-ts1.vf \
tex-Roboto-Thin-tosf-lgr--base.tfm \
tex-Roboto-Thin-tosf-lgr.tfm \
tex-Roboto-Thin-tosf-lgr.vf \
tex-Roboto-Thin-tosf-ly1--base.tfm \
tex-Roboto-Thin-tosf-ly1.tfm \
tex-Roboto-Thin-tosf-ly1.vf \
tex-Roboto-Thin-tosf-ot1.tfm \
tex-Roboto-Thin-tosf-sc-lgr--base.tfm \
tex-Roboto-Thin-tosf-sc-lgr.tfm \
tex-Roboto-Thin-tosf-sc-lgr.vf \
tex-Roboto-Thin-tosf-sc-ly1--base.tfm \
tex-Roboto-Thin-tosf-sc-ly1.tfm \
tex-Roboto-Thin-tosf-sc-ly1.vf \
tex-Roboto-Thin-tosf-sc-ot1--base.tfm \
tex-Roboto-Thin-tosf-sc-ot1.tfm \
tex-Roboto-Thin-tosf-sc-ot1.vf \
tex-Roboto-Thin-tosf-sc-t1--base.tfm \
tex-Roboto-Thin-tosf-sc-t1.tfm \
tex-Roboto-Thin-tosf-sc-t1.vf \
tex-Roboto-Thin-tosf-t1--base.tfm \
tex-Roboto-Thin-tosf-t1.tfm \
tex-Roboto-Thin-tosf-t1.vf \
tex-Roboto-Thin-tosf-ts1--base.tfm \
tex-Roboto-Thin-tosf-ts1.tfm \
tex-Roboto-Thin-tosf-ts1.vf \
tex-Roboto-ThinItalic-lf-lgr--base.tfm \
tex-Roboto-ThinItalic-lf-lgr.tfm \
tex-Roboto-ThinItalic-lf-lgr.vf \
tex-Roboto-ThinItalic-lf-ly1--base.tfm \
tex-Roboto-ThinItalic-lf-ly1.tfm \
tex-Roboto-ThinItalic-lf-ly1.vf \
tex-Roboto-ThinItalic-lf-ot1.tfm \
tex-Roboto-ThinItalic-lf-sc-lgr--base.tfm \
tex-Roboto-ThinItalic-lf-sc-lgr.tfm \
tex-Roboto-ThinItalic-lf-sc-lgr.vf \
tex-Roboto-ThinItalic-lf-sc-ly1--base.tfm \
tex-Roboto-ThinItalic-lf-sc-ly1.tfm \
tex-Roboto-ThinItalic-lf-sc-ly1.vf \
tex-Roboto-ThinItalic-lf-sc-ot1--base.tfm \
tex-Roboto-ThinItalic-lf-sc-ot1.tfm \
tex-Roboto-ThinItalic-lf-sc-ot1.vf \
tex-Roboto-ThinItalic-lf-sc-t1--base.tfm \
tex-Roboto-ThinItalic-lf-sc-t1.tfm \
tex-Roboto-ThinItalic-lf-sc-t1.vf \
tex-Roboto-ThinItalic-lf-t1--base.tfm \
tex-Roboto-ThinItalic-lf-t1.tfm \
tex-Roboto-ThinItalic-lf-t1.vf \
tex-Roboto-ThinItalic-lf-ts1--base.tfm \
tex-Roboto-ThinItalic-lf-ts1.tfm \
tex-Roboto-ThinItalic-lf-ts1.vf \
tex-Roboto-ThinItalic-osf-lgr--base.tfm \
tex-Roboto-ThinItalic-osf-lgr.tfm \
tex-Roboto-ThinItalic-osf-lgr.vf \
tex-Roboto-ThinItalic-osf-ly1--base.tfm \
tex-Roboto-ThinItalic-osf-ly1.tfm \
tex-Roboto-ThinItalic-osf-ly1.vf \
tex-Roboto-ThinItalic-osf-ot1.tfm \
tex-Roboto-ThinItalic-osf-sc-lgr--base.tfm \
tex-Roboto-ThinItalic-osf-sc-lgr.tfm \
tex-Roboto-ThinItalic-osf-sc-lgr.vf \
tex-Roboto-ThinItalic-osf-sc-ly1--base.tfm \
tex-Roboto-ThinItalic-osf-sc-ly1.tfm \
tex-Roboto-ThinItalic-osf-sc-ly1.vf \
tex-Roboto-ThinItalic-osf-sc-ot1--base.tfm \
tex-Roboto-ThinItalic-osf-sc-ot1.tfm \
tex-Roboto-ThinItalic-osf-sc-ot1.vf \
tex-Roboto-ThinItalic-osf-sc-t1--base.tfm \
tex-Roboto-ThinItalic-osf-sc-t1.tfm \
tex-Roboto-ThinItalic-osf-sc-t1.vf \
tex-Roboto-ThinItalic-osf-t1--base.tfm \
tex-Roboto-ThinItalic-osf-t1.tfm \
tex-Roboto-ThinItalic-osf-t1.vf \
tex-Roboto-ThinItalic-osf-ts1--base.tfm \
tex-Roboto-ThinItalic-osf-ts1.tfm \
tex-Roboto-ThinItalic-osf-ts1.vf \
tex-Roboto-ThinItalic-tlf-lgr--base.tfm \
tex-Roboto-ThinItalic-tlf-lgr.tfm \
tex-Roboto-ThinItalic-tlf-lgr.vf \
tex-Roboto-ThinItalic-tlf-ly1--base.tfm \
tex-Roboto-ThinItalic-tlf-ly1.tfm \
tex-Roboto-ThinItalic-tlf-ly1.vf \
tex-Roboto-ThinItalic-tlf-ot1.tfm \
tex-Roboto-ThinItalic-tlf-sc-lgr--base.tfm \
tex-Roboto-ThinItalic-tlf-sc-lgr.tfm \
tex-Roboto-ThinItalic-tlf-sc-lgr.vf \
tex-Roboto-ThinItalic-tlf-sc-ly1--base.tfm \
tex-Roboto-ThinItalic-tlf-sc-ly1.tfm \
tex-Roboto-ThinItalic-tlf-sc-ly1.vf \
tex-Roboto-ThinItalic-tlf-sc-ot1--base.tfm \
tex-Roboto-ThinItalic-tlf-sc-ot1.tfm \
tex-Roboto-ThinItalic-tlf-sc-ot1.vf \
tex-Roboto-ThinItalic-tlf-sc-t1--base.tfm \
tex-Roboto-ThinItalic-tlf-sc-t1.tfm \
tex-Roboto-ThinItalic-tlf-sc-t1.vf \
tex-Roboto-ThinItalic-tlf-t1--base.tfm \
tex-Roboto-ThinItalic-tlf-t1.tfm \
tex-Roboto-ThinItalic-tlf-t1.vf \
tex-Roboto-ThinItalic-tlf-ts1--base.tfm \
tex-Roboto-ThinItalic-tlf-ts1.tfm \
tex-Roboto-ThinItalic-tlf-ts1.vf \
tex-Roboto-ThinItalic-tosf-lgr--base.tfm \
tex-Roboto-ThinItalic-tosf-lgr.tfm \
tex-Roboto-ThinItalic-tosf-lgr.vf \
tex-Roboto-ThinItalic-tosf-ly1--base.tfm \
tex-Roboto-ThinItalic-tosf-ly1.tfm \
tex-Roboto-ThinItalic-tosf-ly1.vf \
tex-Roboto-ThinItalic-tosf-ot1.tfm \
tex-Roboto-ThinItalic-tosf-sc-lgr--base.tfm \
tex-Roboto-ThinItalic-tosf-sc-lgr.tfm \
tex-Roboto-ThinItalic-tosf-sc-lgr.vf \
tex-Roboto-ThinItalic-tosf-sc-ly1--base.tfm \
tex-Roboto-ThinItalic-tosf-sc-ly1.tfm \
tex-Roboto-ThinItalic-tosf-sc-ly1.vf \
tex-Roboto-ThinItalic-tosf-sc-ot1--base.tfm \
tex-Roboto-ThinItalic-tosf-sc-ot1.tfm \
tex-Roboto-ThinItalic-tosf-sc-ot1.vf \
tex-Roboto-ThinItalic-tosf-sc-t1--base.tfm \
tex-Roboto-ThinItalic-tosf-sc-t1.tfm \
tex-Roboto-ThinItalic-tosf-sc-t1.vf \
tex-Roboto-ThinItalic-tosf-t1--base.tfm \
tex-Roboto-ThinItalic-tosf-t1.tfm \
tex-Roboto-ThinItalic-tosf-t1.vf \
tex-Roboto-ThinItalic-tosf-ts1--base.tfm \
tex-Roboto-ThinItalic-tosf-ts1.tfm \
tex-Roboto-ThinItalic-tosf-ts1.vf \
tex-RobotoCondensed-Bold-lf-lgr--base.tfm \
tex-RobotoCondensed-Bold-lf-lgr.tfm \
tex-RobotoCondensed-Bold-lf-lgr.vf \
tex-RobotoCondensed-Bold-lf-ly1--base.tfm \
tex-RobotoCondensed-Bold-lf-ly1.tfm \
tex-RobotoCondensed-Bold-lf-ly1.vf \
tex-RobotoCondensed-Bold-lf-ot1.tfm \
tex-RobotoCondensed-Bold-lf-sc-lgr--base.tfm \
tex-RobotoCondensed-Bold-lf-sc-lgr.tfm \
tex-RobotoCondensed-Bold-lf-sc-lgr.vf \
tex-RobotoCondensed-Bold-lf-sc-ly1--base.tfm \
tex-RobotoCondensed-Bold-lf-sc-ly1.tfm \
tex-RobotoCondensed-Bold-lf-sc-ly1.vf \
tex-RobotoCondensed-Bold-lf-sc-ot1--base.tfm \
tex-RobotoCondensed-Bold-lf-sc-ot1.tfm \
tex-RobotoCondensed-Bold-lf-sc-ot1.vf \
tex-RobotoCondensed-Bold-lf-sc-t1--base.tfm \
tex-RobotoCondensed-Bold-lf-sc-t1.tfm \
tex-RobotoCondensed-Bold-lf-sc-t1.vf \
tex-RobotoCondensed-Bold-lf-t1--base.tfm \
tex-RobotoCondensed-Bold-lf-t1.tfm \
tex-RobotoCondensed-Bold-lf-t1.vf \
tex-RobotoCondensed-Bold-lf-ts1--base.tfm \
tex-RobotoCondensed-Bold-lf-ts1.tfm \
tex-RobotoCondensed-Bold-lf-ts1.vf \
tex-RobotoCondensed-Bold-osf-lgr--base.tfm \
tex-RobotoCondensed-Bold-osf-lgr.tfm \
tex-RobotoCondensed-Bold-osf-lgr.vf \
tex-RobotoCondensed-Bold-osf-ly1--base.tfm \
tex-RobotoCondensed-Bold-osf-ly1.tfm \
tex-RobotoCondensed-Bold-osf-ly1.vf \
tex-RobotoCondensed-Bold-osf-ot1.tfm \
tex-RobotoCondensed-Bold-osf-sc-lgr--base.tfm \
tex-RobotoCondensed-Bold-osf-sc-lgr.tfm \
tex-RobotoCondensed-Bold-osf-sc-lgr.vf \
tex-RobotoCondensed-Bold-osf-sc-ly1--base.tfm \
tex-RobotoCondensed-Bold-osf-sc-ly1.tfm \
tex-RobotoCondensed-Bold-osf-sc-ly1.vf \
tex-RobotoCondensed-Bold-osf-sc-ot1--base.tfm \
tex-RobotoCondensed-Bold-osf-sc-ot1.tfm \
tex-RobotoCondensed-Bold-osf-sc-ot1.vf \
tex-RobotoCondensed-Bold-osf-sc-t1--base.tfm \
tex-RobotoCondensed-Bold-osf-sc-t1.tfm \
tex-RobotoCondensed-Bold-osf-sc-t1.vf \
tex-RobotoCondensed-Bold-osf-t1--base.tfm \
tex-RobotoCondensed-Bold-osf-t1.tfm \
tex-RobotoCondensed-Bold-osf-t1.vf \
tex-RobotoCondensed-Bold-osf-ts1--base.tfm \
tex-RobotoCondensed-Bold-osf-ts1.tfm \
tex-RobotoCondensed-Bold-osf-ts1.vf \
tex-RobotoCondensed-Bold-tlf-lgr--base.tfm \
tex-RobotoCondensed-Bold-tlf-lgr.tfm \
tex-RobotoCondensed-Bold-tlf-lgr.vf \
tex-RobotoCondensed-Bold-tlf-ly1--base.tfm \
tex-RobotoCondensed-Bold-tlf-ly1.tfm \
tex-RobotoCondensed-Bold-tlf-ly1.vf \
tex-RobotoCondensed-Bold-tlf-ot1.tfm \
tex-RobotoCondensed-Bold-tlf-sc-lgr--base.tfm \
tex-RobotoCondensed-Bold-tlf-sc-lgr.tfm \
tex-RobotoCondensed-Bold-tlf-sc-lgr.vf \
tex-RobotoCondensed-Bold-tlf-sc-ly1--base.tfm \
tex-RobotoCondensed-Bold-tlf-sc-ly1.tfm \
tex-RobotoCondensed-Bold-tlf-sc-ly1.vf \
tex-RobotoCondensed-Bold-tlf-sc-ot1--base.tfm \
tex-RobotoCondensed-Bold-tlf-sc-ot1.tfm \
tex-RobotoCondensed-Bold-tlf-sc-ot1.vf \
tex-RobotoCondensed-Bold-tlf-sc-t1--base.tfm \
tex-RobotoCondensed-Bold-tlf-sc-t1.tfm \
tex-RobotoCondensed-Bold-tlf-sc-t1.vf \
tex-RobotoCondensed-Bold-tlf-t1--base.tfm \
tex-RobotoCondensed-Bold-tlf-t1.tfm \
tex-RobotoCondensed-Bold-tlf-t1.vf \
tex-RobotoCondensed-Bold-tlf-ts1--base.tfm \
tex-RobotoCondensed-Bold-tlf-ts1.tfm \
tex-RobotoCondensed-Bold-tlf-ts1.vf \
tex-RobotoCondensed-Bold-tosf-lgr--base.tfm \
tex-RobotoCondensed-Bold-tosf-lgr.tfm \
tex-RobotoCondensed-Bold-tosf-lgr.vf \
tex-RobotoCondensed-Bold-tosf-ly1--base.tfm \
tex-RobotoCondensed-Bold-tosf-ly1.tfm \
tex-RobotoCondensed-Bold-tosf-ly1.vf \
tex-RobotoCondensed-Bold-tosf-ot1.tfm \
tex-RobotoCondensed-Bold-tosf-sc-lgr--base.tfm \
tex-RobotoCondensed-Bold-tosf-sc-lgr.tfm \
tex-RobotoCondensed-Bold-tosf-sc-lgr.vf \
tex-RobotoCondensed-Bold-tosf-sc-ly1--base.tfm \
tex-RobotoCondensed-Bold-tosf-sc-ly1.tfm \
tex-RobotoCondensed-Bold-tosf-sc-ly1.vf \
tex-RobotoCondensed-Bold-tosf-sc-ot1--base.tfm \
tex-RobotoCondensed-Bold-tosf-sc-ot1.tfm \
tex-RobotoCondensed-Bold-tosf-sc-ot1.vf \
tex-RobotoCondensed-Bold-tosf-sc-t1--base.tfm \
tex-RobotoCondensed-Bold-tosf-sc-t1.tfm \
tex-RobotoCondensed-Bold-tosf-sc-t1.vf \
tex-RobotoCondensed-Bold-tosf-t1--base.tfm \
tex-RobotoCondensed-Bold-tosf-t1.tfm \
tex-RobotoCondensed-Bold-tosf-t1.vf \
tex-RobotoCondensed-Bold-tosf-ts1--base.tfm \
tex-RobotoCondensed-Bold-tosf-ts1.tfm \
tex-RobotoCondensed-Bold-tosf-ts1.vf \
tex-RobotoCondensed-BoldItalic-lf-lgr--base.tfm \
tex-RobotoCondensed-BoldItalic-lf-lgr.tfm \
tex-RobotoCondensed-BoldItalic-lf-lgr.vf \
tex-RobotoCondensed-BoldItalic-lf-ly1--base.tfm \
tex-RobotoCondensed-BoldItalic-lf-ly1.tfm \
tex-RobotoCondensed-BoldItalic-lf-ly1.vf \
tex-RobotoCondensed-BoldItalic-lf-ot1.tfm \
tex-RobotoCondensed-BoldItalic-lf-sc-lgr--base.tfm \
tex-RobotoCondensed-BoldItalic-lf-sc-lgr.tfm \
tex-RobotoCondensed-BoldItalic-lf-sc-lgr.vf \
tex-RobotoCondensed-BoldItalic-lf-sc-ly1--base.tfm \
tex-RobotoCondensed-BoldItalic-lf-sc-ly1.tfm \
tex-RobotoCondensed-BoldItalic-lf-sc-ly1.vf \
tex-RobotoCondensed-BoldItalic-lf-sc-ot1--base.tfm \
tex-RobotoCondensed-BoldItalic-lf-sc-ot1.tfm \
tex-RobotoCondensed-BoldItalic-lf-sc-ot1.vf \
tex-RobotoCondensed-BoldItalic-lf-sc-t1--base.tfm \
tex-RobotoCondensed-BoldItalic-lf-sc-t1.tfm \
tex-RobotoCondensed-BoldItalic-lf-sc-t1.vf \
tex-RobotoCondensed-BoldItalic-lf-t1--base.tfm \
tex-RobotoCondensed-BoldItalic-lf-t1.tfm \
tex-RobotoCondensed-BoldItalic-lf-t1.vf \
tex-RobotoCondensed-BoldItalic-lf-ts1--base.tfm \
tex-RobotoCondensed-BoldItalic-lf-ts1.tfm \
tex-RobotoCondensed-BoldItalic-lf-ts1.vf \
tex-RobotoCondensed-BoldItalic-osf-lgr--base.tfm \
tex-RobotoCondensed-BoldItalic-osf-lgr.tfm \
tex-RobotoCondensed-BoldItalic-osf-lgr.vf \
tex-RobotoCondensed-BoldItalic-osf-ly1--base.tfm \
tex-RobotoCondensed-BoldItalic-osf-ly1.tfm \
tex-RobotoCondensed-BoldItalic-osf-ly1.vf \
tex-RobotoCondensed-BoldItalic-osf-ot1.tfm \
tex-RobotoCondensed-BoldItalic-osf-sc-lgr--base.tfm \
tex-RobotoCondensed-BoldItalic-osf-sc-lgr.tfm \
tex-RobotoCondensed-BoldItalic-osf-sc-lgr.vf \
tex-RobotoCondensed-BoldItalic-osf-sc-ly1--base.tfm \
tex-RobotoCondensed-BoldItalic-osf-sc-ly1.tfm \
tex-RobotoCondensed-BoldItalic-osf-sc-ly1.vf \
tex-RobotoCondensed-BoldItalic-osf-sc-ot1--base.tfm \
tex-RobotoCondensed-BoldItalic-osf-sc-ot1.tfm \
tex-RobotoCondensed-BoldItalic-osf-sc-ot1.vf \
tex-RobotoCondensed-BoldItalic-osf-sc-t1--base.tfm \
tex-RobotoCondensed-BoldItalic-osf-sc-t1.tfm \
tex-RobotoCondensed-BoldItalic-osf-sc-t1.vf \
tex-RobotoCondensed-BoldItalic-osf-t1--base.tfm \
tex-RobotoCondensed-BoldItalic-osf-t1.tfm \
tex-RobotoCondensed-BoldItalic-osf-t1.vf \
tex-RobotoCondensed-BoldItalic-osf-ts1--base.tfm \
tex-RobotoCondensed-BoldItalic-osf-ts1.tfm \
tex-RobotoCondensed-BoldItalic-osf-ts1.vf \
tex-RobotoCondensed-BoldItalic-tlf-lgr--base.tfm \
tex-RobotoCondensed-BoldItalic-tlf-lgr.tfm \
tex-RobotoCondensed-BoldItalic-tlf-lgr.vf \
tex-RobotoCondensed-BoldItalic-tlf-ly1--base.tfm \
tex-RobotoCondensed-BoldItalic-tlf-ly1.tfm \
tex-RobotoCondensed-BoldItalic-tlf-ly1.vf \
tex-RobotoCondensed-BoldItalic-tlf-ot1.tfm \
tex-RobotoCondensed-BoldItalic-tlf-sc-lgr--base.tfm \
tex-RobotoCondensed-BoldItalic-tlf-sc-lgr.tfm \
tex-RobotoCondensed-BoldItalic-tlf-sc-lgr.vf \
tex-RobotoCondensed-BoldItalic-tlf-sc-ly1--base.tfm \
tex-RobotoCondensed-BoldItalic-tlf-sc-ly1.tfm \
tex-RobotoCondensed-BoldItalic-tlf-sc-ly1.vf \
tex-RobotoCondensed-BoldItalic-tlf-sc-ot1--base.tfm \
tex-RobotoCondensed-BoldItalic-tlf-sc-ot1.tfm \
tex-RobotoCondensed-BoldItalic-tlf-sc-ot1.vf \
tex-RobotoCondensed-BoldItalic-tlf-sc-t1--base.tfm \
tex-RobotoCondensed-BoldItalic-tlf-sc-t1.tfm \
tex-RobotoCondensed-BoldItalic-tlf-sc-t1.vf \
tex-RobotoCondensed-BoldItalic-tlf-t1--base.tfm \
tex-RobotoCondensed-BoldItalic-tlf-t1.tfm \
tex-RobotoCondensed-BoldItalic-tlf-t1.vf \
tex-RobotoCondensed-BoldItalic-tlf-ts1--base.tfm \
tex-RobotoCondensed-BoldItalic-tlf-ts1.tfm \
tex-RobotoCondensed-BoldItalic-tlf-ts1.vf \
tex-RobotoCondensed-BoldItalic-tosf-lgr--base.tfm \
tex-RobotoCondensed-BoldItalic-tosf-lgr.tfm \
tex-RobotoCondensed-BoldItalic-tosf-lgr.vf \
tex-RobotoCondensed-BoldItalic-tosf-ly1--base.tfm \
tex-RobotoCondensed-BoldItalic-tosf-ly1.tfm \
tex-RobotoCondensed-BoldItalic-tosf-ly1.vf \
tex-RobotoCondensed-BoldItalic-tosf-ot1.tfm \
tex-RobotoCondensed-BoldItalic-tosf-sc-lgr--base.tfm \
tex-RobotoCondensed-BoldItalic-tosf-sc-lgr.tfm \
tex-RobotoCondensed-BoldItalic-tosf-sc-lgr.vf \
tex-RobotoCondensed-BoldItalic-tosf-sc-ly1--base.tfm \
tex-RobotoCondensed-BoldItalic-tosf-sc-ly1.tfm \
tex-RobotoCondensed-BoldItalic-tosf-sc-ly1.vf \
tex-RobotoCondensed-BoldItalic-tosf-sc-ot1--base.tfm \
tex-RobotoCondensed-BoldItalic-tosf-sc-ot1.tfm \
tex-RobotoCondensed-BoldItalic-tosf-sc-ot1.vf \
tex-RobotoCondensed-BoldItalic-tosf-sc-t1--base.tfm \
tex-RobotoCondensed-BoldItalic-tosf-sc-t1.tfm \
tex-RobotoCondensed-BoldItalic-tosf-sc-t1.vf \
tex-RobotoCondensed-BoldItalic-tosf-t1--base.tfm \
tex-RobotoCondensed-BoldItalic-tosf-t1.tfm \
tex-RobotoCondensed-BoldItalic-tosf-t1.vf \
tex-RobotoCondensed-BoldItalic-tosf-ts1--base.tfm \
tex-RobotoCondensed-BoldItalic-tosf-ts1.tfm \
tex-RobotoCondensed-BoldItalic-tosf-ts1.vf \
tex-RobotoCondensed-Italic-lf-lgr--base.tfm \
tex-RobotoCondensed-Italic-lf-lgr.tfm \
tex-RobotoCondensed-Italic-lf-lgr.vf \
tex-RobotoCondensed-Italic-lf-ly1--base.tfm \
tex-RobotoCondensed-Italic-lf-ly1.tfm \
tex-RobotoCondensed-Italic-lf-ly1.vf \
tex-RobotoCondensed-Italic-lf-ot1.tfm \
tex-RobotoCondensed-Italic-lf-sc-lgr--base.tfm \
tex-RobotoCondensed-Italic-lf-sc-lgr.tfm \
tex-RobotoCondensed-Italic-lf-sc-lgr.vf \
tex-RobotoCondensed-Italic-lf-sc-ly1--base.tfm \
tex-RobotoCondensed-Italic-lf-sc-ly1.tfm \
tex-RobotoCondensed-Italic-lf-sc-ly1.vf \
tex-RobotoCondensed-Italic-lf-sc-ot1--base.tfm \
tex-RobotoCondensed-Italic-lf-sc-ot1.tfm \
tex-RobotoCondensed-Italic-lf-sc-ot1.vf \
tex-RobotoCondensed-Italic-lf-sc-t1--base.tfm \
tex-RobotoCondensed-Italic-lf-sc-t1.tfm \
tex-RobotoCondensed-Italic-lf-sc-t1.vf \
tex-RobotoCondensed-Italic-lf-t1--base.tfm \
tex-RobotoCondensed-Italic-lf-t1.tfm \
tex-RobotoCondensed-Italic-lf-t1.vf \
tex-RobotoCondensed-Italic-lf-ts1--base.tfm \
tex-RobotoCondensed-Italic-lf-ts1.tfm \
tex-RobotoCondensed-Italic-lf-ts1.vf \
tex-RobotoCondensed-Italic-osf-lgr--base.tfm \
tex-RobotoCondensed-Italic-osf-lgr.tfm \
tex-RobotoCondensed-Italic-osf-lgr.vf \
tex-RobotoCondensed-Italic-osf-ly1--base.tfm \
tex-RobotoCondensed-Italic-osf-ly1.tfm \
tex-RobotoCondensed-Italic-osf-ly1.vf \
tex-RobotoCondensed-Italic-osf-ot1.tfm \
tex-RobotoCondensed-Italic-osf-sc-lgr--base.tfm \
tex-RobotoCondensed-Italic-osf-sc-lgr.tfm \
tex-RobotoCondensed-Italic-osf-sc-lgr.vf \
tex-RobotoCondensed-Italic-osf-sc-ly1--base.tfm \
tex-RobotoCondensed-Italic-osf-sc-ly1.tfm \
tex-RobotoCondensed-Italic-osf-sc-ly1.vf \
tex-RobotoCondensed-Italic-osf-sc-ot1--base.tfm \
tex-RobotoCondensed-Italic-osf-sc-ot1.tfm \
tex-RobotoCondensed-Italic-osf-sc-ot1.vf \
tex-RobotoCondensed-Italic-osf-sc-t1--base.tfm \
tex-RobotoCondensed-Italic-osf-sc-t1.tfm \
tex-RobotoCondensed-Italic-osf-sc-t1.vf \
tex-RobotoCondensed-Italic-osf-t1--base.tfm \
tex-RobotoCondensed-Italic-osf-t1.tfm \
tex-RobotoCondensed-Italic-osf-t1.vf \
tex-RobotoCondensed-Italic-osf-ts1--base.tfm \
tex-RobotoCondensed-Italic-osf-ts1.tfm \
tex-RobotoCondensed-Italic-osf-ts1.vf \
tex-RobotoCondensed-Italic-tlf-lgr--base.tfm \
tex-RobotoCondensed-Italic-tlf-lgr.tfm \
tex-RobotoCondensed-Italic-tlf-lgr.vf \
tex-RobotoCondensed-Italic-tlf-ly1--base.tfm \
tex-RobotoCondensed-Italic-tlf-ly1.tfm \
tex-RobotoCondensed-Italic-tlf-ly1.vf \
tex-RobotoCondensed-Italic-tlf-ot1.tfm \
tex-RobotoCondensed-Italic-tlf-sc-lgr--base.tfm \
tex-RobotoCondensed-Italic-tlf-sc-lgr.tfm \
tex-RobotoCondensed-Italic-tlf-sc-lgr.vf \
tex-RobotoCondensed-Italic-tlf-sc-ly1--base.tfm \
tex-RobotoCondensed-Italic-tlf-sc-ly1.tfm \
tex-RobotoCondensed-Italic-tlf-sc-ly1.vf \
tex-RobotoCondensed-Italic-tlf-sc-ot1--base.tfm \
tex-RobotoCondensed-Italic-tlf-sc-ot1.tfm \
tex-RobotoCondensed-Italic-tlf-sc-ot1.vf \
tex-RobotoCondensed-Italic-tlf-sc-t1--base.tfm \
tex-RobotoCondensed-Italic-tlf-sc-t1.tfm \
tex-RobotoCondensed-Italic-tlf-sc-t1.vf \
tex-RobotoCondensed-Italic-tlf-t1--base.tfm \
tex-RobotoCondensed-Italic-tlf-t1.tfm \
tex-RobotoCondensed-Italic-tlf-t1.vf \
tex-RobotoCondensed-Italic-tlf-ts1--base.tfm \
tex-RobotoCondensed-Italic-tlf-ts1.tfm \
tex-RobotoCondensed-Italic-tlf-ts1.vf \
tex-RobotoCondensed-Italic-tosf-lgr--base.tfm \
tex-RobotoCondensed-Italic-tosf-lgr.tfm \
tex-RobotoCondensed-Italic-tosf-lgr.vf \
tex-RobotoCondensed-Italic-tosf-ly1--base.tfm \
tex-RobotoCondensed-Italic-tosf-ly1.tfm \
tex-RobotoCondensed-Italic-tosf-ly1.vf \
tex-RobotoCondensed-Italic-tosf-ot1.tfm \
tex-RobotoCondensed-Italic-tosf-sc-lgr--base.tfm \
tex-RobotoCondensed-Italic-tosf-sc-lgr.tfm \
tex-RobotoCondensed-Italic-tosf-sc-lgr.vf \
tex-RobotoCondensed-Italic-tosf-sc-ly1--base.tfm \
tex-RobotoCondensed-Italic-tosf-sc-ly1.tfm \
tex-RobotoCondensed-Italic-tosf-sc-ly1.vf \
tex-RobotoCondensed-Italic-tosf-sc-ot1--base.tfm \
tex-RobotoCondensed-Italic-tosf-sc-ot1.tfm \
tex-RobotoCondensed-Italic-tosf-sc-ot1.vf \
tex-RobotoCondensed-Italic-tosf-sc-t1--base.tfm \
tex-RobotoCondensed-Italic-tosf-sc-t1.tfm \
tex-RobotoCondensed-Italic-tosf-sc-t1.vf \
tex-RobotoCondensed-Italic-tosf-t1--base.tfm \
tex-RobotoCondensed-Italic-tosf-t1.tfm \
tex-RobotoCondensed-Italic-tosf-t1.vf \
tex-RobotoCondensed-Italic-tosf-ts1--base.tfm \
tex-RobotoCondensed-Italic-tosf-ts1.tfm \
tex-RobotoCondensed-Italic-tosf-ts1.vf \
tex-RobotoCondensed-Light-lf-lgr--base.tfm \
tex-RobotoCondensed-Light-lf-lgr.tfm \
tex-RobotoCondensed-Light-lf-lgr.vf \
tex-RobotoCondensed-Light-lf-ly1--base.tfm \
tex-RobotoCondensed-Light-lf-ly1.tfm \
tex-RobotoCondensed-Light-lf-ly1.vf \
tex-RobotoCondensed-Light-lf-ot1.tfm \
tex-RobotoCondensed-Light-lf-sc-lgr--base.tfm \
tex-RobotoCondensed-Light-lf-sc-lgr.tfm \
tex-RobotoCondensed-Light-lf-sc-lgr.vf \
tex-RobotoCondensed-Light-lf-sc-ly1--base.tfm \
tex-RobotoCondensed-Light-lf-sc-ly1.tfm \
tex-RobotoCondensed-Light-lf-sc-ly1.vf \
tex-RobotoCondensed-Light-lf-sc-ot1--base.tfm \
tex-RobotoCondensed-Light-lf-sc-ot1.tfm \
tex-RobotoCondensed-Light-lf-sc-ot1.vf \
tex-RobotoCondensed-Light-lf-sc-t1--base.tfm \
tex-RobotoCondensed-Light-lf-sc-t1.tfm \
tex-RobotoCondensed-Light-lf-sc-t1.vf \
tex-RobotoCondensed-Light-lf-t1--base.tfm \
tex-RobotoCondensed-Light-lf-t1.tfm \
tex-RobotoCondensed-Light-lf-t1.vf \
tex-RobotoCondensed-Light-lf-ts1--base.tfm \
tex-RobotoCondensed-Light-lf-ts1.tfm \
tex-RobotoCondensed-Light-lf-ts1.vf \
tex-RobotoCondensed-Light-osf-lgr--base.tfm \
tex-RobotoCondensed-Light-osf-lgr.tfm \
tex-RobotoCondensed-Light-osf-lgr.vf \
tex-RobotoCondensed-Light-osf-ly1--base.tfm \
tex-RobotoCondensed-Light-osf-ly1.tfm \
tex-RobotoCondensed-Light-osf-ly1.vf \
tex-RobotoCondensed-Light-osf-ot1.tfm \
tex-RobotoCondensed-Light-osf-sc-lgr--base.tfm \
tex-RobotoCondensed-Light-osf-sc-lgr.tfm \
tex-RobotoCondensed-Light-osf-sc-lgr.vf \
tex-RobotoCondensed-Light-osf-sc-ly1--base.tfm \
tex-RobotoCondensed-Light-osf-sc-ly1.tfm \
tex-RobotoCondensed-Light-osf-sc-ly1.vf \
tex-RobotoCondensed-Light-osf-sc-ot1--base.tfm \
tex-RobotoCondensed-Light-osf-sc-ot1.tfm \
tex-RobotoCondensed-Light-osf-sc-ot1.vf \
tex-RobotoCondensed-Light-osf-sc-t1--base.tfm \
tex-RobotoCondensed-Light-osf-sc-t1.tfm \
tex-RobotoCondensed-Light-osf-sc-t1.vf \
tex-RobotoCondensed-Light-osf-t1--base.tfm \
tex-RobotoCondensed-Light-osf-t1.tfm \
tex-RobotoCondensed-Light-osf-t1.vf \
tex-RobotoCondensed-Light-osf-ts1--base.tfm \
tex-RobotoCondensed-Light-osf-ts1.tfm \
tex-RobotoCondensed-Light-osf-ts1.vf \
tex-RobotoCondensed-Light-tlf-lgr--base.tfm \
tex-RobotoCondensed-Light-tlf-lgr.tfm \
tex-RobotoCondensed-Light-tlf-lgr.vf \
tex-RobotoCondensed-Light-tlf-ly1--base.tfm \
tex-RobotoCondensed-Light-tlf-ly1.tfm \
tex-RobotoCondensed-Light-tlf-ly1.vf \
tex-RobotoCondensed-Light-tlf-ot1.tfm \
tex-RobotoCondensed-Light-tlf-sc-lgr--base.tfm \
tex-RobotoCondensed-Light-tlf-sc-lgr.tfm \
tex-RobotoCondensed-Light-tlf-sc-lgr.vf \
tex-RobotoCondensed-Light-tlf-sc-ly1--base.tfm \
tex-RobotoCondensed-Light-tlf-sc-ly1.tfm \
tex-RobotoCondensed-Light-tlf-sc-ly1.vf \
tex-RobotoCondensed-Light-tlf-sc-ot1--base.tfm \
tex-RobotoCondensed-Light-tlf-sc-ot1.tfm \
tex-RobotoCondensed-Light-tlf-sc-ot1.vf \
tex-RobotoCondensed-Light-tlf-sc-t1--base.tfm \
tex-RobotoCondensed-Light-tlf-sc-t1.tfm \
tex-RobotoCondensed-Light-tlf-sc-t1.vf \
tex-RobotoCondensed-Light-tlf-t1--base.tfm \
tex-RobotoCondensed-Light-tlf-t1.tfm \
tex-RobotoCondensed-Light-tlf-t1.vf \
tex-RobotoCondensed-Light-tlf-ts1--base.tfm \
tex-RobotoCondensed-Light-tlf-ts1.tfm \
tex-RobotoCondensed-Light-tlf-ts1.vf \
tex-RobotoCondensed-Light-tosf-lgr--base.tfm \
tex-RobotoCondensed-Light-tosf-lgr.tfm \
tex-RobotoCondensed-Light-tosf-lgr.vf \
tex-RobotoCondensed-Light-tosf-ly1--base.tfm \
tex-RobotoCondensed-Light-tosf-ly1.tfm \
tex-RobotoCondensed-Light-tosf-ly1.vf \
tex-RobotoCondensed-Light-tosf-ot1.tfm \
tex-RobotoCondensed-Light-tosf-sc-lgr--base.tfm \
tex-RobotoCondensed-Light-tosf-sc-lgr.tfm \
tex-RobotoCondensed-Light-tosf-sc-lgr.vf \
tex-RobotoCondensed-Light-tosf-sc-ly1--base.tfm \
tex-RobotoCondensed-Light-tosf-sc-ly1.tfm \
tex-RobotoCondensed-Light-tosf-sc-ly1.vf \
tex-RobotoCondensed-Light-tosf-sc-ot1--base.tfm \
tex-RobotoCondensed-Light-tosf-sc-ot1.tfm \
tex-RobotoCondensed-Light-tosf-sc-ot1.vf \
tex-RobotoCondensed-Light-tosf-sc-t1--base.tfm \
tex-RobotoCondensed-Light-tosf-sc-t1.tfm \
tex-RobotoCondensed-Light-tosf-sc-t1.vf \
tex-RobotoCondensed-Light-tosf-t1--base.tfm \
tex-RobotoCondensed-Light-tosf-t1.tfm \
tex-RobotoCondensed-Light-tosf-t1.vf \
tex-RobotoCondensed-Light-tosf-ts1--base.tfm \
tex-RobotoCondensed-Light-tosf-ts1.tfm \
tex-RobotoCondensed-Light-tosf-ts1.vf \
tex-RobotoCondensed-LightItalic-lf-lgr--base.tfm \
tex-RobotoCondensed-LightItalic-lf-lgr.tfm \
tex-RobotoCondensed-LightItalic-lf-lgr.vf \
tex-RobotoCondensed-LightItalic-lf-ly1--base.tfm \
tex-RobotoCondensed-LightItalic-lf-ly1.tfm \
tex-RobotoCondensed-LightItalic-lf-ly1.vf \
tex-RobotoCondensed-LightItalic-lf-ot1.tfm \
tex-RobotoCondensed-LightItalic-lf-sc-lgr--base.tfm \
tex-RobotoCondensed-LightItalic-lf-sc-lgr.tfm \
tex-RobotoCondensed-LightItalic-lf-sc-lgr.vf \
tex-RobotoCondensed-LightItalic-lf-sc-ly1--base.tfm \
tex-RobotoCondensed-LightItalic-lf-sc-ly1.tfm \
tex-RobotoCondensed-LightItalic-lf-sc-ly1.vf \
tex-RobotoCondensed-LightItalic-lf-sc-ot1--base.tfm \
tex-RobotoCondensed-LightItalic-lf-sc-ot1.tfm \
tex-RobotoCondensed-LightItalic-lf-sc-ot1.vf \
tex-RobotoCondensed-LightItalic-lf-sc-t1--base.tfm \
tex-RobotoCondensed-LightItalic-lf-sc-t1.tfm \
tex-RobotoCondensed-LightItalic-lf-sc-t1.vf \
tex-RobotoCondensed-LightItalic-lf-t1--base.tfm \
tex-RobotoCondensed-LightItalic-lf-t1.tfm \
tex-RobotoCondensed-LightItalic-lf-t1.vf \
tex-RobotoCondensed-LightItalic-lf-ts1--base.tfm \
tex-RobotoCondensed-LightItalic-lf-ts1.tfm \
tex-RobotoCondensed-LightItalic-lf-ts1.vf \
tex-RobotoCondensed-LightItalic-osf-lgr--base.tfm \
tex-RobotoCondensed-LightItalic-osf-lgr.tfm \
tex-RobotoCondensed-LightItalic-osf-lgr.vf \
tex-RobotoCondensed-LightItalic-osf-ly1--base.tfm \
tex-RobotoCondensed-LightItalic-osf-ly1.tfm \
tex-RobotoCondensed-LightItalic-osf-ly1.vf \
tex-RobotoCondensed-LightItalic-osf-ot1.tfm \
tex-RobotoCondensed-LightItalic-osf-sc-lgr--base.tfm \
tex-RobotoCondensed-LightItalic-osf-sc-lgr.tfm \
tex-RobotoCondensed-LightItalic-osf-sc-lgr.vf \
tex-RobotoCondensed-LightItalic-osf-sc-ly1--base.tfm \
tex-RobotoCondensed-LightItalic-osf-sc-ly1.tfm \
tex-RobotoCondensed-LightItalic-osf-sc-ly1.vf \
tex-RobotoCondensed-LightItalic-osf-sc-ot1--base.tfm \
tex-RobotoCondensed-LightItalic-osf-sc-ot1.tfm \
tex-RobotoCondensed-LightItalic-osf-sc-ot1.vf \
tex-RobotoCondensed-LightItalic-osf-sc-t1--base.tfm \
tex-RobotoCondensed-LightItalic-osf-sc-t1.tfm \
tex-RobotoCondensed-LightItalic-osf-sc-t1.vf \
tex-RobotoCondensed-LightItalic-osf-t1--base.tfm \
tex-RobotoCondensed-LightItalic-osf-t1.tfm \
tex-RobotoCondensed-LightItalic-osf-t1.vf \
tex-RobotoCondensed-LightItalic-osf-ts1--base.tfm \
tex-RobotoCondensed-LightItalic-osf-ts1.tfm \
tex-RobotoCondensed-LightItalic-osf-ts1.vf \
tex-RobotoCondensed-LightItalic-tlf-lgr--base.tfm \
tex-RobotoCondensed-LightItalic-tlf-lgr.tfm \
tex-RobotoCondensed-LightItalic-tlf-lgr.vf \
tex-RobotoCondensed-LightItalic-tlf-ly1--base.tfm \
tex-RobotoCondensed-LightItalic-tlf-ly1.tfm \
tex-RobotoCondensed-LightItalic-tlf-ly1.vf \
tex-RobotoCondensed-LightItalic-tlf-ot1.tfm \
tex-RobotoCondensed-LightItalic-tlf-sc-lgr--base.tfm \
tex-RobotoCondensed-LightItalic-tlf-sc-lgr.tfm \
tex-RobotoCondensed-LightItalic-tlf-sc-lgr.vf \
tex-RobotoCondensed-LightItalic-tlf-sc-ly1--base.tfm \
tex-RobotoCondensed-LightItalic-tlf-sc-ly1.tfm \
tex-RobotoCondensed-LightItalic-tlf-sc-ly1.vf \
tex-RobotoCondensed-LightItalic-tlf-sc-ot1--base.tfm \
tex-RobotoCondensed-LightItalic-tlf-sc-ot1.tfm \
tex-RobotoCondensed-LightItalic-tlf-sc-ot1.vf \
tex-RobotoCondensed-LightItalic-tlf-sc-t1--base.tfm \
tex-RobotoCondensed-LightItalic-tlf-sc-t1.tfm \
tex-RobotoCondensed-LightItalic-tlf-sc-t1.vf \
tex-RobotoCondensed-LightItalic-tlf-t1--base.tfm \
tex-RobotoCondensed-LightItalic-tlf-t1.tfm \
tex-RobotoCondensed-LightItalic-tlf-t1.vf \
tex-RobotoCondensed-LightItalic-tlf-ts1--base.tfm \
tex-RobotoCondensed-LightItalic-tlf-ts1.tfm \
tex-RobotoCondensed-LightItalic-tlf-ts1.vf \
tex-RobotoCondensed-LightItalic-tosf-lgr--base.tfm \
tex-RobotoCondensed-LightItalic-tosf-lgr.tfm \
tex-RobotoCondensed-LightItalic-tosf-lgr.vf \
tex-RobotoCondensed-LightItalic-tosf-ly1--base.tfm \
tex-RobotoCondensed-LightItalic-tosf-ly1.tfm \
tex-RobotoCondensed-LightItalic-tosf-ly1.vf \
tex-RobotoCondensed-LightItalic-tosf-ot1.tfm \
tex-RobotoCondensed-LightItalic-tosf-sc-lgr--base.tfm \
tex-RobotoCondensed-LightItalic-tosf-sc-lgr.tfm \
tex-RobotoCondensed-LightItalic-tosf-sc-lgr.vf \
tex-RobotoCondensed-LightItalic-tosf-sc-ly1--base.tfm \
tex-RobotoCondensed-LightItalic-tosf-sc-ly1.tfm \
tex-RobotoCondensed-LightItalic-tosf-sc-ly1.vf \
tex-RobotoCondensed-LightItalic-tosf-sc-ot1--base.tfm \
tex-RobotoCondensed-LightItalic-tosf-sc-ot1.tfm \
tex-RobotoCondensed-LightItalic-tosf-sc-ot1.vf \
tex-RobotoCondensed-LightItalic-tosf-sc-t1--base.tfm \
tex-RobotoCondensed-LightItalic-tosf-sc-t1.tfm \
tex-RobotoCondensed-LightItalic-tosf-sc-t1.vf \
tex-RobotoCondensed-LightItalic-tosf-t1--base.tfm \
tex-RobotoCondensed-LightItalic-tosf-t1.tfm \
tex-RobotoCondensed-LightItalic-tosf-t1.vf \
tex-RobotoCondensed-LightItalic-tosf-ts1--base.tfm \
tex-RobotoCondensed-LightItalic-tosf-ts1.tfm \
tex-RobotoCondensed-LightItalic-tosf-ts1.vf \
tex-RobotoCondensed-Regular-lf-lgr--base.tfm \
tex-RobotoCondensed-Regular-lf-lgr.tfm \
tex-RobotoCondensed-Regular-lf-lgr.vf \
tex-RobotoCondensed-Regular-lf-ly1--base.tfm \
tex-RobotoCondensed-Regular-lf-ly1.tfm \
tex-RobotoCondensed-Regular-lf-ly1.vf \
tex-RobotoCondensed-Regular-lf-ot1.tfm \
tex-RobotoCondensed-Regular-lf-sc-lgr--base.tfm \
tex-RobotoCondensed-Regular-lf-sc-lgr.tfm \
tex-RobotoCondensed-Regular-lf-sc-lgr.vf \
tex-RobotoCondensed-Regular-lf-sc-ly1--base.tfm \
tex-RobotoCondensed-Regular-lf-sc-ly1.tfm \
tex-RobotoCondensed-Regular-lf-sc-ly1.vf \
tex-RobotoCondensed-Regular-lf-sc-ot1--base.tfm \
tex-RobotoCondensed-Regular-lf-sc-ot1.tfm \
tex-RobotoCondensed-Regular-lf-sc-ot1.vf \
tex-RobotoCondensed-Regular-lf-sc-t1--base.tfm \
tex-RobotoCondensed-Regular-lf-sc-t1.tfm \
tex-RobotoCondensed-Regular-lf-sc-t1.vf \
tex-RobotoCondensed-Regular-lf-t1--base.tfm \
tex-RobotoCondensed-Regular-lf-t1.tfm \
tex-RobotoCondensed-Regular-lf-t1.vf \
tex-RobotoCondensed-Regular-lf-ts1--base.tfm \
tex-RobotoCondensed-Regular-lf-ts1.tfm \
tex-RobotoCondensed-Regular-lf-ts1.vf \
tex-RobotoCondensed-Regular-osf-lgr--base.tfm \
tex-RobotoCondensed-Regular-osf-lgr.tfm \
tex-RobotoCondensed-Regular-osf-lgr.vf \
tex-RobotoCondensed-Regular-osf-ly1--base.tfm \
tex-RobotoCondensed-Regular-osf-ly1.tfm \
tex-RobotoCondensed-Regular-osf-ly1.vf \
tex-RobotoCondensed-Regular-osf-ot1.tfm \
tex-RobotoCondensed-Regular-osf-sc-lgr--base.tfm \
tex-RobotoCondensed-Regular-osf-sc-lgr.tfm \
tex-RobotoCondensed-Regular-osf-sc-lgr.vf \
tex-RobotoCondensed-Regular-osf-sc-ly1--base.tfm \
tex-RobotoCondensed-Regular-osf-sc-ly1.tfm \
tex-RobotoCondensed-Regular-osf-sc-ly1.vf \
tex-RobotoCondensed-Regular-osf-sc-ot1--base.tfm \
tex-RobotoCondensed-Regular-osf-sc-ot1.tfm \
tex-RobotoCondensed-Regular-osf-sc-ot1.vf \
tex-RobotoCondensed-Regular-osf-sc-t1--base.tfm \
tex-RobotoCondensed-Regular-osf-sc-t1.tfm \
tex-RobotoCondensed-Regular-osf-sc-t1.vf \
tex-RobotoCondensed-Regular-osf-t1--base.tfm \
tex-RobotoCondensed-Regular-osf-t1.tfm \
tex-RobotoCondensed-Regular-osf-t1.vf \
tex-RobotoCondensed-Regular-osf-ts1--base.tfm \
tex-RobotoCondensed-Regular-osf-ts1.tfm \
tex-RobotoCondensed-Regular-osf-ts1.vf \
tex-RobotoCondensed-Regular-tlf-lgr--base.tfm \
tex-RobotoCondensed-Regular-tlf-lgr.tfm \
tex-RobotoCondensed-Regular-tlf-lgr.vf \
tex-RobotoCondensed-Regular-tlf-ly1--base.tfm \
tex-RobotoCondensed-Regular-tlf-ly1.tfm \
tex-RobotoCondensed-Regular-tlf-ly1.vf \
tex-RobotoCondensed-Regular-tlf-ot1.tfm \
tex-RobotoCondensed-Regular-tlf-sc-lgr--base.tfm \
tex-RobotoCondensed-Regular-tlf-sc-lgr.tfm \
tex-RobotoCondensed-Regular-tlf-sc-lgr.vf \
tex-RobotoCondensed-Regular-tlf-sc-ly1--base.tfm \
tex-RobotoCondensed-Regular-tlf-sc-ly1.tfm \
tex-RobotoCondensed-Regular-tlf-sc-ly1.vf \
tex-RobotoCondensed-Regular-tlf-sc-ot1--base.tfm \
tex-RobotoCondensed-Regular-tlf-sc-ot1.tfm \
tex-RobotoCondensed-Regular-tlf-sc-ot1.vf \
tex-RobotoCondensed-Regular-tlf-sc-t1--base.tfm \
tex-RobotoCondensed-Regular-tlf-sc-t1.tfm \
tex-RobotoCondensed-Regular-tlf-sc-t1.vf \
tex-RobotoCondensed-Regular-tlf-t1--base.tfm \
tex-RobotoCondensed-Regular-tlf-t1.tfm \
tex-RobotoCondensed-Regular-tlf-t1.vf \
tex-RobotoCondensed-Regular-tlf-ts1--base.tfm \
tex-RobotoCondensed-Regular-tlf-ts1.tfm \
tex-RobotoCondensed-Regular-tlf-ts1.vf \
tex-RobotoCondensed-Regular-tosf-lgr--base.tfm \
tex-RobotoCondensed-Regular-tosf-lgr.tfm \
tex-RobotoCondensed-Regular-tosf-lgr.vf \
tex-RobotoCondensed-Regular-tosf-ly1--base.tfm \
tex-RobotoCondensed-Regular-tosf-ly1.tfm \
tex-RobotoCondensed-Regular-tosf-ly1.vf \
tex-RobotoCondensed-Regular-tosf-ot1.tfm \
tex-RobotoCondensed-Regular-tosf-sc-lgr--base.tfm \
tex-RobotoCondensed-Regular-tosf-sc-lgr.tfm \
tex-RobotoCondensed-Regular-tosf-sc-lgr.vf \
tex-RobotoCondensed-Regular-tosf-sc-ly1--base.tfm \
tex-RobotoCondensed-Regular-tosf-sc-ly1.tfm \
tex-RobotoCondensed-Regular-tosf-sc-ly1.vf \
tex-RobotoCondensed-Regular-tosf-sc-ot1--base.tfm \
tex-RobotoCondensed-Regular-tosf-sc-ot1.tfm \
tex-RobotoCondensed-Regular-tosf-sc-ot1.vf \
tex-RobotoCondensed-Regular-tosf-sc-t1--base.tfm \
tex-RobotoCondensed-Regular-tosf-sc-t1.tfm \
tex-RobotoCondensed-Regular-tosf-sc-t1.vf \
tex-RobotoCondensed-Regular-tosf-t1--base.tfm \
tex-RobotoCondensed-Regular-tosf-t1.tfm \
tex-RobotoCondensed-Regular-tosf-t1.vf \
tex-RobotoCondensed-Regular-tosf-ts1--base.tfm \
tex-RobotoCondensed-Regular-tosf-ts1.tfm \
tex-RobotoCondensed-Regular-tosf-ts1.vf \
tex-RobotoMono-Bold-tlf-lgr--base.tfm \
tex-RobotoMono-Bold-tlf-lgr.tfm \
tex-RobotoMono-Bold-tlf-lgr.vf \
tex-RobotoMono-Bold-tlf-ly1--base.tfm \
tex-RobotoMono-Bold-tlf-ly1.tfm \
tex-RobotoMono-Bold-tlf-ly1.vf \
tex-RobotoMono-Bold-tlf-ot1.tfm \
tex-RobotoMono-Bold-tlf-sc-lgr--base.tfm \
tex-RobotoMono-Bold-tlf-sc-lgr.tfm \
tex-RobotoMono-Bold-tlf-sc-lgr.vf \
tex-RobotoMono-Bold-tlf-sc-ly1--base.tfm \
tex-RobotoMono-Bold-tlf-sc-ly1.tfm \
tex-RobotoMono-Bold-tlf-sc-ly1.vf \
tex-RobotoMono-Bold-tlf-sc-ot1--base.tfm \
tex-RobotoMono-Bold-tlf-sc-ot1.tfm \
tex-RobotoMono-Bold-tlf-sc-ot1.vf \
tex-RobotoMono-Bold-tlf-sc-t1--base.tfm \
tex-RobotoMono-Bold-tlf-sc-t1.tfm \
tex-RobotoMono-Bold-tlf-sc-t1.vf \
tex-RobotoMono-Bold-tlf-t1--base.tfm \
tex-RobotoMono-Bold-tlf-t1.tfm \
tex-RobotoMono-Bold-tlf-t1.vf \
tex-RobotoMono-Bold-tlf-ts1--base.tfm \
tex-RobotoMono-Bold-tlf-ts1.tfm \
tex-RobotoMono-Bold-tlf-ts1.vf \
tex-RobotoMono-BoldItalic-tlf-lgr--base.tfm \
tex-RobotoMono-BoldItalic-tlf-lgr.tfm \
tex-RobotoMono-BoldItalic-tlf-lgr.vf \
tex-RobotoMono-BoldItalic-tlf-ly1--base.tfm \
tex-RobotoMono-BoldItalic-tlf-ly1.tfm \
tex-RobotoMono-BoldItalic-tlf-ly1.vf \
tex-RobotoMono-BoldItalic-tlf-ot1.tfm \
tex-RobotoMono-BoldItalic-tlf-sc-lgr--base.tfm \
tex-RobotoMono-BoldItalic-tlf-sc-lgr.tfm \
tex-RobotoMono-BoldItalic-tlf-sc-lgr.vf \
tex-RobotoMono-BoldItalic-tlf-sc-ly1--base.tfm \
tex-RobotoMono-BoldItalic-tlf-sc-ly1.tfm \
tex-RobotoMono-BoldItalic-tlf-sc-ly1.vf \
tex-RobotoMono-BoldItalic-tlf-sc-ot1--base.tfm \
tex-RobotoMono-BoldItalic-tlf-sc-ot1.tfm \
tex-RobotoMono-BoldItalic-tlf-sc-ot1.vf \
tex-RobotoMono-BoldItalic-tlf-sc-t1--base.tfm \
tex-RobotoMono-BoldItalic-tlf-sc-t1.tfm \
tex-RobotoMono-BoldItalic-tlf-sc-t1.vf \
tex-RobotoMono-BoldItalic-tlf-t1--base.tfm \
tex-RobotoMono-BoldItalic-tlf-t1.tfm \
tex-RobotoMono-BoldItalic-tlf-t1.vf \
tex-RobotoMono-BoldItalic-tlf-ts1--base.tfm \
tex-RobotoMono-BoldItalic-tlf-ts1.tfm \
tex-RobotoMono-BoldItalic-tlf-ts1.vf \
tex-RobotoMono-Italic-tlf-lgr--base.tfm \
tex-RobotoMono-Italic-tlf-lgr.tfm \
tex-RobotoMono-Italic-tlf-lgr.vf \
tex-RobotoMono-Italic-tlf-ly1--base.tfm \
tex-RobotoMono-Italic-tlf-ly1.tfm \
tex-RobotoMono-Italic-tlf-ly1.vf \
tex-RobotoMono-Italic-tlf-ot1.tfm \
tex-RobotoMono-Italic-tlf-sc-lgr--base.tfm \
tex-RobotoMono-Italic-tlf-sc-lgr.tfm \
tex-RobotoMono-Italic-tlf-sc-lgr.vf \
tex-RobotoMono-Italic-tlf-sc-ly1--base.tfm \
tex-RobotoMono-Italic-tlf-sc-ly1.tfm \
tex-RobotoMono-Italic-tlf-sc-ly1.vf \
tex-RobotoMono-Italic-tlf-sc-ot1--base.tfm \
tex-RobotoMono-Italic-tlf-sc-ot1.tfm \
tex-RobotoMono-Italic-tlf-sc-ot1.vf \
tex-RobotoMono-Italic-tlf-sc-t1--base.tfm \
tex-RobotoMono-Italic-tlf-sc-t1.tfm \
tex-RobotoMono-Italic-tlf-sc-t1.vf \
tex-RobotoMono-Italic-tlf-t1--base.tfm \
tex-RobotoMono-Italic-tlf-t1.tfm \
tex-RobotoMono-Italic-tlf-t1.vf \
tex-RobotoMono-Italic-tlf-ts1--base.tfm \
tex-RobotoMono-Italic-tlf-ts1.tfm \
tex-RobotoMono-Italic-tlf-ts1.vf \
tex-RobotoMono-Light-tlf-lgr--base.tfm \
tex-RobotoMono-Light-tlf-lgr.tfm \
tex-RobotoMono-Light-tlf-lgr.vf \
tex-RobotoMono-Light-tlf-ly1--base.tfm \
tex-RobotoMono-Light-tlf-ly1.tfm \
tex-RobotoMono-Light-tlf-ly1.vf \
tex-RobotoMono-Light-tlf-ot1.tfm \
tex-RobotoMono-Light-tlf-sc-lgr--base.tfm \
tex-RobotoMono-Light-tlf-sc-lgr.tfm \
tex-RobotoMono-Light-tlf-sc-lgr.vf \
tex-RobotoMono-Light-tlf-sc-ly1--base.tfm \
tex-RobotoMono-Light-tlf-sc-ly1.tfm \
tex-RobotoMono-Light-tlf-sc-ly1.vf \
tex-RobotoMono-Light-tlf-sc-ot1--base.tfm \
tex-RobotoMono-Light-tlf-sc-ot1.tfm \
tex-RobotoMono-Light-tlf-sc-ot1.vf \
tex-RobotoMono-Light-tlf-sc-t1--base.tfm \
tex-RobotoMono-Light-tlf-sc-t1.tfm \
tex-RobotoMono-Light-tlf-sc-t1.vf \
tex-RobotoMono-Light-tlf-t1--base.tfm \
tex-RobotoMono-Light-tlf-t1.tfm \
tex-RobotoMono-Light-tlf-t1.vf \
tex-RobotoMono-Light-tlf-ts1--base.tfm \
tex-RobotoMono-Light-tlf-ts1.tfm \
tex-RobotoMono-Light-tlf-ts1.vf \
tex-RobotoMono-LightItalic-tlf-lgr--base.tfm \
tex-RobotoMono-LightItalic-tlf-lgr.tfm \
tex-RobotoMono-LightItalic-tlf-lgr.vf \
tex-RobotoMono-LightItalic-tlf-ly1--base.tfm \
tex-RobotoMono-LightItalic-tlf-ly1.tfm \
tex-RobotoMono-LightItalic-tlf-ly1.vf \
tex-RobotoMono-LightItalic-tlf-ot1.tfm \
tex-RobotoMono-LightItalic-tlf-sc-lgr--base.tfm \
tex-RobotoMono-LightItalic-tlf-sc-lgr.tfm \
tex-RobotoMono-LightItalic-tlf-sc-lgr.vf \
tex-RobotoMono-LightItalic-tlf-sc-ly1--base.tfm \
tex-RobotoMono-LightItalic-tlf-sc-ly1.tfm \
tex-RobotoMono-LightItalic-tlf-sc-ly1.vf \
tex-RobotoMono-LightItalic-tlf-sc-ot1--base.tfm \
tex-RobotoMono-LightItalic-tlf-sc-ot1.tfm \
tex-RobotoMono-LightItalic-tlf-sc-ot1.vf \
tex-RobotoMono-LightItalic-tlf-sc-t1--base.tfm \
tex-RobotoMono-LightItalic-tlf-sc-t1.tfm \
tex-RobotoMono-LightItalic-tlf-sc-t1.vf \
tex-RobotoMono-LightItalic-tlf-t1--base.tfm \
tex-RobotoMono-LightItalic-tlf-t1.tfm \
tex-RobotoMono-LightItalic-tlf-t1.vf \
tex-RobotoMono-LightItalic-tlf-ts1--base.tfm \
tex-RobotoMono-LightItalic-tlf-ts1.tfm \
tex-RobotoMono-LightItalic-tlf-ts1.vf \
tex-RobotoMono-Medium-tlf-lgr--base.tfm \
tex-RobotoMono-Medium-tlf-lgr.tfm \
tex-RobotoMono-Medium-tlf-lgr.vf \
tex-RobotoMono-Medium-tlf-ly1--base.tfm \
tex-RobotoMono-Medium-tlf-ly1.tfm \
tex-RobotoMono-Medium-tlf-ly1.vf \
tex-RobotoMono-Medium-tlf-ot1.tfm \
tex-RobotoMono-Medium-tlf-sc-lgr--base.tfm \
tex-RobotoMono-Medium-tlf-sc-lgr.tfm \
tex-RobotoMono-Medium-tlf-sc-lgr.vf \
tex-RobotoMono-Medium-tlf-sc-ly1--base.tfm \
tex-RobotoMono-Medium-tlf-sc-ly1.tfm \
tex-RobotoMono-Medium-tlf-sc-ly1.vf \
tex-RobotoMono-Medium-tlf-sc-ot1--base.tfm \
tex-RobotoMono-Medium-tlf-sc-ot1.tfm \
tex-RobotoMono-Medium-tlf-sc-ot1.vf \
tex-RobotoMono-Medium-tlf-sc-t1--base.tfm \
tex-RobotoMono-Medium-tlf-sc-t1.tfm \
tex-RobotoMono-Medium-tlf-sc-t1.vf \
tex-RobotoMono-Medium-tlf-t1--base.tfm \
tex-RobotoMono-Medium-tlf-t1.tfm \
tex-RobotoMono-Medium-tlf-t1.vf \
tex-RobotoMono-Medium-tlf-ts1--base.tfm \
tex-RobotoMono-Medium-tlf-ts1.tfm \
tex-RobotoMono-Medium-tlf-ts1.vf \
tex-RobotoMono-MediumItalic-tlf-lgr--base.tfm \
tex-RobotoMono-MediumItalic-tlf-lgr.tfm \
tex-RobotoMono-MediumItalic-tlf-lgr.vf \
tex-RobotoMono-MediumItalic-tlf-ly1--base.tfm \
tex-RobotoMono-MediumItalic-tlf-ly1.tfm \
tex-RobotoMono-MediumItalic-tlf-ly1.vf \
tex-RobotoMono-MediumItalic-tlf-ot1.tfm \
tex-RobotoMono-MediumItalic-tlf-sc-lgr--base.tfm \
tex-RobotoMono-MediumItalic-tlf-sc-lgr.tfm \
tex-RobotoMono-MediumItalic-tlf-sc-lgr.vf \
tex-RobotoMono-MediumItalic-tlf-sc-ly1--base.tfm \
tex-RobotoMono-MediumItalic-tlf-sc-ly1.tfm \
tex-RobotoMono-MediumItalic-tlf-sc-ly1.vf \
tex-RobotoMono-MediumItalic-tlf-sc-ot1--base.tfm \
tex-RobotoMono-MediumItalic-tlf-sc-ot1.tfm \
tex-RobotoMono-MediumItalic-tlf-sc-ot1.vf \
tex-RobotoMono-MediumItalic-tlf-sc-t1--base.tfm \
tex-RobotoMono-MediumItalic-tlf-sc-t1.tfm \
tex-RobotoMono-MediumItalic-tlf-sc-t1.vf \
tex-RobotoMono-MediumItalic-tlf-t1--base.tfm \
tex-RobotoMono-MediumItalic-tlf-t1.tfm \
tex-RobotoMono-MediumItalic-tlf-t1.vf \
tex-RobotoMono-MediumItalic-tlf-ts1--base.tfm \
tex-RobotoMono-MediumItalic-tlf-ts1.tfm \
tex-RobotoMono-MediumItalic-tlf-ts1.vf \
tex-RobotoMono-Regular-tlf-lgr--base.tfm \
tex-RobotoMono-Regular-tlf-lgr.tfm \
tex-RobotoMono-Regular-tlf-lgr.vf \
tex-RobotoMono-Regular-tlf-ly1--base.tfm \
tex-RobotoMono-Regular-tlf-ly1.tfm \
tex-RobotoMono-Regular-tlf-ly1.vf \
tex-RobotoMono-Regular-tlf-ot1.tfm \
tex-RobotoMono-Regular-tlf-sc-lgr--base.tfm \
tex-RobotoMono-Regular-tlf-sc-lgr.tfm \
tex-RobotoMono-Regular-tlf-sc-lgr.vf \
tex-RobotoMono-Regular-tlf-sc-ly1--base.tfm \
tex-RobotoMono-Regular-tlf-sc-ly1.tfm \
tex-RobotoMono-Regular-tlf-sc-ly1.vf \
tex-RobotoMono-Regular-tlf-sc-ot1--base.tfm \
tex-RobotoMono-Regular-tlf-sc-ot1.tfm \
tex-RobotoMono-Regular-tlf-sc-ot1.vf \
tex-RobotoMono-Regular-tlf-sc-t1--base.tfm \
tex-RobotoMono-Regular-tlf-sc-t1.tfm \
tex-RobotoMono-Regular-tlf-sc-t1.vf \
tex-RobotoMono-Regular-tlf-t1--base.tfm \
tex-RobotoMono-Regular-tlf-t1.tfm \
tex-RobotoMono-Regular-tlf-t1.vf \
tex-RobotoMono-Regular-tlf-ts1--base.tfm \
tex-RobotoMono-Regular-tlf-ts1.tfm \
tex-RobotoMono-Regular-tlf-ts1.vf \
tex-RobotoMono-Thin-tlf-lgr--base.tfm \
tex-RobotoMono-Thin-tlf-lgr.tfm \
tex-RobotoMono-Thin-tlf-lgr.vf \
tex-RobotoMono-Thin-tlf-ly1--base.tfm \
tex-RobotoMono-Thin-tlf-ly1.tfm \
tex-RobotoMono-Thin-tlf-ly1.vf \
tex-RobotoMono-Thin-tlf-ot1.tfm \
tex-RobotoMono-Thin-tlf-sc-lgr--base.tfm \
tex-RobotoMono-Thin-tlf-sc-lgr.tfm \
tex-RobotoMono-Thin-tlf-sc-lgr.vf \
tex-RobotoMono-Thin-tlf-sc-ly1--base.tfm \
tex-RobotoMono-Thin-tlf-sc-ly1.tfm \
tex-RobotoMono-Thin-tlf-sc-ly1.vf \
tex-RobotoMono-Thin-tlf-sc-ot1--base.tfm \
tex-RobotoMono-Thin-tlf-sc-ot1.tfm \
tex-RobotoMono-Thin-tlf-sc-ot1.vf \
tex-RobotoMono-Thin-tlf-sc-t1--base.tfm \
tex-RobotoMono-Thin-tlf-sc-t1.tfm \
tex-RobotoMono-Thin-tlf-sc-t1.vf \
tex-RobotoMono-Thin-tlf-t1--base.tfm \
tex-RobotoMono-Thin-tlf-t1.tfm \
tex-RobotoMono-Thin-tlf-t1.vf \
tex-RobotoMono-Thin-tlf-ts1--base.tfm \
tex-RobotoMono-Thin-tlf-ts1.tfm \
tex-RobotoMono-Thin-tlf-ts1.vf \
tex-RobotoMono-ThinItalic-tlf-lgr--base.tfm \
tex-RobotoMono-ThinItalic-tlf-lgr.tfm \
tex-RobotoMono-ThinItalic-tlf-lgr.vf \
tex-RobotoMono-ThinItalic-tlf-ly1--base.tfm \
tex-RobotoMono-ThinItalic-tlf-ly1.tfm \
tex-RobotoMono-ThinItalic-tlf-ly1.vf \
tex-RobotoMono-ThinItalic-tlf-ot1.tfm \
tex-RobotoMono-ThinItalic-tlf-sc-lgr--base.tfm \
tex-RobotoMono-ThinItalic-tlf-sc-lgr.tfm \
tex-RobotoMono-ThinItalic-tlf-sc-lgr.vf \
tex-RobotoMono-ThinItalic-tlf-sc-ly1--base.tfm \
tex-RobotoMono-ThinItalic-tlf-sc-ly1.tfm \
tex-RobotoMono-ThinItalic-tlf-sc-ly1.vf \
tex-RobotoMono-ThinItalic-tlf-sc-ot1--base.tfm \
tex-RobotoMono-ThinItalic-tlf-sc-ot1.tfm \
tex-RobotoMono-ThinItalic-tlf-sc-ot1.vf \
tex-RobotoMono-ThinItalic-tlf-sc-t1--base.tfm \
tex-RobotoMono-ThinItalic-tlf-sc-t1.tfm \
tex-RobotoMono-ThinItalic-tlf-sc-t1.vf \
tex-RobotoMono-ThinItalic-tlf-t1--base.tfm \
tex-RobotoMono-ThinItalic-tlf-t1.tfm \
tex-RobotoMono-ThinItalic-tlf-t1.vf \
tex-RobotoMono-ThinItalic-tlf-ts1--base.tfm \
tex-RobotoMono-ThinItalic-tlf-ts1.tfm \
tex-RobotoMono-ThinItalic-tlf-ts1.vf \
tex-RobotoSerif-Black-lf-lgr--base.tfm \
tex-RobotoSerif-Black-lf-lgr.tfm \
tex-RobotoSerif-Black-lf-lgr.vf \
tex-RobotoSerif-Black-lf-ly1--base.tfm \
tex-RobotoSerif-Black-lf-ly1.tfm \
tex-RobotoSerif-Black-lf-ly1.vf \
tex-RobotoSerif-Black-lf-ot1.tfm \
tex-RobotoSerif-Black-lf-t1--base.tfm \
tex-RobotoSerif-Black-lf-t1.tfm \
tex-RobotoSerif-Black-lf-t1.vf \
tex-RobotoSerif-Black-lf-ts1--base.tfm \
tex-RobotoSerif-Black-lf-ts1.tfm \
tex-RobotoSerif-Black-lf-ts1.vf \
tex-RobotoSerif-Black-osf-lgr--base.tfm \
tex-RobotoSerif-Black-osf-lgr.tfm \
tex-RobotoSerif-Black-osf-lgr.vf \
tex-RobotoSerif-Black-osf-ly1--base.tfm \
tex-RobotoSerif-Black-osf-ly1.tfm \
tex-RobotoSerif-Black-osf-ly1.vf \
tex-RobotoSerif-Black-osf-ot1.tfm \
tex-RobotoSerif-Black-osf-t1--base.tfm \
tex-RobotoSerif-Black-osf-t1.tfm \
tex-RobotoSerif-Black-osf-t1.vf \
tex-RobotoSerif-Black-osf-ts1--base.tfm \
tex-RobotoSerif-Black-osf-ts1.tfm \
tex-RobotoSerif-Black-osf-ts1.vf \
tex-RobotoSerif-Black-sup-lgr--base.tfm \
tex-RobotoSerif-Black-sup-lgr.tfm \
tex-RobotoSerif-Black-sup-lgr.vf \
tex-RobotoSerif-Black-sup-ly1--base.tfm \
tex-RobotoSerif-Black-sup-ly1.tfm \
tex-RobotoSerif-Black-sup-ly1.vf \
tex-RobotoSerif-Black-sup-ot1.tfm \
tex-RobotoSerif-Black-sup-t1--base.tfm \
tex-RobotoSerif-Black-sup-t1.tfm \
tex-RobotoSerif-Black-sup-t1.vf \
tex-RobotoSerif-Black-tlf-lgr--base.tfm \
tex-RobotoSerif-Black-tlf-lgr.tfm \
tex-RobotoSerif-Black-tlf-lgr.vf \
tex-RobotoSerif-Black-tlf-ly1--base.tfm \
tex-RobotoSerif-Black-tlf-ly1.tfm \
tex-RobotoSerif-Black-tlf-ly1.vf \
tex-RobotoSerif-Black-tlf-ot1--base.tfm \
tex-RobotoSerif-Black-tlf-ot1.tfm \
tex-RobotoSerif-Black-tlf-ot1.vf \
tex-RobotoSerif-Black-tlf-t1--base.tfm \
tex-RobotoSerif-Black-tlf-t1.tfm \
tex-RobotoSerif-Black-tlf-t1.vf \
tex-RobotoSerif-Black-tlf-ts1--base.tfm \
tex-RobotoSerif-Black-tlf-ts1.tfm \
tex-RobotoSerif-Black-tlf-ts1.vf \
tex-RobotoSerif-Black-tosf-lgr--base.tfm \
tex-RobotoSerif-Black-tosf-lgr.tfm \
tex-RobotoSerif-Black-tosf-lgr.vf \
tex-RobotoSerif-Black-tosf-ly1--base.tfm \
tex-RobotoSerif-Black-tosf-ly1.tfm \
tex-RobotoSerif-Black-tosf-ly1.vf \
tex-RobotoSerif-Black-tosf-ot1--base.tfm \
tex-RobotoSerif-Black-tosf-ot1.tfm \
tex-RobotoSerif-Black-tosf-ot1.vf \
tex-RobotoSerif-Black-tosf-t1--base.tfm \
tex-RobotoSerif-Black-tosf-t1.tfm \
tex-RobotoSerif-Black-tosf-t1.vf \
tex-RobotoSerif-Black-tosf-ts1--base.tfm \
tex-RobotoSerif-Black-tosf-ts1.tfm \
tex-RobotoSerif-Black-tosf-ts1.vf \
tex-RobotoSerif-BlackItalic-lf-lgr--base.tfm \
tex-RobotoSerif-BlackItalic-lf-lgr.tfm \
tex-RobotoSerif-BlackItalic-lf-lgr.vf \
tex-RobotoSerif-BlackItalic-lf-ly1--base.tfm \
tex-RobotoSerif-BlackItalic-lf-ly1.tfm \
tex-RobotoSerif-BlackItalic-lf-ly1.vf \
tex-RobotoSerif-BlackItalic-lf-ot1.tfm \
tex-RobotoSerif-BlackItalic-lf-t1--base.tfm \
tex-RobotoSerif-BlackItalic-lf-t1.tfm \
tex-RobotoSerif-BlackItalic-lf-t1.vf \
tex-RobotoSerif-BlackItalic-lf-ts1--base.tfm \
tex-RobotoSerif-BlackItalic-lf-ts1.tfm \
tex-RobotoSerif-BlackItalic-lf-ts1.vf \
tex-RobotoSerif-BlackItalic-osf-lgr--base.tfm \
tex-RobotoSerif-BlackItalic-osf-lgr.tfm \
tex-RobotoSerif-BlackItalic-osf-lgr.vf \
tex-RobotoSerif-BlackItalic-osf-ly1--base.tfm \
tex-RobotoSerif-BlackItalic-osf-ly1.tfm \
tex-RobotoSerif-BlackItalic-osf-ly1.vf \
tex-RobotoSerif-BlackItalic-osf-ot1.tfm \
tex-RobotoSerif-BlackItalic-osf-t1--base.tfm \
tex-RobotoSerif-BlackItalic-osf-t1.tfm \
tex-RobotoSerif-BlackItalic-osf-t1.vf \
tex-RobotoSerif-BlackItalic-osf-ts1--base.tfm \
tex-RobotoSerif-BlackItalic-osf-ts1.tfm \
tex-RobotoSerif-BlackItalic-osf-ts1.vf \
tex-RobotoSerif-BlackItalic-sup-lgr--base.tfm \
tex-RobotoSerif-BlackItalic-sup-lgr.tfm \
tex-RobotoSerif-BlackItalic-sup-lgr.vf \
tex-RobotoSerif-BlackItalic-sup-ly1--base.tfm \
tex-RobotoSerif-BlackItalic-sup-ly1.tfm \
tex-RobotoSerif-BlackItalic-sup-ly1.vf \
tex-RobotoSerif-BlackItalic-sup-ot1.tfm \
tex-RobotoSerif-BlackItalic-sup-t1--base.tfm \
tex-RobotoSerif-BlackItalic-sup-t1.tfm \
tex-RobotoSerif-BlackItalic-sup-t1.vf \
tex-RobotoSerif-BlackItalic-tlf-lgr--base.tfm \
tex-RobotoSerif-BlackItalic-tlf-lgr.tfm \
tex-RobotoSerif-BlackItalic-tlf-lgr.vf \
tex-RobotoSerif-BlackItalic-tlf-ly1--base.tfm \
tex-RobotoSerif-BlackItalic-tlf-ly1.tfm \
tex-RobotoSerif-BlackItalic-tlf-ly1.vf \
tex-RobotoSerif-BlackItalic-tlf-ot1--base.tfm \
tex-RobotoSerif-BlackItalic-tlf-ot1.tfm \
tex-RobotoSerif-BlackItalic-tlf-ot1.vf \
tex-RobotoSerif-BlackItalic-tlf-t1--base.tfm \
tex-RobotoSerif-BlackItalic-tlf-t1.tfm \
tex-RobotoSerif-BlackItalic-tlf-t1.vf \
tex-RobotoSerif-BlackItalic-tlf-ts1--base.tfm \
tex-RobotoSerif-BlackItalic-tlf-ts1.tfm \
tex-RobotoSerif-BlackItalic-tlf-ts1.vf \
tex-RobotoSerif-BlackItalic-tosf-lgr--base.tfm \
tex-RobotoSerif-BlackItalic-tosf-lgr.tfm \
tex-RobotoSerif-BlackItalic-tosf-lgr.vf \
tex-RobotoSerif-BlackItalic-tosf-ly1--base.tfm \
tex-RobotoSerif-BlackItalic-tosf-ly1.tfm \
tex-RobotoSerif-BlackItalic-tosf-ly1.vf \
tex-RobotoSerif-BlackItalic-tosf-ot1--base.tfm \
tex-RobotoSerif-BlackItalic-tosf-ot1.tfm \
tex-RobotoSerif-BlackItalic-tosf-ot1.vf \
tex-RobotoSerif-BlackItalic-tosf-t1--base.tfm \
tex-RobotoSerif-BlackItalic-tosf-t1.tfm \
tex-RobotoSerif-BlackItalic-tosf-t1.vf \
tex-RobotoSerif-BlackItalic-tosf-ts1--base.tfm \
tex-RobotoSerif-BlackItalic-tosf-ts1.tfm \
tex-RobotoSerif-BlackItalic-tosf-ts1.vf \
tex-RobotoSerif-Bold-lf-lgr--base.tfm \
tex-RobotoSerif-Bold-lf-lgr.tfm \
tex-RobotoSerif-Bold-lf-lgr.vf \
tex-RobotoSerif-Bold-lf-ly1--base.tfm \
tex-RobotoSerif-Bold-lf-ly1.tfm \
tex-RobotoSerif-Bold-lf-ly1.vf \
tex-RobotoSerif-Bold-lf-ot1.tfm \
tex-RobotoSerif-Bold-lf-t1--base.tfm \
tex-RobotoSerif-Bold-lf-t1.tfm \
tex-RobotoSerif-Bold-lf-t1.vf \
tex-RobotoSerif-Bold-lf-ts1--base.tfm \
tex-RobotoSerif-Bold-lf-ts1.tfm \
tex-RobotoSerif-Bold-lf-ts1.vf \
tex-RobotoSerif-Bold-osf-lgr--base.tfm \
tex-RobotoSerif-Bold-osf-lgr.tfm \
tex-RobotoSerif-Bold-osf-lgr.vf \
tex-RobotoSerif-Bold-osf-ly1--base.tfm \
tex-RobotoSerif-Bold-osf-ly1.tfm \
tex-RobotoSerif-Bold-osf-ly1.vf \
tex-RobotoSerif-Bold-osf-ot1.tfm \
tex-RobotoSerif-Bold-osf-t1--base.tfm \
tex-RobotoSerif-Bold-osf-t1.tfm \
tex-RobotoSerif-Bold-osf-t1.vf \
tex-RobotoSerif-Bold-osf-ts1--base.tfm \
tex-RobotoSerif-Bold-osf-ts1.tfm \
tex-RobotoSerif-Bold-osf-ts1.vf \
tex-RobotoSerif-Bold-sup-lgr--base.tfm \
tex-RobotoSerif-Bold-sup-lgr.tfm \
tex-RobotoSerif-Bold-sup-lgr.vf \
tex-RobotoSerif-Bold-sup-ly1--base.tfm \
tex-RobotoSerif-Bold-sup-ly1.tfm \
tex-RobotoSerif-Bold-sup-ly1.vf \
tex-RobotoSerif-Bold-sup-ot1.tfm \
tex-RobotoSerif-Bold-sup-t1--base.tfm \
tex-RobotoSerif-Bold-sup-t1.tfm \
tex-RobotoSerif-Bold-sup-t1.vf \
tex-RobotoSerif-Bold-tlf-lgr--base.tfm \
tex-RobotoSerif-Bold-tlf-lgr.tfm \
tex-RobotoSerif-Bold-tlf-lgr.vf \
tex-RobotoSerif-Bold-tlf-ly1--base.tfm \
tex-RobotoSerif-Bold-tlf-ly1.tfm \
tex-RobotoSerif-Bold-tlf-ly1.vf \
tex-RobotoSerif-Bold-tlf-ot1--base.tfm \
tex-RobotoSerif-Bold-tlf-ot1.tfm \
tex-RobotoSerif-Bold-tlf-ot1.vf \
tex-RobotoSerif-Bold-tlf-t1--base.tfm \
tex-RobotoSerif-Bold-tlf-t1.tfm \
tex-RobotoSerif-Bold-tlf-t1.vf \
tex-RobotoSerif-Bold-tlf-ts1--base.tfm \
tex-RobotoSerif-Bold-tlf-ts1.tfm \
tex-RobotoSerif-Bold-tlf-ts1.vf \
tex-RobotoSerif-Bold-tosf-lgr--base.tfm \
tex-RobotoSerif-Bold-tosf-lgr.tfm \
tex-RobotoSerif-Bold-tosf-lgr.vf \
tex-RobotoSerif-Bold-tosf-ly1--base.tfm \
tex-RobotoSerif-Bold-tosf-ly1.tfm \
tex-RobotoSerif-Bold-tosf-ly1.vf \
tex-RobotoSerif-Bold-tosf-ot1--base.tfm \
tex-RobotoSerif-Bold-tosf-ot1.tfm \
tex-RobotoSerif-Bold-tosf-ot1.vf \
tex-RobotoSerif-Bold-tosf-t1--base.tfm \
tex-RobotoSerif-Bold-tosf-t1.tfm \
tex-RobotoSerif-Bold-tosf-t1.vf \
tex-RobotoSerif-Bold-tosf-ts1--base.tfm \
tex-RobotoSerif-Bold-tosf-ts1.tfm \
tex-RobotoSerif-Bold-tosf-ts1.vf \
tex-RobotoSerif-BoldItalic-lf-lgr--base.tfm \
tex-RobotoSerif-BoldItalic-lf-lgr.tfm \
tex-RobotoSerif-BoldItalic-lf-lgr.vf \
tex-RobotoSerif-BoldItalic-lf-ly1--base.tfm \
tex-RobotoSerif-BoldItalic-lf-ly1.tfm \
tex-RobotoSerif-BoldItalic-lf-ly1.vf \
tex-RobotoSerif-BoldItalic-lf-ot1.tfm \
tex-RobotoSerif-BoldItalic-lf-t1--base.tfm \
tex-RobotoSerif-BoldItalic-lf-t1.tfm \
tex-RobotoSerif-BoldItalic-lf-t1.vf \
tex-RobotoSerif-BoldItalic-lf-ts1--base.tfm \
tex-RobotoSerif-BoldItalic-lf-ts1.tfm \
tex-RobotoSerif-BoldItalic-lf-ts1.vf \
tex-RobotoSerif-BoldItalic-osf-lgr--base.tfm \
tex-RobotoSerif-BoldItalic-osf-lgr.tfm \
tex-RobotoSerif-BoldItalic-osf-lgr.vf \
tex-RobotoSerif-BoldItalic-osf-ly1--base.tfm \
tex-RobotoSerif-BoldItalic-osf-ly1.tfm \
tex-RobotoSerif-BoldItalic-osf-ly1.vf \
tex-RobotoSerif-BoldItalic-osf-ot1.tfm \
tex-RobotoSerif-BoldItalic-osf-t1--base.tfm \
tex-RobotoSerif-BoldItalic-osf-t1.tfm \
tex-RobotoSerif-BoldItalic-osf-t1.vf \
tex-RobotoSerif-BoldItalic-osf-ts1--base.tfm \
tex-RobotoSerif-BoldItalic-osf-ts1.tfm \
tex-RobotoSerif-BoldItalic-osf-ts1.vf \
tex-RobotoSerif-BoldItalic-sup-lgr--base.tfm \
tex-RobotoSerif-BoldItalic-sup-lgr.tfm \
tex-RobotoSerif-BoldItalic-sup-lgr.vf \
tex-RobotoSerif-BoldItalic-sup-ly1--base.tfm \
tex-RobotoSerif-BoldItalic-sup-ly1.tfm \
tex-RobotoSerif-BoldItalic-sup-ly1.vf \
tex-RobotoSerif-BoldItalic-sup-ot1.tfm \
tex-RobotoSerif-BoldItalic-sup-t1--base.tfm \
tex-RobotoSerif-BoldItalic-sup-t1.tfm \
tex-RobotoSerif-BoldItalic-sup-t1.vf \
tex-RobotoSerif-BoldItalic-tlf-lgr--base.tfm \
tex-RobotoSerif-BoldItalic-tlf-lgr.tfm \
tex-RobotoSerif-BoldItalic-tlf-lgr.vf \
tex-RobotoSerif-BoldItalic-tlf-ly1--base.tfm \
tex-RobotoSerif-BoldItalic-tlf-ly1.tfm \
tex-RobotoSerif-BoldItalic-tlf-ly1.vf \
tex-RobotoSerif-BoldItalic-tlf-ot1--base.tfm \
tex-RobotoSerif-BoldItalic-tlf-ot1.tfm \
tex-RobotoSerif-BoldItalic-tlf-ot1.vf \
tex-RobotoSerif-BoldItalic-tlf-t1--base.tfm \
tex-RobotoSerif-BoldItalic-tlf-t1.tfm \
tex-RobotoSerif-BoldItalic-tlf-t1.vf \
tex-RobotoSerif-BoldItalic-tlf-ts1--base.tfm \
tex-RobotoSerif-BoldItalic-tlf-ts1.tfm \
tex-RobotoSerif-BoldItalic-tlf-ts1.vf \
tex-RobotoSerif-BoldItalic-tosf-lgr--base.tfm \
tex-RobotoSerif-BoldItalic-tosf-lgr.tfm \
tex-RobotoSerif-BoldItalic-tosf-lgr.vf \
tex-RobotoSerif-BoldItalic-tosf-ly1--base.tfm \
tex-RobotoSerif-BoldItalic-tosf-ly1.tfm \
tex-RobotoSerif-BoldItalic-tosf-ly1.vf \
tex-RobotoSerif-BoldItalic-tosf-ot1--base.tfm \
tex-RobotoSerif-BoldItalic-tosf-ot1.tfm \
tex-RobotoSerif-BoldItalic-tosf-ot1.vf \
tex-RobotoSerif-BoldItalic-tosf-t1--base.tfm \
tex-RobotoSerif-BoldItalic-tosf-t1.tfm \
tex-RobotoSerif-BoldItalic-tosf-t1.vf \
tex-RobotoSerif-BoldItalic-tosf-ts1--base.tfm \
tex-RobotoSerif-BoldItalic-tosf-ts1.tfm \
tex-RobotoSerif-BoldItalic-tosf-ts1.vf \
tex-RobotoSerif-ExtraBold-lf-lgr--base.tfm \
tex-RobotoSerif-ExtraBold-lf-lgr.tfm \
tex-RobotoSerif-ExtraBold-lf-lgr.vf \
tex-RobotoSerif-ExtraBold-lf-ly1--base.tfm \
tex-RobotoSerif-ExtraBold-lf-ly1.tfm \
tex-RobotoSerif-ExtraBold-lf-ly1.vf \
tex-RobotoSerif-ExtraBold-lf-ot1.tfm \
tex-RobotoSerif-ExtraBold-lf-t1--base.tfm \
tex-RobotoSerif-ExtraBold-lf-t1.tfm \
tex-RobotoSerif-ExtraBold-lf-t1.vf \
tex-RobotoSerif-ExtraBold-lf-ts1--base.tfm \
tex-RobotoSerif-ExtraBold-lf-ts1.tfm \
tex-RobotoSerif-ExtraBold-lf-ts1.vf \
tex-RobotoSerif-ExtraBold-osf-lgr--base.tfm \
tex-RobotoSerif-ExtraBold-osf-lgr.tfm \
tex-RobotoSerif-ExtraBold-osf-lgr.vf \
tex-RobotoSerif-ExtraBold-osf-ly1--base.tfm \
tex-RobotoSerif-ExtraBold-osf-ly1.tfm \
tex-RobotoSerif-ExtraBold-osf-ly1.vf \
tex-RobotoSerif-ExtraBold-osf-ot1.tfm \
tex-RobotoSerif-ExtraBold-osf-t1--base.tfm \
tex-RobotoSerif-ExtraBold-osf-t1.tfm \
tex-RobotoSerif-ExtraBold-osf-t1.vf \
tex-RobotoSerif-ExtraBold-osf-ts1--base.tfm \
tex-RobotoSerif-ExtraBold-osf-ts1.tfm \
tex-RobotoSerif-ExtraBold-osf-ts1.vf \
tex-RobotoSerif-ExtraBold-sup-lgr--base.tfm \
tex-RobotoSerif-ExtraBold-sup-lgr.tfm \
tex-RobotoSerif-ExtraBold-sup-lgr.vf \
tex-RobotoSerif-ExtraBold-sup-ly1--base.tfm \
tex-RobotoSerif-ExtraBold-sup-ly1.tfm \
tex-RobotoSerif-ExtraBold-sup-ly1.vf \
tex-RobotoSerif-ExtraBold-sup-ot1.tfm \
tex-RobotoSerif-ExtraBold-sup-t1--base.tfm \
tex-RobotoSerif-ExtraBold-sup-t1.tfm \
tex-RobotoSerif-ExtraBold-sup-t1.vf \
tex-RobotoSerif-ExtraBold-tlf-lgr--base.tfm \
tex-RobotoSerif-ExtraBold-tlf-lgr.tfm \
tex-RobotoSerif-ExtraBold-tlf-lgr.vf \
tex-RobotoSerif-ExtraBold-tlf-ly1--base.tfm \
tex-RobotoSerif-ExtraBold-tlf-ly1.tfm \
tex-RobotoSerif-ExtraBold-tlf-ly1.vf \
tex-RobotoSerif-ExtraBold-tlf-ot1--base.tfm \
tex-RobotoSerif-ExtraBold-tlf-ot1.tfm \
tex-RobotoSerif-ExtraBold-tlf-ot1.vf \
tex-RobotoSerif-ExtraBold-tlf-t1--base.tfm \
tex-RobotoSerif-ExtraBold-tlf-t1.tfm \
tex-RobotoSerif-ExtraBold-tlf-t1.vf \
tex-RobotoSerif-ExtraBold-tlf-ts1--base.tfm \
tex-RobotoSerif-ExtraBold-tlf-ts1.tfm \
tex-RobotoSerif-ExtraBold-tlf-ts1.vf \
tex-RobotoSerif-ExtraBold-tosf-lgr--base.tfm \
tex-RobotoSerif-ExtraBold-tosf-lgr.tfm \
tex-RobotoSerif-ExtraBold-tosf-lgr.vf \
tex-RobotoSerif-ExtraBold-tosf-ly1--base.tfm \
tex-RobotoSerif-ExtraBold-tosf-ly1.tfm \
tex-RobotoSerif-ExtraBold-tosf-ly1.vf \
tex-RobotoSerif-ExtraBold-tosf-ot1--base.tfm \
tex-RobotoSerif-ExtraBold-tosf-ot1.tfm \
tex-RobotoSerif-ExtraBold-tosf-ot1.vf \
tex-RobotoSerif-ExtraBold-tosf-t1--base.tfm \
tex-RobotoSerif-ExtraBold-tosf-t1.tfm \
tex-RobotoSerif-ExtraBold-tosf-t1.vf \
tex-RobotoSerif-ExtraBold-tosf-ts1--base.tfm \
tex-RobotoSerif-ExtraBold-tosf-ts1.tfm \
tex-RobotoSerif-ExtraBold-tosf-ts1.vf \
tex-RobotoSerif-ExtraBoldItalic-lf-lgr--base.tfm \
tex-RobotoSerif-ExtraBoldItalic-lf-lgr.tfm \
tex-RobotoSerif-ExtraBoldItalic-lf-lgr.vf \
tex-RobotoSerif-ExtraBoldItalic-lf-ly1--base.tfm \
tex-RobotoSerif-ExtraBoldItalic-lf-ly1.tfm \
tex-RobotoSerif-ExtraBoldItalic-lf-ly1.vf \
tex-RobotoSerif-ExtraBoldItalic-lf-ot1.tfm \
tex-RobotoSerif-ExtraBoldItalic-lf-t1--base.tfm \
tex-RobotoSerif-ExtraBoldItalic-lf-t1.tfm \
tex-RobotoSerif-ExtraBoldItalic-lf-t1.vf \
tex-RobotoSerif-ExtraBoldItalic-lf-ts1--base.tfm \
tex-RobotoSerif-ExtraBoldItalic-lf-ts1.tfm \
tex-RobotoSerif-ExtraBoldItalic-lf-ts1.vf \
tex-RobotoSerif-ExtraBoldItalic-osf-lgr--base.tfm \
tex-RobotoSerif-ExtraBoldItalic-osf-lgr.tfm \
tex-RobotoSerif-ExtraBoldItalic-osf-lgr.vf \
tex-RobotoSerif-ExtraBoldItalic-osf-ly1--base.tfm \
tex-RobotoSerif-ExtraBoldItalic-osf-ly1.tfm \
tex-RobotoSerif-ExtraBoldItalic-osf-ly1.vf \
tex-RobotoSerif-ExtraBoldItalic-osf-ot1.tfm \
tex-RobotoSerif-ExtraBoldItalic-osf-t1--base.tfm \
tex-RobotoSerif-ExtraBoldItalic-osf-t1.tfm \
tex-RobotoSerif-ExtraBoldItalic-osf-t1.vf \
tex-RobotoSerif-ExtraBoldItalic-osf-ts1--base.tfm \
tex-RobotoSerif-ExtraBoldItalic-osf-ts1.tfm \
tex-RobotoSerif-ExtraBoldItalic-osf-ts1.vf \
tex-RobotoSerif-ExtraBoldItalic-sup-lgr--base.tfm \
tex-RobotoSerif-ExtraBoldItalic-sup-lgr.tfm \
tex-RobotoSerif-ExtraBoldItalic-sup-lgr.vf \
tex-RobotoSerif-ExtraBoldItalic-sup-ly1--base.tfm \
tex-RobotoSerif-ExtraBoldItalic-sup-ly1.tfm \
tex-RobotoSerif-ExtraBoldItalic-sup-ly1.vf \
tex-RobotoSerif-ExtraBoldItalic-sup-ot1.tfm \
tex-RobotoSerif-ExtraBoldItalic-sup-t1--base.tfm \
tex-RobotoSerif-ExtraBoldItalic-sup-t1.tfm \
tex-RobotoSerif-ExtraBoldItalic-sup-t1.vf \
tex-RobotoSerif-ExtraBoldItalic-tlf-lgr--base.tfm \
tex-RobotoSerif-ExtraBoldItalic-tlf-lgr.tfm \
tex-RobotoSerif-ExtraBoldItalic-tlf-lgr.vf \
tex-RobotoSerif-ExtraBoldItalic-tlf-ly1--base.tfm \
tex-RobotoSerif-ExtraBoldItalic-tlf-ly1.tfm \
tex-RobotoSerif-ExtraBoldItalic-tlf-ly1.vf \
tex-RobotoSerif-ExtraBoldItalic-tlf-ot1--base.tfm \
tex-RobotoSerif-ExtraBoldItalic-tlf-ot1.tfm \
tex-RobotoSerif-ExtraBoldItalic-tlf-ot1.vf \
tex-RobotoSerif-ExtraBoldItalic-tlf-t1--base.tfm \
tex-RobotoSerif-ExtraBoldItalic-tlf-t1.tfm \
tex-RobotoSerif-ExtraBoldItalic-tlf-t1.vf \
tex-RobotoSerif-ExtraBoldItalic-tlf-ts1--base.tfm \
tex-RobotoSerif-ExtraBoldItalic-tlf-ts1.tfm \
tex-RobotoSerif-ExtraBoldItalic-tlf-ts1.vf \
tex-RobotoSerif-ExtraBoldItalic-tosf-lgr--base.tfm \
tex-RobotoSerif-ExtraBoldItalic-tosf-lgr.tfm \
tex-RobotoSerif-ExtraBoldItalic-tosf-lgr.vf \
tex-RobotoSerif-ExtraBoldItalic-tosf-ly1--base.tfm \
tex-RobotoSerif-ExtraBoldItalic-tosf-ly1.tfm \
tex-RobotoSerif-ExtraBoldItalic-tosf-ly1.vf \
tex-RobotoSerif-ExtraBoldItalic-tosf-ot1--base.tfm \
tex-RobotoSerif-ExtraBoldItalic-tosf-ot1.tfm \
tex-RobotoSerif-ExtraBoldItalic-tosf-ot1.vf \
tex-RobotoSerif-ExtraBoldItalic-tosf-t1--base.tfm \
tex-RobotoSerif-ExtraBoldItalic-tosf-t1.tfm \
tex-RobotoSerif-ExtraBoldItalic-tosf-t1.vf \
tex-RobotoSerif-ExtraBoldItalic-tosf-ts1--base.tfm \
tex-RobotoSerif-ExtraBoldItalic-tosf-ts1.tfm \
tex-RobotoSerif-ExtraBoldItalic-tosf-ts1.vf \
tex-RobotoSerif-ExtraLight-lf-lgr--base.tfm \
tex-RobotoSerif-ExtraLight-lf-lgr.tfm \
tex-RobotoSerif-ExtraLight-lf-lgr.vf \
tex-RobotoSerif-ExtraLight-lf-ly1--base.tfm \
tex-RobotoSerif-ExtraLight-lf-ly1.tfm \
tex-RobotoSerif-ExtraLight-lf-ly1.vf \
tex-RobotoSerif-ExtraLight-lf-ot1.tfm \
tex-RobotoSerif-ExtraLight-lf-t1--base.tfm \
tex-RobotoSerif-ExtraLight-lf-t1.tfm \
tex-RobotoSerif-ExtraLight-lf-t1.vf \
tex-RobotoSerif-ExtraLight-lf-ts1--base.tfm \
tex-RobotoSerif-ExtraLight-lf-ts1.tfm \
tex-RobotoSerif-ExtraLight-lf-ts1.vf \
tex-RobotoSerif-ExtraLight-osf-lgr--base.tfm \
tex-RobotoSerif-ExtraLight-osf-lgr.tfm \
tex-RobotoSerif-ExtraLight-osf-lgr.vf \
tex-RobotoSerif-ExtraLight-osf-ly1--base.tfm \
tex-RobotoSerif-ExtraLight-osf-ly1.tfm \
tex-RobotoSerif-ExtraLight-osf-ly1.vf \
tex-RobotoSerif-ExtraLight-osf-ot1.tfm \
tex-RobotoSerif-ExtraLight-osf-t1--base.tfm \
tex-RobotoSerif-ExtraLight-osf-t1.tfm \
tex-RobotoSerif-ExtraLight-osf-t1.vf \
tex-RobotoSerif-ExtraLight-osf-ts1--base.tfm \
tex-RobotoSerif-ExtraLight-osf-ts1.tfm \
tex-RobotoSerif-ExtraLight-osf-ts1.vf \
tex-RobotoSerif-ExtraLight-sup-lgr--base.tfm \
tex-RobotoSerif-ExtraLight-sup-lgr.tfm \
tex-RobotoSerif-ExtraLight-sup-lgr.vf \
tex-RobotoSerif-ExtraLight-sup-ly1--base.tfm \
tex-RobotoSerif-ExtraLight-sup-ly1.tfm \
tex-RobotoSerif-ExtraLight-sup-ly1.vf \
tex-RobotoSerif-ExtraLight-sup-ot1.tfm \
tex-RobotoSerif-ExtraLight-sup-t1--base.tfm \
tex-RobotoSerif-ExtraLight-sup-t1.tfm \
tex-RobotoSerif-ExtraLight-sup-t1.vf \
tex-RobotoSerif-ExtraLight-tlf-lgr--base.tfm \
tex-RobotoSerif-ExtraLight-tlf-lgr.tfm \
tex-RobotoSerif-ExtraLight-tlf-lgr.vf \
tex-RobotoSerif-ExtraLight-tlf-ly1--base.tfm \
tex-RobotoSerif-ExtraLight-tlf-ly1.tfm \
tex-RobotoSerif-ExtraLight-tlf-ly1.vf \
tex-RobotoSerif-ExtraLight-tlf-ot1--base.tfm \
tex-RobotoSerif-ExtraLight-tlf-ot1.tfm \
tex-RobotoSerif-ExtraLight-tlf-ot1.vf \
tex-RobotoSerif-ExtraLight-tlf-t1--base.tfm \
tex-RobotoSerif-ExtraLight-tlf-t1.tfm \
tex-RobotoSerif-ExtraLight-tlf-t1.vf \
tex-RobotoSerif-ExtraLight-tlf-ts1--base.tfm \
tex-RobotoSerif-ExtraLight-tlf-ts1.tfm \
tex-RobotoSerif-ExtraLight-tlf-ts1.vf \
tex-RobotoSerif-ExtraLight-tosf-lgr--base.tfm \
tex-RobotoSerif-ExtraLight-tosf-lgr.tfm \
tex-RobotoSerif-ExtraLight-tosf-lgr.vf \
tex-RobotoSerif-ExtraLight-tosf-ly1--base.tfm \
tex-RobotoSerif-ExtraLight-tosf-ly1.tfm \
tex-RobotoSerif-ExtraLight-tosf-ly1.vf \
tex-RobotoSerif-ExtraLight-tosf-ot1--base.tfm \
tex-RobotoSerif-ExtraLight-tosf-ot1.tfm \
tex-RobotoSerif-ExtraLight-tosf-ot1.vf \
tex-RobotoSerif-ExtraLight-tosf-t1--base.tfm \
tex-RobotoSerif-ExtraLight-tosf-t1.tfm \
tex-RobotoSerif-ExtraLight-tosf-t1.vf \
tex-RobotoSerif-ExtraLight-tosf-ts1--base.tfm \
tex-RobotoSerif-ExtraLight-tosf-ts1.tfm \
tex-RobotoSerif-ExtraLight-tosf-ts1.vf \
tex-RobotoSerif-ExtraLightItalic-lf-lgr--base.tfm \
tex-RobotoSerif-ExtraLightItalic-lf-lgr.tfm \
tex-RobotoSerif-ExtraLightItalic-lf-lgr.vf \
tex-RobotoSerif-ExtraLightItalic-lf-ly1--base.tfm \
tex-RobotoSerif-ExtraLightItalic-lf-ly1.tfm \
tex-RobotoSerif-ExtraLightItalic-lf-ly1.vf \
tex-RobotoSerif-ExtraLightItalic-lf-ot1.tfm \
tex-RobotoSerif-ExtraLightItalic-lf-t1--base.tfm \
tex-RobotoSerif-ExtraLightItalic-lf-t1.tfm \
tex-RobotoSerif-ExtraLightItalic-lf-t1.vf \
tex-RobotoSerif-ExtraLightItalic-lf-ts1--base.tfm \
tex-RobotoSerif-ExtraLightItalic-lf-ts1.tfm \
tex-RobotoSerif-ExtraLightItalic-lf-ts1.vf \
tex-RobotoSerif-ExtraLightItalic-osf-lgr--base.tfm \
tex-RobotoSerif-ExtraLightItalic-osf-lgr.tfm \
tex-RobotoSerif-ExtraLightItalic-osf-lgr.vf \
tex-RobotoSerif-ExtraLightItalic-osf-ly1--base.tfm \
tex-RobotoSerif-ExtraLightItalic-osf-ly1.tfm \
tex-RobotoSerif-ExtraLightItalic-osf-ly1.vf \
tex-RobotoSerif-ExtraLightItalic-osf-ot1.tfm \
tex-RobotoSerif-ExtraLightItalic-osf-t1--base.tfm \
tex-RobotoSerif-ExtraLightItalic-osf-t1.tfm \
tex-RobotoSerif-ExtraLightItalic-osf-t1.vf \
tex-RobotoSerif-ExtraLightItalic-osf-ts1--base.tfm \
tex-RobotoSerif-ExtraLightItalic-osf-ts1.tfm \
tex-RobotoSerif-ExtraLightItalic-osf-ts1.vf \
tex-RobotoSerif-ExtraLightItalic-sup-lgr--base.tfm \
tex-RobotoSerif-ExtraLightItalic-sup-lgr.tfm \
tex-RobotoSerif-ExtraLightItalic-sup-lgr.vf \
tex-RobotoSerif-ExtraLightItalic-sup-ly1--base.tfm \
tex-RobotoSerif-ExtraLightItalic-sup-ly1.tfm \
tex-RobotoSerif-ExtraLightItalic-sup-ly1.vf \
tex-RobotoSerif-ExtraLightItalic-sup-ot1.tfm \
tex-RobotoSerif-ExtraLightItalic-sup-t1--base.tfm \
tex-RobotoSerif-ExtraLightItalic-sup-t1.tfm \
tex-RobotoSerif-ExtraLightItalic-sup-t1.vf \
tex-RobotoSerif-ExtraLightItalic-tlf-lgr--base.tfm \
tex-RobotoSerif-ExtraLightItalic-tlf-lgr.tfm \
tex-RobotoSerif-ExtraLightItalic-tlf-lgr.vf \
tex-RobotoSerif-ExtraLightItalic-tlf-ly1--base.tfm \
tex-RobotoSerif-ExtraLightItalic-tlf-ly1.tfm \
tex-RobotoSerif-ExtraLightItalic-tlf-ly1.vf \
tex-RobotoSerif-ExtraLightItalic-tlf-ot1--base.tfm \
tex-RobotoSerif-ExtraLightItalic-tlf-ot1.tfm \
tex-RobotoSerif-ExtraLightItalic-tlf-ot1.vf \
tex-RobotoSerif-ExtraLightItalic-tlf-t1--base.tfm \
tex-RobotoSerif-ExtraLightItalic-tlf-t1.tfm \
tex-RobotoSerif-ExtraLightItalic-tlf-t1.vf \
tex-RobotoSerif-ExtraLightItalic-tlf-ts1--base.tfm \
tex-RobotoSerif-ExtraLightItalic-tlf-ts1.tfm \
tex-RobotoSerif-ExtraLightItalic-tlf-ts1.vf \
tex-RobotoSerif-ExtraLightItalic-tosf-lgr--base.tfm \
tex-RobotoSerif-ExtraLightItalic-tosf-lgr.tfm \
tex-RobotoSerif-ExtraLightItalic-tosf-lgr.vf \
tex-RobotoSerif-ExtraLightItalic-tosf-ly1--base.tfm \
tex-RobotoSerif-ExtraLightItalic-tosf-ly1.tfm \
tex-RobotoSerif-ExtraLightItalic-tosf-ly1.vf \
tex-RobotoSerif-ExtraLightItalic-tosf-ot1--base.tfm \
tex-RobotoSerif-ExtraLightItalic-tosf-ot1.tfm \
tex-RobotoSerif-ExtraLightItalic-tosf-ot1.vf \
tex-RobotoSerif-ExtraLightItalic-tosf-t1--base.tfm \
tex-RobotoSerif-ExtraLightItalic-tosf-t1.tfm \
tex-RobotoSerif-ExtraLightItalic-tosf-t1.vf \
tex-RobotoSerif-ExtraLightItalic-tosf-ts1--base.tfm \
tex-RobotoSerif-ExtraLightItalic-tosf-ts1.tfm \
tex-RobotoSerif-ExtraLightItalic-tosf-ts1.vf \
tex-RobotoSerif-Italic-lf-lgr--base.tfm \
tex-RobotoSerif-Italic-lf-lgr.tfm \
tex-RobotoSerif-Italic-lf-lgr.vf \
tex-RobotoSerif-Italic-lf-ly1--base.tfm \
tex-RobotoSerif-Italic-lf-ly1.tfm \
tex-RobotoSerif-Italic-lf-ly1.vf \
tex-RobotoSerif-Italic-lf-ot1.tfm \
tex-RobotoSerif-Italic-lf-t1--base.tfm \
tex-RobotoSerif-Italic-lf-t1.tfm \
tex-RobotoSerif-Italic-lf-t1.vf \
tex-RobotoSerif-Italic-lf-ts1--base.tfm \
tex-RobotoSerif-Italic-lf-ts1.tfm \
tex-RobotoSerif-Italic-lf-ts1.vf \
tex-RobotoSerif-Italic-osf-lgr--base.tfm \
tex-RobotoSerif-Italic-osf-lgr.tfm \
tex-RobotoSerif-Italic-osf-lgr.vf \
tex-RobotoSerif-Italic-osf-ly1--base.tfm \
tex-RobotoSerif-Italic-osf-ly1.tfm \
tex-RobotoSerif-Italic-osf-ly1.vf \
tex-RobotoSerif-Italic-osf-ot1.tfm \
tex-RobotoSerif-Italic-osf-t1--base.tfm \
tex-RobotoSerif-Italic-osf-t1.tfm \
tex-RobotoSerif-Italic-osf-t1.vf \
tex-RobotoSerif-Italic-osf-ts1--base.tfm \
tex-RobotoSerif-Italic-osf-ts1.tfm \
tex-RobotoSerif-Italic-osf-ts1.vf \
tex-RobotoSerif-Italic-sup-lgr--base.tfm \
tex-RobotoSerif-Italic-sup-lgr.tfm \
tex-RobotoSerif-Italic-sup-lgr.vf \
tex-RobotoSerif-Italic-sup-ly1--base.tfm \
tex-RobotoSerif-Italic-sup-ly1.tfm \
tex-RobotoSerif-Italic-sup-ly1.vf \
tex-RobotoSerif-Italic-sup-ot1.tfm \
tex-RobotoSerif-Italic-sup-t1--base.tfm \
tex-RobotoSerif-Italic-sup-t1.tfm \
tex-RobotoSerif-Italic-sup-t1.vf \
tex-RobotoSerif-Italic-tlf-lgr--base.tfm \
tex-RobotoSerif-Italic-tlf-lgr.tfm \
tex-RobotoSerif-Italic-tlf-lgr.vf \
tex-RobotoSerif-Italic-tlf-ly1--base.tfm \
tex-RobotoSerif-Italic-tlf-ly1.tfm \
tex-RobotoSerif-Italic-tlf-ly1.vf \
tex-RobotoSerif-Italic-tlf-ot1--base.tfm \
tex-RobotoSerif-Italic-tlf-ot1.tfm \
tex-RobotoSerif-Italic-tlf-ot1.vf \
tex-RobotoSerif-Italic-tlf-t1--base.tfm \
tex-RobotoSerif-Italic-tlf-t1.tfm \
tex-RobotoSerif-Italic-tlf-t1.vf \
tex-RobotoSerif-Italic-tlf-ts1--base.tfm \
tex-RobotoSerif-Italic-tlf-ts1.tfm \
tex-RobotoSerif-Italic-tlf-ts1.vf \
tex-RobotoSerif-Italic-tosf-lgr--base.tfm \
tex-RobotoSerif-Italic-tosf-lgr.tfm \
tex-RobotoSerif-Italic-tosf-lgr.vf \
tex-RobotoSerif-Italic-tosf-ly1--base.tfm \
tex-RobotoSerif-Italic-tosf-ly1.tfm \
tex-RobotoSerif-Italic-tosf-ly1.vf \
tex-RobotoSerif-Italic-tosf-ot1--base.tfm \
tex-RobotoSerif-Italic-tosf-ot1.tfm \
tex-RobotoSerif-Italic-tosf-ot1.vf \
tex-RobotoSerif-Italic-tosf-t1--base.tfm \
tex-RobotoSerif-Italic-tosf-t1.tfm \
tex-RobotoSerif-Italic-tosf-t1.vf \
tex-RobotoSerif-Italic-tosf-ts1--base.tfm \
tex-RobotoSerif-Italic-tosf-ts1.tfm \
tex-RobotoSerif-Italic-tosf-ts1.vf \
tex-RobotoSerif-Light-lf-lgr--base.tfm \
tex-RobotoSerif-Light-lf-lgr.tfm \
tex-RobotoSerif-Light-lf-lgr.vf \
tex-RobotoSerif-Light-lf-ly1--base.tfm \
tex-RobotoSerif-Light-lf-ly1.tfm \
tex-RobotoSerif-Light-lf-ly1.vf \
tex-RobotoSerif-Light-lf-ot1.tfm \
tex-RobotoSerif-Light-lf-t1--base.tfm \
tex-RobotoSerif-Light-lf-t1.tfm \
tex-RobotoSerif-Light-lf-t1.vf \
tex-RobotoSerif-Light-lf-ts1--base.tfm \
tex-RobotoSerif-Light-lf-ts1.tfm \
tex-RobotoSerif-Light-lf-ts1.vf \
tex-RobotoSerif-Light-osf-lgr--base.tfm \
tex-RobotoSerif-Light-osf-lgr.tfm \
tex-RobotoSerif-Light-osf-lgr.vf \
tex-RobotoSerif-Light-osf-ly1--base.tfm \
tex-RobotoSerif-Light-osf-ly1.tfm \
tex-RobotoSerif-Light-osf-ly1.vf \
tex-RobotoSerif-Light-osf-ot1.tfm \
tex-RobotoSerif-Light-osf-t1--base.tfm \
tex-RobotoSerif-Light-osf-t1.tfm \
tex-RobotoSerif-Light-osf-t1.vf \
tex-RobotoSerif-Light-osf-ts1--base.tfm \
tex-RobotoSerif-Light-osf-ts1.tfm \
tex-RobotoSerif-Light-osf-ts1.vf \
tex-RobotoSerif-Light-sup-lgr--base.tfm \
tex-RobotoSerif-Light-sup-lgr.tfm \
tex-RobotoSerif-Light-sup-lgr.vf \
tex-RobotoSerif-Light-sup-ly1--base.tfm \
tex-RobotoSerif-Light-sup-ly1.tfm \
tex-RobotoSerif-Light-sup-ly1.vf \
tex-RobotoSerif-Light-sup-ot1.tfm \
tex-RobotoSerif-Light-sup-t1--base.tfm \
tex-RobotoSerif-Light-sup-t1.tfm \
tex-RobotoSerif-Light-sup-t1.vf \
tex-RobotoSerif-Light-tlf-lgr--base.tfm \
tex-RobotoSerif-Light-tlf-lgr.tfm \
tex-RobotoSerif-Light-tlf-lgr.vf \
tex-RobotoSerif-Light-tlf-ly1--base.tfm \
tex-RobotoSerif-Light-tlf-ly1.tfm \
tex-RobotoSerif-Light-tlf-ly1.vf \
tex-RobotoSerif-Light-tlf-ot1--base.tfm \
tex-RobotoSerif-Light-tlf-ot1.tfm \
tex-RobotoSerif-Light-tlf-ot1.vf \
tex-RobotoSerif-Light-tlf-t1--base.tfm \
tex-RobotoSerif-Light-tlf-t1.tfm \
tex-RobotoSerif-Light-tlf-t1.vf \
tex-RobotoSerif-Light-tlf-ts1--base.tfm \
tex-RobotoSerif-Light-tlf-ts1.tfm \
tex-RobotoSerif-Light-tlf-ts1.vf \
tex-RobotoSerif-Light-tosf-lgr--base.tfm \
tex-RobotoSerif-Light-tosf-lgr.tfm \
tex-RobotoSerif-Light-tosf-lgr.vf \
tex-RobotoSerif-Light-tosf-ly1--base.tfm \
tex-RobotoSerif-Light-tosf-ly1.tfm \
tex-RobotoSerif-Light-tosf-ly1.vf \
tex-RobotoSerif-Light-tosf-ot1--base.tfm \
tex-RobotoSerif-Light-tosf-ot1.tfm \
tex-RobotoSerif-Light-tosf-ot1.vf \
tex-RobotoSerif-Light-tosf-t1--base.tfm \
tex-RobotoSerif-Light-tosf-t1.tfm \
tex-RobotoSerif-Light-tosf-t1.vf \
tex-RobotoSerif-Light-tosf-ts1--base.tfm \
tex-RobotoSerif-Light-tosf-ts1.tfm \
tex-RobotoSerif-Light-tosf-ts1.vf \
tex-RobotoSerif-LightItalic-lf-lgr--base.tfm \
tex-RobotoSerif-LightItalic-lf-lgr.tfm \
tex-RobotoSerif-LightItalic-lf-lgr.vf \
tex-RobotoSerif-LightItalic-lf-ly1--base.tfm \
tex-RobotoSerif-LightItalic-lf-ly1.tfm \
tex-RobotoSerif-LightItalic-lf-ly1.vf \
tex-RobotoSerif-LightItalic-lf-ot1.tfm \
tex-RobotoSerif-LightItalic-lf-t1--base.tfm \
tex-RobotoSerif-LightItalic-lf-t1.tfm \
tex-RobotoSerif-LightItalic-lf-t1.vf \
tex-RobotoSerif-LightItalic-lf-ts1--base.tfm \
tex-RobotoSerif-LightItalic-lf-ts1.tfm \
tex-RobotoSerif-LightItalic-lf-ts1.vf \
tex-RobotoSerif-LightItalic-osf-lgr--base.tfm \
tex-RobotoSerif-LightItalic-osf-lgr.tfm \
tex-RobotoSerif-LightItalic-osf-lgr.vf \
tex-RobotoSerif-LightItalic-osf-ly1--base.tfm \
tex-RobotoSerif-LightItalic-osf-ly1.tfm \
tex-RobotoSerif-LightItalic-osf-ly1.vf \
tex-RobotoSerif-LightItalic-osf-ot1.tfm \
tex-RobotoSerif-LightItalic-osf-t1--base.tfm \
tex-RobotoSerif-LightItalic-osf-t1.tfm \
tex-RobotoSerif-LightItalic-osf-t1.vf \
tex-RobotoSerif-LightItalic-osf-ts1--base.tfm \
tex-RobotoSerif-LightItalic-osf-ts1.tfm \
tex-RobotoSerif-LightItalic-osf-ts1.vf \
tex-RobotoSerif-LightItalic-sup-lgr--base.tfm \
tex-RobotoSerif-LightItalic-sup-lgr.tfm \
tex-RobotoSerif-LightItalic-sup-lgr.vf \
tex-RobotoSerif-LightItalic-sup-ly1--base.tfm \
tex-RobotoSerif-LightItalic-sup-ly1.tfm \
tex-RobotoSerif-LightItalic-sup-ly1.vf \
tex-RobotoSerif-LightItalic-sup-ot1.tfm \
tex-RobotoSerif-LightItalic-sup-t1--base.tfm \
tex-RobotoSerif-LightItalic-sup-t1.tfm \
tex-RobotoSerif-LightItalic-sup-t1.vf \
tex-RobotoSerif-LightItalic-tlf-lgr--base.tfm \
tex-RobotoSerif-LightItalic-tlf-lgr.tfm \
tex-RobotoSerif-LightItalic-tlf-lgr.vf \
tex-RobotoSerif-LightItalic-tlf-ly1--base.tfm \
tex-RobotoSerif-LightItalic-tlf-ly1.tfm \
tex-RobotoSerif-LightItalic-tlf-ly1.vf \
tex-RobotoSerif-LightItalic-tlf-ot1--base.tfm \
tex-RobotoSerif-LightItalic-tlf-ot1.tfm \
tex-RobotoSerif-LightItalic-tlf-ot1.vf \
tex-RobotoSerif-LightItalic-tlf-t1--base.tfm \
tex-RobotoSerif-LightItalic-tlf-t1.tfm \
tex-RobotoSerif-LightItalic-tlf-t1.vf \
tex-RobotoSerif-LightItalic-tlf-ts1--base.tfm \
tex-RobotoSerif-LightItalic-tlf-ts1.tfm \
tex-RobotoSerif-LightItalic-tlf-ts1.vf \
tex-RobotoSerif-LightItalic-tosf-lgr--base.tfm \
tex-RobotoSerif-LightItalic-tosf-lgr.tfm \
tex-RobotoSerif-LightItalic-tosf-lgr.vf \
tex-RobotoSerif-LightItalic-tosf-ly1--base.tfm \
tex-RobotoSerif-LightItalic-tosf-ly1.tfm \
tex-RobotoSerif-LightItalic-tosf-ly1.vf \
tex-RobotoSerif-LightItalic-tosf-ot1--base.tfm \
tex-RobotoSerif-LightItalic-tosf-ot1.tfm \
tex-RobotoSerif-LightItalic-tosf-ot1.vf \
tex-RobotoSerif-LightItalic-tosf-t1--base.tfm \
tex-RobotoSerif-LightItalic-tosf-t1.tfm \
tex-RobotoSerif-LightItalic-tosf-t1.vf \
tex-RobotoSerif-LightItalic-tosf-ts1--base.tfm \
tex-RobotoSerif-LightItalic-tosf-ts1.tfm \
tex-RobotoSerif-LightItalic-tosf-ts1.vf \
tex-RobotoSerif-Medium-lf-lgr--base.tfm \
tex-RobotoSerif-Medium-lf-lgr.tfm \
tex-RobotoSerif-Medium-lf-lgr.vf \
tex-RobotoSerif-Medium-lf-ly1--base.tfm \
tex-RobotoSerif-Medium-lf-ly1.tfm \
tex-RobotoSerif-Medium-lf-ly1.vf \
tex-RobotoSerif-Medium-lf-ot1.tfm \
tex-RobotoSerif-Medium-lf-t1--base.tfm \
tex-RobotoSerif-Medium-lf-t1.tfm \
tex-RobotoSerif-Medium-lf-t1.vf \
tex-RobotoSerif-Medium-lf-ts1--base.tfm \
tex-RobotoSerif-Medium-lf-ts1.tfm \
tex-RobotoSerif-Medium-lf-ts1.vf \
tex-RobotoSerif-Medium-osf-lgr--base.tfm \
tex-RobotoSerif-Medium-osf-lgr.tfm \
tex-RobotoSerif-Medium-osf-lgr.vf \
tex-RobotoSerif-Medium-osf-ly1--base.tfm \
tex-RobotoSerif-Medium-osf-ly1.tfm \
tex-RobotoSerif-Medium-osf-ly1.vf \
tex-RobotoSerif-Medium-osf-ot1.tfm \
tex-RobotoSerif-Medium-osf-t1--base.tfm \
tex-RobotoSerif-Medium-osf-t1.tfm \
tex-RobotoSerif-Medium-osf-t1.vf \
tex-RobotoSerif-Medium-osf-ts1--base.tfm \
tex-RobotoSerif-Medium-osf-ts1.tfm \
tex-RobotoSerif-Medium-osf-ts1.vf \
tex-RobotoSerif-Medium-sup-lgr--base.tfm \
tex-RobotoSerif-Medium-sup-lgr.tfm \
tex-RobotoSerif-Medium-sup-lgr.vf \
tex-RobotoSerif-Medium-sup-ly1--base.tfm \
tex-RobotoSerif-Medium-sup-ly1.tfm \
tex-RobotoSerif-Medium-sup-ly1.vf \
tex-RobotoSerif-Medium-sup-ot1.tfm \
tex-RobotoSerif-Medium-sup-t1--base.tfm \
tex-RobotoSerif-Medium-sup-t1.tfm \
tex-RobotoSerif-Medium-sup-t1.vf \
tex-RobotoSerif-Medium-tlf-lgr--base.tfm \
tex-RobotoSerif-Medium-tlf-lgr.tfm \
tex-RobotoSerif-Medium-tlf-lgr.vf \
tex-RobotoSerif-Medium-tlf-ly1--base.tfm \
tex-RobotoSerif-Medium-tlf-ly1.tfm \
tex-RobotoSerif-Medium-tlf-ly1.vf \
tex-RobotoSerif-Medium-tlf-ot1--base.tfm \
tex-RobotoSerif-Medium-tlf-ot1.tfm \
tex-RobotoSerif-Medium-tlf-ot1.vf \
tex-RobotoSerif-Medium-tlf-t1--base.tfm \
tex-RobotoSerif-Medium-tlf-t1.tfm \
tex-RobotoSerif-Medium-tlf-t1.vf \
tex-RobotoSerif-Medium-tlf-ts1--base.tfm \
tex-RobotoSerif-Medium-tlf-ts1.tfm \
tex-RobotoSerif-Medium-tlf-ts1.vf \
tex-RobotoSerif-Medium-tosf-lgr--base.tfm \
tex-RobotoSerif-Medium-tosf-lgr.tfm \
tex-RobotoSerif-Medium-tosf-lgr.vf \
tex-RobotoSerif-Medium-tosf-ly1--base.tfm \
tex-RobotoSerif-Medium-tosf-ly1.tfm \
tex-RobotoSerif-Medium-tosf-ly1.vf \
tex-RobotoSerif-Medium-tosf-ot1--base.tfm \
tex-RobotoSerif-Medium-tosf-ot1.tfm \
tex-RobotoSerif-Medium-tosf-ot1.vf \
tex-RobotoSerif-Medium-tosf-t1--base.tfm \
tex-RobotoSerif-Medium-tosf-t1.tfm \
tex-RobotoSerif-Medium-tosf-t1.vf \
tex-RobotoSerif-Medium-tosf-ts1--base.tfm \
tex-RobotoSerif-Medium-tosf-ts1.tfm \
tex-RobotoSerif-Medium-tosf-ts1.vf \
tex-RobotoSerif-MediumItalic-lf-lgr--base.tfm \
tex-RobotoSerif-MediumItalic-lf-lgr.tfm \
tex-RobotoSerif-MediumItalic-lf-lgr.vf \
tex-RobotoSerif-MediumItalic-lf-ly1--base.tfm \
tex-RobotoSerif-MediumItalic-lf-ly1.tfm \
tex-RobotoSerif-MediumItalic-lf-ly1.vf \
tex-RobotoSerif-MediumItalic-lf-ot1.tfm \
tex-RobotoSerif-MediumItalic-lf-t1--base.tfm \
tex-RobotoSerif-MediumItalic-lf-t1.tfm \
tex-RobotoSerif-MediumItalic-lf-t1.vf \
tex-RobotoSerif-MediumItalic-lf-ts1--base.tfm \
tex-RobotoSerif-MediumItalic-lf-ts1.tfm \
tex-RobotoSerif-MediumItalic-lf-ts1.vf \
tex-RobotoSerif-MediumItalic-osf-lgr--base.tfm \
tex-RobotoSerif-MediumItalic-osf-lgr.tfm \
tex-RobotoSerif-MediumItalic-osf-lgr.vf \
tex-RobotoSerif-MediumItalic-osf-ly1--base.tfm \
tex-RobotoSerif-MediumItalic-osf-ly1.tfm \
tex-RobotoSerif-MediumItalic-osf-ly1.vf \
tex-RobotoSerif-MediumItalic-osf-ot1.tfm \
tex-RobotoSerif-MediumItalic-osf-t1--base.tfm \
tex-RobotoSerif-MediumItalic-osf-t1.tfm \
tex-RobotoSerif-MediumItalic-osf-t1.vf \
tex-RobotoSerif-MediumItalic-osf-ts1--base.tfm \
tex-RobotoSerif-MediumItalic-osf-ts1.tfm \
tex-RobotoSerif-MediumItalic-osf-ts1.vf \
tex-RobotoSerif-MediumItalic-sup-lgr--base.tfm \
tex-RobotoSerif-MediumItalic-sup-lgr.tfm \
tex-RobotoSerif-MediumItalic-sup-lgr.vf \
tex-RobotoSerif-MediumItalic-sup-ly1--base.tfm \
tex-RobotoSerif-MediumItalic-sup-ly1.tfm \
tex-RobotoSerif-MediumItalic-sup-ly1.vf \
tex-RobotoSerif-MediumItalic-sup-ot1.tfm \
tex-RobotoSerif-MediumItalic-sup-t1--base.tfm \
tex-RobotoSerif-MediumItalic-sup-t1.tfm \
tex-RobotoSerif-MediumItalic-sup-t1.vf \
tex-RobotoSerif-MediumItalic-tlf-lgr--base.tfm \
tex-RobotoSerif-MediumItalic-tlf-lgr.tfm \
tex-RobotoSerif-MediumItalic-tlf-lgr.vf \
tex-RobotoSerif-MediumItalic-tlf-ly1--base.tfm \
tex-RobotoSerif-MediumItalic-tlf-ly1.tfm \
tex-RobotoSerif-MediumItalic-tlf-ly1.vf \
tex-RobotoSerif-MediumItalic-tlf-ot1--base.tfm \
tex-RobotoSerif-MediumItalic-tlf-ot1.tfm \
tex-RobotoSerif-MediumItalic-tlf-ot1.vf \
tex-RobotoSerif-MediumItalic-tlf-t1--base.tfm \
tex-RobotoSerif-MediumItalic-tlf-t1.tfm \
tex-RobotoSerif-MediumItalic-tlf-t1.vf \
tex-RobotoSerif-MediumItalic-tlf-ts1--base.tfm \
tex-RobotoSerif-MediumItalic-tlf-ts1.tfm \
tex-RobotoSerif-MediumItalic-tlf-ts1.vf \
tex-RobotoSerif-MediumItalic-tosf-lgr--base.tfm \
tex-RobotoSerif-MediumItalic-tosf-lgr.tfm \
tex-RobotoSerif-MediumItalic-tosf-lgr.vf \
tex-RobotoSerif-MediumItalic-tosf-ly1--base.tfm \
tex-RobotoSerif-MediumItalic-tosf-ly1.tfm \
tex-RobotoSerif-MediumItalic-tosf-ly1.vf \
tex-RobotoSerif-MediumItalic-tosf-ot1--base.tfm \
tex-RobotoSerif-MediumItalic-tosf-ot1.tfm \
tex-RobotoSerif-MediumItalic-tosf-ot1.vf \
tex-RobotoSerif-MediumItalic-tosf-t1--base.tfm \
tex-RobotoSerif-MediumItalic-tosf-t1.tfm \
tex-RobotoSerif-MediumItalic-tosf-t1.vf \
tex-RobotoSerif-MediumItalic-tosf-ts1--base.tfm \
tex-RobotoSerif-MediumItalic-tosf-ts1.tfm \
tex-RobotoSerif-MediumItalic-tosf-ts1.vf \
tex-RobotoSerif-Regular-lf-lgr--base.tfm \
tex-RobotoSerif-Regular-lf-lgr.tfm \
tex-RobotoSerif-Regular-lf-lgr.vf \
tex-RobotoSerif-Regular-lf-ly1--base.tfm \
tex-RobotoSerif-Regular-lf-ly1.tfm \
tex-RobotoSerif-Regular-lf-ly1.vf \
tex-RobotoSerif-Regular-lf-ot1.tfm \
tex-RobotoSerif-Regular-lf-t1--base.tfm \
tex-RobotoSerif-Regular-lf-t1.tfm \
tex-RobotoSerif-Regular-lf-t1.vf \
tex-RobotoSerif-Regular-lf-ts1--base.tfm \
tex-RobotoSerif-Regular-lf-ts1.tfm \
tex-RobotoSerif-Regular-lf-ts1.vf \
tex-RobotoSerif-Regular-osf-lgr--base.tfm \
tex-RobotoSerif-Regular-osf-lgr.tfm \
tex-RobotoSerif-Regular-osf-lgr.vf \
tex-RobotoSerif-Regular-osf-ly1--base.tfm \
tex-RobotoSerif-Regular-osf-ly1.tfm \
tex-RobotoSerif-Regular-osf-ly1.vf \
tex-RobotoSerif-Regular-osf-ot1.tfm \
tex-RobotoSerif-Regular-osf-t1--base.tfm \
tex-RobotoSerif-Regular-osf-t1.tfm \
tex-RobotoSerif-Regular-osf-t1.vf \
tex-RobotoSerif-Regular-osf-ts1--base.tfm \
tex-RobotoSerif-Regular-osf-ts1.tfm \
tex-RobotoSerif-Regular-osf-ts1.vf \
tex-RobotoSerif-Regular-sup-lgr--base.tfm \
tex-RobotoSerif-Regular-sup-lgr.tfm \
tex-RobotoSerif-Regular-sup-lgr.vf \
tex-RobotoSerif-Regular-sup-ly1--base.tfm \
tex-RobotoSerif-Regular-sup-ly1.tfm \
tex-RobotoSerif-Regular-sup-ly1.vf \
tex-RobotoSerif-Regular-sup-ot1.tfm \
tex-RobotoSerif-Regular-sup-t1--base.tfm \
tex-RobotoSerif-Regular-sup-t1.tfm \
tex-RobotoSerif-Regular-sup-t1.vf \
tex-RobotoSerif-Regular-tlf-lgr--base.tfm \
tex-RobotoSerif-Regular-tlf-lgr.tfm \
tex-RobotoSerif-Regular-tlf-lgr.vf \
tex-RobotoSerif-Regular-tlf-ly1--base.tfm \
tex-RobotoSerif-Regular-tlf-ly1.tfm \
tex-RobotoSerif-Regular-tlf-ly1.vf \
tex-RobotoSerif-Regular-tlf-ot1--base.tfm \
tex-RobotoSerif-Regular-tlf-ot1.tfm \
tex-RobotoSerif-Regular-tlf-ot1.vf \
tex-RobotoSerif-Regular-tlf-t1--base.tfm \
tex-RobotoSerif-Regular-tlf-t1.tfm \
tex-RobotoSerif-Regular-tlf-t1.vf \
tex-RobotoSerif-Regular-tlf-ts1--base.tfm \
tex-RobotoSerif-Regular-tlf-ts1.tfm \
tex-RobotoSerif-Regular-tlf-ts1.vf \
tex-RobotoSerif-Regular-tosf-lgr--base.tfm \
tex-RobotoSerif-Regular-tosf-lgr.tfm \
tex-RobotoSerif-Regular-tosf-lgr.vf \
tex-RobotoSerif-Regular-tosf-ly1--base.tfm \
tex-RobotoSerif-Regular-tosf-ly1.tfm \
tex-RobotoSerif-Regular-tosf-ly1.vf \
tex-RobotoSerif-Regular-tosf-ot1--base.tfm \
tex-RobotoSerif-Regular-tosf-ot1.tfm \
tex-RobotoSerif-Regular-tosf-ot1.vf \
tex-RobotoSerif-Regular-tosf-t1--base.tfm \
tex-RobotoSerif-Regular-tosf-t1.tfm \
tex-RobotoSerif-Regular-tosf-t1.vf \
tex-RobotoSerif-Regular-tosf-ts1--base.tfm \
tex-RobotoSerif-Regular-tosf-ts1.tfm \
tex-RobotoSerif-Regular-tosf-ts1.vf \
tex-RobotoSerif-SemiBold-lf-lgr--base.tfm \
tex-RobotoSerif-SemiBold-lf-lgr.tfm \
tex-RobotoSerif-SemiBold-lf-lgr.vf \
tex-RobotoSerif-SemiBold-lf-ly1--base.tfm \
tex-RobotoSerif-SemiBold-lf-ly1.tfm \
tex-RobotoSerif-SemiBold-lf-ly1.vf \
tex-RobotoSerif-SemiBold-lf-ot1.tfm \
tex-RobotoSerif-SemiBold-lf-t1--base.tfm \
tex-RobotoSerif-SemiBold-lf-t1.tfm \
tex-RobotoSerif-SemiBold-lf-t1.vf \
tex-RobotoSerif-SemiBold-lf-ts1--base.tfm \
tex-RobotoSerif-SemiBold-lf-ts1.tfm \
tex-RobotoSerif-SemiBold-lf-ts1.vf \
tex-RobotoSerif-SemiBold-osf-lgr--base.tfm \
tex-RobotoSerif-SemiBold-osf-lgr.tfm \
tex-RobotoSerif-SemiBold-osf-lgr.vf \
tex-RobotoSerif-SemiBold-osf-ly1--base.tfm \
tex-RobotoSerif-SemiBold-osf-ly1.tfm \
tex-RobotoSerif-SemiBold-osf-ly1.vf \
tex-RobotoSerif-SemiBold-osf-ot1.tfm \
tex-RobotoSerif-SemiBold-osf-t1--base.tfm \
tex-RobotoSerif-SemiBold-osf-t1.tfm \
tex-RobotoSerif-SemiBold-osf-t1.vf \
tex-RobotoSerif-SemiBold-osf-ts1--base.tfm \
tex-RobotoSerif-SemiBold-osf-ts1.tfm \
tex-RobotoSerif-SemiBold-osf-ts1.vf \
tex-RobotoSerif-SemiBold-sup-lgr--base.tfm \
tex-RobotoSerif-SemiBold-sup-lgr.tfm \
tex-RobotoSerif-SemiBold-sup-lgr.vf \
tex-RobotoSerif-SemiBold-sup-ly1--base.tfm \
tex-RobotoSerif-SemiBold-sup-ly1.tfm \
tex-RobotoSerif-SemiBold-sup-ly1.vf \
tex-RobotoSerif-SemiBold-sup-ot1.tfm \
tex-RobotoSerif-SemiBold-sup-t1--base.tfm \
tex-RobotoSerif-SemiBold-sup-t1.tfm \
tex-RobotoSerif-SemiBold-sup-t1.vf \
tex-RobotoSerif-SemiBold-tlf-lgr--base.tfm \
tex-RobotoSerif-SemiBold-tlf-lgr.tfm \
tex-RobotoSerif-SemiBold-tlf-lgr.vf \
tex-RobotoSerif-SemiBold-tlf-ly1--base.tfm \
tex-RobotoSerif-SemiBold-tlf-ly1.tfm \
tex-RobotoSerif-SemiBold-tlf-ly1.vf \
tex-RobotoSerif-SemiBold-tlf-ot1--base.tfm \
tex-RobotoSerif-SemiBold-tlf-ot1.tfm \
tex-RobotoSerif-SemiBold-tlf-ot1.vf \
tex-RobotoSerif-SemiBold-tlf-t1--base.tfm \
tex-RobotoSerif-SemiBold-tlf-t1.tfm \
tex-RobotoSerif-SemiBold-tlf-t1.vf \
tex-RobotoSerif-SemiBold-tlf-ts1--base.tfm \
tex-RobotoSerif-SemiBold-tlf-ts1.tfm \
tex-RobotoSerif-SemiBold-tlf-ts1.vf \
tex-RobotoSerif-SemiBold-tosf-lgr--base.tfm \
tex-RobotoSerif-SemiBold-tosf-lgr.tfm \
tex-RobotoSerif-SemiBold-tosf-lgr.vf \
tex-RobotoSerif-SemiBold-tosf-ly1--base.tfm \
tex-RobotoSerif-SemiBold-tosf-ly1.tfm \
tex-RobotoSerif-SemiBold-tosf-ly1.vf \
tex-RobotoSerif-SemiBold-tosf-ot1--base.tfm \
tex-RobotoSerif-SemiBold-tosf-ot1.tfm \
tex-RobotoSerif-SemiBold-tosf-ot1.vf \
tex-RobotoSerif-SemiBold-tosf-t1--base.tfm \
tex-RobotoSerif-SemiBold-tosf-t1.tfm \
tex-RobotoSerif-SemiBold-tosf-t1.vf \
tex-RobotoSerif-SemiBold-tosf-ts1--base.tfm \
tex-RobotoSerif-SemiBold-tosf-ts1.tfm \
tex-RobotoSerif-SemiBold-tosf-ts1.vf \
tex-RobotoSerif-SemiBoldItalic-lf-lgr--base.tfm \
tex-RobotoSerif-SemiBoldItalic-lf-lgr.tfm \
tex-RobotoSerif-SemiBoldItalic-lf-lgr.vf \
tex-RobotoSerif-SemiBoldItalic-lf-ly1--base.tfm \
tex-RobotoSerif-SemiBoldItalic-lf-ly1.tfm \
tex-RobotoSerif-SemiBoldItalic-lf-ly1.vf \
tex-RobotoSerif-SemiBoldItalic-lf-ot1.tfm \
tex-RobotoSerif-SemiBoldItalic-lf-t1--base.tfm \
tex-RobotoSerif-SemiBoldItalic-lf-t1.tfm \
tex-RobotoSerif-SemiBoldItalic-lf-t1.vf \
tex-RobotoSerif-SemiBoldItalic-lf-ts1--base.tfm \
tex-RobotoSerif-SemiBoldItalic-lf-ts1.tfm \
tex-RobotoSerif-SemiBoldItalic-lf-ts1.vf \
tex-RobotoSerif-SemiBoldItalic-osf-lgr--base.tfm \
tex-RobotoSerif-SemiBoldItalic-osf-lgr.tfm \
tex-RobotoSerif-SemiBoldItalic-osf-lgr.vf \
tex-RobotoSerif-SemiBoldItalic-osf-ly1--base.tfm \
tex-RobotoSerif-SemiBoldItalic-osf-ly1.tfm \
tex-RobotoSerif-SemiBoldItalic-osf-ly1.vf \
tex-RobotoSerif-SemiBoldItalic-osf-ot1.tfm \
tex-RobotoSerif-SemiBoldItalic-osf-t1--base.tfm \
tex-RobotoSerif-SemiBoldItalic-osf-t1.tfm \
tex-RobotoSerif-SemiBoldItalic-osf-t1.vf \
tex-RobotoSerif-SemiBoldItalic-osf-ts1--base.tfm \
tex-RobotoSerif-SemiBoldItalic-osf-ts1.tfm \
tex-RobotoSerif-SemiBoldItalic-osf-ts1.vf \
tex-RobotoSerif-SemiBoldItalic-sup-lgr--base.tfm \
tex-RobotoSerif-SemiBoldItalic-sup-lgr.tfm \
tex-RobotoSerif-SemiBoldItalic-sup-lgr.vf \
tex-RobotoSerif-SemiBoldItalic-sup-ly1--base.tfm \
tex-RobotoSerif-SemiBoldItalic-sup-ly1.tfm \
tex-RobotoSerif-SemiBoldItalic-sup-ly1.vf \
tex-RobotoSerif-SemiBoldItalic-sup-ot1.tfm \
tex-RobotoSerif-SemiBoldItalic-sup-t1--base.tfm \
tex-RobotoSerif-SemiBoldItalic-sup-t1.tfm \
tex-RobotoSerif-SemiBoldItalic-sup-t1.vf \
tex-RobotoSerif-SemiBoldItalic-tlf-lgr--base.tfm \
tex-RobotoSerif-SemiBoldItalic-tlf-lgr.tfm \
tex-RobotoSerif-SemiBoldItalic-tlf-lgr.vf \
tex-RobotoSerif-SemiBoldItalic-tlf-ly1--base.tfm \
tex-RobotoSerif-SemiBoldItalic-tlf-ly1.tfm \
tex-RobotoSerif-SemiBoldItalic-tlf-ly1.vf \
tex-RobotoSerif-SemiBoldItalic-tlf-ot1--base.tfm \
tex-RobotoSerif-SemiBoldItalic-tlf-ot1.tfm \
tex-RobotoSerif-SemiBoldItalic-tlf-ot1.vf \
tex-RobotoSerif-SemiBoldItalic-tlf-t1--base.tfm \
tex-RobotoSerif-SemiBoldItalic-tlf-t1.tfm \
tex-RobotoSerif-SemiBoldItalic-tlf-t1.vf \
tex-RobotoSerif-SemiBoldItalic-tlf-ts1--base.tfm \
tex-RobotoSerif-SemiBoldItalic-tlf-ts1.tfm \
tex-RobotoSerif-SemiBoldItalic-tlf-ts1.vf \
tex-RobotoSerif-SemiBoldItalic-tosf-lgr--base.tfm \
tex-RobotoSerif-SemiBoldItalic-tosf-lgr.tfm \
tex-RobotoSerif-SemiBoldItalic-tosf-lgr.vf \
tex-RobotoSerif-SemiBoldItalic-tosf-ly1--base.tfm \
tex-RobotoSerif-SemiBoldItalic-tosf-ly1.tfm \
tex-RobotoSerif-SemiBoldItalic-tosf-ly1.vf \
tex-RobotoSerif-SemiBoldItalic-tosf-ot1--base.tfm \
tex-RobotoSerif-SemiBoldItalic-tosf-ot1.tfm \
tex-RobotoSerif-SemiBoldItalic-tosf-ot1.vf \
tex-RobotoSerif-SemiBoldItalic-tosf-t1--base.tfm \
tex-RobotoSerif-SemiBoldItalic-tosf-t1.tfm \
tex-RobotoSerif-SemiBoldItalic-tosf-t1.vf \
tex-RobotoSerif-SemiBoldItalic-tosf-ts1--base.tfm \
tex-RobotoSerif-SemiBoldItalic-tosf-ts1.tfm \
tex-RobotoSerif-SemiBoldItalic-tosf-ts1.vf \
tex-RobotoSerif-Thin-lf-lgr--base.tfm \
tex-RobotoSerif-Thin-lf-lgr.tfm \
tex-RobotoSerif-Thin-lf-lgr.vf \
tex-RobotoSerif-Thin-lf-ly1--base.tfm \
tex-RobotoSerif-Thin-lf-ly1.tfm \
tex-RobotoSerif-Thin-lf-ly1.vf \
tex-RobotoSerif-Thin-lf-ot1.tfm \
tex-RobotoSerif-Thin-lf-t1--base.tfm \
tex-RobotoSerif-Thin-lf-t1.tfm \
tex-RobotoSerif-Thin-lf-t1.vf \
tex-RobotoSerif-Thin-lf-ts1--base.tfm \
tex-RobotoSerif-Thin-lf-ts1.tfm \
tex-RobotoSerif-Thin-lf-ts1.vf \
tex-RobotoSerif-Thin-osf-lgr--base.tfm \
tex-RobotoSerif-Thin-osf-lgr.tfm \
tex-RobotoSerif-Thin-osf-lgr.vf \
tex-RobotoSerif-Thin-osf-ly1--base.tfm \
tex-RobotoSerif-Thin-osf-ly1.tfm \
tex-RobotoSerif-Thin-osf-ly1.vf \
tex-RobotoSerif-Thin-osf-ot1.tfm \
tex-RobotoSerif-Thin-osf-t1--base.tfm \
tex-RobotoSerif-Thin-osf-t1.tfm \
tex-RobotoSerif-Thin-osf-t1.vf \
tex-RobotoSerif-Thin-osf-ts1--base.tfm \
tex-RobotoSerif-Thin-osf-ts1.tfm \
tex-RobotoSerif-Thin-osf-ts1.vf \
tex-RobotoSerif-Thin-sup-lgr--base.tfm \
tex-RobotoSerif-Thin-sup-lgr.tfm \
tex-RobotoSerif-Thin-sup-lgr.vf \
tex-RobotoSerif-Thin-sup-ly1--base.tfm \
tex-RobotoSerif-Thin-sup-ly1.tfm \
tex-RobotoSerif-Thin-sup-ly1.vf \
tex-RobotoSerif-Thin-sup-ot1.tfm \
tex-RobotoSerif-Thin-sup-t1--base.tfm \
tex-RobotoSerif-Thin-sup-t1.tfm \
tex-RobotoSerif-Thin-sup-t1.vf \
tex-RobotoSerif-Thin-tlf-lgr--base.tfm \
tex-RobotoSerif-Thin-tlf-lgr.tfm \
tex-RobotoSerif-Thin-tlf-lgr.vf \
tex-RobotoSerif-Thin-tlf-ly1--base.tfm \
tex-RobotoSerif-Thin-tlf-ly1.tfm \
tex-RobotoSerif-Thin-tlf-ly1.vf \
tex-RobotoSerif-Thin-tlf-ot1--base.tfm \
tex-RobotoSerif-Thin-tlf-ot1.tfm \
tex-RobotoSerif-Thin-tlf-ot1.vf \
tex-RobotoSerif-Thin-tlf-t1--base.tfm \
tex-RobotoSerif-Thin-tlf-t1.tfm \
tex-RobotoSerif-Thin-tlf-t1.vf \
tex-RobotoSerif-Thin-tlf-ts1--base.tfm \
tex-RobotoSerif-Thin-tlf-ts1.tfm \
tex-RobotoSerif-Thin-tlf-ts1.vf \
tex-RobotoSerif-Thin-tosf-lgr--base.tfm \
tex-RobotoSerif-Thin-tosf-lgr.tfm \
tex-RobotoSerif-Thin-tosf-lgr.vf \
tex-RobotoSerif-Thin-tosf-ly1--base.tfm \
tex-RobotoSerif-Thin-tosf-ly1.tfm \
tex-RobotoSerif-Thin-tosf-ly1.vf \
tex-RobotoSerif-Thin-tosf-ot1--base.tfm \
tex-RobotoSerif-Thin-tosf-ot1.tfm \
tex-RobotoSerif-Thin-tosf-ot1.vf \
tex-RobotoSerif-Thin-tosf-t1--base.tfm \
tex-RobotoSerif-Thin-tosf-t1.tfm \
tex-RobotoSerif-Thin-tosf-t1.vf \
tex-RobotoSerif-Thin-tosf-ts1--base.tfm \
tex-RobotoSerif-Thin-tosf-ts1.tfm \
tex-RobotoSerif-Thin-tosf-ts1.vf \
tex-RobotoSerif-ThinItalic-lf-lgr--base.tfm \
tex-RobotoSerif-ThinItalic-lf-lgr.tfm \
tex-RobotoSerif-ThinItalic-lf-lgr.vf \
tex-RobotoSerif-ThinItalic-lf-ly1--base.tfm \
tex-RobotoSerif-ThinItalic-lf-ly1.tfm \
tex-RobotoSerif-ThinItalic-lf-ly1.vf \
tex-RobotoSerif-ThinItalic-lf-ot1.tfm \
tex-RobotoSerif-ThinItalic-lf-t1--base.tfm \
tex-RobotoSerif-ThinItalic-lf-t1.tfm \
tex-RobotoSerif-ThinItalic-lf-t1.vf \
tex-RobotoSerif-ThinItalic-lf-ts1--base.tfm \
tex-RobotoSerif-ThinItalic-lf-ts1.tfm \
tex-RobotoSerif-ThinItalic-lf-ts1.vf \
tex-RobotoSerif-ThinItalic-osf-lgr--base.tfm \
tex-RobotoSerif-ThinItalic-osf-lgr.tfm \
tex-RobotoSerif-ThinItalic-osf-lgr.vf \
tex-RobotoSerif-ThinItalic-osf-ly1--base.tfm \
tex-RobotoSerif-ThinItalic-osf-ly1.tfm \
tex-RobotoSerif-ThinItalic-osf-ly1.vf \
tex-RobotoSerif-ThinItalic-osf-ot1.tfm \
tex-RobotoSerif-ThinItalic-osf-t1--base.tfm \
tex-RobotoSerif-ThinItalic-osf-t1.tfm \
tex-RobotoSerif-ThinItalic-osf-t1.vf \
tex-RobotoSerif-ThinItalic-osf-ts1--base.tfm \
tex-RobotoSerif-ThinItalic-osf-ts1.tfm \
tex-RobotoSerif-ThinItalic-osf-ts1.vf \
tex-RobotoSerif-ThinItalic-sup-lgr--base.tfm \
tex-RobotoSerif-ThinItalic-sup-lgr.tfm \
tex-RobotoSerif-ThinItalic-sup-lgr.vf \
tex-RobotoSerif-ThinItalic-sup-ly1--base.tfm \
tex-RobotoSerif-ThinItalic-sup-ly1.tfm \
tex-RobotoSerif-ThinItalic-sup-ly1.vf \
tex-RobotoSerif-ThinItalic-sup-ot1.tfm \
tex-RobotoSerif-ThinItalic-sup-t1--base.tfm \
tex-RobotoSerif-ThinItalic-sup-t1.tfm \
tex-RobotoSerif-ThinItalic-sup-t1.vf \
tex-RobotoSerif-ThinItalic-tlf-lgr--base.tfm \
tex-RobotoSerif-ThinItalic-tlf-lgr.tfm \
tex-RobotoSerif-ThinItalic-tlf-lgr.vf \
tex-RobotoSerif-ThinItalic-tlf-ly1--base.tfm \
tex-RobotoSerif-ThinItalic-tlf-ly1.tfm \
tex-RobotoSerif-ThinItalic-tlf-ly1.vf \
tex-RobotoSerif-ThinItalic-tlf-ot1--base.tfm \
tex-RobotoSerif-ThinItalic-tlf-ot1.tfm \
tex-RobotoSerif-ThinItalic-tlf-ot1.vf \
tex-RobotoSerif-ThinItalic-tlf-t1--base.tfm \
tex-RobotoSerif-ThinItalic-tlf-t1.tfm \
tex-RobotoSerif-ThinItalic-tlf-t1.vf \
tex-RobotoSerif-ThinItalic-tlf-ts1--base.tfm \
tex-RobotoSerif-ThinItalic-tlf-ts1.tfm \
tex-RobotoSerif-ThinItalic-tlf-ts1.vf \
tex-RobotoSerif-ThinItalic-tosf-lgr--base.tfm \
tex-RobotoSerif-ThinItalic-tosf-lgr.tfm \
tex-RobotoSerif-ThinItalic-tosf-lgr.vf \
tex-RobotoSerif-ThinItalic-tosf-ly1--base.tfm \
tex-RobotoSerif-ThinItalic-tosf-ly1.tfm \
tex-RobotoSerif-ThinItalic-tosf-ly1.vf \
tex-RobotoSerif-ThinItalic-tosf-ot1--base.tfm \
tex-RobotoSerif-ThinItalic-tosf-ot1.tfm \
tex-RobotoSerif-ThinItalic-tosf-ot1.vf \
tex-RobotoSerif-ThinItalic-tosf-t1--base.tfm \
tex-RobotoSerif-ThinItalic-tosf-t1.tfm \
tex-RobotoSerif-ThinItalic-tosf-t1.vf \
tex-RobotoSerif-ThinItalic-tosf-ts1--base.tfm \
tex-RobotoSerif-ThinItalic-tosf-ts1.tfm \
tex-RobotoSerif-ThinItalic-tosf-ts1.vf \
tex-RobotoSerifCondensed-Black-lf-lgr--base.tfm \
tex-RobotoSerifCondensed-Black-lf-lgr.tfm \
tex-RobotoSerifCondensed-Black-lf-lgr.vf \
tex-RobotoSerifCondensed-Black-lf-ly1--base.tfm \
tex-RobotoSerifCondensed-Black-lf-ly1.tfm \
tex-RobotoSerifCondensed-Black-lf-ly1.vf \
tex-RobotoSerifCondensed-Black-lf-ot1.tfm \
tex-RobotoSerifCondensed-Black-lf-t1--base.tfm \
tex-RobotoSerifCondensed-Black-lf-t1.tfm \
tex-RobotoSerifCondensed-Black-lf-t1.vf \
tex-RobotoSerifCondensed-Black-lf-ts1--base.tfm \
tex-RobotoSerifCondensed-Black-lf-ts1.tfm \
tex-RobotoSerifCondensed-Black-lf-ts1.vf \
tex-RobotoSerifCondensed-Black-osf-lgr--base.tfm \
tex-RobotoSerifCondensed-Black-osf-lgr.tfm \
tex-RobotoSerifCondensed-Black-osf-lgr.vf \
tex-RobotoSerifCondensed-Black-osf-ly1--base.tfm \
tex-RobotoSerifCondensed-Black-osf-ly1.tfm \
tex-RobotoSerifCondensed-Black-osf-ly1.vf \
tex-RobotoSerifCondensed-Black-osf-ot1.tfm \
tex-RobotoSerifCondensed-Black-osf-t1--base.tfm \
tex-RobotoSerifCondensed-Black-osf-t1.tfm \
tex-RobotoSerifCondensed-Black-osf-t1.vf \
tex-RobotoSerifCondensed-Black-osf-ts1--base.tfm \
tex-RobotoSerifCondensed-Black-osf-ts1.tfm \
tex-RobotoSerifCondensed-Black-osf-ts1.vf \
tex-RobotoSerifCondensed-Black-sup-lgr--base.tfm \
tex-RobotoSerifCondensed-Black-sup-lgr.tfm \
tex-RobotoSerifCondensed-Black-sup-lgr.vf \
tex-RobotoSerifCondensed-Black-sup-ly1--base.tfm \
tex-RobotoSerifCondensed-Black-sup-ly1.tfm \
tex-RobotoSerifCondensed-Black-sup-ly1.vf \
tex-RobotoSerifCondensed-Black-sup-ot1.tfm \
tex-RobotoSerifCondensed-Black-sup-t1--base.tfm \
tex-RobotoSerifCondensed-Black-sup-t1.tfm \
tex-RobotoSerifCondensed-Black-sup-t1.vf \
tex-RobotoSerifCondensed-Black-tlf-lgr--base.tfm \
tex-RobotoSerifCondensed-Black-tlf-lgr.tfm \
tex-RobotoSerifCondensed-Black-tlf-lgr.vf \
tex-RobotoSerifCondensed-Black-tlf-ly1--base.tfm \
tex-RobotoSerifCondensed-Black-tlf-ly1.tfm \
tex-RobotoSerifCondensed-Black-tlf-ly1.vf \
tex-RobotoSerifCondensed-Black-tlf-ot1--base.tfm \
tex-RobotoSerifCondensed-Black-tlf-ot1.tfm \
tex-RobotoSerifCondensed-Black-tlf-ot1.vf \
tex-RobotoSerifCondensed-Black-tlf-t1--base.tfm \
tex-RobotoSerifCondensed-Black-tlf-t1.tfm \
tex-RobotoSerifCondensed-Black-tlf-t1.vf \
tex-RobotoSerifCondensed-Black-tlf-ts1--base.tfm \
tex-RobotoSerifCondensed-Black-tlf-ts1.tfm \
tex-RobotoSerifCondensed-Black-tlf-ts1.vf \
tex-RobotoSerifCondensed-Black-tosf-lgr--base.tfm \
tex-RobotoSerifCondensed-Black-tosf-lgr.tfm \
tex-RobotoSerifCondensed-Black-tosf-lgr.vf \
tex-RobotoSerifCondensed-Black-tosf-ly1--base.tfm \
tex-RobotoSerifCondensed-Black-tosf-ly1.tfm \
tex-RobotoSerifCondensed-Black-tosf-ly1.vf \
tex-RobotoSerifCondensed-Black-tosf-ot1--base.tfm \
tex-RobotoSerifCondensed-Black-tosf-ot1.tfm \
tex-RobotoSerifCondensed-Black-tosf-ot1.vf \
tex-RobotoSerifCondensed-Black-tosf-t1--base.tfm \
tex-RobotoSerifCondensed-Black-tosf-t1.tfm \
tex-RobotoSerifCondensed-Black-tosf-t1.vf \
tex-RobotoSerifCondensed-Black-tosf-ts1--base.tfm \
tex-RobotoSerifCondensed-Black-tosf-ts1.tfm \
tex-RobotoSerifCondensed-Black-tosf-ts1.vf \
tex-RobotoSerifCondensed-BlackItalic-lf-lgr--base.tfm \
tex-RobotoSerifCondensed-BlackItalic-lf-lgr.tfm \
tex-RobotoSerifCondensed-BlackItalic-lf-lgr.vf \
tex-RobotoSerifCondensed-BlackItalic-lf-ly1--base.tfm \
tex-RobotoSerifCondensed-BlackItalic-lf-ly1.tfm \
tex-RobotoSerifCondensed-BlackItalic-lf-ly1.vf \
tex-RobotoSerifCondensed-BlackItalic-lf-ot1.tfm \
tex-RobotoSerifCondensed-BlackItalic-lf-t1--base.tfm \
tex-RobotoSerifCondensed-BlackItalic-lf-t1.tfm \
tex-RobotoSerifCondensed-BlackItalic-lf-t1.vf \
tex-RobotoSerifCondensed-BlackItalic-lf-ts1--base.tfm \
tex-RobotoSerifCondensed-BlackItalic-lf-ts1.tfm \
tex-RobotoSerifCondensed-BlackItalic-lf-ts1.vf \
tex-RobotoSerifCondensed-BlackItalic-osf-lgr--base.tfm \
tex-RobotoSerifCondensed-BlackItalic-osf-lgr.tfm \
tex-RobotoSerifCondensed-BlackItalic-osf-lgr.vf \
tex-RobotoSerifCondensed-BlackItalic-osf-ly1--base.tfm \
tex-RobotoSerifCondensed-BlackItalic-osf-ly1.tfm \
tex-RobotoSerifCondensed-BlackItalic-osf-ly1.vf \
tex-RobotoSerifCondensed-BlackItalic-osf-ot1.tfm \
tex-RobotoSerifCondensed-BlackItalic-osf-t1--base.tfm \
tex-RobotoSerifCondensed-BlackItalic-osf-t1.tfm \
tex-RobotoSerifCondensed-BlackItalic-osf-t1.vf \
tex-RobotoSerifCondensed-BlackItalic-osf-ts1--base.tfm \
tex-RobotoSerifCondensed-BlackItalic-osf-ts1.tfm \
tex-RobotoSerifCondensed-BlackItalic-osf-ts1.vf \
tex-RobotoSerifCondensed-BlackItalic-sup-lgr--base.tfm \
tex-RobotoSerifCondensed-BlackItalic-sup-lgr.tfm \
tex-RobotoSerifCondensed-BlackItalic-sup-lgr.vf \
tex-RobotoSerifCondensed-BlackItalic-sup-ly1--base.tfm \
tex-RobotoSerifCondensed-BlackItalic-sup-ly1.tfm \
tex-RobotoSerifCondensed-BlackItalic-sup-ly1.vf \
tex-RobotoSerifCondensed-BlackItalic-sup-ot1.tfm \
tex-RobotoSerifCondensed-BlackItalic-sup-t1--base.tfm \
tex-RobotoSerifCondensed-BlackItalic-sup-t1.tfm \
tex-RobotoSerifCondensed-BlackItalic-sup-t1.vf \
tex-RobotoSerifCondensed-BlackItalic-tlf-lgr--base.tfm \
tex-RobotoSerifCondensed-BlackItalic-tlf-lgr.tfm \
tex-RobotoSerifCondensed-BlackItalic-tlf-lgr.vf \
tex-RobotoSerifCondensed-BlackItalic-tlf-ly1--base.tfm \
tex-RobotoSerifCondensed-BlackItalic-tlf-ly1.tfm \
tex-RobotoSerifCondensed-BlackItalic-tlf-ly1.vf \
tex-RobotoSerifCondensed-BlackItalic-tlf-ot1--base.tfm \
tex-RobotoSerifCondensed-BlackItalic-tlf-ot1.tfm \
tex-RobotoSerifCondensed-BlackItalic-tlf-ot1.vf \
tex-RobotoSerifCondensed-BlackItalic-tlf-t1--base.tfm \
tex-RobotoSerifCondensed-BlackItalic-tlf-t1.tfm \
tex-RobotoSerifCondensed-BlackItalic-tlf-t1.vf \
tex-RobotoSerifCondensed-BlackItalic-tlf-ts1--base.tfm \
tex-RobotoSerifCondensed-BlackItalic-tlf-ts1.tfm \
tex-RobotoSerifCondensed-BlackItalic-tlf-ts1.vf \
tex-RobotoSerifCondensed-BlackItalic-tosf-lgr--base.tfm \
tex-RobotoSerifCondensed-BlackItalic-tosf-lgr.tfm \
tex-RobotoSerifCondensed-BlackItalic-tosf-lgr.vf \
tex-RobotoSerifCondensed-BlackItalic-tosf-ly1--base.tfm \
tex-RobotoSerifCondensed-BlackItalic-tosf-ly1.tfm \
tex-RobotoSerifCondensed-BlackItalic-tosf-ly1.vf \
tex-RobotoSerifCondensed-BlackItalic-tosf-ot1--base.tfm \
tex-RobotoSerifCondensed-BlackItalic-tosf-ot1.tfm \
tex-RobotoSerifCondensed-BlackItalic-tosf-ot1.vf \
tex-RobotoSerifCondensed-BlackItalic-tosf-t1--base.tfm \
tex-RobotoSerifCondensed-BlackItalic-tosf-t1.tfm \
tex-RobotoSerifCondensed-BlackItalic-tosf-t1.vf \
tex-RobotoSerifCondensed-BlackItalic-tosf-ts1--base.tfm \
tex-RobotoSerifCondensed-BlackItalic-tosf-ts1.tfm \
tex-RobotoSerifCondensed-BlackItalic-tosf-ts1.vf \
tex-RobotoSerifCondensed-Bold-lf-lgr--base.tfm \
tex-RobotoSerifCondensed-Bold-lf-lgr.tfm \
tex-RobotoSerifCondensed-Bold-lf-lgr.vf \
tex-RobotoSerifCondensed-Bold-lf-ly1--base.tfm \
tex-RobotoSerifCondensed-Bold-lf-ly1.tfm \
tex-RobotoSerifCondensed-Bold-lf-ly1.vf \
tex-RobotoSerifCondensed-Bold-lf-ot1.tfm \
tex-RobotoSerifCondensed-Bold-lf-t1--base.tfm \
tex-RobotoSerifCondensed-Bold-lf-t1.tfm \
tex-RobotoSerifCondensed-Bold-lf-t1.vf \
tex-RobotoSerifCondensed-Bold-lf-ts1--base.tfm \
tex-RobotoSerifCondensed-Bold-lf-ts1.tfm \
tex-RobotoSerifCondensed-Bold-lf-ts1.vf \
tex-RobotoSerifCondensed-Bold-osf-lgr--base.tfm \
tex-RobotoSerifCondensed-Bold-osf-lgr.tfm \
tex-RobotoSerifCondensed-Bold-osf-lgr.vf \
tex-RobotoSerifCondensed-Bold-osf-ly1--base.tfm \
tex-RobotoSerifCondensed-Bold-osf-ly1.tfm \
tex-RobotoSerifCondensed-Bold-osf-ly1.vf \
tex-RobotoSerifCondensed-Bold-osf-ot1.tfm \
tex-RobotoSerifCondensed-Bold-osf-t1--base.tfm \
tex-RobotoSerifCondensed-Bold-osf-t1.tfm \
tex-RobotoSerifCondensed-Bold-osf-t1.vf \
tex-RobotoSerifCondensed-Bold-osf-ts1--base.tfm \
tex-RobotoSerifCondensed-Bold-osf-ts1.tfm \
tex-RobotoSerifCondensed-Bold-osf-ts1.vf \
tex-RobotoSerifCondensed-Bold-sup-lgr--base.tfm \
tex-RobotoSerifCondensed-Bold-sup-lgr.tfm \
tex-RobotoSerifCondensed-Bold-sup-lgr.vf \
tex-RobotoSerifCondensed-Bold-sup-ly1--base.tfm \
tex-RobotoSerifCondensed-Bold-sup-ly1.tfm \
tex-RobotoSerifCondensed-Bold-sup-ly1.vf \
tex-RobotoSerifCondensed-Bold-sup-ot1.tfm \
tex-RobotoSerifCondensed-Bold-sup-t1--base.tfm \
tex-RobotoSerifCondensed-Bold-sup-t1.tfm \
tex-RobotoSerifCondensed-Bold-sup-t1.vf \
tex-RobotoSerifCondensed-Bold-tlf-lgr--base.tfm \
tex-RobotoSerifCondensed-Bold-tlf-lgr.tfm \
tex-RobotoSerifCondensed-Bold-tlf-lgr.vf \
tex-RobotoSerifCondensed-Bold-tlf-ly1--base.tfm \
tex-RobotoSerifCondensed-Bold-tlf-ly1.tfm \
tex-RobotoSerifCondensed-Bold-tlf-ly1.vf \
tex-RobotoSerifCondensed-Bold-tlf-ot1--base.tfm \
tex-RobotoSerifCondensed-Bold-tlf-ot1.tfm \
tex-RobotoSerifCondensed-Bold-tlf-ot1.vf \
tex-RobotoSerifCondensed-Bold-tlf-t1--base.tfm \
tex-RobotoSerifCondensed-Bold-tlf-t1.tfm \
tex-RobotoSerifCondensed-Bold-tlf-t1.vf \
tex-RobotoSerifCondensed-Bold-tlf-ts1--base.tfm \
tex-RobotoSerifCondensed-Bold-tlf-ts1.tfm \
tex-RobotoSerifCondensed-Bold-tlf-ts1.vf \
tex-RobotoSerifCondensed-Bold-tosf-lgr--base.tfm \
tex-RobotoSerifCondensed-Bold-tosf-lgr.tfm \
tex-RobotoSerifCondensed-Bold-tosf-lgr.vf \
tex-RobotoSerifCondensed-Bold-tosf-ly1--base.tfm \
tex-RobotoSerifCondensed-Bold-tosf-ly1.tfm \
tex-RobotoSerifCondensed-Bold-tosf-ly1.vf \
tex-RobotoSerifCondensed-Bold-tosf-ot1--base.tfm \
tex-RobotoSerifCondensed-Bold-tosf-ot1.tfm \
tex-RobotoSerifCondensed-Bold-tosf-ot1.vf \
tex-RobotoSerifCondensed-Bold-tosf-t1--base.tfm \
tex-RobotoSerifCondensed-Bold-tosf-t1.tfm \
tex-RobotoSerifCondensed-Bold-tosf-t1.vf \
tex-RobotoSerifCondensed-Bold-tosf-ts1--base.tfm \
tex-RobotoSerifCondensed-Bold-tosf-ts1.tfm \
tex-RobotoSerifCondensed-Bold-tosf-ts1.vf \
tex-RobotoSerifCondensed-BoldItalic-lf-lgr--base.tfm \
tex-RobotoSerifCondensed-BoldItalic-lf-lgr.tfm \
tex-RobotoSerifCondensed-BoldItalic-lf-lgr.vf \
tex-RobotoSerifCondensed-BoldItalic-lf-ly1--base.tfm \
tex-RobotoSerifCondensed-BoldItalic-lf-ly1.tfm \
tex-RobotoSerifCondensed-BoldItalic-lf-ly1.vf \
tex-RobotoSerifCondensed-BoldItalic-lf-ot1.tfm \
tex-RobotoSerifCondensed-BoldItalic-lf-t1--base.tfm \
tex-RobotoSerifCondensed-BoldItalic-lf-t1.tfm \
tex-RobotoSerifCondensed-BoldItalic-lf-t1.vf \
tex-RobotoSerifCondensed-BoldItalic-lf-ts1--base.tfm \
tex-RobotoSerifCondensed-BoldItalic-lf-ts1.tfm \
tex-RobotoSerifCondensed-BoldItalic-lf-ts1.vf \
tex-RobotoSerifCondensed-BoldItalic-osf-lgr--base.tfm \
tex-RobotoSerifCondensed-BoldItalic-osf-lgr.tfm \
tex-RobotoSerifCondensed-BoldItalic-osf-lgr.vf \
tex-RobotoSerifCondensed-BoldItalic-osf-ly1--base.tfm \
tex-RobotoSerifCondensed-BoldItalic-osf-ly1.tfm \
tex-RobotoSerifCondensed-BoldItalic-osf-ly1.vf \
tex-RobotoSerifCondensed-BoldItalic-osf-ot1.tfm \
tex-RobotoSerifCondensed-BoldItalic-osf-t1--base.tfm \
tex-RobotoSerifCondensed-BoldItalic-osf-t1.tfm \
tex-RobotoSerifCondensed-BoldItalic-osf-t1.vf \
tex-RobotoSerifCondensed-BoldItalic-osf-ts1--base.tfm \
tex-RobotoSerifCondensed-BoldItalic-osf-ts1.tfm \
tex-RobotoSerifCondensed-BoldItalic-osf-ts1.vf \
tex-RobotoSerifCondensed-BoldItalic-sup-lgr--base.tfm \
tex-RobotoSerifCondensed-BoldItalic-sup-lgr.tfm \
tex-RobotoSerifCondensed-BoldItalic-sup-lgr.vf \
tex-RobotoSerifCondensed-BoldItalic-sup-ly1--base.tfm \
tex-RobotoSerifCondensed-BoldItalic-sup-ly1.tfm \
tex-RobotoSerifCondensed-BoldItalic-sup-ly1.vf \
tex-RobotoSerifCondensed-BoldItalic-sup-ot1.tfm \
tex-RobotoSerifCondensed-BoldItalic-sup-t1--base.tfm \
tex-RobotoSerifCondensed-BoldItalic-sup-t1.tfm \
tex-RobotoSerifCondensed-BoldItalic-sup-t1.vf \
tex-RobotoSerifCondensed-BoldItalic-tlf-lgr--base.tfm \
tex-RobotoSerifCondensed-BoldItalic-tlf-lgr.tfm \
tex-RobotoSerifCondensed-BoldItalic-tlf-lgr.vf \
tex-RobotoSerifCondensed-BoldItalic-tlf-ly1--base.tfm \
tex-RobotoSerifCondensed-BoldItalic-tlf-ly1.tfm \
tex-RobotoSerifCondensed-BoldItalic-tlf-ly1.vf \
tex-RobotoSerifCondensed-BoldItalic-tlf-ot1--base.tfm \
tex-RobotoSerifCondensed-BoldItalic-tlf-ot1.tfm \
tex-RobotoSerifCondensed-BoldItalic-tlf-ot1.vf \
tex-RobotoSerifCondensed-BoldItalic-tlf-t1--base.tfm \
tex-RobotoSerifCondensed-BoldItalic-tlf-t1.tfm \
tex-RobotoSerifCondensed-BoldItalic-tlf-t1.vf \
tex-RobotoSerifCondensed-BoldItalic-tlf-ts1--base.tfm \
tex-RobotoSerifCondensed-BoldItalic-tlf-ts1.tfm \
tex-RobotoSerifCondensed-BoldItalic-tlf-ts1.vf \
tex-RobotoSerifCondensed-BoldItalic-tosf-lgr--base.tfm \
tex-RobotoSerifCondensed-BoldItalic-tosf-lgr.tfm \
tex-RobotoSerifCondensed-BoldItalic-tosf-lgr.vf \
tex-RobotoSerifCondensed-BoldItalic-tosf-ly1--base.tfm \
tex-RobotoSerifCondensed-BoldItalic-tosf-ly1.tfm \
tex-RobotoSerifCondensed-BoldItalic-tosf-ly1.vf \
tex-RobotoSerifCondensed-BoldItalic-tosf-ot1--base.tfm \
tex-RobotoSerifCondensed-BoldItalic-tosf-ot1.tfm \
tex-RobotoSerifCondensed-BoldItalic-tosf-ot1.vf \
tex-RobotoSerifCondensed-BoldItalic-tosf-t1--base.tfm \
tex-RobotoSerifCondensed-BoldItalic-tosf-t1.tfm \
tex-RobotoSerifCondensed-BoldItalic-tosf-t1.vf \
tex-RobotoSerifCondensed-BoldItalic-tosf-ts1--base.tfm \
tex-RobotoSerifCondensed-BoldItalic-tosf-ts1.tfm \
tex-RobotoSerifCondensed-BoldItalic-tosf-ts1.vf \
tex-RobotoSerifCondensed-ExtraBold-lf-lgr--base.tfm \
tex-RobotoSerifCondensed-ExtraBold-lf-lgr.tfm \
tex-RobotoSerifCondensed-ExtraBold-lf-lgr.vf \
tex-RobotoSerifCondensed-ExtraBold-lf-ly1--base.tfm \
tex-RobotoSerifCondensed-ExtraBold-lf-ly1.tfm \
tex-RobotoSerifCondensed-ExtraBold-lf-ly1.vf \
tex-RobotoSerifCondensed-ExtraBold-lf-ot1.tfm \
tex-RobotoSerifCondensed-ExtraBold-lf-t1--base.tfm \
tex-RobotoSerifCondensed-ExtraBold-lf-t1.tfm \
tex-RobotoSerifCondensed-ExtraBold-lf-t1.vf \
tex-RobotoSerifCondensed-ExtraBold-lf-ts1--base.tfm \
tex-RobotoSerifCondensed-ExtraBold-lf-ts1.tfm \
tex-RobotoSerifCondensed-ExtraBold-lf-ts1.vf \
tex-RobotoSerifCondensed-ExtraBold-osf-lgr--base.tfm \
tex-RobotoSerifCondensed-ExtraBold-osf-lgr.tfm \
tex-RobotoSerifCondensed-ExtraBold-osf-lgr.vf \
tex-RobotoSerifCondensed-ExtraBold-osf-ly1--base.tfm \
tex-RobotoSerifCondensed-ExtraBold-osf-ly1.tfm \
tex-RobotoSerifCondensed-ExtraBold-osf-ly1.vf \
tex-RobotoSerifCondensed-ExtraBold-osf-ot1.tfm \
tex-RobotoSerifCondensed-ExtraBold-osf-t1--base.tfm \
tex-RobotoSerifCondensed-ExtraBold-osf-t1.tfm \
tex-RobotoSerifCondensed-ExtraBold-osf-t1.vf \
tex-RobotoSerifCondensed-ExtraBold-osf-ts1--base.tfm \
tex-RobotoSerifCondensed-ExtraBold-osf-ts1.tfm \
tex-RobotoSerifCondensed-ExtraBold-osf-ts1.vf \
tex-RobotoSerifCondensed-ExtraBold-sup-lgr--base.tfm \
tex-RobotoSerifCondensed-ExtraBold-sup-lgr.tfm \
tex-RobotoSerifCondensed-ExtraBold-sup-lgr.vf \
tex-RobotoSerifCondensed-ExtraBold-sup-ly1--base.tfm \
tex-RobotoSerifCondensed-ExtraBold-sup-ly1.tfm \
tex-RobotoSerifCondensed-ExtraBold-sup-ly1.vf \
tex-RobotoSerifCondensed-ExtraBold-sup-ot1.tfm \
tex-RobotoSerifCondensed-ExtraBold-sup-t1--base.tfm \
tex-RobotoSerifCondensed-ExtraBold-sup-t1.tfm \
tex-RobotoSerifCondensed-ExtraBold-sup-t1.vf \
tex-RobotoSerifCondensed-ExtraBold-tlf-lgr--base.tfm \
tex-RobotoSerifCondensed-ExtraBold-tlf-lgr.tfm \
tex-RobotoSerifCondensed-ExtraBold-tlf-lgr.vf \
tex-RobotoSerifCondensed-ExtraBold-tlf-ly1--base.tfm \
tex-RobotoSerifCondensed-ExtraBold-tlf-ly1.tfm \
tex-RobotoSerifCondensed-ExtraBold-tlf-ly1.vf \
tex-RobotoSerifCondensed-ExtraBold-tlf-ot1--base.tfm \
tex-RobotoSerifCondensed-ExtraBold-tlf-ot1.tfm \
tex-RobotoSerifCondensed-ExtraBold-tlf-ot1.vf \
tex-RobotoSerifCondensed-ExtraBold-tlf-t1--base.tfm \
tex-RobotoSerifCondensed-ExtraBold-tlf-t1.tfm \
tex-RobotoSerifCondensed-ExtraBold-tlf-t1.vf \
tex-RobotoSerifCondensed-ExtraBold-tlf-ts1--base.tfm \
tex-RobotoSerifCondensed-ExtraBold-tlf-ts1.tfm \
tex-RobotoSerifCondensed-ExtraBold-tlf-ts1.vf \
tex-RobotoSerifCondensed-ExtraBold-tosf-lgr--base.tfm \
tex-RobotoSerifCondensed-ExtraBold-tosf-lgr.tfm \
tex-RobotoSerifCondensed-ExtraBold-tosf-lgr.vf \
tex-RobotoSerifCondensed-ExtraBold-tosf-ly1--base.tfm \
tex-RobotoSerifCondensed-ExtraBold-tosf-ly1.tfm \
tex-RobotoSerifCondensed-ExtraBold-tosf-ly1.vf \
tex-RobotoSerifCondensed-ExtraBold-tosf-ot1--base.tfm \
tex-RobotoSerifCondensed-ExtraBold-tosf-ot1.tfm \
tex-RobotoSerifCondensed-ExtraBold-tosf-ot1.vf \
tex-RobotoSerifCondensed-ExtraBold-tosf-t1--base.tfm \
tex-RobotoSerifCondensed-ExtraBold-tosf-t1.tfm \
tex-RobotoSerifCondensed-ExtraBold-tosf-t1.vf \
tex-RobotoSerifCondensed-ExtraBold-tosf-ts1--base.tfm \
tex-RobotoSerifCondensed-ExtraBold-tosf-ts1.tfm \
tex-RobotoSerifCondensed-ExtraBold-tosf-ts1.vf \
tex-RobotoSerifCondensed-ExtraBoldItalic-lf-lgr--base.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-lf-lgr.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-lf-lgr.vf \
tex-RobotoSerifCondensed-ExtraBoldItalic-lf-ly1--base.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-lf-ly1.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-lf-ly1.vf \
tex-RobotoSerifCondensed-ExtraBoldItalic-lf-ot1.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-lf-t1--base.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-lf-t1.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-lf-t1.vf \
tex-RobotoSerifCondensed-ExtraBoldItalic-lf-ts1--base.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-lf-ts1.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-lf-ts1.vf \
tex-RobotoSerifCondensed-ExtraBoldItalic-osf-lgr--base.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-osf-lgr.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-osf-lgr.vf \
tex-RobotoSerifCondensed-ExtraBoldItalic-osf-ly1--base.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-osf-ly1.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-osf-ly1.vf \
tex-RobotoSerifCondensed-ExtraBoldItalic-osf-ot1.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-osf-t1--base.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-osf-t1.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-osf-t1.vf \
tex-RobotoSerifCondensed-ExtraBoldItalic-osf-ts1--base.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-osf-ts1.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-osf-ts1.vf \
tex-RobotoSerifCondensed-ExtraBoldItalic-sup-lgr--base.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-sup-lgr.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-sup-lgr.vf \
tex-RobotoSerifCondensed-ExtraBoldItalic-sup-ly1--base.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-sup-ly1.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-sup-ly1.vf \
tex-RobotoSerifCondensed-ExtraBoldItalic-sup-ot1.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-sup-t1--base.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-sup-t1.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-sup-t1.vf \
tex-RobotoSerifCondensed-ExtraBoldItalic-tlf-lgr--base.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-tlf-lgr.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-tlf-lgr.vf \
tex-RobotoSerifCondensed-ExtraBoldItalic-tlf-ly1--base.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-tlf-ly1.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-tlf-ly1.vf \
tex-RobotoSerifCondensed-ExtraBoldItalic-tlf-ot1--base.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-tlf-ot1.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-tlf-ot1.vf \
tex-RobotoSerifCondensed-ExtraBoldItalic-tlf-t1--base.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-tlf-t1.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-tlf-t1.vf \
tex-RobotoSerifCondensed-ExtraBoldItalic-tlf-ts1--base.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-tlf-ts1.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-tlf-ts1.vf \
tex-RobotoSerifCondensed-ExtraBoldItalic-tosf-lgr--base.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-tosf-lgr.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-tosf-lgr.vf \
tex-RobotoSerifCondensed-ExtraBoldItalic-tosf-ly1--base.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-tosf-ly1.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-tosf-ly1.vf \
tex-RobotoSerifCondensed-ExtraBoldItalic-tosf-ot1--base.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-tosf-ot1.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-tosf-ot1.vf \
tex-RobotoSerifCondensed-ExtraBoldItalic-tosf-t1--base.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-tosf-t1.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-tosf-t1.vf \
tex-RobotoSerifCondensed-ExtraBoldItalic-tosf-ts1--base.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-tosf-ts1.tfm \
tex-RobotoSerifCondensed-ExtraBoldItalic-tosf-ts1.vf \
tex-RobotoSerifCondensed-ExtraLight-lf-lgr--base.tfm \
tex-RobotoSerifCondensed-ExtraLight-lf-lgr.tfm \
tex-RobotoSerifCondensed-ExtraLight-lf-lgr.vf \
tex-RobotoSerifCondensed-ExtraLight-lf-ly1--base.tfm \
tex-RobotoSerifCondensed-ExtraLight-lf-ly1.tfm \
tex-RobotoSerifCondensed-ExtraLight-lf-ly1.vf \
tex-RobotoSerifCondensed-ExtraLight-lf-ot1.tfm \
tex-RobotoSerifCondensed-ExtraLight-lf-t1--base.tfm \
tex-RobotoSerifCondensed-ExtraLight-lf-t1.tfm \
tex-RobotoSerifCondensed-ExtraLight-lf-t1.vf \
tex-RobotoSerifCondensed-ExtraLight-lf-ts1--base.tfm \
tex-RobotoSerifCondensed-ExtraLight-lf-ts1.tfm \
tex-RobotoSerifCondensed-ExtraLight-lf-ts1.vf \
tex-RobotoSerifCondensed-ExtraLight-osf-lgr--base.tfm \
tex-RobotoSerifCondensed-ExtraLight-osf-lgr.tfm \
tex-RobotoSerifCondensed-ExtraLight-osf-lgr.vf \
tex-RobotoSerifCondensed-ExtraLight-osf-ly1--base.tfm \
tex-RobotoSerifCondensed-ExtraLight-osf-ly1.tfm \
tex-RobotoSerifCondensed-ExtraLight-osf-ly1.vf \
tex-RobotoSerifCondensed-ExtraLight-osf-ot1.tfm \
tex-RobotoSerifCondensed-ExtraLight-osf-t1--base.tfm \
tex-RobotoSerifCondensed-ExtraLight-osf-t1.tfm \
tex-RobotoSerifCondensed-ExtraLight-osf-t1.vf \
tex-RobotoSerifCondensed-ExtraLight-osf-ts1--base.tfm \
tex-RobotoSerifCondensed-ExtraLight-osf-ts1.tfm \
tex-RobotoSerifCondensed-ExtraLight-osf-ts1.vf \
tex-RobotoSerifCondensed-ExtraLight-sup-lgr--base.tfm \
tex-RobotoSerifCondensed-ExtraLight-sup-lgr.tfm \
tex-RobotoSerifCondensed-ExtraLight-sup-lgr.vf \
tex-RobotoSerifCondensed-ExtraLight-sup-ly1--base.tfm \
tex-RobotoSerifCondensed-ExtraLight-sup-ly1.tfm \
tex-RobotoSerifCondensed-ExtraLight-sup-ly1.vf \
tex-RobotoSerifCondensed-ExtraLight-sup-ot1.tfm \
tex-RobotoSerifCondensed-ExtraLight-sup-t1--base.tfm \
tex-RobotoSerifCondensed-ExtraLight-sup-t1.tfm \
tex-RobotoSerifCondensed-ExtraLight-sup-t1.vf \
tex-RobotoSerifCondensed-ExtraLight-tlf-lgr--base.tfm \
tex-RobotoSerifCondensed-ExtraLight-tlf-lgr.tfm \
tex-RobotoSerifCondensed-ExtraLight-tlf-lgr.vf \
tex-RobotoSerifCondensed-ExtraLight-tlf-ly1--base.tfm \
tex-RobotoSerifCondensed-ExtraLight-tlf-ly1.tfm \
tex-RobotoSerifCondensed-ExtraLight-tlf-ly1.vf \
tex-RobotoSerifCondensed-ExtraLight-tlf-ot1--base.tfm \
tex-RobotoSerifCondensed-ExtraLight-tlf-ot1.tfm \
tex-RobotoSerifCondensed-ExtraLight-tlf-ot1.vf \
tex-RobotoSerifCondensed-ExtraLight-tlf-t1--base.tfm \
tex-RobotoSerifCondensed-ExtraLight-tlf-t1.tfm \
tex-RobotoSerifCondensed-ExtraLight-tlf-t1.vf \
tex-RobotoSerifCondensed-ExtraLight-tlf-ts1--base.tfm \
tex-RobotoSerifCondensed-ExtraLight-tlf-ts1.tfm \
tex-RobotoSerifCondensed-ExtraLight-tlf-ts1.vf \
tex-RobotoSerifCondensed-ExtraLight-tosf-lgr--base.tfm \
tex-RobotoSerifCondensed-ExtraLight-tosf-lgr.tfm \
tex-RobotoSerifCondensed-ExtraLight-tosf-lgr.vf \
tex-RobotoSerifCondensed-ExtraLight-tosf-ly1--base.tfm \
tex-RobotoSerifCondensed-ExtraLight-tosf-ly1.tfm \
tex-RobotoSerifCondensed-ExtraLight-tosf-ly1.vf \
tex-RobotoSerifCondensed-ExtraLight-tosf-ot1--base.tfm \
tex-RobotoSerifCondensed-ExtraLight-tosf-ot1.tfm \
tex-RobotoSerifCondensed-ExtraLight-tosf-ot1.vf \
tex-RobotoSerifCondensed-ExtraLight-tosf-t1--base.tfm \
tex-RobotoSerifCondensed-ExtraLight-tosf-t1.tfm \
tex-RobotoSerifCondensed-ExtraLight-tosf-t1.vf \
tex-RobotoSerifCondensed-ExtraLight-tosf-ts1--base.tfm \
tex-RobotoSerifCondensed-ExtraLight-tosf-ts1.tfm \
tex-RobotoSerifCondensed-ExtraLight-tosf-ts1.vf \
tex-RobotoSerifCondensed-ExtraLightItalic-lf-lgr--base.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-lf-lgr.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-lf-lgr.vf \
tex-RobotoSerifCondensed-ExtraLightItalic-lf-ly1--base.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-lf-ly1.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-lf-ly1.vf \
tex-RobotoSerifCondensed-ExtraLightItalic-lf-ot1.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-lf-t1--base.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-lf-t1.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-lf-t1.vf \
tex-RobotoSerifCondensed-ExtraLightItalic-lf-ts1--base.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-lf-ts1.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-lf-ts1.vf \
tex-RobotoSerifCondensed-ExtraLightItalic-osf-lgr--base.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-osf-lgr.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-osf-lgr.vf \
tex-RobotoSerifCondensed-ExtraLightItalic-osf-ly1--base.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-osf-ly1.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-osf-ly1.vf \
tex-RobotoSerifCondensed-ExtraLightItalic-osf-ot1.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-osf-t1--base.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-osf-t1.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-osf-t1.vf \
tex-RobotoSerifCondensed-ExtraLightItalic-osf-ts1--base.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-osf-ts1.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-osf-ts1.vf \
tex-RobotoSerifCondensed-ExtraLightItalic-sup-lgr--base.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-sup-lgr.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-sup-lgr.vf \
tex-RobotoSerifCondensed-ExtraLightItalic-sup-ly1--base.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-sup-ly1.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-sup-ly1.vf \
tex-RobotoSerifCondensed-ExtraLightItalic-sup-ot1.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-sup-t1--base.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-sup-t1.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-sup-t1.vf \
tex-RobotoSerifCondensed-ExtraLightItalic-tlf-lgr--base.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-tlf-lgr.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-tlf-lgr.vf \
tex-RobotoSerifCondensed-ExtraLightItalic-tlf-ly1--base.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-tlf-ly1.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-tlf-ly1.vf \
tex-RobotoSerifCondensed-ExtraLightItalic-tlf-ot1--base.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-tlf-ot1.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-tlf-ot1.vf \
tex-RobotoSerifCondensed-ExtraLightItalic-tlf-t1--base.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-tlf-t1.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-tlf-t1.vf \
tex-RobotoSerifCondensed-ExtraLightItalic-tlf-ts1--base.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-tlf-ts1.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-tlf-ts1.vf \
tex-RobotoSerifCondensed-ExtraLightItalic-tosf-lgr--base.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-tosf-lgr.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-tosf-lgr.vf \
tex-RobotoSerifCondensed-ExtraLightItalic-tosf-ly1--base.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-tosf-ly1.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-tosf-ly1.vf \
tex-RobotoSerifCondensed-ExtraLightItalic-tosf-ot1--base.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-tosf-ot1.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-tosf-ot1.vf \
tex-RobotoSerifCondensed-ExtraLightItalic-tosf-t1--base.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-tosf-t1.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-tosf-t1.vf \
tex-RobotoSerifCondensed-ExtraLightItalic-tosf-ts1--base.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-tosf-ts1.tfm \
tex-RobotoSerifCondensed-ExtraLightItalic-tosf-ts1.vf \
tex-RobotoSerifCondensed-Italic-lf-lgr--base.tfm \
tex-RobotoSerifCondensed-Italic-lf-lgr.tfm \
tex-RobotoSerifCondensed-Italic-lf-lgr.vf \
tex-RobotoSerifCondensed-Italic-lf-ly1--base.tfm \
tex-RobotoSerifCondensed-Italic-lf-ly1.tfm \
tex-RobotoSerifCondensed-Italic-lf-ly1.vf \
tex-RobotoSerifCondensed-Italic-lf-ot1.tfm \
tex-RobotoSerifCondensed-Italic-lf-t1--base.tfm \
tex-RobotoSerifCondensed-Italic-lf-t1.tfm \
tex-RobotoSerifCondensed-Italic-lf-t1.vf \
tex-RobotoSerifCondensed-Italic-lf-ts1--base.tfm \
tex-RobotoSerifCondensed-Italic-lf-ts1.tfm \
tex-RobotoSerifCondensed-Italic-lf-ts1.vf \
tex-RobotoSerifCondensed-Italic-osf-lgr--base.tfm \
tex-RobotoSerifCondensed-Italic-osf-lgr.tfm \
tex-RobotoSerifCondensed-Italic-osf-lgr.vf \
tex-RobotoSerifCondensed-Italic-osf-ly1--base.tfm \
tex-RobotoSerifCondensed-Italic-osf-ly1.tfm \
tex-RobotoSerifCondensed-Italic-osf-ly1.vf \
tex-RobotoSerifCondensed-Italic-osf-ot1.tfm \
tex-RobotoSerifCondensed-Italic-osf-t1--base.tfm \
tex-RobotoSerifCondensed-Italic-osf-t1.tfm \
tex-RobotoSerifCondensed-Italic-osf-t1.vf \
tex-RobotoSerifCondensed-Italic-osf-ts1--base.tfm \
tex-RobotoSerifCondensed-Italic-osf-ts1.tfm \
tex-RobotoSerifCondensed-Italic-osf-ts1.vf \
tex-RobotoSerifCondensed-Italic-sup-lgr--base.tfm \
tex-RobotoSerifCondensed-Italic-sup-lgr.tfm \
tex-RobotoSerifCondensed-Italic-sup-lgr.vf \
tex-RobotoSerifCondensed-Italic-sup-ly1--base.tfm \
tex-RobotoSerifCondensed-Italic-sup-ly1.tfm \
tex-RobotoSerifCondensed-Italic-sup-ly1.vf \
tex-RobotoSerifCondensed-Italic-sup-ot1.tfm \
tex-RobotoSerifCondensed-Italic-sup-t1--base.tfm \
tex-RobotoSerifCondensed-Italic-sup-t1.tfm \
tex-RobotoSerifCondensed-Italic-sup-t1.vf \
tex-RobotoSerifCondensed-Italic-tlf-lgr--base.tfm \
tex-RobotoSerifCondensed-Italic-tlf-lgr.tfm \
tex-RobotoSerifCondensed-Italic-tlf-lgr.vf \
tex-RobotoSerifCondensed-Italic-tlf-ly1--base.tfm \
tex-RobotoSerifCondensed-Italic-tlf-ly1.tfm \
tex-RobotoSerifCondensed-Italic-tlf-ly1.vf \
tex-RobotoSerifCondensed-Italic-tlf-ot1--base.tfm \
tex-RobotoSerifCondensed-Italic-tlf-ot1.tfm \
tex-RobotoSerifCondensed-Italic-tlf-ot1.vf \
tex-RobotoSerifCondensed-Italic-tlf-t1--base.tfm \
tex-RobotoSerifCondensed-Italic-tlf-t1.tfm \
tex-RobotoSerifCondensed-Italic-tlf-t1.vf \
tex-RobotoSerifCondensed-Italic-tlf-ts1--base.tfm \
tex-RobotoSerifCondensed-Italic-tlf-ts1.tfm \
tex-RobotoSerifCondensed-Italic-tlf-ts1.vf \
tex-RobotoSerifCondensed-Italic-tosf-lgr--base.tfm \
tex-RobotoSerifCondensed-Italic-tosf-lgr.tfm \
tex-RobotoSerifCondensed-Italic-tosf-lgr.vf \
tex-RobotoSerifCondensed-Italic-tosf-ly1--base.tfm \
tex-RobotoSerifCondensed-Italic-tosf-ly1.tfm \
tex-RobotoSerifCondensed-Italic-tosf-ly1.vf \
tex-RobotoSerifCondensed-Italic-tosf-ot1--base.tfm \
tex-RobotoSerifCondensed-Italic-tosf-ot1.tfm \
tex-RobotoSerifCondensed-Italic-tosf-ot1.vf \
tex-RobotoSerifCondensed-Italic-tosf-t1--base.tfm \
tex-RobotoSerifCondensed-Italic-tosf-t1.tfm \
tex-RobotoSerifCondensed-Italic-tosf-t1.vf \
tex-RobotoSerifCondensed-Italic-tosf-ts1--base.tfm \
tex-RobotoSerifCondensed-Italic-tosf-ts1.tfm \
tex-RobotoSerifCondensed-Italic-tosf-ts1.vf \
tex-RobotoSerifCondensed-Light-lf-lgr--base.tfm \
tex-RobotoSerifCondensed-Light-lf-lgr.tfm \
tex-RobotoSerifCondensed-Light-lf-lgr.vf \
tex-RobotoSerifCondensed-Light-lf-ly1--base.tfm \
tex-RobotoSerifCondensed-Light-lf-ly1.tfm \
tex-RobotoSerifCondensed-Light-lf-ly1.vf \
tex-RobotoSerifCondensed-Light-lf-ot1.tfm \
tex-RobotoSerifCondensed-Light-lf-t1--base.tfm \
tex-RobotoSerifCondensed-Light-lf-t1.tfm \
tex-RobotoSerifCondensed-Light-lf-t1.vf \
tex-RobotoSerifCondensed-Light-lf-ts1--base.tfm \
tex-RobotoSerifCondensed-Light-lf-ts1.tfm \
tex-RobotoSerifCondensed-Light-lf-ts1.vf \
tex-RobotoSerifCondensed-Light-osf-lgr--base.tfm \
tex-RobotoSerifCondensed-Light-osf-lgr.tfm \
tex-RobotoSerifCondensed-Light-osf-lgr.vf \
tex-RobotoSerifCondensed-Light-osf-ly1--base.tfm \
tex-RobotoSerifCondensed-Light-osf-ly1.tfm \
tex-RobotoSerifCondensed-Light-osf-ly1.vf \
tex-RobotoSerifCondensed-Light-osf-ot1.tfm \
tex-RobotoSerifCondensed-Light-osf-t1--base.tfm \
tex-RobotoSerifCondensed-Light-osf-t1.tfm \
tex-RobotoSerifCondensed-Light-osf-t1.vf \
tex-RobotoSerifCondensed-Light-osf-ts1--base.tfm \
tex-RobotoSerifCondensed-Light-osf-ts1.tfm \
tex-RobotoSerifCondensed-Light-osf-ts1.vf \
tex-RobotoSerifCondensed-Light-sup-lgr--base.tfm \
tex-RobotoSerifCondensed-Light-sup-lgr.tfm \
tex-RobotoSerifCondensed-Light-sup-lgr.vf \
tex-RobotoSerifCondensed-Light-sup-ly1--base.tfm \
tex-RobotoSerifCondensed-Light-sup-ly1.tfm \
tex-RobotoSerifCondensed-Light-sup-ly1.vf \
tex-RobotoSerifCondensed-Light-sup-ot1.tfm \
tex-RobotoSerifCondensed-Light-sup-t1--base.tfm \
tex-RobotoSerifCondensed-Light-sup-t1.tfm \
tex-RobotoSerifCondensed-Light-sup-t1.vf \
tex-RobotoSerifCondensed-Light-tlf-lgr--base.tfm \
tex-RobotoSerifCondensed-Light-tlf-lgr.tfm \
tex-RobotoSerifCondensed-Light-tlf-lgr.vf \
tex-RobotoSerifCondensed-Light-tlf-ly1--base.tfm \
tex-RobotoSerifCondensed-Light-tlf-ly1.tfm \
tex-RobotoSerifCondensed-Light-tlf-ly1.vf \
tex-RobotoSerifCondensed-Light-tlf-ot1--base.tfm \
tex-RobotoSerifCondensed-Light-tlf-ot1.tfm \
tex-RobotoSerifCondensed-Light-tlf-ot1.vf \
tex-RobotoSerifCondensed-Light-tlf-t1--base.tfm \
tex-RobotoSerifCondensed-Light-tlf-t1.tfm \
tex-RobotoSerifCondensed-Light-tlf-t1.vf \
tex-RobotoSerifCondensed-Light-tlf-ts1--base.tfm \
tex-RobotoSerifCondensed-Light-tlf-ts1.tfm \
tex-RobotoSerifCondensed-Light-tlf-ts1.vf \
tex-RobotoSerifCondensed-Light-tosf-lgr--base.tfm \
tex-RobotoSerifCondensed-Light-tosf-lgr.tfm \
tex-RobotoSerifCondensed-Light-tosf-lgr.vf \
tex-RobotoSerifCondensed-Light-tosf-ly1--base.tfm \
tex-RobotoSerifCondensed-Light-tosf-ly1.tfm \
tex-RobotoSerifCondensed-Light-tosf-ly1.vf \
tex-RobotoSerifCondensed-Light-tosf-ot1--base.tfm \
tex-RobotoSerifCondensed-Light-tosf-ot1.tfm \
tex-RobotoSerifCondensed-Light-tosf-ot1.vf \
tex-RobotoSerifCondensed-Light-tosf-t1--base.tfm \
tex-RobotoSerifCondensed-Light-tosf-t1.tfm \
tex-RobotoSerifCondensed-Light-tosf-t1.vf \
tex-RobotoSerifCondensed-Light-tosf-ts1--base.tfm \
tex-RobotoSerifCondensed-Light-tosf-ts1.tfm \
tex-RobotoSerifCondensed-Light-tosf-ts1.vf \
tex-RobotoSerifCondensed-LightItalic-lf-lgr--base.tfm \
tex-RobotoSerifCondensed-LightItalic-lf-lgr.tfm \
tex-RobotoSerifCondensed-LightItalic-lf-lgr.vf \
tex-RobotoSerifCondensed-LightItalic-lf-ly1--base.tfm \
tex-RobotoSerifCondensed-LightItalic-lf-ly1.tfm \
tex-RobotoSerifCondensed-LightItalic-lf-ly1.vf \
tex-RobotoSerifCondensed-LightItalic-lf-ot1.tfm \
tex-RobotoSerifCondensed-LightItalic-lf-t1--base.tfm \
tex-RobotoSerifCondensed-LightItalic-lf-t1.tfm \
tex-RobotoSerifCondensed-LightItalic-lf-t1.vf \
tex-RobotoSerifCondensed-LightItalic-lf-ts1--base.tfm \
tex-RobotoSerifCondensed-LightItalic-lf-ts1.tfm \
tex-RobotoSerifCondensed-LightItalic-lf-ts1.vf \
tex-RobotoSerifCondensed-LightItalic-osf-lgr--base.tfm \
tex-RobotoSerifCondensed-LightItalic-osf-lgr.tfm \
tex-RobotoSerifCondensed-LightItalic-osf-lgr.vf \
tex-RobotoSerifCondensed-LightItalic-osf-ly1--base.tfm \
tex-RobotoSerifCondensed-LightItalic-osf-ly1.tfm \
tex-RobotoSerifCondensed-LightItalic-osf-ly1.vf \
tex-RobotoSerifCondensed-LightItalic-osf-ot1.tfm \
tex-RobotoSerifCondensed-LightItalic-osf-t1--base.tfm \
tex-RobotoSerifCondensed-LightItalic-osf-t1.tfm \
tex-RobotoSerifCondensed-LightItalic-osf-t1.vf \
tex-RobotoSerifCondensed-LightItalic-osf-ts1--base.tfm \
tex-RobotoSerifCondensed-LightItalic-osf-ts1.tfm \
tex-RobotoSerifCondensed-LightItalic-osf-ts1.vf \
tex-RobotoSerifCondensed-LightItalic-sup-lgr--base.tfm \
tex-RobotoSerifCondensed-LightItalic-sup-lgr.tfm \
tex-RobotoSerifCondensed-LightItalic-sup-lgr.vf \
tex-RobotoSerifCondensed-LightItalic-sup-ly1--base.tfm \
tex-RobotoSerifCondensed-LightItalic-sup-ly1.tfm \
tex-RobotoSerifCondensed-LightItalic-sup-ly1.vf \
tex-RobotoSerifCondensed-LightItalic-sup-ot1.tfm \
tex-RobotoSerifCondensed-LightItalic-sup-t1--base.tfm \
tex-RobotoSerifCondensed-LightItalic-sup-t1.tfm \
tex-RobotoSerifCondensed-LightItalic-sup-t1.vf \
tex-RobotoSerifCondensed-LightItalic-tlf-lgr--base.tfm \
tex-RobotoSerifCondensed-LightItalic-tlf-lgr.tfm \
tex-RobotoSerifCondensed-LightItalic-tlf-lgr.vf \
tex-RobotoSerifCondensed-LightItalic-tlf-ly1--base.tfm \
tex-RobotoSerifCondensed-LightItalic-tlf-ly1.tfm \
tex-RobotoSerifCondensed-LightItalic-tlf-ly1.vf \
tex-RobotoSerifCondensed-LightItalic-tlf-ot1--base.tfm \
tex-RobotoSerifCondensed-LightItalic-tlf-ot1.tfm \
tex-RobotoSerifCondensed-LightItalic-tlf-ot1.vf \
tex-RobotoSerifCondensed-LightItalic-tlf-t1--base.tfm \
tex-RobotoSerifCondensed-LightItalic-tlf-t1.tfm \
tex-RobotoSerifCondensed-LightItalic-tlf-t1.vf \
tex-RobotoSerifCondensed-LightItalic-tlf-ts1--base.tfm \
tex-RobotoSerifCondensed-LightItalic-tlf-ts1.tfm \
tex-RobotoSerifCondensed-LightItalic-tlf-ts1.vf \
tex-RobotoSerifCondensed-LightItalic-tosf-lgr--base.tfm \
tex-RobotoSerifCondensed-LightItalic-tosf-lgr.tfm \
tex-RobotoSerifCondensed-LightItalic-tosf-lgr.vf \
tex-RobotoSerifCondensed-LightItalic-tosf-ly1--base.tfm \
tex-RobotoSerifCondensed-LightItalic-tosf-ly1.tfm \
tex-RobotoSerifCondensed-LightItalic-tosf-ly1.vf \
tex-RobotoSerifCondensed-LightItalic-tosf-ot1--base.tfm \
tex-RobotoSerifCondensed-LightItalic-tosf-ot1.tfm \
tex-RobotoSerifCondensed-LightItalic-tosf-ot1.vf \
tex-RobotoSerifCondensed-LightItalic-tosf-t1--base.tfm \
tex-RobotoSerifCondensed-LightItalic-tosf-t1.tfm \
tex-RobotoSerifCondensed-LightItalic-tosf-t1.vf \
tex-RobotoSerifCondensed-LightItalic-tosf-ts1--base.tfm \
tex-RobotoSerifCondensed-LightItalic-tosf-ts1.tfm \
tex-RobotoSerifCondensed-LightItalic-tosf-ts1.vf \
tex-RobotoSerifCondensed-Medium-lf-lgr--base.tfm \
tex-RobotoSerifCondensed-Medium-lf-lgr.tfm \
tex-RobotoSerifCondensed-Medium-lf-lgr.vf \
tex-RobotoSerifCondensed-Medium-lf-ly1--base.tfm \
tex-RobotoSerifCondensed-Medium-lf-ly1.tfm \
tex-RobotoSerifCondensed-Medium-lf-ly1.vf \
tex-RobotoSerifCondensed-Medium-lf-ot1.tfm \
tex-RobotoSerifCondensed-Medium-lf-t1--base.tfm \
tex-RobotoSerifCondensed-Medium-lf-t1.tfm \
tex-RobotoSerifCondensed-Medium-lf-t1.vf \
tex-RobotoSerifCondensed-Medium-lf-ts1--base.tfm \
tex-RobotoSerifCondensed-Medium-lf-ts1.tfm \
tex-RobotoSerifCondensed-Medium-lf-ts1.vf \
tex-RobotoSerifCondensed-Medium-osf-lgr--base.tfm \
tex-RobotoSerifCondensed-Medium-osf-lgr.tfm \
tex-RobotoSerifCondensed-Medium-osf-lgr.vf \
tex-RobotoSerifCondensed-Medium-osf-ly1--base.tfm \
tex-RobotoSerifCondensed-Medium-osf-ly1.tfm \
tex-RobotoSerifCondensed-Medium-osf-ly1.vf \
tex-RobotoSerifCondensed-Medium-osf-ot1.tfm \
tex-RobotoSerifCondensed-Medium-osf-t1--base.tfm \
tex-RobotoSerifCondensed-Medium-osf-t1.tfm \
tex-RobotoSerifCondensed-Medium-osf-t1.vf \
tex-RobotoSerifCondensed-Medium-osf-ts1--base.tfm \
tex-RobotoSerifCondensed-Medium-osf-ts1.tfm \
tex-RobotoSerifCondensed-Medium-osf-ts1.vf \
tex-RobotoSerifCondensed-Medium-sup-lgr--base.tfm \
tex-RobotoSerifCondensed-Medium-sup-lgr.tfm \
tex-RobotoSerifCondensed-Medium-sup-lgr.vf \
tex-RobotoSerifCondensed-Medium-sup-ly1--base.tfm \
tex-RobotoSerifCondensed-Medium-sup-ly1.tfm \
tex-RobotoSerifCondensed-Medium-sup-ly1.vf \
tex-RobotoSerifCondensed-Medium-sup-ot1.tfm \
tex-RobotoSerifCondensed-Medium-sup-t1--base.tfm \
tex-RobotoSerifCondensed-Medium-sup-t1.tfm \
tex-RobotoSerifCondensed-Medium-sup-t1.vf \
tex-RobotoSerifCondensed-Medium-tlf-lgr--base.tfm \
tex-RobotoSerifCondensed-Medium-tlf-lgr.tfm \
tex-RobotoSerifCondensed-Medium-tlf-lgr.vf \
tex-RobotoSerifCondensed-Medium-tlf-ly1--base.tfm \
tex-RobotoSerifCondensed-Medium-tlf-ly1.tfm \
tex-RobotoSerifCondensed-Medium-tlf-ly1.vf \
tex-RobotoSerifCondensed-Medium-tlf-ot1--base.tfm \
tex-RobotoSerifCondensed-Medium-tlf-ot1.tfm \
tex-RobotoSerifCondensed-Medium-tlf-ot1.vf \
tex-RobotoSerifCondensed-Medium-tlf-t1--base.tfm \
tex-RobotoSerifCondensed-Medium-tlf-t1.tfm \
tex-RobotoSerifCondensed-Medium-tlf-t1.vf \
tex-RobotoSerifCondensed-Medium-tlf-ts1--base.tfm \
tex-RobotoSerifCondensed-Medium-tlf-ts1.tfm \
tex-RobotoSerifCondensed-Medium-tlf-ts1.vf \
tex-RobotoSerifCondensed-Medium-tosf-lgr--base.tfm \
tex-RobotoSerifCondensed-Medium-tosf-lgr.tfm \
tex-RobotoSerifCondensed-Medium-tosf-lgr.vf \
tex-RobotoSerifCondensed-Medium-tosf-ly1--base.tfm \
tex-RobotoSerifCondensed-Medium-tosf-ly1.tfm \
tex-RobotoSerifCondensed-Medium-tosf-ly1.vf \
tex-RobotoSerifCondensed-Medium-tosf-ot1--base.tfm \
tex-RobotoSerifCondensed-Medium-tosf-ot1.tfm \
tex-RobotoSerifCondensed-Medium-tosf-ot1.vf \
tex-RobotoSerifCondensed-Medium-tosf-t1--base.tfm \
tex-RobotoSerifCondensed-Medium-tosf-t1.tfm \
tex-RobotoSerifCondensed-Medium-tosf-t1.vf \
tex-RobotoSerifCondensed-Medium-tosf-ts1--base.tfm \
tex-RobotoSerifCondensed-Medium-tosf-ts1.tfm \
tex-RobotoSerifCondensed-Medium-tosf-ts1.vf \
tex-RobotoSerifCondensed-MediumItalic-lf-lgr--base.tfm \
tex-RobotoSerifCondensed-MediumItalic-lf-lgr.tfm \
tex-RobotoSerifCondensed-MediumItalic-lf-lgr.vf \
tex-RobotoSerifCondensed-MediumItalic-lf-ly1--base.tfm \
tex-RobotoSerifCondensed-MediumItalic-lf-ly1.tfm \
tex-RobotoSerifCondensed-MediumItalic-lf-ly1.vf \
tex-RobotoSerifCondensed-MediumItalic-lf-ot1.tfm \
tex-RobotoSerifCondensed-MediumItalic-lf-t1--base.tfm \
tex-RobotoSerifCondensed-MediumItalic-lf-t1.tfm \
tex-RobotoSerifCondensed-MediumItalic-lf-t1.vf \
tex-RobotoSerifCondensed-MediumItalic-lf-ts1--base.tfm \
tex-RobotoSerifCondensed-MediumItalic-lf-ts1.tfm \
tex-RobotoSerifCondensed-MediumItalic-lf-ts1.vf \
tex-RobotoSerifCondensed-MediumItalic-osf-lgr--base.tfm \
tex-RobotoSerifCondensed-MediumItalic-osf-lgr.tfm \
tex-RobotoSerifCondensed-MediumItalic-osf-lgr.vf \
tex-RobotoSerifCondensed-MediumItalic-osf-ly1--base.tfm \
tex-RobotoSerifCondensed-MediumItalic-osf-ly1.tfm \
tex-RobotoSerifCondensed-MediumItalic-osf-ly1.vf \
tex-RobotoSerifCondensed-MediumItalic-osf-ot1.tfm \
tex-RobotoSerifCondensed-MediumItalic-osf-t1--base.tfm \
tex-RobotoSerifCondensed-MediumItalic-osf-t1.tfm \
tex-RobotoSerifCondensed-MediumItalic-osf-t1.vf \
tex-RobotoSerifCondensed-MediumItalic-osf-ts1--base.tfm \
tex-RobotoSerifCondensed-MediumItalic-osf-ts1.tfm \
tex-RobotoSerifCondensed-MediumItalic-osf-ts1.vf \
tex-RobotoSerifCondensed-MediumItalic-sup-lgr--base.tfm \
tex-RobotoSerifCondensed-MediumItalic-sup-lgr.tfm \
tex-RobotoSerifCondensed-MediumItalic-sup-lgr.vf \
tex-RobotoSerifCondensed-MediumItalic-sup-ly1--base.tfm \
tex-RobotoSerifCondensed-MediumItalic-sup-ly1.tfm \
tex-RobotoSerifCondensed-MediumItalic-sup-ly1.vf \
tex-RobotoSerifCondensed-MediumItalic-sup-ot1.tfm \
tex-RobotoSerifCondensed-MediumItalic-sup-t1--base.tfm \
tex-RobotoSerifCondensed-MediumItalic-sup-t1.tfm \
tex-RobotoSerifCondensed-MediumItalic-sup-t1.vf \
tex-RobotoSerifCondensed-MediumItalic-tlf-lgr--base.tfm \
tex-RobotoSerifCondensed-MediumItalic-tlf-lgr.tfm \
tex-RobotoSerifCondensed-MediumItalic-tlf-lgr.vf \
tex-RobotoSerifCondensed-MediumItalic-tlf-ly1--base.tfm \
tex-RobotoSerifCondensed-MediumItalic-tlf-ly1.tfm \
tex-RobotoSerifCondensed-MediumItalic-tlf-ly1.vf \
tex-RobotoSerifCondensed-MediumItalic-tlf-ot1--base.tfm \
tex-RobotoSerifCondensed-MediumItalic-tlf-ot1.tfm \
tex-RobotoSerifCondensed-MediumItalic-tlf-ot1.vf \
tex-RobotoSerifCondensed-MediumItalic-tlf-t1--base.tfm \
tex-RobotoSerifCondensed-MediumItalic-tlf-t1.tfm \
tex-RobotoSerifCondensed-MediumItalic-tlf-t1.vf \
tex-RobotoSerifCondensed-MediumItalic-tlf-ts1--base.tfm \
tex-RobotoSerifCondensed-MediumItalic-tlf-ts1.tfm \
tex-RobotoSerifCondensed-MediumItalic-tlf-ts1.vf \
tex-RobotoSerifCondensed-MediumItalic-tosf-lgr--base.tfm \
tex-RobotoSerifCondensed-MediumItalic-tosf-lgr.tfm \
tex-RobotoSerifCondensed-MediumItalic-tosf-lgr.vf \
tex-RobotoSerifCondensed-MediumItalic-tosf-ly1--base.tfm \
tex-RobotoSerifCondensed-MediumItalic-tosf-ly1.tfm \
tex-RobotoSerifCondensed-MediumItalic-tosf-ly1.vf \
tex-RobotoSerifCondensed-MediumItalic-tosf-ot1--base.tfm \
tex-RobotoSerifCondensed-MediumItalic-tosf-ot1.tfm \
tex-RobotoSerifCondensed-MediumItalic-tosf-ot1.vf \
tex-RobotoSerifCondensed-MediumItalic-tosf-t1--base.tfm \
tex-RobotoSerifCondensed-MediumItalic-tosf-t1.tfm \
tex-RobotoSerifCondensed-MediumItalic-tosf-t1.vf \
tex-RobotoSerifCondensed-MediumItalic-tosf-ts1--base.tfm \
tex-RobotoSerifCondensed-MediumItalic-tosf-ts1.tfm \
tex-RobotoSerifCondensed-MediumItalic-tosf-ts1.vf \
tex-RobotoSerifCondensed-Regular-lf-lgr--base.tfm \
tex-RobotoSerifCondensed-Regular-lf-lgr.tfm \
tex-RobotoSerifCondensed-Regular-lf-lgr.vf \
tex-RobotoSerifCondensed-Regular-lf-ly1--base.tfm \
tex-RobotoSerifCondensed-Regular-lf-ly1.tfm \
tex-RobotoSerifCondensed-Regular-lf-ly1.vf \
tex-RobotoSerifCondensed-Regular-lf-ot1.tfm \
tex-RobotoSerifCondensed-Regular-lf-t1--base.tfm \
tex-RobotoSerifCondensed-Regular-lf-t1.tfm \
tex-RobotoSerifCondensed-Regular-lf-t1.vf \
tex-RobotoSerifCondensed-Regular-lf-ts1--base.tfm \
tex-RobotoSerifCondensed-Regular-lf-ts1.tfm \
tex-RobotoSerifCondensed-Regular-lf-ts1.vf \
tex-RobotoSerifCondensed-Regular-osf-lgr--base.tfm \
tex-RobotoSerifCondensed-Regular-osf-lgr.tfm \
tex-RobotoSerifCondensed-Regular-osf-lgr.vf \
tex-RobotoSerifCondensed-Regular-osf-ly1--base.tfm \
tex-RobotoSerifCondensed-Regular-osf-ly1.tfm \
tex-RobotoSerifCondensed-Regular-osf-ly1.vf \
tex-RobotoSerifCondensed-Regular-osf-ot1.tfm \
tex-RobotoSerifCondensed-Regular-osf-t1--base.tfm \
tex-RobotoSerifCondensed-Regular-osf-t1.tfm \
tex-RobotoSerifCondensed-Regular-osf-t1.vf \
tex-RobotoSerifCondensed-Regular-osf-ts1--base.tfm \
tex-RobotoSerifCondensed-Regular-osf-ts1.tfm \
tex-RobotoSerifCondensed-Regular-osf-ts1.vf \
tex-RobotoSerifCondensed-Regular-sup-lgr--base.tfm \
tex-RobotoSerifCondensed-Regular-sup-lgr.tfm \
tex-RobotoSerifCondensed-Regular-sup-lgr.vf \
tex-RobotoSerifCondensed-Regular-sup-ly1--base.tfm \
tex-RobotoSerifCondensed-Regular-sup-ly1.tfm \
tex-RobotoSerifCondensed-Regular-sup-ly1.vf \
tex-RobotoSerifCondensed-Regular-sup-ot1.tfm \
tex-RobotoSerifCondensed-Regular-sup-t1--base.tfm \
tex-RobotoSerifCondensed-Regular-sup-t1.tfm \
tex-RobotoSerifCondensed-Regular-sup-t1.vf \
tex-RobotoSerifCondensed-Regular-tlf-lgr--base.tfm \
tex-RobotoSerifCondensed-Regular-tlf-lgr.tfm \
tex-RobotoSerifCondensed-Regular-tlf-lgr.vf \
tex-RobotoSerifCondensed-Regular-tlf-ly1--base.tfm \
tex-RobotoSerifCondensed-Regular-tlf-ly1.tfm \
tex-RobotoSerifCondensed-Regular-tlf-ly1.vf \
tex-RobotoSerifCondensed-Regular-tlf-ot1--base.tfm \
tex-RobotoSerifCondensed-Regular-tlf-ot1.tfm \
tex-RobotoSerifCondensed-Regular-tlf-ot1.vf \
tex-RobotoSerifCondensed-Regular-tlf-t1--base.tfm \
tex-RobotoSerifCondensed-Regular-tlf-t1.tfm \
tex-RobotoSerifCondensed-Regular-tlf-t1.vf \
tex-RobotoSerifCondensed-Regular-tlf-ts1--base.tfm \
tex-RobotoSerifCondensed-Regular-tlf-ts1.tfm \
tex-RobotoSerifCondensed-Regular-tlf-ts1.vf \
tex-RobotoSerifCondensed-Regular-tosf-lgr--base.tfm \
tex-RobotoSerifCondensed-Regular-tosf-lgr.tfm \
tex-RobotoSerifCondensed-Regular-tosf-lgr.vf \
tex-RobotoSerifCondensed-Regular-tosf-ly1--base.tfm \
tex-RobotoSerifCondensed-Regular-tosf-ly1.tfm \
tex-RobotoSerifCondensed-Regular-tosf-ly1.vf \
tex-RobotoSerifCondensed-Regular-tosf-ot1--base.tfm \
tex-RobotoSerifCondensed-Regular-tosf-ot1.tfm \
tex-RobotoSerifCondensed-Regular-tosf-ot1.vf \
tex-RobotoSerifCondensed-Regular-tosf-t1--base.tfm \
tex-RobotoSerifCondensed-Regular-tosf-t1.tfm \
tex-RobotoSerifCondensed-Regular-tosf-t1.vf \
tex-RobotoSerifCondensed-Regular-tosf-ts1--base.tfm \
tex-RobotoSerifCondensed-Regular-tosf-ts1.tfm \
tex-RobotoSerifCondensed-Regular-tosf-ts1.vf \
tex-RobotoSerifCondensed-SemiBold-lf-lgr--base.tfm \
tex-RobotoSerifCondensed-SemiBold-lf-lgr.tfm \
tex-RobotoSerifCondensed-SemiBold-lf-lgr.vf \
tex-RobotoSerifCondensed-SemiBold-lf-ly1--base.tfm \
tex-RobotoSerifCondensed-SemiBold-lf-ly1.tfm \
tex-RobotoSerifCondensed-SemiBold-lf-ly1.vf \
tex-RobotoSerifCondensed-SemiBold-lf-ot1.tfm \
tex-RobotoSerifCondensed-SemiBold-lf-t1--base.tfm \
tex-RobotoSerifCondensed-SemiBold-lf-t1.tfm \
tex-RobotoSerifCondensed-SemiBold-lf-t1.vf \
tex-RobotoSerifCondensed-SemiBold-lf-ts1--base.tfm \
tex-RobotoSerifCondensed-SemiBold-lf-ts1.tfm \
tex-RobotoSerifCondensed-SemiBold-lf-ts1.vf \
tex-RobotoSerifCondensed-SemiBold-osf-lgr--base.tfm \
tex-RobotoSerifCondensed-SemiBold-osf-lgr.tfm \
tex-RobotoSerifCondensed-SemiBold-osf-lgr.vf \
tex-RobotoSerifCondensed-SemiBold-osf-ly1--base.tfm \
tex-RobotoSerifCondensed-SemiBold-osf-ly1.tfm \
tex-RobotoSerifCondensed-SemiBold-osf-ly1.vf \
tex-RobotoSerifCondensed-SemiBold-osf-ot1.tfm \
tex-RobotoSerifCondensed-SemiBold-osf-t1--base.tfm \
tex-RobotoSerifCondensed-SemiBold-osf-t1.tfm \
tex-RobotoSerifCondensed-SemiBold-osf-t1.vf \
tex-RobotoSerifCondensed-SemiBold-osf-ts1--base.tfm \
tex-RobotoSerifCondensed-SemiBold-osf-ts1.tfm \
tex-RobotoSerifCondensed-SemiBold-osf-ts1.vf \
tex-RobotoSerifCondensed-SemiBold-sup-lgr--base.tfm \
tex-RobotoSerifCondensed-SemiBold-sup-lgr.tfm \
tex-RobotoSerifCondensed-SemiBold-sup-lgr.vf \
tex-RobotoSerifCondensed-SemiBold-sup-ly1--base.tfm \
tex-RobotoSerifCondensed-SemiBold-sup-ly1.tfm \
tex-RobotoSerifCondensed-SemiBold-sup-ly1.vf \
tex-RobotoSerifCondensed-SemiBold-sup-ot1.tfm \
tex-RobotoSerifCondensed-SemiBold-sup-t1--base.tfm \
tex-RobotoSerifCondensed-SemiBold-sup-t1.tfm \
tex-RobotoSerifCondensed-SemiBold-sup-t1.vf \
tex-RobotoSerifCondensed-SemiBold-tlf-lgr--base.tfm \
tex-RobotoSerifCondensed-SemiBold-tlf-lgr.tfm \
tex-RobotoSerifCondensed-SemiBold-tlf-lgr.vf \
tex-RobotoSerifCondensed-SemiBold-tlf-ly1--base.tfm \
tex-RobotoSerifCondensed-SemiBold-tlf-ly1.tfm \
tex-RobotoSerifCondensed-SemiBold-tlf-ly1.vf \
tex-RobotoSerifCondensed-SemiBold-tlf-ot1--base.tfm \
tex-RobotoSerifCondensed-SemiBold-tlf-ot1.tfm \
tex-RobotoSerifCondensed-SemiBold-tlf-ot1.vf \
tex-RobotoSerifCondensed-SemiBold-tlf-t1--base.tfm \
tex-RobotoSerifCondensed-SemiBold-tlf-t1.tfm \
tex-RobotoSerifCondensed-SemiBold-tlf-t1.vf \
tex-RobotoSerifCondensed-SemiBold-tlf-ts1--base.tfm \
tex-RobotoSerifCondensed-SemiBold-tlf-ts1.tfm \
tex-RobotoSerifCondensed-SemiBold-tlf-ts1.vf \
tex-RobotoSerifCondensed-SemiBold-tosf-lgr--base.tfm \
tex-RobotoSerifCondensed-SemiBold-tosf-lgr.tfm \
tex-RobotoSerifCondensed-SemiBold-tosf-lgr.vf \
tex-RobotoSerifCondensed-SemiBold-tosf-ly1--base.tfm \
tex-RobotoSerifCondensed-SemiBold-tosf-ly1.tfm \
tex-RobotoSerifCondensed-SemiBold-tosf-ly1.vf \
tex-RobotoSerifCondensed-SemiBold-tosf-ot1--base.tfm \
tex-RobotoSerifCondensed-SemiBold-tosf-ot1.tfm \
tex-RobotoSerifCondensed-SemiBold-tosf-ot1.vf \
tex-RobotoSerifCondensed-SemiBold-tosf-t1--base.tfm \
tex-RobotoSerifCondensed-SemiBold-tosf-t1.tfm \
tex-RobotoSerifCondensed-SemiBold-tosf-t1.vf \
tex-RobotoSerifCondensed-SemiBold-tosf-ts1--base.tfm \
tex-RobotoSerifCondensed-SemiBold-tosf-ts1.tfm \
tex-RobotoSerifCondensed-SemiBold-tosf-ts1.vf \
tex-RobotoSerifCondensed-SemiBoldItalic-lf-lgr--base.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-lf-lgr.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-lf-lgr.vf \
tex-RobotoSerifCondensed-SemiBoldItalic-lf-ly1--base.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-lf-ly1.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-lf-ly1.vf \
tex-RobotoSerifCondensed-SemiBoldItalic-lf-ot1.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-lf-t1--base.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-lf-t1.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-lf-t1.vf \
tex-RobotoSerifCondensed-SemiBoldItalic-lf-ts1--base.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-lf-ts1.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-lf-ts1.vf \
tex-RobotoSerifCondensed-SemiBoldItalic-osf-lgr--base.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-osf-lgr.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-osf-lgr.vf \
tex-RobotoSerifCondensed-SemiBoldItalic-osf-ly1--base.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-osf-ly1.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-osf-ly1.vf \
tex-RobotoSerifCondensed-SemiBoldItalic-osf-ot1.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-osf-t1--base.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-osf-t1.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-osf-t1.vf \
tex-RobotoSerifCondensed-SemiBoldItalic-osf-ts1--base.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-osf-ts1.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-osf-ts1.vf \
tex-RobotoSerifCondensed-SemiBoldItalic-sup-lgr--base.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-sup-lgr.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-sup-lgr.vf \
tex-RobotoSerifCondensed-SemiBoldItalic-sup-ly1--base.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-sup-ly1.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-sup-ly1.vf \
tex-RobotoSerifCondensed-SemiBoldItalic-sup-ot1.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-sup-t1--base.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-sup-t1.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-sup-t1.vf \
tex-RobotoSerifCondensed-SemiBoldItalic-tlf-lgr--base.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-tlf-lgr.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-tlf-lgr.vf \
tex-RobotoSerifCondensed-SemiBoldItalic-tlf-ly1--base.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-tlf-ly1.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-tlf-ly1.vf \
tex-RobotoSerifCondensed-SemiBoldItalic-tlf-ot1--base.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-tlf-ot1.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-tlf-ot1.vf \
tex-RobotoSerifCondensed-SemiBoldItalic-tlf-t1--base.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-tlf-t1.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-tlf-t1.vf \
tex-RobotoSerifCondensed-SemiBoldItalic-tlf-ts1--base.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-tlf-ts1.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-tlf-ts1.vf \
tex-RobotoSerifCondensed-SemiBoldItalic-tosf-lgr--base.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-tosf-lgr.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-tosf-lgr.vf \
tex-RobotoSerifCondensed-SemiBoldItalic-tosf-ly1--base.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-tosf-ly1.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-tosf-ly1.vf \
tex-RobotoSerifCondensed-SemiBoldItalic-tosf-ot1--base.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-tosf-ot1.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-tosf-ot1.vf \
tex-RobotoSerifCondensed-SemiBoldItalic-tosf-t1--base.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-tosf-t1.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-tosf-t1.vf \
tex-RobotoSerifCondensed-SemiBoldItalic-tosf-ts1--base.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-tosf-ts1.tfm \
tex-RobotoSerifCondensed-SemiBoldItalic-tosf-ts1.vf \
tex-RobotoSerifCondensed-Thin-lf-lgr--base.tfm \
tex-RobotoSerifCondensed-Thin-lf-lgr.tfm \
tex-RobotoSerifCondensed-Thin-lf-lgr.vf \
tex-RobotoSerifCondensed-Thin-lf-ly1--base.tfm \
tex-RobotoSerifCondensed-Thin-lf-ly1.tfm \
tex-RobotoSerifCondensed-Thin-lf-ly1.vf \
tex-RobotoSerifCondensed-Thin-lf-ot1.tfm \
tex-RobotoSerifCondensed-Thin-lf-t1--base.tfm \
tex-RobotoSerifCondensed-Thin-lf-t1.tfm \
tex-RobotoSerifCondensed-Thin-lf-t1.vf \
tex-RobotoSerifCondensed-Thin-lf-ts1--base.tfm \
tex-RobotoSerifCondensed-Thin-lf-ts1.tfm \
tex-RobotoSerifCondensed-Thin-lf-ts1.vf \
tex-RobotoSerifCondensed-Thin-osf-lgr--base.tfm \
tex-RobotoSerifCondensed-Thin-osf-lgr.tfm \
tex-RobotoSerifCondensed-Thin-osf-lgr.vf \
tex-RobotoSerifCondensed-Thin-osf-ly1--base.tfm \
tex-RobotoSerifCondensed-Thin-osf-ly1.tfm \
tex-RobotoSerifCondensed-Thin-osf-ly1.vf \
tex-RobotoSerifCondensed-Thin-osf-ot1.tfm \
tex-RobotoSerifCondensed-Thin-osf-t1--base.tfm \
tex-RobotoSerifCondensed-Thin-osf-t1.tfm \
tex-RobotoSerifCondensed-Thin-osf-t1.vf \
tex-RobotoSerifCondensed-Thin-osf-ts1--base.tfm \
tex-RobotoSerifCondensed-Thin-osf-ts1.tfm \
tex-RobotoSerifCondensed-Thin-osf-ts1.vf \
tex-RobotoSerifCondensed-Thin-sup-lgr--base.tfm \
tex-RobotoSerifCondensed-Thin-sup-lgr.tfm \
tex-RobotoSerifCondensed-Thin-sup-lgr.vf \
tex-RobotoSerifCondensed-Thin-sup-ly1--base.tfm \
tex-RobotoSerifCondensed-Thin-sup-ly1.tfm \
tex-RobotoSerifCondensed-Thin-sup-ly1.vf \
tex-RobotoSerifCondensed-Thin-sup-ot1.tfm \
tex-RobotoSerifCondensed-Thin-sup-t1--base.tfm \
tex-RobotoSerifCondensed-Thin-sup-t1.tfm \
tex-RobotoSerifCondensed-Thin-sup-t1.vf \
tex-RobotoSerifCondensed-Thin-tlf-lgr--base.tfm \
tex-RobotoSerifCondensed-Thin-tlf-lgr.tfm \
tex-RobotoSerifCondensed-Thin-tlf-lgr.vf \
tex-RobotoSerifCondensed-Thin-tlf-ly1--base.tfm \
tex-RobotoSerifCondensed-Thin-tlf-ly1.tfm \
tex-RobotoSerifCondensed-Thin-tlf-ly1.vf \
tex-RobotoSerifCondensed-Thin-tlf-ot1--base.tfm \
tex-RobotoSerifCondensed-Thin-tlf-ot1.tfm \
tex-RobotoSerifCondensed-Thin-tlf-ot1.vf \
tex-RobotoSerifCondensed-Thin-tlf-t1--base.tfm \
tex-RobotoSerifCondensed-Thin-tlf-t1.tfm \
tex-RobotoSerifCondensed-Thin-tlf-t1.vf \
tex-RobotoSerifCondensed-Thin-tlf-ts1--base.tfm \
tex-RobotoSerifCondensed-Thin-tlf-ts1.tfm \
tex-RobotoSerifCondensed-Thin-tlf-ts1.vf \
tex-RobotoSerifCondensed-Thin-tosf-lgr--base.tfm \
tex-RobotoSerifCondensed-Thin-tosf-lgr.tfm \
tex-RobotoSerifCondensed-Thin-tosf-lgr.vf \
tex-RobotoSerifCondensed-Thin-tosf-ly1--base.tfm \
tex-RobotoSerifCondensed-Thin-tosf-ly1.tfm \
tex-RobotoSerifCondensed-Thin-tosf-ly1.vf \
tex-RobotoSerifCondensed-Thin-tosf-ot1--base.tfm \
tex-RobotoSerifCondensed-Thin-tosf-ot1.tfm \
tex-RobotoSerifCondensed-Thin-tosf-ot1.vf \
tex-RobotoSerifCondensed-Thin-tosf-t1--base.tfm \
tex-RobotoSerifCondensed-Thin-tosf-t1.tfm \
tex-RobotoSerifCondensed-Thin-tosf-t1.vf \
tex-RobotoSerifCondensed-Thin-tosf-ts1--base.tfm \
tex-RobotoSerifCondensed-Thin-tosf-ts1.tfm \
tex-RobotoSerifCondensed-Thin-tosf-ts1.vf \
tex-RobotoSerifCondensed-ThinItalic-lf-lgr--base.tfm \
tex-RobotoSerifCondensed-ThinItalic-lf-lgr.tfm \
tex-RobotoSerifCondensed-ThinItalic-lf-lgr.vf \
tex-RobotoSerifCondensed-ThinItalic-lf-ly1--base.tfm \
tex-RobotoSerifCondensed-ThinItalic-lf-ly1.tfm \
tex-RobotoSerifCondensed-ThinItalic-lf-ly1.vf \
tex-RobotoSerifCondensed-ThinItalic-lf-ot1.tfm \
tex-RobotoSerifCondensed-ThinItalic-lf-t1--base.tfm \
tex-RobotoSerifCondensed-ThinItalic-lf-t1.tfm \
tex-RobotoSerifCondensed-ThinItalic-lf-t1.vf \
tex-RobotoSerifCondensed-ThinItalic-lf-ts1--base.tfm \
tex-RobotoSerifCondensed-ThinItalic-lf-ts1.tfm \
tex-RobotoSerifCondensed-ThinItalic-lf-ts1.vf \
tex-RobotoSerifCondensed-ThinItalic-osf-lgr--base.tfm \
tex-RobotoSerifCondensed-ThinItalic-osf-lgr.tfm \
tex-RobotoSerifCondensed-ThinItalic-osf-lgr.vf \
tex-RobotoSerifCondensed-ThinItalic-osf-ly1--base.tfm \
tex-RobotoSerifCondensed-ThinItalic-osf-ly1.tfm \
tex-RobotoSerifCondensed-ThinItalic-osf-ly1.vf \
tex-RobotoSerifCondensed-ThinItalic-osf-ot1.tfm \
tex-RobotoSerifCondensed-ThinItalic-osf-t1--base.tfm \
tex-RobotoSerifCondensed-ThinItalic-osf-t1.tfm \
tex-RobotoSerifCondensed-ThinItalic-osf-t1.vf \
tex-RobotoSerifCondensed-ThinItalic-osf-ts1--base.tfm \
tex-RobotoSerifCondensed-ThinItalic-osf-ts1.tfm \
tex-RobotoSerifCondensed-ThinItalic-osf-ts1.vf \
tex-RobotoSerifCondensed-ThinItalic-sup-lgr--base.tfm \
tex-RobotoSerifCondensed-ThinItalic-sup-lgr.tfm \
tex-RobotoSerifCondensed-ThinItalic-sup-lgr.vf \
tex-RobotoSerifCondensed-ThinItalic-sup-ly1--base.tfm \
tex-RobotoSerifCondensed-ThinItalic-sup-ly1.tfm \
tex-RobotoSerifCondensed-ThinItalic-sup-ly1.vf \
tex-RobotoSerifCondensed-ThinItalic-sup-ot1.tfm \
tex-RobotoSerifCondensed-ThinItalic-sup-t1--base.tfm \
tex-RobotoSerifCondensed-ThinItalic-sup-t1.tfm \
tex-RobotoSerifCondensed-ThinItalic-sup-t1.vf \
tex-RobotoSerifCondensed-ThinItalic-tlf-lgr--base.tfm \
tex-RobotoSerifCondensed-ThinItalic-tlf-lgr.tfm \
tex-RobotoSerifCondensed-ThinItalic-tlf-lgr.vf \
tex-RobotoSerifCondensed-ThinItalic-tlf-ly1--base.tfm \
tex-RobotoSerifCondensed-ThinItalic-tlf-ly1.tfm \
tex-RobotoSerifCondensed-ThinItalic-tlf-ly1.vf \
tex-RobotoSerifCondensed-ThinItalic-tlf-ot1--base.tfm \
tex-RobotoSerifCondensed-ThinItalic-tlf-ot1.tfm \
tex-RobotoSerifCondensed-ThinItalic-tlf-ot1.vf \
tex-RobotoSerifCondensed-ThinItalic-tlf-t1--base.tfm \
tex-RobotoSerifCondensed-ThinItalic-tlf-t1.tfm \
tex-RobotoSerifCondensed-ThinItalic-tlf-t1.vf \
tex-RobotoSerifCondensed-ThinItalic-tlf-ts1--base.tfm \
tex-RobotoSerifCondensed-ThinItalic-tlf-ts1.tfm \
tex-RobotoSerifCondensed-ThinItalic-tlf-ts1.vf \
tex-RobotoSerifCondensed-ThinItalic-tosf-lgr--base.tfm \
tex-RobotoSerifCondensed-ThinItalic-tosf-lgr.tfm \
tex-RobotoSerifCondensed-ThinItalic-tosf-lgr.vf \
tex-RobotoSerifCondensed-ThinItalic-tosf-ly1--base.tfm \
tex-RobotoSerifCondensed-ThinItalic-tosf-ly1.tfm \
tex-RobotoSerifCondensed-ThinItalic-tosf-ly1.vf \
tex-RobotoSerifCondensed-ThinItalic-tosf-ot1--base.tfm \
tex-RobotoSerifCondensed-ThinItalic-tosf-ot1.tfm \
tex-RobotoSerifCondensed-ThinItalic-tosf-ot1.vf \
tex-RobotoSerifCondensed-ThinItalic-tosf-t1--base.tfm \
tex-RobotoSerifCondensed-ThinItalic-tosf-t1.tfm \
tex-RobotoSerifCondensed-ThinItalic-tosf-t1.vf \
tex-RobotoSerifCondensed-ThinItalic-tosf-ts1--base.tfm \
tex-RobotoSerifCondensed-ThinItalic-tosf-ts1.tfm \
tex-RobotoSerifCondensed-ThinItalic-tosf-ts1.vf \
tex-RobotoSlab-Bold-tlf-lgr--base.tfm \
tex-RobotoSlab-Bold-tlf-lgr.tfm \
tex-RobotoSlab-Bold-tlf-lgr.vf \
tex-RobotoSlab-Bold-tlf-ly1--base.tfm \
tex-RobotoSlab-Bold-tlf-ly1.tfm \
tex-RobotoSlab-Bold-tlf-ly1.vf \
tex-RobotoSlab-Bold-tlf-ot1.tfm \
tex-RobotoSlab-Bold-tlf-sc-lgr--base.tfm \
tex-RobotoSlab-Bold-tlf-sc-lgr.tfm \
tex-RobotoSlab-Bold-tlf-sc-lgr.vf \
tex-RobotoSlab-Bold-tlf-sc-ly1--base.tfm \
tex-RobotoSlab-Bold-tlf-sc-ly1.tfm \
tex-RobotoSlab-Bold-tlf-sc-ly1.vf \
tex-RobotoSlab-Bold-tlf-sc-ot1--base.tfm \
tex-RobotoSlab-Bold-tlf-sc-ot1.tfm \
tex-RobotoSlab-Bold-tlf-sc-ot1.vf \
tex-RobotoSlab-Bold-tlf-sc-t1--base.tfm \
tex-RobotoSlab-Bold-tlf-sc-t1.tfm \
tex-RobotoSlab-Bold-tlf-sc-t1.vf \
tex-RobotoSlab-Bold-tlf-t1--base.tfm \
tex-RobotoSlab-Bold-tlf-t1.tfm \
tex-RobotoSlab-Bold-tlf-t1.vf \
tex-RobotoSlab-Bold-tlf-ts1--base.tfm \
tex-RobotoSlab-Bold-tlf-ts1.tfm \
tex-RobotoSlab-Bold-tlf-ts1.vf \
tex-RobotoSlab-Light-tlf-lgr--base.tfm \
tex-RobotoSlab-Light-tlf-lgr.tfm \
tex-RobotoSlab-Light-tlf-lgr.vf \
tex-RobotoSlab-Light-tlf-ly1--base.tfm \
tex-RobotoSlab-Light-tlf-ly1.tfm \
tex-RobotoSlab-Light-tlf-ly1.vf \
tex-RobotoSlab-Light-tlf-ot1.tfm \
tex-RobotoSlab-Light-tlf-sc-lgr--base.tfm \
tex-RobotoSlab-Light-tlf-sc-lgr.tfm \
tex-RobotoSlab-Light-tlf-sc-lgr.vf \
tex-RobotoSlab-Light-tlf-sc-ly1--base.tfm \
tex-RobotoSlab-Light-tlf-sc-ly1.tfm \
tex-RobotoSlab-Light-tlf-sc-ly1.vf \
tex-RobotoSlab-Light-tlf-sc-ot1--base.tfm \
tex-RobotoSlab-Light-tlf-sc-ot1.tfm \
tex-RobotoSlab-Light-tlf-sc-ot1.vf \
tex-RobotoSlab-Light-tlf-sc-t1--base.tfm \
tex-RobotoSlab-Light-tlf-sc-t1.tfm \
tex-RobotoSlab-Light-tlf-sc-t1.vf \
tex-RobotoSlab-Light-tlf-t1--base.tfm \
tex-RobotoSlab-Light-tlf-t1.tfm \
tex-RobotoSlab-Light-tlf-t1.vf \
tex-RobotoSlab-Light-tlf-ts1--base.tfm \
tex-RobotoSlab-Light-tlf-ts1.tfm \
tex-RobotoSlab-Light-tlf-ts1.vf \
tex-RobotoSlab-Regular-tlf-lgr--base.tfm \
tex-RobotoSlab-Regular-tlf-lgr.tfm \
tex-RobotoSlab-Regular-tlf-lgr.vf \
tex-RobotoSlab-Regular-tlf-ly1--base.tfm \
tex-RobotoSlab-Regular-tlf-ly1.tfm \
tex-RobotoSlab-Regular-tlf-ly1.vf \
tex-RobotoSlab-Regular-tlf-ot1.tfm \
tex-RobotoSlab-Regular-tlf-sc-lgr--base.tfm \
tex-RobotoSlab-Regular-tlf-sc-lgr.tfm \
tex-RobotoSlab-Regular-tlf-sc-lgr.vf \
tex-RobotoSlab-Regular-tlf-sc-ly1--base.tfm \
tex-RobotoSlab-Regular-tlf-sc-ly1.tfm \
tex-RobotoSlab-Regular-tlf-sc-ly1.vf \
tex-RobotoSlab-Regular-tlf-sc-ot1--base.tfm \
tex-RobotoSlab-Regular-tlf-sc-ot1.tfm \
tex-RobotoSlab-Regular-tlf-sc-ot1.vf \
tex-RobotoSlab-Regular-tlf-sc-t1--base.tfm \
tex-RobotoSlab-Regular-tlf-sc-t1.tfm \
tex-RobotoSlab-Regular-tlf-sc-t1.vf \
tex-RobotoSlab-Regular-tlf-t1--base.tfm \
tex-RobotoSlab-Regular-tlf-t1.tfm \
tex-RobotoSlab-Regular-tlf-t1.vf \
tex-RobotoSlab-Regular-tlf-ts1--base.tfm \
tex-RobotoSlab-Regular-tlf-ts1.tfm \
tex-RobotoSlab-Regular-tlf-ts1.vf \
tex-RobotoSlab-Thin-tlf-lgr--base.tfm \
tex-RobotoSlab-Thin-tlf-lgr.tfm \
tex-RobotoSlab-Thin-tlf-lgr.vf \
tex-RobotoSlab-Thin-tlf-ly1--base.tfm \
tex-RobotoSlab-Thin-tlf-ly1.tfm \
tex-RobotoSlab-Thin-tlf-ly1.vf \
tex-RobotoSlab-Thin-tlf-ot1.tfm \
tex-RobotoSlab-Thin-tlf-sc-lgr--base.tfm \
tex-RobotoSlab-Thin-tlf-sc-lgr.tfm \
tex-RobotoSlab-Thin-tlf-sc-lgr.vf \
tex-RobotoSlab-Thin-tlf-sc-ly1--base.tfm \
tex-RobotoSlab-Thin-tlf-sc-ly1.tfm \
tex-RobotoSlab-Thin-tlf-sc-ly1.vf \
tex-RobotoSlab-Thin-tlf-sc-ot1--base.tfm \
tex-RobotoSlab-Thin-tlf-sc-ot1.tfm \
tex-RobotoSlab-Thin-tlf-sc-ot1.vf \
tex-RobotoSlab-Thin-tlf-sc-t1--base.tfm \
tex-RobotoSlab-Thin-tlf-sc-t1.tfm \
tex-RobotoSlab-Thin-tlf-sc-t1.vf \
tex-RobotoSlab-Thin-tlf-t1--base.tfm \
tex-RobotoSlab-Thin-tlf-t1.tfm \
tex-RobotoSlab-Thin-tlf-t1.vf \
tex-RobotoSlab-Thin-tlf-ts1--base.tfm \
tex-RobotoSlab-Thin-tlf-ts1.tfm \
tex-RobotoSlab-Thin-tlf-ts1.vf \
tex-T1Roboto-LF.fd \
tex-T1Roboto-OsF.fd \
tex-T1Roboto-TLF.fd \
tex-T1Roboto-TOsF.fd \
tex-T1RobotoMono-TLF.fd \
tex-T1RobotoSerif-LF.fd \
tex-T1RobotoSerif-OsF.fd \
tex-T1RobotoSerif-Sup.fd \
tex-T1RobotoSerif-TLF.fd \
tex-T1RobotoSerif-TOsF.fd \
tex-T1RobotoSlab-TLF.fd \
tex-TS1Roboto-LF.fd \
tex-TS1Roboto-OsF.fd \
tex-TS1Roboto-TLF.fd \
tex-TS1Roboto-TOsF.fd \
tex-TS1RobotoMono-TLF.fd \
tex-TS1RobotoSerif-LF.fd \
tex-TS1RobotoSerif-OsF.fd \
tex-TS1RobotoSerif-TLF.fd \
tex-TS1RobotoSerif-TOsF.fd \
tex-TS1RobotoSlab-TLF.fd \
tex-rbto-2cs4gp.enc \
tex-rbto-2uubtm.enc \
tex-rbto-2ylw52.enc \
tex-rbto-33jnad.enc \
tex-rbto-35j2t6.enc \
tex-rbto-4jpen6.enc \
tex-rbto-5au2tj.enc \
tex-rbto-5wuobl.enc \
tex-rbto-5xgh2b.enc \
tex-rbto-6i2fao.enc \
tex-rbto-6rxeh6.enc \
tex-rbto-7juiin.enc \
tex-rbto-a4rth4.enc \
tex-rbto-acwfoz.enc \
tex-rbto-adklll.enc \
tex-rbto-as7fdj.enc \
tex-rbto-b5rac7.enc \
tex-rbto-bsqqk2.enc \
tex-rbto-bzwjdb.enc \
tex-rbto-ddkove.enc \
tex-rbto-dfqeeu.enc \
tex-rbto-dqsbwe.enc \
tex-rbto-dwsqhe.enc \
tex-rbto-e24joy.enc \
tex-rbto-el2qpt.enc \
tex-rbto-epkquw.enc \
tex-rbto-ghuabv.enc \
tex-rbto-h4xxl2.enc \
tex-rbto-h6xohf.enc \
tex-rbto-hdhu7c.enc \
tex-rbto-hlrajr.enc \
tex-rbto-ifem6v.enc \
tex-rbto-ihpqsf.enc \
tex-rbto-imandq.enc \
tex-rbto-iqgrsz.enc \
tex-rbto-j2bk2t.enc \
tex-rbto-je7obu.enc \
tex-rbto-jsccdt.enc \
tex-rbto-ktqtin.enc \
tex-rbto-lbdvpp.enc \
tex-rbto-lfutjz.enc \
tex-rbto-lhlrii.enc \
tex-rbto-lkebxp.enc \
tex-rbto-meyhpi.enc \
tex-rbto-muuaub.enc \
tex-rbto-ocbbsb.enc \
tex-rbto-ogts26.enc \
tex-rbto-pn7nyn.enc \
tex-rbto-pufewj.enc \
tex-rbto-q5hjoy.enc \
tex-rbto-qb5szn.enc \
tex-rbto-qhmgos.enc \
tex-rbto-qi3puo.enc \
tex-rbto-qtf2ec.enc \
tex-rbto-qulak4.enc \
tex-rbto-r7pbwp.enc \
tex-rbto-rehtu3.enc \
tex-rbto-s5b5bo.enc \
tex-rbto-schjax.enc \
tex-rbto-shbyjm.enc \
tex-rbto-swa2hd.enc \
tex-rbto-t46jwv.enc \
tex-rbto-t4kqic.enc \
tex-rbto-tp43rw.enc \
tex-rbto-u4yc4h.enc \
tex-rbto-uf77so.enc \
tex-rbto-wkn3wn.enc \
tex-rbto-wttfgh.enc \
tex-rbto-wywsyy.enc \
tex-rbto-xzfhjt.enc \
tex-rbto-z4nc45.enc \
tex-rbto-zf56p3.enc \
tex-rbto-zfcuyn.enc \
tex-roboto-mono.sty \
tex-roboto-serif.sty \
tex-roboto.map \
tex-roboto.sty \
texlive-roboto"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontaxes.sty \
tex-fontenc.sty \
tex-fontspec.sty \
tex-ifluatex.sty \
tex-ifxetex.sty \
tex-mweights.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-roboto-fonts \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
