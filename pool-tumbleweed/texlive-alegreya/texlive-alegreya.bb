SUMMARY = "Alegreya fonts with LaTeX support"
DESCRIPTION = "The Alegreya fonts are designed by Juan Pablo del Peral for \
Huerta Tipografica. Alegreya is a typeface originally intended \
for literature. It conveys a dynamic and varied rhythm which \
facilitates the reading of long texts. The italic has just as \
much care and attention to detail in the design as the roman. \
Bold, black, small caps and five number styles are available."
LICENSE = "OFL-1.1"

PV = "2023.209.svn64384"

RPM_NAME = "texlive-alegreya-2023.209.svn64384-55.1.noarch.rpm"
RPM_HASH = "c95b117b187ff995e2f23e9cdb06bb61c062ae777d9611d11affa4b64faf423a2fadbe41c7c9c567ffc1a667e511828c1d61c4b3c9d583f04b873ffe352c6a5a"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-Alegreya-Black-inf-lgr--base.tfm \
tex-Alegreya-Black-inf-lgr.tfm \
tex-Alegreya-Black-inf-lgr.vf \
tex-Alegreya-Black-inf-ly1--base.tfm \
tex-Alegreya-Black-inf-ly1.tfm \
tex-Alegreya-Black-inf-ly1.vf \
tex-Alegreya-Black-inf-ot1.tfm \
tex-Alegreya-Black-inf-t1--base.tfm \
tex-Alegreya-Black-inf-t1.tfm \
tex-Alegreya-Black-inf-t1.vf \
tex-Alegreya-Black-lf-lgr--base.tfm \
tex-Alegreya-Black-lf-lgr.tfm \
tex-Alegreya-Black-lf-lgr.vf \
tex-Alegreya-Black-lf-ly1--base.tfm \
tex-Alegreya-Black-lf-ly1.tfm \
tex-Alegreya-Black-lf-ly1.vf \
tex-Alegreya-Black-lf-ot1.tfm \
tex-Alegreya-Black-lf-sc-lgr--base.tfm \
tex-Alegreya-Black-lf-sc-lgr.tfm \
tex-Alegreya-Black-lf-sc-lgr.vf \
tex-Alegreya-Black-lf-sc-ly1--base.tfm \
tex-Alegreya-Black-lf-sc-ly1.tfm \
tex-Alegreya-Black-lf-sc-ly1.vf \
tex-Alegreya-Black-lf-sc-ot1--base.tfm \
tex-Alegreya-Black-lf-sc-ot1.tfm \
tex-Alegreya-Black-lf-sc-ot1.vf \
tex-Alegreya-Black-lf-sc-t1--base.tfm \
tex-Alegreya-Black-lf-sc-t1.tfm \
tex-Alegreya-Black-lf-sc-t1.vf \
tex-Alegreya-Black-lf-t1--base.tfm \
tex-Alegreya-Black-lf-t1.tfm \
tex-Alegreya-Black-lf-t1.vf \
tex-Alegreya-Black-lf-ts1--base.tfm \
tex-Alegreya-Black-lf-ts1.tfm \
tex-Alegreya-Black-lf-ts1.vf \
tex-Alegreya-Black-osf-lgr--base.tfm \
tex-Alegreya-Black-osf-lgr.tfm \
tex-Alegreya-Black-osf-lgr.vf \
tex-Alegreya-Black-osf-ly1--base.tfm \
tex-Alegreya-Black-osf-ly1.tfm \
tex-Alegreya-Black-osf-ly1.vf \
tex-Alegreya-Black-osf-ot1.tfm \
tex-Alegreya-Black-osf-sc-lgr--base.tfm \
tex-Alegreya-Black-osf-sc-lgr.tfm \
tex-Alegreya-Black-osf-sc-lgr.vf \
tex-Alegreya-Black-osf-sc-ly1--base.tfm \
tex-Alegreya-Black-osf-sc-ly1.tfm \
tex-Alegreya-Black-osf-sc-ly1.vf \
tex-Alegreya-Black-osf-sc-ot1--base.tfm \
tex-Alegreya-Black-osf-sc-ot1.tfm \
tex-Alegreya-Black-osf-sc-ot1.vf \
tex-Alegreya-Black-osf-sc-t1--base.tfm \
tex-Alegreya-Black-osf-sc-t1.tfm \
tex-Alegreya-Black-osf-sc-t1.vf \
tex-Alegreya-Black-osf-t1--base.tfm \
tex-Alegreya-Black-osf-t1.tfm \
tex-Alegreya-Black-osf-t1.vf \
tex-Alegreya-Black-osf-ts1--base.tfm \
tex-Alegreya-Black-osf-ts1.tfm \
tex-Alegreya-Black-osf-ts1.vf \
tex-Alegreya-Black-sup-lgr--base.tfm \
tex-Alegreya-Black-sup-lgr.tfm \
tex-Alegreya-Black-sup-lgr.vf \
tex-Alegreya-Black-sup-ly1--base.tfm \
tex-Alegreya-Black-sup-ly1.tfm \
tex-Alegreya-Black-sup-ly1.vf \
tex-Alegreya-Black-sup-ot1.tfm \
tex-Alegreya-Black-sup-t1--base.tfm \
tex-Alegreya-Black-sup-t1.tfm \
tex-Alegreya-Black-sup-t1.vf \
tex-Alegreya-Black-tlf-lgr--base.tfm \
tex-Alegreya-Black-tlf-lgr.tfm \
tex-Alegreya-Black-tlf-lgr.vf \
tex-Alegreya-Black-tlf-ly1--base.tfm \
tex-Alegreya-Black-tlf-ly1.tfm \
tex-Alegreya-Black-tlf-ly1.vf \
tex-Alegreya-Black-tlf-ot1.tfm \
tex-Alegreya-Black-tlf-sc-lgr--base.tfm \
tex-Alegreya-Black-tlf-sc-lgr.tfm \
tex-Alegreya-Black-tlf-sc-lgr.vf \
tex-Alegreya-Black-tlf-sc-ly1--base.tfm \
tex-Alegreya-Black-tlf-sc-ly1.tfm \
tex-Alegreya-Black-tlf-sc-ly1.vf \
tex-Alegreya-Black-tlf-sc-ot1--base.tfm \
tex-Alegreya-Black-tlf-sc-ot1.tfm \
tex-Alegreya-Black-tlf-sc-ot1.vf \
tex-Alegreya-Black-tlf-sc-t1--base.tfm \
tex-Alegreya-Black-tlf-sc-t1.tfm \
tex-Alegreya-Black-tlf-sc-t1.vf \
tex-Alegreya-Black-tlf-t1--base.tfm \
tex-Alegreya-Black-tlf-t1.tfm \
tex-Alegreya-Black-tlf-t1.vf \
tex-Alegreya-Black-tlf-ts1--base.tfm \
tex-Alegreya-Black-tlf-ts1.tfm \
tex-Alegreya-Black-tlf-ts1.vf \
tex-Alegreya-Black-tosf-lgr--base.tfm \
tex-Alegreya-Black-tosf-lgr.tfm \
tex-Alegreya-Black-tosf-lgr.vf \
tex-Alegreya-Black-tosf-ly1--base.tfm \
tex-Alegreya-Black-tosf-ly1.tfm \
tex-Alegreya-Black-tosf-ly1.vf \
tex-Alegreya-Black-tosf-ot1.tfm \
tex-Alegreya-Black-tosf-sc-lgr--base.tfm \
tex-Alegreya-Black-tosf-sc-lgr.tfm \
tex-Alegreya-Black-tosf-sc-lgr.vf \
tex-Alegreya-Black-tosf-sc-ly1--base.tfm \
tex-Alegreya-Black-tosf-sc-ly1.tfm \
tex-Alegreya-Black-tosf-sc-ly1.vf \
tex-Alegreya-Black-tosf-sc-ot1--base.tfm \
tex-Alegreya-Black-tosf-sc-ot1.tfm \
tex-Alegreya-Black-tosf-sc-ot1.vf \
tex-Alegreya-Black-tosf-sc-t1--base.tfm \
tex-Alegreya-Black-tosf-sc-t1.tfm \
tex-Alegreya-Black-tosf-sc-t1.vf \
tex-Alegreya-Black-tosf-t1--base.tfm \
tex-Alegreya-Black-tosf-t1.tfm \
tex-Alegreya-Black-tosf-t1.vf \
tex-Alegreya-Black-tosf-ts1--base.tfm \
tex-Alegreya-Black-tosf-ts1.tfm \
tex-Alegreya-Black-tosf-ts1.vf \
tex-Alegreya-BlackItalic-inf-lgr--base.tfm \
tex-Alegreya-BlackItalic-inf-lgr.tfm \
tex-Alegreya-BlackItalic-inf-lgr.vf \
tex-Alegreya-BlackItalic-inf-ly1--base.tfm \
tex-Alegreya-BlackItalic-inf-ly1.tfm \
tex-Alegreya-BlackItalic-inf-ly1.vf \
tex-Alegreya-BlackItalic-inf-ot1.tfm \
tex-Alegreya-BlackItalic-inf-t1--base.tfm \
tex-Alegreya-BlackItalic-inf-t1.tfm \
tex-Alegreya-BlackItalic-inf-t1.vf \
tex-Alegreya-BlackItalic-lf-lgr--base.tfm \
tex-Alegreya-BlackItalic-lf-lgr.tfm \
tex-Alegreya-BlackItalic-lf-lgr.vf \
tex-Alegreya-BlackItalic-lf-ly1--base.tfm \
tex-Alegreya-BlackItalic-lf-ly1.tfm \
tex-Alegreya-BlackItalic-lf-ly1.vf \
tex-Alegreya-BlackItalic-lf-ot1.tfm \
tex-Alegreya-BlackItalic-lf-sc-lgr--base.tfm \
tex-Alegreya-BlackItalic-lf-sc-lgr.tfm \
tex-Alegreya-BlackItalic-lf-sc-lgr.vf \
tex-Alegreya-BlackItalic-lf-sc-ly1--base.tfm \
tex-Alegreya-BlackItalic-lf-sc-ly1.tfm \
tex-Alegreya-BlackItalic-lf-sc-ly1.vf \
tex-Alegreya-BlackItalic-lf-sc-ot1--base.tfm \
tex-Alegreya-BlackItalic-lf-sc-ot1.tfm \
tex-Alegreya-BlackItalic-lf-sc-ot1.vf \
tex-Alegreya-BlackItalic-lf-sc-t1--base.tfm \
tex-Alegreya-BlackItalic-lf-sc-t1.tfm \
tex-Alegreya-BlackItalic-lf-sc-t1.vf \
tex-Alegreya-BlackItalic-lf-t1--base.tfm \
tex-Alegreya-BlackItalic-lf-t1.tfm \
tex-Alegreya-BlackItalic-lf-t1.vf \
tex-Alegreya-BlackItalic-lf-ts1--base.tfm \
tex-Alegreya-BlackItalic-lf-ts1.tfm \
tex-Alegreya-BlackItalic-lf-ts1.vf \
tex-Alegreya-BlackItalic-osf-lgr--base.tfm \
tex-Alegreya-BlackItalic-osf-lgr.tfm \
tex-Alegreya-BlackItalic-osf-lgr.vf \
tex-Alegreya-BlackItalic-osf-ly1--base.tfm \
tex-Alegreya-BlackItalic-osf-ly1.tfm \
tex-Alegreya-BlackItalic-osf-ly1.vf \
tex-Alegreya-BlackItalic-osf-ot1.tfm \
tex-Alegreya-BlackItalic-osf-sc-lgr--base.tfm \
tex-Alegreya-BlackItalic-osf-sc-lgr.tfm \
tex-Alegreya-BlackItalic-osf-sc-lgr.vf \
tex-Alegreya-BlackItalic-osf-sc-ly1--base.tfm \
tex-Alegreya-BlackItalic-osf-sc-ly1.tfm \
tex-Alegreya-BlackItalic-osf-sc-ly1.vf \
tex-Alegreya-BlackItalic-osf-sc-ot1--base.tfm \
tex-Alegreya-BlackItalic-osf-sc-ot1.tfm \
tex-Alegreya-BlackItalic-osf-sc-ot1.vf \
tex-Alegreya-BlackItalic-osf-sc-t1--base.tfm \
tex-Alegreya-BlackItalic-osf-sc-t1.tfm \
tex-Alegreya-BlackItalic-osf-sc-t1.vf \
tex-Alegreya-BlackItalic-osf-t1--base.tfm \
tex-Alegreya-BlackItalic-osf-t1.tfm \
tex-Alegreya-BlackItalic-osf-t1.vf \
tex-Alegreya-BlackItalic-osf-ts1--base.tfm \
tex-Alegreya-BlackItalic-osf-ts1.tfm \
tex-Alegreya-BlackItalic-osf-ts1.vf \
tex-Alegreya-BlackItalic-sup-lgr--base.tfm \
tex-Alegreya-BlackItalic-sup-lgr.tfm \
tex-Alegreya-BlackItalic-sup-lgr.vf \
tex-Alegreya-BlackItalic-sup-ly1--base.tfm \
tex-Alegreya-BlackItalic-sup-ly1.tfm \
tex-Alegreya-BlackItalic-sup-ly1.vf \
tex-Alegreya-BlackItalic-sup-ot1.tfm \
tex-Alegreya-BlackItalic-sup-t1--base.tfm \
tex-Alegreya-BlackItalic-sup-t1.tfm \
tex-Alegreya-BlackItalic-sup-t1.vf \
tex-Alegreya-BlackItalic-tlf-lgr--base.tfm \
tex-Alegreya-BlackItalic-tlf-lgr.tfm \
tex-Alegreya-BlackItalic-tlf-lgr.vf \
tex-Alegreya-BlackItalic-tlf-ly1--base.tfm \
tex-Alegreya-BlackItalic-tlf-ly1.tfm \
tex-Alegreya-BlackItalic-tlf-ly1.vf \
tex-Alegreya-BlackItalic-tlf-ot1.tfm \
tex-Alegreya-BlackItalic-tlf-sc-lgr--base.tfm \
tex-Alegreya-BlackItalic-tlf-sc-lgr.tfm \
tex-Alegreya-BlackItalic-tlf-sc-lgr.vf \
tex-Alegreya-BlackItalic-tlf-sc-ly1--base.tfm \
tex-Alegreya-BlackItalic-tlf-sc-ly1.tfm \
tex-Alegreya-BlackItalic-tlf-sc-ly1.vf \
tex-Alegreya-BlackItalic-tlf-sc-ot1--base.tfm \
tex-Alegreya-BlackItalic-tlf-sc-ot1.tfm \
tex-Alegreya-BlackItalic-tlf-sc-ot1.vf \
tex-Alegreya-BlackItalic-tlf-sc-t1--base.tfm \
tex-Alegreya-BlackItalic-tlf-sc-t1.tfm \
tex-Alegreya-BlackItalic-tlf-sc-t1.vf \
tex-Alegreya-BlackItalic-tlf-t1--base.tfm \
tex-Alegreya-BlackItalic-tlf-t1.tfm \
tex-Alegreya-BlackItalic-tlf-t1.vf \
tex-Alegreya-BlackItalic-tlf-ts1--base.tfm \
tex-Alegreya-BlackItalic-tlf-ts1.tfm \
tex-Alegreya-BlackItalic-tlf-ts1.vf \
tex-Alegreya-BlackItalic-tosf-lgr--base.tfm \
tex-Alegreya-BlackItalic-tosf-lgr.tfm \
tex-Alegreya-BlackItalic-tosf-lgr.vf \
tex-Alegreya-BlackItalic-tosf-ly1--base.tfm \
tex-Alegreya-BlackItalic-tosf-ly1.tfm \
tex-Alegreya-BlackItalic-tosf-ly1.vf \
tex-Alegreya-BlackItalic-tosf-ot1.tfm \
tex-Alegreya-BlackItalic-tosf-sc-lgr--base.tfm \
tex-Alegreya-BlackItalic-tosf-sc-lgr.tfm \
tex-Alegreya-BlackItalic-tosf-sc-lgr.vf \
tex-Alegreya-BlackItalic-tosf-sc-ly1--base.tfm \
tex-Alegreya-BlackItalic-tosf-sc-ly1.tfm \
tex-Alegreya-BlackItalic-tosf-sc-ly1.vf \
tex-Alegreya-BlackItalic-tosf-sc-ot1--base.tfm \
tex-Alegreya-BlackItalic-tosf-sc-ot1.tfm \
tex-Alegreya-BlackItalic-tosf-sc-ot1.vf \
tex-Alegreya-BlackItalic-tosf-sc-t1--base.tfm \
tex-Alegreya-BlackItalic-tosf-sc-t1.tfm \
tex-Alegreya-BlackItalic-tosf-sc-t1.vf \
tex-Alegreya-BlackItalic-tosf-t1--base.tfm \
tex-Alegreya-BlackItalic-tosf-t1.tfm \
tex-Alegreya-BlackItalic-tosf-t1.vf \
tex-Alegreya-BlackItalic-tosf-ts1--base.tfm \
tex-Alegreya-BlackItalic-tosf-ts1.tfm \
tex-Alegreya-BlackItalic-tosf-ts1.vf \
tex-Alegreya-Bold-inf-lgr--base.tfm \
tex-Alegreya-Bold-inf-lgr.tfm \
tex-Alegreya-Bold-inf-lgr.vf \
tex-Alegreya-Bold-inf-ly1--base.tfm \
tex-Alegreya-Bold-inf-ly1.tfm \
tex-Alegreya-Bold-inf-ly1.vf \
tex-Alegreya-Bold-inf-ot1.tfm \
tex-Alegreya-Bold-inf-t1--base.tfm \
tex-Alegreya-Bold-inf-t1.tfm \
tex-Alegreya-Bold-inf-t1.vf \
tex-Alegreya-Bold-lf-lgr--base.tfm \
tex-Alegreya-Bold-lf-lgr.tfm \
tex-Alegreya-Bold-lf-lgr.vf \
tex-Alegreya-Bold-lf-ly1--base.tfm \
tex-Alegreya-Bold-lf-ly1.tfm \
tex-Alegreya-Bold-lf-ly1.vf \
tex-Alegreya-Bold-lf-ot1.tfm \
tex-Alegreya-Bold-lf-sc-lgr--base.tfm \
tex-Alegreya-Bold-lf-sc-lgr.tfm \
tex-Alegreya-Bold-lf-sc-lgr.vf \
tex-Alegreya-Bold-lf-sc-ly1--base.tfm \
tex-Alegreya-Bold-lf-sc-ly1.tfm \
tex-Alegreya-Bold-lf-sc-ly1.vf \
tex-Alegreya-Bold-lf-sc-ot1--base.tfm \
tex-Alegreya-Bold-lf-sc-ot1.tfm \
tex-Alegreya-Bold-lf-sc-ot1.vf \
tex-Alegreya-Bold-lf-sc-t1--base.tfm \
tex-Alegreya-Bold-lf-sc-t1.tfm \
tex-Alegreya-Bold-lf-sc-t1.vf \
tex-Alegreya-Bold-lf-t1--base.tfm \
tex-Alegreya-Bold-lf-t1.tfm \
tex-Alegreya-Bold-lf-t1.vf \
tex-Alegreya-Bold-lf-ts1--base.tfm \
tex-Alegreya-Bold-lf-ts1.tfm \
tex-Alegreya-Bold-lf-ts1.vf \
tex-Alegreya-Bold-osf-lgr--base.tfm \
tex-Alegreya-Bold-osf-lgr.tfm \
tex-Alegreya-Bold-osf-lgr.vf \
tex-Alegreya-Bold-osf-ly1--base.tfm \
tex-Alegreya-Bold-osf-ly1.tfm \
tex-Alegreya-Bold-osf-ly1.vf \
tex-Alegreya-Bold-osf-ot1.tfm \
tex-Alegreya-Bold-osf-sc-lgr--base.tfm \
tex-Alegreya-Bold-osf-sc-lgr.tfm \
tex-Alegreya-Bold-osf-sc-lgr.vf \
tex-Alegreya-Bold-osf-sc-ly1--base.tfm \
tex-Alegreya-Bold-osf-sc-ly1.tfm \
tex-Alegreya-Bold-osf-sc-ly1.vf \
tex-Alegreya-Bold-osf-sc-ot1--base.tfm \
tex-Alegreya-Bold-osf-sc-ot1.tfm \
tex-Alegreya-Bold-osf-sc-ot1.vf \
tex-Alegreya-Bold-osf-sc-t1--base.tfm \
tex-Alegreya-Bold-osf-sc-t1.tfm \
tex-Alegreya-Bold-osf-sc-t1.vf \
tex-Alegreya-Bold-osf-t1--base.tfm \
tex-Alegreya-Bold-osf-t1.tfm \
tex-Alegreya-Bold-osf-t1.vf \
tex-Alegreya-Bold-osf-ts1--base.tfm \
tex-Alegreya-Bold-osf-ts1.tfm \
tex-Alegreya-Bold-osf-ts1.vf \
tex-Alegreya-Bold-sup-lgr--base.tfm \
tex-Alegreya-Bold-sup-lgr.tfm \
tex-Alegreya-Bold-sup-lgr.vf \
tex-Alegreya-Bold-sup-ly1--base.tfm \
tex-Alegreya-Bold-sup-ly1.tfm \
tex-Alegreya-Bold-sup-ly1.vf \
tex-Alegreya-Bold-sup-ot1.tfm \
tex-Alegreya-Bold-sup-t1--base.tfm \
tex-Alegreya-Bold-sup-t1.tfm \
tex-Alegreya-Bold-sup-t1.vf \
tex-Alegreya-Bold-tlf-lgr--base.tfm \
tex-Alegreya-Bold-tlf-lgr.tfm \
tex-Alegreya-Bold-tlf-lgr.vf \
tex-Alegreya-Bold-tlf-ly1--base.tfm \
tex-Alegreya-Bold-tlf-ly1.tfm \
tex-Alegreya-Bold-tlf-ly1.vf \
tex-Alegreya-Bold-tlf-ot1.tfm \
tex-Alegreya-Bold-tlf-sc-lgr--base.tfm \
tex-Alegreya-Bold-tlf-sc-lgr.tfm \
tex-Alegreya-Bold-tlf-sc-lgr.vf \
tex-Alegreya-Bold-tlf-sc-ly1--base.tfm \
tex-Alegreya-Bold-tlf-sc-ly1.tfm \
tex-Alegreya-Bold-tlf-sc-ly1.vf \
tex-Alegreya-Bold-tlf-sc-ot1--base.tfm \
tex-Alegreya-Bold-tlf-sc-ot1.tfm \
tex-Alegreya-Bold-tlf-sc-ot1.vf \
tex-Alegreya-Bold-tlf-sc-t1--base.tfm \
tex-Alegreya-Bold-tlf-sc-t1.tfm \
tex-Alegreya-Bold-tlf-sc-t1.vf \
tex-Alegreya-Bold-tlf-t1--base.tfm \
tex-Alegreya-Bold-tlf-t1.tfm \
tex-Alegreya-Bold-tlf-t1.vf \
tex-Alegreya-Bold-tlf-ts1--base.tfm \
tex-Alegreya-Bold-tlf-ts1.tfm \
tex-Alegreya-Bold-tlf-ts1.vf \
tex-Alegreya-Bold-tosf-lgr--base.tfm \
tex-Alegreya-Bold-tosf-lgr.tfm \
tex-Alegreya-Bold-tosf-lgr.vf \
tex-Alegreya-Bold-tosf-ly1--base.tfm \
tex-Alegreya-Bold-tosf-ly1.tfm \
tex-Alegreya-Bold-tosf-ly1.vf \
tex-Alegreya-Bold-tosf-ot1.tfm \
tex-Alegreya-Bold-tosf-sc-lgr--base.tfm \
tex-Alegreya-Bold-tosf-sc-lgr.tfm \
tex-Alegreya-Bold-tosf-sc-lgr.vf \
tex-Alegreya-Bold-tosf-sc-ly1--base.tfm \
tex-Alegreya-Bold-tosf-sc-ly1.tfm \
tex-Alegreya-Bold-tosf-sc-ly1.vf \
tex-Alegreya-Bold-tosf-sc-ot1--base.tfm \
tex-Alegreya-Bold-tosf-sc-ot1.tfm \
tex-Alegreya-Bold-tosf-sc-ot1.vf \
tex-Alegreya-Bold-tosf-sc-t1--base.tfm \
tex-Alegreya-Bold-tosf-sc-t1.tfm \
tex-Alegreya-Bold-tosf-sc-t1.vf \
tex-Alegreya-Bold-tosf-t1--base.tfm \
tex-Alegreya-Bold-tosf-t1.tfm \
tex-Alegreya-Bold-tosf-t1.vf \
tex-Alegreya-Bold-tosf-ts1--base.tfm \
tex-Alegreya-Bold-tosf-ts1.tfm \
tex-Alegreya-Bold-tosf-ts1.vf \
tex-Alegreya-BoldItalic-inf-lgr--base.tfm \
tex-Alegreya-BoldItalic-inf-lgr.tfm \
tex-Alegreya-BoldItalic-inf-lgr.vf \
tex-Alegreya-BoldItalic-inf-ly1--base.tfm \
tex-Alegreya-BoldItalic-inf-ly1.tfm \
tex-Alegreya-BoldItalic-inf-ly1.vf \
tex-Alegreya-BoldItalic-inf-ot1.tfm \
tex-Alegreya-BoldItalic-inf-t1--base.tfm \
tex-Alegreya-BoldItalic-inf-t1.tfm \
tex-Alegreya-BoldItalic-inf-t1.vf \
tex-Alegreya-BoldItalic-lf-lgr--base.tfm \
tex-Alegreya-BoldItalic-lf-lgr.tfm \
tex-Alegreya-BoldItalic-lf-lgr.vf \
tex-Alegreya-BoldItalic-lf-ly1--base.tfm \
tex-Alegreya-BoldItalic-lf-ly1.tfm \
tex-Alegreya-BoldItalic-lf-ly1.vf \
tex-Alegreya-BoldItalic-lf-ot1.tfm \
tex-Alegreya-BoldItalic-lf-sc-lgr--base.tfm \
tex-Alegreya-BoldItalic-lf-sc-lgr.tfm \
tex-Alegreya-BoldItalic-lf-sc-lgr.vf \
tex-Alegreya-BoldItalic-lf-sc-ly1--base.tfm \
tex-Alegreya-BoldItalic-lf-sc-ly1.tfm \
tex-Alegreya-BoldItalic-lf-sc-ly1.vf \
tex-Alegreya-BoldItalic-lf-sc-ot1--base.tfm \
tex-Alegreya-BoldItalic-lf-sc-ot1.tfm \
tex-Alegreya-BoldItalic-lf-sc-ot1.vf \
tex-Alegreya-BoldItalic-lf-sc-t1--base.tfm \
tex-Alegreya-BoldItalic-lf-sc-t1.tfm \
tex-Alegreya-BoldItalic-lf-sc-t1.vf \
tex-Alegreya-BoldItalic-lf-t1--base.tfm \
tex-Alegreya-BoldItalic-lf-t1.tfm \
tex-Alegreya-BoldItalic-lf-t1.vf \
tex-Alegreya-BoldItalic-lf-ts1--base.tfm \
tex-Alegreya-BoldItalic-lf-ts1.tfm \
tex-Alegreya-BoldItalic-lf-ts1.vf \
tex-Alegreya-BoldItalic-osf-lgr--base.tfm \
tex-Alegreya-BoldItalic-osf-lgr.tfm \
tex-Alegreya-BoldItalic-osf-lgr.vf \
tex-Alegreya-BoldItalic-osf-ly1--base.tfm \
tex-Alegreya-BoldItalic-osf-ly1.tfm \
tex-Alegreya-BoldItalic-osf-ly1.vf \
tex-Alegreya-BoldItalic-osf-ot1.tfm \
tex-Alegreya-BoldItalic-osf-sc-lgr--base.tfm \
tex-Alegreya-BoldItalic-osf-sc-lgr.tfm \
tex-Alegreya-BoldItalic-osf-sc-lgr.vf \
tex-Alegreya-BoldItalic-osf-sc-ly1--base.tfm \
tex-Alegreya-BoldItalic-osf-sc-ly1.tfm \
tex-Alegreya-BoldItalic-osf-sc-ly1.vf \
tex-Alegreya-BoldItalic-osf-sc-ot1--base.tfm \
tex-Alegreya-BoldItalic-osf-sc-ot1.tfm \
tex-Alegreya-BoldItalic-osf-sc-ot1.vf \
tex-Alegreya-BoldItalic-osf-sc-t1--base.tfm \
tex-Alegreya-BoldItalic-osf-sc-t1.tfm \
tex-Alegreya-BoldItalic-osf-sc-t1.vf \
tex-Alegreya-BoldItalic-osf-t1--base.tfm \
tex-Alegreya-BoldItalic-osf-t1.tfm \
tex-Alegreya-BoldItalic-osf-t1.vf \
tex-Alegreya-BoldItalic-osf-ts1--base.tfm \
tex-Alegreya-BoldItalic-osf-ts1.tfm \
tex-Alegreya-BoldItalic-osf-ts1.vf \
tex-Alegreya-BoldItalic-sup-lgr--base.tfm \
tex-Alegreya-BoldItalic-sup-lgr.tfm \
tex-Alegreya-BoldItalic-sup-lgr.vf \
tex-Alegreya-BoldItalic-sup-ly1--base.tfm \
tex-Alegreya-BoldItalic-sup-ly1.tfm \
tex-Alegreya-BoldItalic-sup-ly1.vf \
tex-Alegreya-BoldItalic-sup-ot1.tfm \
tex-Alegreya-BoldItalic-sup-t1--base.tfm \
tex-Alegreya-BoldItalic-sup-t1.tfm \
tex-Alegreya-BoldItalic-sup-t1.vf \
tex-Alegreya-BoldItalic-tlf-lgr--base.tfm \
tex-Alegreya-BoldItalic-tlf-lgr.tfm \
tex-Alegreya-BoldItalic-tlf-lgr.vf \
tex-Alegreya-BoldItalic-tlf-ly1--base.tfm \
tex-Alegreya-BoldItalic-tlf-ly1.tfm \
tex-Alegreya-BoldItalic-tlf-ly1.vf \
tex-Alegreya-BoldItalic-tlf-ot1.tfm \
tex-Alegreya-BoldItalic-tlf-sc-lgr--base.tfm \
tex-Alegreya-BoldItalic-tlf-sc-lgr.tfm \
tex-Alegreya-BoldItalic-tlf-sc-lgr.vf \
tex-Alegreya-BoldItalic-tlf-sc-ly1--base.tfm \
tex-Alegreya-BoldItalic-tlf-sc-ly1.tfm \
tex-Alegreya-BoldItalic-tlf-sc-ly1.vf \
tex-Alegreya-BoldItalic-tlf-sc-ot1--base.tfm \
tex-Alegreya-BoldItalic-tlf-sc-ot1.tfm \
tex-Alegreya-BoldItalic-tlf-sc-ot1.vf \
tex-Alegreya-BoldItalic-tlf-sc-t1--base.tfm \
tex-Alegreya-BoldItalic-tlf-sc-t1.tfm \
tex-Alegreya-BoldItalic-tlf-sc-t1.vf \
tex-Alegreya-BoldItalic-tlf-t1--base.tfm \
tex-Alegreya-BoldItalic-tlf-t1.tfm \
tex-Alegreya-BoldItalic-tlf-t1.vf \
tex-Alegreya-BoldItalic-tlf-ts1--base.tfm \
tex-Alegreya-BoldItalic-tlf-ts1.tfm \
tex-Alegreya-BoldItalic-tlf-ts1.vf \
tex-Alegreya-BoldItalic-tosf-lgr--base.tfm \
tex-Alegreya-BoldItalic-tosf-lgr.tfm \
tex-Alegreya-BoldItalic-tosf-lgr.vf \
tex-Alegreya-BoldItalic-tosf-ly1--base.tfm \
tex-Alegreya-BoldItalic-tosf-ly1.tfm \
tex-Alegreya-BoldItalic-tosf-ly1.vf \
tex-Alegreya-BoldItalic-tosf-ot1.tfm \
tex-Alegreya-BoldItalic-tosf-sc-lgr--base.tfm \
tex-Alegreya-BoldItalic-tosf-sc-lgr.tfm \
tex-Alegreya-BoldItalic-tosf-sc-lgr.vf \
tex-Alegreya-BoldItalic-tosf-sc-ly1--base.tfm \
tex-Alegreya-BoldItalic-tosf-sc-ly1.tfm \
tex-Alegreya-BoldItalic-tosf-sc-ly1.vf \
tex-Alegreya-BoldItalic-tosf-sc-ot1--base.tfm \
tex-Alegreya-BoldItalic-tosf-sc-ot1.tfm \
tex-Alegreya-BoldItalic-tosf-sc-ot1.vf \
tex-Alegreya-BoldItalic-tosf-sc-t1--base.tfm \
tex-Alegreya-BoldItalic-tosf-sc-t1.tfm \
tex-Alegreya-BoldItalic-tosf-sc-t1.vf \
tex-Alegreya-BoldItalic-tosf-t1--base.tfm \
tex-Alegreya-BoldItalic-tosf-t1.tfm \
tex-Alegreya-BoldItalic-tosf-t1.vf \
tex-Alegreya-BoldItalic-tosf-ts1--base.tfm \
tex-Alegreya-BoldItalic-tosf-ts1.tfm \
tex-Alegreya-BoldItalic-tosf-ts1.vf \
tex-Alegreya-ExtraBold-inf-lgr--base.tfm \
tex-Alegreya-ExtraBold-inf-lgr.tfm \
tex-Alegreya-ExtraBold-inf-lgr.vf \
tex-Alegreya-ExtraBold-inf-ly1--base.tfm \
tex-Alegreya-ExtraBold-inf-ly1.tfm \
tex-Alegreya-ExtraBold-inf-ly1.vf \
tex-Alegreya-ExtraBold-inf-ot1.tfm \
tex-Alegreya-ExtraBold-inf-t1--base.tfm \
tex-Alegreya-ExtraBold-inf-t1.tfm \
tex-Alegreya-ExtraBold-inf-t1.vf \
tex-Alegreya-ExtraBold-lf-lgr--base.tfm \
tex-Alegreya-ExtraBold-lf-lgr.tfm \
tex-Alegreya-ExtraBold-lf-lgr.vf \
tex-Alegreya-ExtraBold-lf-ly1--base.tfm \
tex-Alegreya-ExtraBold-lf-ly1.tfm \
tex-Alegreya-ExtraBold-lf-ly1.vf \
tex-Alegreya-ExtraBold-lf-ot1.tfm \
tex-Alegreya-ExtraBold-lf-sc-lgr--base.tfm \
tex-Alegreya-ExtraBold-lf-sc-lgr.tfm \
tex-Alegreya-ExtraBold-lf-sc-lgr.vf \
tex-Alegreya-ExtraBold-lf-sc-ly1--base.tfm \
tex-Alegreya-ExtraBold-lf-sc-ly1.tfm \
tex-Alegreya-ExtraBold-lf-sc-ly1.vf \
tex-Alegreya-ExtraBold-lf-sc-ot1--base.tfm \
tex-Alegreya-ExtraBold-lf-sc-ot1.tfm \
tex-Alegreya-ExtraBold-lf-sc-ot1.vf \
tex-Alegreya-ExtraBold-lf-sc-t1--base.tfm \
tex-Alegreya-ExtraBold-lf-sc-t1.tfm \
tex-Alegreya-ExtraBold-lf-sc-t1.vf \
tex-Alegreya-ExtraBold-lf-t1--base.tfm \
tex-Alegreya-ExtraBold-lf-t1.tfm \
tex-Alegreya-ExtraBold-lf-t1.vf \
tex-Alegreya-ExtraBold-lf-ts1--base.tfm \
tex-Alegreya-ExtraBold-lf-ts1.tfm \
tex-Alegreya-ExtraBold-lf-ts1.vf \
tex-Alegreya-ExtraBold-osf-lgr--base.tfm \
tex-Alegreya-ExtraBold-osf-lgr.tfm \
tex-Alegreya-ExtraBold-osf-lgr.vf \
tex-Alegreya-ExtraBold-osf-ly1--base.tfm \
tex-Alegreya-ExtraBold-osf-ly1.tfm \
tex-Alegreya-ExtraBold-osf-ly1.vf \
tex-Alegreya-ExtraBold-osf-ot1.tfm \
tex-Alegreya-ExtraBold-osf-sc-lgr--base.tfm \
tex-Alegreya-ExtraBold-osf-sc-lgr.tfm \
tex-Alegreya-ExtraBold-osf-sc-lgr.vf \
tex-Alegreya-ExtraBold-osf-sc-ly1--base.tfm \
tex-Alegreya-ExtraBold-osf-sc-ly1.tfm \
tex-Alegreya-ExtraBold-osf-sc-ly1.vf \
tex-Alegreya-ExtraBold-osf-sc-ot1--base.tfm \
tex-Alegreya-ExtraBold-osf-sc-ot1.tfm \
tex-Alegreya-ExtraBold-osf-sc-ot1.vf \
tex-Alegreya-ExtraBold-osf-sc-t1--base.tfm \
tex-Alegreya-ExtraBold-osf-sc-t1.tfm \
tex-Alegreya-ExtraBold-osf-sc-t1.vf \
tex-Alegreya-ExtraBold-osf-t1--base.tfm \
tex-Alegreya-ExtraBold-osf-t1.tfm \
tex-Alegreya-ExtraBold-osf-t1.vf \
tex-Alegreya-ExtraBold-osf-ts1--base.tfm \
tex-Alegreya-ExtraBold-osf-ts1.tfm \
tex-Alegreya-ExtraBold-osf-ts1.vf \
tex-Alegreya-ExtraBold-sup-lgr--base.tfm \
tex-Alegreya-ExtraBold-sup-lgr.tfm \
tex-Alegreya-ExtraBold-sup-lgr.vf \
tex-Alegreya-ExtraBold-sup-ly1--base.tfm \
tex-Alegreya-ExtraBold-sup-ly1.tfm \
tex-Alegreya-ExtraBold-sup-ly1.vf \
tex-Alegreya-ExtraBold-sup-ot1.tfm \
tex-Alegreya-ExtraBold-sup-t1--base.tfm \
tex-Alegreya-ExtraBold-sup-t1.tfm \
tex-Alegreya-ExtraBold-sup-t1.vf \
tex-Alegreya-ExtraBold-tlf-lgr--base.tfm \
tex-Alegreya-ExtraBold-tlf-lgr.tfm \
tex-Alegreya-ExtraBold-tlf-lgr.vf \
tex-Alegreya-ExtraBold-tlf-ly1--base.tfm \
tex-Alegreya-ExtraBold-tlf-ly1.tfm \
tex-Alegreya-ExtraBold-tlf-ly1.vf \
tex-Alegreya-ExtraBold-tlf-ot1.tfm \
tex-Alegreya-ExtraBold-tlf-sc-lgr--base.tfm \
tex-Alegreya-ExtraBold-tlf-sc-lgr.tfm \
tex-Alegreya-ExtraBold-tlf-sc-lgr.vf \
tex-Alegreya-ExtraBold-tlf-sc-ly1--base.tfm \
tex-Alegreya-ExtraBold-tlf-sc-ly1.tfm \
tex-Alegreya-ExtraBold-tlf-sc-ly1.vf \
tex-Alegreya-ExtraBold-tlf-sc-ot1--base.tfm \
tex-Alegreya-ExtraBold-tlf-sc-ot1.tfm \
tex-Alegreya-ExtraBold-tlf-sc-ot1.vf \
tex-Alegreya-ExtraBold-tlf-sc-t1--base.tfm \
tex-Alegreya-ExtraBold-tlf-sc-t1.tfm \
tex-Alegreya-ExtraBold-tlf-sc-t1.vf \
tex-Alegreya-ExtraBold-tlf-t1--base.tfm \
tex-Alegreya-ExtraBold-tlf-t1.tfm \
tex-Alegreya-ExtraBold-tlf-t1.vf \
tex-Alegreya-ExtraBold-tlf-ts1--base.tfm \
tex-Alegreya-ExtraBold-tlf-ts1.tfm \
tex-Alegreya-ExtraBold-tlf-ts1.vf \
tex-Alegreya-ExtraBold-tosf-lgr--base.tfm \
tex-Alegreya-ExtraBold-tosf-lgr.tfm \
tex-Alegreya-ExtraBold-tosf-lgr.vf \
tex-Alegreya-ExtraBold-tosf-ly1--base.tfm \
tex-Alegreya-ExtraBold-tosf-ly1.tfm \
tex-Alegreya-ExtraBold-tosf-ly1.vf \
tex-Alegreya-ExtraBold-tosf-ot1.tfm \
tex-Alegreya-ExtraBold-tosf-sc-lgr--base.tfm \
tex-Alegreya-ExtraBold-tosf-sc-lgr.tfm \
tex-Alegreya-ExtraBold-tosf-sc-lgr.vf \
tex-Alegreya-ExtraBold-tosf-sc-ly1--base.tfm \
tex-Alegreya-ExtraBold-tosf-sc-ly1.tfm \
tex-Alegreya-ExtraBold-tosf-sc-ly1.vf \
tex-Alegreya-ExtraBold-tosf-sc-ot1--base.tfm \
tex-Alegreya-ExtraBold-tosf-sc-ot1.tfm \
tex-Alegreya-ExtraBold-tosf-sc-ot1.vf \
tex-Alegreya-ExtraBold-tosf-sc-t1--base.tfm \
tex-Alegreya-ExtraBold-tosf-sc-t1.tfm \
tex-Alegreya-ExtraBold-tosf-sc-t1.vf \
tex-Alegreya-ExtraBold-tosf-t1--base.tfm \
tex-Alegreya-ExtraBold-tosf-t1.tfm \
tex-Alegreya-ExtraBold-tosf-t1.vf \
tex-Alegreya-ExtraBold-tosf-ts1--base.tfm \
tex-Alegreya-ExtraBold-tosf-ts1.tfm \
tex-Alegreya-ExtraBold-tosf-ts1.vf \
tex-Alegreya-ExtraBoldItalic-inf-lgr--base.tfm \
tex-Alegreya-ExtraBoldItalic-inf-lgr.tfm \
tex-Alegreya-ExtraBoldItalic-inf-lgr.vf \
tex-Alegreya-ExtraBoldItalic-inf-ly1--base.tfm \
tex-Alegreya-ExtraBoldItalic-inf-ly1.tfm \
tex-Alegreya-ExtraBoldItalic-inf-ly1.vf \
tex-Alegreya-ExtraBoldItalic-inf-ot1.tfm \
tex-Alegreya-ExtraBoldItalic-inf-t1--base.tfm \
tex-Alegreya-ExtraBoldItalic-inf-t1.tfm \
tex-Alegreya-ExtraBoldItalic-inf-t1.vf \
tex-Alegreya-ExtraBoldItalic-lf-lgr--base.tfm \
tex-Alegreya-ExtraBoldItalic-lf-lgr.tfm \
tex-Alegreya-ExtraBoldItalic-lf-lgr.vf \
tex-Alegreya-ExtraBoldItalic-lf-ly1--base.tfm \
tex-Alegreya-ExtraBoldItalic-lf-ly1.tfm \
tex-Alegreya-ExtraBoldItalic-lf-ly1.vf \
tex-Alegreya-ExtraBoldItalic-lf-ot1.tfm \
tex-Alegreya-ExtraBoldItalic-lf-sc-lgr--base.tfm \
tex-Alegreya-ExtraBoldItalic-lf-sc-lgr.tfm \
tex-Alegreya-ExtraBoldItalic-lf-sc-lgr.vf \
tex-Alegreya-ExtraBoldItalic-lf-sc-ly1--base.tfm \
tex-Alegreya-ExtraBoldItalic-lf-sc-ly1.tfm \
tex-Alegreya-ExtraBoldItalic-lf-sc-ly1.vf \
tex-Alegreya-ExtraBoldItalic-lf-sc-ot1--base.tfm \
tex-Alegreya-ExtraBoldItalic-lf-sc-ot1.tfm \
tex-Alegreya-ExtraBoldItalic-lf-sc-ot1.vf \
tex-Alegreya-ExtraBoldItalic-lf-sc-t1--base.tfm \
tex-Alegreya-ExtraBoldItalic-lf-sc-t1.tfm \
tex-Alegreya-ExtraBoldItalic-lf-sc-t1.vf \
tex-Alegreya-ExtraBoldItalic-lf-t1--base.tfm \
tex-Alegreya-ExtraBoldItalic-lf-t1.tfm \
tex-Alegreya-ExtraBoldItalic-lf-t1.vf \
tex-Alegreya-ExtraBoldItalic-lf-ts1--base.tfm \
tex-Alegreya-ExtraBoldItalic-lf-ts1.tfm \
tex-Alegreya-ExtraBoldItalic-lf-ts1.vf \
tex-Alegreya-ExtraBoldItalic-osf-lgr--base.tfm \
tex-Alegreya-ExtraBoldItalic-osf-lgr.tfm \
tex-Alegreya-ExtraBoldItalic-osf-lgr.vf \
tex-Alegreya-ExtraBoldItalic-osf-ly1--base.tfm \
tex-Alegreya-ExtraBoldItalic-osf-ly1.tfm \
tex-Alegreya-ExtraBoldItalic-osf-ly1.vf \
tex-Alegreya-ExtraBoldItalic-osf-ot1.tfm \
tex-Alegreya-ExtraBoldItalic-osf-sc-lgr--base.tfm \
tex-Alegreya-ExtraBoldItalic-osf-sc-lgr.tfm \
tex-Alegreya-ExtraBoldItalic-osf-sc-lgr.vf \
tex-Alegreya-ExtraBoldItalic-osf-sc-ly1--base.tfm \
tex-Alegreya-ExtraBoldItalic-osf-sc-ly1.tfm \
tex-Alegreya-ExtraBoldItalic-osf-sc-ly1.vf \
tex-Alegreya-ExtraBoldItalic-osf-sc-ot1--base.tfm \
tex-Alegreya-ExtraBoldItalic-osf-sc-ot1.tfm \
tex-Alegreya-ExtraBoldItalic-osf-sc-ot1.vf \
tex-Alegreya-ExtraBoldItalic-osf-sc-t1--base.tfm \
tex-Alegreya-ExtraBoldItalic-osf-sc-t1.tfm \
tex-Alegreya-ExtraBoldItalic-osf-sc-t1.vf \
tex-Alegreya-ExtraBoldItalic-osf-t1--base.tfm \
tex-Alegreya-ExtraBoldItalic-osf-t1.tfm \
tex-Alegreya-ExtraBoldItalic-osf-t1.vf \
tex-Alegreya-ExtraBoldItalic-osf-ts1--base.tfm \
tex-Alegreya-ExtraBoldItalic-osf-ts1.tfm \
tex-Alegreya-ExtraBoldItalic-osf-ts1.vf \
tex-Alegreya-ExtraBoldItalic-sup-lgr--base.tfm \
tex-Alegreya-ExtraBoldItalic-sup-lgr.tfm \
tex-Alegreya-ExtraBoldItalic-sup-lgr.vf \
tex-Alegreya-ExtraBoldItalic-sup-ly1--base.tfm \
tex-Alegreya-ExtraBoldItalic-sup-ly1.tfm \
tex-Alegreya-ExtraBoldItalic-sup-ly1.vf \
tex-Alegreya-ExtraBoldItalic-sup-ot1.tfm \
tex-Alegreya-ExtraBoldItalic-sup-t1--base.tfm \
tex-Alegreya-ExtraBoldItalic-sup-t1.tfm \
tex-Alegreya-ExtraBoldItalic-sup-t1.vf \
tex-Alegreya-ExtraBoldItalic-tlf-lgr--base.tfm \
tex-Alegreya-ExtraBoldItalic-tlf-lgr.tfm \
tex-Alegreya-ExtraBoldItalic-tlf-lgr.vf \
tex-Alegreya-ExtraBoldItalic-tlf-ly1--base.tfm \
tex-Alegreya-ExtraBoldItalic-tlf-ly1.tfm \
tex-Alegreya-ExtraBoldItalic-tlf-ly1.vf \
tex-Alegreya-ExtraBoldItalic-tlf-ot1.tfm \
tex-Alegreya-ExtraBoldItalic-tlf-sc-lgr--base.tfm \
tex-Alegreya-ExtraBoldItalic-tlf-sc-lgr.tfm \
tex-Alegreya-ExtraBoldItalic-tlf-sc-lgr.vf \
tex-Alegreya-ExtraBoldItalic-tlf-sc-ly1--base.tfm \
tex-Alegreya-ExtraBoldItalic-tlf-sc-ly1.tfm \
tex-Alegreya-ExtraBoldItalic-tlf-sc-ly1.vf \
tex-Alegreya-ExtraBoldItalic-tlf-sc-ot1--base.tfm \
tex-Alegreya-ExtraBoldItalic-tlf-sc-ot1.tfm \
tex-Alegreya-ExtraBoldItalic-tlf-sc-ot1.vf \
tex-Alegreya-ExtraBoldItalic-tlf-sc-t1--base.tfm \
tex-Alegreya-ExtraBoldItalic-tlf-sc-t1.tfm \
tex-Alegreya-ExtraBoldItalic-tlf-sc-t1.vf \
tex-Alegreya-ExtraBoldItalic-tlf-t1--base.tfm \
tex-Alegreya-ExtraBoldItalic-tlf-t1.tfm \
tex-Alegreya-ExtraBoldItalic-tlf-t1.vf \
tex-Alegreya-ExtraBoldItalic-tlf-ts1--base.tfm \
tex-Alegreya-ExtraBoldItalic-tlf-ts1.tfm \
tex-Alegreya-ExtraBoldItalic-tlf-ts1.vf \
tex-Alegreya-ExtraBoldItalic-tosf-lgr--base.tfm \
tex-Alegreya-ExtraBoldItalic-tosf-lgr.tfm \
tex-Alegreya-ExtraBoldItalic-tosf-lgr.vf \
tex-Alegreya-ExtraBoldItalic-tosf-ly1--base.tfm \
tex-Alegreya-ExtraBoldItalic-tosf-ly1.tfm \
tex-Alegreya-ExtraBoldItalic-tosf-ly1.vf \
tex-Alegreya-ExtraBoldItalic-tosf-ot1.tfm \
tex-Alegreya-ExtraBoldItalic-tosf-sc-lgr--base.tfm \
tex-Alegreya-ExtraBoldItalic-tosf-sc-lgr.tfm \
tex-Alegreya-ExtraBoldItalic-tosf-sc-lgr.vf \
tex-Alegreya-ExtraBoldItalic-tosf-sc-ly1--base.tfm \
tex-Alegreya-ExtraBoldItalic-tosf-sc-ly1.tfm \
tex-Alegreya-ExtraBoldItalic-tosf-sc-ly1.vf \
tex-Alegreya-ExtraBoldItalic-tosf-sc-ot1--base.tfm \
tex-Alegreya-ExtraBoldItalic-tosf-sc-ot1.tfm \
tex-Alegreya-ExtraBoldItalic-tosf-sc-ot1.vf \
tex-Alegreya-ExtraBoldItalic-tosf-sc-t1--base.tfm \
tex-Alegreya-ExtraBoldItalic-tosf-sc-t1.tfm \
tex-Alegreya-ExtraBoldItalic-tosf-sc-t1.vf \
tex-Alegreya-ExtraBoldItalic-tosf-t1--base.tfm \
tex-Alegreya-ExtraBoldItalic-tosf-t1.tfm \
tex-Alegreya-ExtraBoldItalic-tosf-t1.vf \
tex-Alegreya-ExtraBoldItalic-tosf-ts1--base.tfm \
tex-Alegreya-ExtraBoldItalic-tosf-ts1.tfm \
tex-Alegreya-ExtraBoldItalic-tosf-ts1.vf \
tex-Alegreya-Italic-inf-lgr--base.tfm \
tex-Alegreya-Italic-inf-lgr.tfm \
tex-Alegreya-Italic-inf-lgr.vf \
tex-Alegreya-Italic-inf-ly1--base.tfm \
tex-Alegreya-Italic-inf-ly1.tfm \
tex-Alegreya-Italic-inf-ly1.vf \
tex-Alegreya-Italic-inf-ot1.tfm \
tex-Alegreya-Italic-inf-t1--base.tfm \
tex-Alegreya-Italic-inf-t1.tfm \
tex-Alegreya-Italic-inf-t1.vf \
tex-Alegreya-Italic-lf-lgr--base.tfm \
tex-Alegreya-Italic-lf-lgr.tfm \
tex-Alegreya-Italic-lf-lgr.vf \
tex-Alegreya-Italic-lf-ly1--base.tfm \
tex-Alegreya-Italic-lf-ly1.tfm \
tex-Alegreya-Italic-lf-ly1.vf \
tex-Alegreya-Italic-lf-ot1.tfm \
tex-Alegreya-Italic-lf-sc-lgr--base.tfm \
tex-Alegreya-Italic-lf-sc-lgr.tfm \
tex-Alegreya-Italic-lf-sc-lgr.vf \
tex-Alegreya-Italic-lf-sc-ly1--base.tfm \
tex-Alegreya-Italic-lf-sc-ly1.tfm \
tex-Alegreya-Italic-lf-sc-ly1.vf \
tex-Alegreya-Italic-lf-sc-ot1--base.tfm \
tex-Alegreya-Italic-lf-sc-ot1.tfm \
tex-Alegreya-Italic-lf-sc-ot1.vf \
tex-Alegreya-Italic-lf-sc-t1--base.tfm \
tex-Alegreya-Italic-lf-sc-t1.tfm \
tex-Alegreya-Italic-lf-sc-t1.vf \
tex-Alegreya-Italic-lf-t1--base.tfm \
tex-Alegreya-Italic-lf-t1.tfm \
tex-Alegreya-Italic-lf-t1.vf \
tex-Alegreya-Italic-lf-ts1--base.tfm \
tex-Alegreya-Italic-lf-ts1.tfm \
tex-Alegreya-Italic-lf-ts1.vf \
tex-Alegreya-Italic-osf-lgr--base.tfm \
tex-Alegreya-Italic-osf-lgr.tfm \
tex-Alegreya-Italic-osf-lgr.vf \
tex-Alegreya-Italic-osf-ly1--base.tfm \
tex-Alegreya-Italic-osf-ly1.tfm \
tex-Alegreya-Italic-osf-ly1.vf \
tex-Alegreya-Italic-osf-ot1.tfm \
tex-Alegreya-Italic-osf-sc-lgr--base.tfm \
tex-Alegreya-Italic-osf-sc-lgr.tfm \
tex-Alegreya-Italic-osf-sc-lgr.vf \
tex-Alegreya-Italic-osf-sc-ly1--base.tfm \
tex-Alegreya-Italic-osf-sc-ly1.tfm \
tex-Alegreya-Italic-osf-sc-ly1.vf \
tex-Alegreya-Italic-osf-sc-ot1--base.tfm \
tex-Alegreya-Italic-osf-sc-ot1.tfm \
tex-Alegreya-Italic-osf-sc-ot1.vf \
tex-Alegreya-Italic-osf-sc-t1--base.tfm \
tex-Alegreya-Italic-osf-sc-t1.tfm \
tex-Alegreya-Italic-osf-sc-t1.vf \
tex-Alegreya-Italic-osf-t1--base.tfm \
tex-Alegreya-Italic-osf-t1.tfm \
tex-Alegreya-Italic-osf-t1.vf \
tex-Alegreya-Italic-osf-ts1--base.tfm \
tex-Alegreya-Italic-osf-ts1.tfm \
tex-Alegreya-Italic-osf-ts1.vf \
tex-Alegreya-Italic-sup-lgr--base.tfm \
tex-Alegreya-Italic-sup-lgr.tfm \
tex-Alegreya-Italic-sup-lgr.vf \
tex-Alegreya-Italic-sup-ly1--base.tfm \
tex-Alegreya-Italic-sup-ly1.tfm \
tex-Alegreya-Italic-sup-ly1.vf \
tex-Alegreya-Italic-sup-ot1.tfm \
tex-Alegreya-Italic-sup-t1--base.tfm \
tex-Alegreya-Italic-sup-t1.tfm \
tex-Alegreya-Italic-sup-t1.vf \
tex-Alegreya-Italic-tlf-lgr--base.tfm \
tex-Alegreya-Italic-tlf-lgr.tfm \
tex-Alegreya-Italic-tlf-lgr.vf \
tex-Alegreya-Italic-tlf-ly1--base.tfm \
tex-Alegreya-Italic-tlf-ly1.tfm \
tex-Alegreya-Italic-tlf-ly1.vf \
tex-Alegreya-Italic-tlf-ot1.tfm \
tex-Alegreya-Italic-tlf-sc-lgr--base.tfm \
tex-Alegreya-Italic-tlf-sc-lgr.tfm \
tex-Alegreya-Italic-tlf-sc-lgr.vf \
tex-Alegreya-Italic-tlf-sc-ly1--base.tfm \
tex-Alegreya-Italic-tlf-sc-ly1.tfm \
tex-Alegreya-Italic-tlf-sc-ly1.vf \
tex-Alegreya-Italic-tlf-sc-ot1--base.tfm \
tex-Alegreya-Italic-tlf-sc-ot1.tfm \
tex-Alegreya-Italic-tlf-sc-ot1.vf \
tex-Alegreya-Italic-tlf-sc-t1--base.tfm \
tex-Alegreya-Italic-tlf-sc-t1.tfm \
tex-Alegreya-Italic-tlf-sc-t1.vf \
tex-Alegreya-Italic-tlf-t1--base.tfm \
tex-Alegreya-Italic-tlf-t1.tfm \
tex-Alegreya-Italic-tlf-t1.vf \
tex-Alegreya-Italic-tlf-ts1--base.tfm \
tex-Alegreya-Italic-tlf-ts1.tfm \
tex-Alegreya-Italic-tlf-ts1.vf \
tex-Alegreya-Italic-tosf-lgr--base.tfm \
tex-Alegreya-Italic-tosf-lgr.tfm \
tex-Alegreya-Italic-tosf-lgr.vf \
tex-Alegreya-Italic-tosf-ly1--base.tfm \
tex-Alegreya-Italic-tosf-ly1.tfm \
tex-Alegreya-Italic-tosf-ly1.vf \
tex-Alegreya-Italic-tosf-ot1.tfm \
tex-Alegreya-Italic-tosf-sc-lgr--base.tfm \
tex-Alegreya-Italic-tosf-sc-lgr.tfm \
tex-Alegreya-Italic-tosf-sc-lgr.vf \
tex-Alegreya-Italic-tosf-sc-ly1--base.tfm \
tex-Alegreya-Italic-tosf-sc-ly1.tfm \
tex-Alegreya-Italic-tosf-sc-ly1.vf \
tex-Alegreya-Italic-tosf-sc-ot1--base.tfm \
tex-Alegreya-Italic-tosf-sc-ot1.tfm \
tex-Alegreya-Italic-tosf-sc-ot1.vf \
tex-Alegreya-Italic-tosf-sc-t1--base.tfm \
tex-Alegreya-Italic-tosf-sc-t1.tfm \
tex-Alegreya-Italic-tosf-sc-t1.vf \
tex-Alegreya-Italic-tosf-t1--base.tfm \
tex-Alegreya-Italic-tosf-t1.tfm \
tex-Alegreya-Italic-tosf-t1.vf \
tex-Alegreya-Italic-tosf-ts1--base.tfm \
tex-Alegreya-Italic-tosf-ts1.tfm \
tex-Alegreya-Italic-tosf-ts1.vf \
tex-Alegreya-Medium-inf-lgr--base.tfm \
tex-Alegreya-Medium-inf-lgr.tfm \
tex-Alegreya-Medium-inf-lgr.vf \
tex-Alegreya-Medium-inf-ly1--base.tfm \
tex-Alegreya-Medium-inf-ly1.tfm \
tex-Alegreya-Medium-inf-ly1.vf \
tex-Alegreya-Medium-inf-ot1.tfm \
tex-Alegreya-Medium-inf-t1--base.tfm \
tex-Alegreya-Medium-inf-t1.tfm \
tex-Alegreya-Medium-inf-t1.vf \
tex-Alegreya-Medium-lf-lgr--base.tfm \
tex-Alegreya-Medium-lf-lgr.tfm \
tex-Alegreya-Medium-lf-lgr.vf \
tex-Alegreya-Medium-lf-ly1--base.tfm \
tex-Alegreya-Medium-lf-ly1.tfm \
tex-Alegreya-Medium-lf-ly1.vf \
tex-Alegreya-Medium-lf-ot1.tfm \
tex-Alegreya-Medium-lf-sc-lgr--base.tfm \
tex-Alegreya-Medium-lf-sc-lgr.tfm \
tex-Alegreya-Medium-lf-sc-lgr.vf \
tex-Alegreya-Medium-lf-sc-ly1--base.tfm \
tex-Alegreya-Medium-lf-sc-ly1.tfm \
tex-Alegreya-Medium-lf-sc-ly1.vf \
tex-Alegreya-Medium-lf-sc-ot1--base.tfm \
tex-Alegreya-Medium-lf-sc-ot1.tfm \
tex-Alegreya-Medium-lf-sc-ot1.vf \
tex-Alegreya-Medium-lf-sc-t1--base.tfm \
tex-Alegreya-Medium-lf-sc-t1.tfm \
tex-Alegreya-Medium-lf-sc-t1.vf \
tex-Alegreya-Medium-lf-t1--base.tfm \
tex-Alegreya-Medium-lf-t1.tfm \
tex-Alegreya-Medium-lf-t1.vf \
tex-Alegreya-Medium-lf-ts1--base.tfm \
tex-Alegreya-Medium-lf-ts1.tfm \
tex-Alegreya-Medium-lf-ts1.vf \
tex-Alegreya-Medium-osf-lgr--base.tfm \
tex-Alegreya-Medium-osf-lgr.tfm \
tex-Alegreya-Medium-osf-lgr.vf \
tex-Alegreya-Medium-osf-ly1--base.tfm \
tex-Alegreya-Medium-osf-ly1.tfm \
tex-Alegreya-Medium-osf-ly1.vf \
tex-Alegreya-Medium-osf-ot1.tfm \
tex-Alegreya-Medium-osf-sc-lgr--base.tfm \
tex-Alegreya-Medium-osf-sc-lgr.tfm \
tex-Alegreya-Medium-osf-sc-lgr.vf \
tex-Alegreya-Medium-osf-sc-ly1--base.tfm \
tex-Alegreya-Medium-osf-sc-ly1.tfm \
tex-Alegreya-Medium-osf-sc-ly1.vf \
tex-Alegreya-Medium-osf-sc-ot1--base.tfm \
tex-Alegreya-Medium-osf-sc-ot1.tfm \
tex-Alegreya-Medium-osf-sc-ot1.vf \
tex-Alegreya-Medium-osf-sc-t1--base.tfm \
tex-Alegreya-Medium-osf-sc-t1.tfm \
tex-Alegreya-Medium-osf-sc-t1.vf \
tex-Alegreya-Medium-osf-t1--base.tfm \
tex-Alegreya-Medium-osf-t1.tfm \
tex-Alegreya-Medium-osf-t1.vf \
tex-Alegreya-Medium-osf-ts1--base.tfm \
tex-Alegreya-Medium-osf-ts1.tfm \
tex-Alegreya-Medium-osf-ts1.vf \
tex-Alegreya-Medium-sup-lgr--base.tfm \
tex-Alegreya-Medium-sup-lgr.tfm \
tex-Alegreya-Medium-sup-lgr.vf \
tex-Alegreya-Medium-sup-ly1--base.tfm \
tex-Alegreya-Medium-sup-ly1.tfm \
tex-Alegreya-Medium-sup-ly1.vf \
tex-Alegreya-Medium-sup-ot1.tfm \
tex-Alegreya-Medium-sup-t1--base.tfm \
tex-Alegreya-Medium-sup-t1.tfm \
tex-Alegreya-Medium-sup-t1.vf \
tex-Alegreya-Medium-tlf-lgr--base.tfm \
tex-Alegreya-Medium-tlf-lgr.tfm \
tex-Alegreya-Medium-tlf-lgr.vf \
tex-Alegreya-Medium-tlf-ly1--base.tfm \
tex-Alegreya-Medium-tlf-ly1.tfm \
tex-Alegreya-Medium-tlf-ly1.vf \
tex-Alegreya-Medium-tlf-ot1.tfm \
tex-Alegreya-Medium-tlf-sc-lgr--base.tfm \
tex-Alegreya-Medium-tlf-sc-lgr.tfm \
tex-Alegreya-Medium-tlf-sc-lgr.vf \
tex-Alegreya-Medium-tlf-sc-ly1--base.tfm \
tex-Alegreya-Medium-tlf-sc-ly1.tfm \
tex-Alegreya-Medium-tlf-sc-ly1.vf \
tex-Alegreya-Medium-tlf-sc-ot1--base.tfm \
tex-Alegreya-Medium-tlf-sc-ot1.tfm \
tex-Alegreya-Medium-tlf-sc-ot1.vf \
tex-Alegreya-Medium-tlf-sc-t1--base.tfm \
tex-Alegreya-Medium-tlf-sc-t1.tfm \
tex-Alegreya-Medium-tlf-sc-t1.vf \
tex-Alegreya-Medium-tlf-t1--base.tfm \
tex-Alegreya-Medium-tlf-t1.tfm \
tex-Alegreya-Medium-tlf-t1.vf \
tex-Alegreya-Medium-tlf-ts1--base.tfm \
tex-Alegreya-Medium-tlf-ts1.tfm \
tex-Alegreya-Medium-tlf-ts1.vf \
tex-Alegreya-Medium-tosf-lgr--base.tfm \
tex-Alegreya-Medium-tosf-lgr.tfm \
tex-Alegreya-Medium-tosf-lgr.vf \
tex-Alegreya-Medium-tosf-ly1--base.tfm \
tex-Alegreya-Medium-tosf-ly1.tfm \
tex-Alegreya-Medium-tosf-ly1.vf \
tex-Alegreya-Medium-tosf-ot1.tfm \
tex-Alegreya-Medium-tosf-sc-lgr--base.tfm \
tex-Alegreya-Medium-tosf-sc-lgr.tfm \
tex-Alegreya-Medium-tosf-sc-lgr.vf \
tex-Alegreya-Medium-tosf-sc-ly1--base.tfm \
tex-Alegreya-Medium-tosf-sc-ly1.tfm \
tex-Alegreya-Medium-tosf-sc-ly1.vf \
tex-Alegreya-Medium-tosf-sc-ot1--base.tfm \
tex-Alegreya-Medium-tosf-sc-ot1.tfm \
tex-Alegreya-Medium-tosf-sc-ot1.vf \
tex-Alegreya-Medium-tosf-sc-t1--base.tfm \
tex-Alegreya-Medium-tosf-sc-t1.tfm \
tex-Alegreya-Medium-tosf-sc-t1.vf \
tex-Alegreya-Medium-tosf-t1--base.tfm \
tex-Alegreya-Medium-tosf-t1.tfm \
tex-Alegreya-Medium-tosf-t1.vf \
tex-Alegreya-Medium-tosf-ts1--base.tfm \
tex-Alegreya-Medium-tosf-ts1.tfm \
tex-Alegreya-Medium-tosf-ts1.vf \
tex-Alegreya-MediumItalic-inf-lgr--base.tfm \
tex-Alegreya-MediumItalic-inf-lgr.tfm \
tex-Alegreya-MediumItalic-inf-lgr.vf \
tex-Alegreya-MediumItalic-inf-ly1--base.tfm \
tex-Alegreya-MediumItalic-inf-ly1.tfm \
tex-Alegreya-MediumItalic-inf-ly1.vf \
tex-Alegreya-MediumItalic-inf-ot1.tfm \
tex-Alegreya-MediumItalic-inf-t1--base.tfm \
tex-Alegreya-MediumItalic-inf-t1.tfm \
tex-Alegreya-MediumItalic-inf-t1.vf \
tex-Alegreya-MediumItalic-lf-lgr--base.tfm \
tex-Alegreya-MediumItalic-lf-lgr.tfm \
tex-Alegreya-MediumItalic-lf-lgr.vf \
tex-Alegreya-MediumItalic-lf-ly1--base.tfm \
tex-Alegreya-MediumItalic-lf-ly1.tfm \
tex-Alegreya-MediumItalic-lf-ly1.vf \
tex-Alegreya-MediumItalic-lf-ot1.tfm \
tex-Alegreya-MediumItalic-lf-sc-lgr--base.tfm \
tex-Alegreya-MediumItalic-lf-sc-lgr.tfm \
tex-Alegreya-MediumItalic-lf-sc-lgr.vf \
tex-Alegreya-MediumItalic-lf-sc-ly1--base.tfm \
tex-Alegreya-MediumItalic-lf-sc-ly1.tfm \
tex-Alegreya-MediumItalic-lf-sc-ly1.vf \
tex-Alegreya-MediumItalic-lf-sc-ot1--base.tfm \
tex-Alegreya-MediumItalic-lf-sc-ot1.tfm \
tex-Alegreya-MediumItalic-lf-sc-ot1.vf \
tex-Alegreya-MediumItalic-lf-sc-t1--base.tfm \
tex-Alegreya-MediumItalic-lf-sc-t1.tfm \
tex-Alegreya-MediumItalic-lf-sc-t1.vf \
tex-Alegreya-MediumItalic-lf-t1--base.tfm \
tex-Alegreya-MediumItalic-lf-t1.tfm \
tex-Alegreya-MediumItalic-lf-t1.vf \
tex-Alegreya-MediumItalic-lf-ts1--base.tfm \
tex-Alegreya-MediumItalic-lf-ts1.tfm \
tex-Alegreya-MediumItalic-lf-ts1.vf \
tex-Alegreya-MediumItalic-osf-lgr--base.tfm \
tex-Alegreya-MediumItalic-osf-lgr.tfm \
tex-Alegreya-MediumItalic-osf-lgr.vf \
tex-Alegreya-MediumItalic-osf-ly1--base.tfm \
tex-Alegreya-MediumItalic-osf-ly1.tfm \
tex-Alegreya-MediumItalic-osf-ly1.vf \
tex-Alegreya-MediumItalic-osf-ot1.tfm \
tex-Alegreya-MediumItalic-osf-sc-lgr--base.tfm \
tex-Alegreya-MediumItalic-osf-sc-lgr.tfm \
tex-Alegreya-MediumItalic-osf-sc-lgr.vf \
tex-Alegreya-MediumItalic-osf-sc-ly1--base.tfm \
tex-Alegreya-MediumItalic-osf-sc-ly1.tfm \
tex-Alegreya-MediumItalic-osf-sc-ly1.vf \
tex-Alegreya-MediumItalic-osf-sc-ot1--base.tfm \
tex-Alegreya-MediumItalic-osf-sc-ot1.tfm \
tex-Alegreya-MediumItalic-osf-sc-ot1.vf \
tex-Alegreya-MediumItalic-osf-sc-t1--base.tfm \
tex-Alegreya-MediumItalic-osf-sc-t1.tfm \
tex-Alegreya-MediumItalic-osf-sc-t1.vf \
tex-Alegreya-MediumItalic-osf-t1--base.tfm \
tex-Alegreya-MediumItalic-osf-t1.tfm \
tex-Alegreya-MediumItalic-osf-t1.vf \
tex-Alegreya-MediumItalic-osf-ts1--base.tfm \
tex-Alegreya-MediumItalic-osf-ts1.tfm \
tex-Alegreya-MediumItalic-osf-ts1.vf \
tex-Alegreya-MediumItalic-sup-lgr--base.tfm \
tex-Alegreya-MediumItalic-sup-lgr.tfm \
tex-Alegreya-MediumItalic-sup-lgr.vf \
tex-Alegreya-MediumItalic-sup-ly1--base.tfm \
tex-Alegreya-MediumItalic-sup-ly1.tfm \
tex-Alegreya-MediumItalic-sup-ly1.vf \
tex-Alegreya-MediumItalic-sup-ot1.tfm \
tex-Alegreya-MediumItalic-sup-t1--base.tfm \
tex-Alegreya-MediumItalic-sup-t1.tfm \
tex-Alegreya-MediumItalic-sup-t1.vf \
tex-Alegreya-MediumItalic-tlf-lgr--base.tfm \
tex-Alegreya-MediumItalic-tlf-lgr.tfm \
tex-Alegreya-MediumItalic-tlf-lgr.vf \
tex-Alegreya-MediumItalic-tlf-ly1--base.tfm \
tex-Alegreya-MediumItalic-tlf-ly1.tfm \
tex-Alegreya-MediumItalic-tlf-ly1.vf \
tex-Alegreya-MediumItalic-tlf-ot1.tfm \
tex-Alegreya-MediumItalic-tlf-sc-lgr--base.tfm \
tex-Alegreya-MediumItalic-tlf-sc-lgr.tfm \
tex-Alegreya-MediumItalic-tlf-sc-lgr.vf \
tex-Alegreya-MediumItalic-tlf-sc-ly1--base.tfm \
tex-Alegreya-MediumItalic-tlf-sc-ly1.tfm \
tex-Alegreya-MediumItalic-tlf-sc-ly1.vf \
tex-Alegreya-MediumItalic-tlf-sc-ot1--base.tfm \
tex-Alegreya-MediumItalic-tlf-sc-ot1.tfm \
tex-Alegreya-MediumItalic-tlf-sc-ot1.vf \
tex-Alegreya-MediumItalic-tlf-sc-t1--base.tfm \
tex-Alegreya-MediumItalic-tlf-sc-t1.tfm \
tex-Alegreya-MediumItalic-tlf-sc-t1.vf \
tex-Alegreya-MediumItalic-tlf-t1--base.tfm \
tex-Alegreya-MediumItalic-tlf-t1.tfm \
tex-Alegreya-MediumItalic-tlf-t1.vf \
tex-Alegreya-MediumItalic-tlf-ts1--base.tfm \
tex-Alegreya-MediumItalic-tlf-ts1.tfm \
tex-Alegreya-MediumItalic-tlf-ts1.vf \
tex-Alegreya-MediumItalic-tosf-lgr--base.tfm \
tex-Alegreya-MediumItalic-tosf-lgr.tfm \
tex-Alegreya-MediumItalic-tosf-lgr.vf \
tex-Alegreya-MediumItalic-tosf-ly1--base.tfm \
tex-Alegreya-MediumItalic-tosf-ly1.tfm \
tex-Alegreya-MediumItalic-tosf-ly1.vf \
tex-Alegreya-MediumItalic-tosf-ot1.tfm \
tex-Alegreya-MediumItalic-tosf-sc-lgr--base.tfm \
tex-Alegreya-MediumItalic-tosf-sc-lgr.tfm \
tex-Alegreya-MediumItalic-tosf-sc-lgr.vf \
tex-Alegreya-MediumItalic-tosf-sc-ly1--base.tfm \
tex-Alegreya-MediumItalic-tosf-sc-ly1.tfm \
tex-Alegreya-MediumItalic-tosf-sc-ly1.vf \
tex-Alegreya-MediumItalic-tosf-sc-ot1--base.tfm \
tex-Alegreya-MediumItalic-tosf-sc-ot1.tfm \
tex-Alegreya-MediumItalic-tosf-sc-ot1.vf \
tex-Alegreya-MediumItalic-tosf-sc-t1--base.tfm \
tex-Alegreya-MediumItalic-tosf-sc-t1.tfm \
tex-Alegreya-MediumItalic-tosf-sc-t1.vf \
tex-Alegreya-MediumItalic-tosf-t1--base.tfm \
tex-Alegreya-MediumItalic-tosf-t1.tfm \
tex-Alegreya-MediumItalic-tosf-t1.vf \
tex-Alegreya-MediumItalic-tosf-ts1--base.tfm \
tex-Alegreya-MediumItalic-tosf-ts1.tfm \
tex-Alegreya-MediumItalic-tosf-ts1.vf \
tex-Alegreya-Regular-inf-lgr--base.tfm \
tex-Alegreya-Regular-inf-lgr.tfm \
tex-Alegreya-Regular-inf-lgr.vf \
tex-Alegreya-Regular-inf-ly1--base.tfm \
tex-Alegreya-Regular-inf-ly1.tfm \
tex-Alegreya-Regular-inf-ly1.vf \
tex-Alegreya-Regular-inf-ot1.tfm \
tex-Alegreya-Regular-inf-t1--base.tfm \
tex-Alegreya-Regular-inf-t1.tfm \
tex-Alegreya-Regular-inf-t1.vf \
tex-Alegreya-Regular-lf-lgr--base.tfm \
tex-Alegreya-Regular-lf-lgr.tfm \
tex-Alegreya-Regular-lf-lgr.vf \
tex-Alegreya-Regular-lf-ly1--base.tfm \
tex-Alegreya-Regular-lf-ly1.tfm \
tex-Alegreya-Regular-lf-ly1.vf \
tex-Alegreya-Regular-lf-ot1.tfm \
tex-Alegreya-Regular-lf-sc-lgr--base.tfm \
tex-Alegreya-Regular-lf-sc-lgr.tfm \
tex-Alegreya-Regular-lf-sc-lgr.vf \
tex-Alegreya-Regular-lf-sc-ly1--base.tfm \
tex-Alegreya-Regular-lf-sc-ly1.tfm \
tex-Alegreya-Regular-lf-sc-ly1.vf \
tex-Alegreya-Regular-lf-sc-ot1--base.tfm \
tex-Alegreya-Regular-lf-sc-ot1.tfm \
tex-Alegreya-Regular-lf-sc-ot1.vf \
tex-Alegreya-Regular-lf-sc-t1--base.tfm \
tex-Alegreya-Regular-lf-sc-t1.tfm \
tex-Alegreya-Regular-lf-sc-t1.vf \
tex-Alegreya-Regular-lf-t1--base.tfm \
tex-Alegreya-Regular-lf-t1.tfm \
tex-Alegreya-Regular-lf-t1.vf \
tex-Alegreya-Regular-lf-ts1--base.tfm \
tex-Alegreya-Regular-lf-ts1.tfm \
tex-Alegreya-Regular-lf-ts1.vf \
tex-Alegreya-Regular-osf-lgr--base.tfm \
tex-Alegreya-Regular-osf-lgr.tfm \
tex-Alegreya-Regular-osf-lgr.vf \
tex-Alegreya-Regular-osf-ly1--base.tfm \
tex-Alegreya-Regular-osf-ly1.tfm \
tex-Alegreya-Regular-osf-ly1.vf \
tex-Alegreya-Regular-osf-ot1.tfm \
tex-Alegreya-Regular-osf-sc-lgr--base.tfm \
tex-Alegreya-Regular-osf-sc-lgr.tfm \
tex-Alegreya-Regular-osf-sc-lgr.vf \
tex-Alegreya-Regular-osf-sc-ly1--base.tfm \
tex-Alegreya-Regular-osf-sc-ly1.tfm \
tex-Alegreya-Regular-osf-sc-ly1.vf \
tex-Alegreya-Regular-osf-sc-ot1--base.tfm \
tex-Alegreya-Regular-osf-sc-ot1.tfm \
tex-Alegreya-Regular-osf-sc-ot1.vf \
tex-Alegreya-Regular-osf-sc-t1--base.tfm \
tex-Alegreya-Regular-osf-sc-t1.tfm \
tex-Alegreya-Regular-osf-sc-t1.vf \
tex-Alegreya-Regular-osf-t1--base.tfm \
tex-Alegreya-Regular-osf-t1.tfm \
tex-Alegreya-Regular-osf-t1.vf \
tex-Alegreya-Regular-osf-ts1--base.tfm \
tex-Alegreya-Regular-osf-ts1.tfm \
tex-Alegreya-Regular-osf-ts1.vf \
tex-Alegreya-Regular-sup-lgr--base.tfm \
tex-Alegreya-Regular-sup-lgr.tfm \
tex-Alegreya-Regular-sup-lgr.vf \
tex-Alegreya-Regular-sup-ly1--base.tfm \
tex-Alegreya-Regular-sup-ly1.tfm \
tex-Alegreya-Regular-sup-ly1.vf \
tex-Alegreya-Regular-sup-ot1.tfm \
tex-Alegreya-Regular-sup-t1--base.tfm \
tex-Alegreya-Regular-sup-t1.tfm \
tex-Alegreya-Regular-sup-t1.vf \
tex-Alegreya-Regular-tlf-lgr--base.tfm \
tex-Alegreya-Regular-tlf-lgr.tfm \
tex-Alegreya-Regular-tlf-lgr.vf \
tex-Alegreya-Regular-tlf-ly1--base.tfm \
tex-Alegreya-Regular-tlf-ly1.tfm \
tex-Alegreya-Regular-tlf-ly1.vf \
tex-Alegreya-Regular-tlf-ot1.tfm \
tex-Alegreya-Regular-tlf-sc-lgr--base.tfm \
tex-Alegreya-Regular-tlf-sc-lgr.tfm \
tex-Alegreya-Regular-tlf-sc-lgr.vf \
tex-Alegreya-Regular-tlf-sc-ly1--base.tfm \
tex-Alegreya-Regular-tlf-sc-ly1.tfm \
tex-Alegreya-Regular-tlf-sc-ly1.vf \
tex-Alegreya-Regular-tlf-sc-ot1--base.tfm \
tex-Alegreya-Regular-tlf-sc-ot1.tfm \
tex-Alegreya-Regular-tlf-sc-ot1.vf \
tex-Alegreya-Regular-tlf-sc-t1--base.tfm \
tex-Alegreya-Regular-tlf-sc-t1.tfm \
tex-Alegreya-Regular-tlf-sc-t1.vf \
tex-Alegreya-Regular-tlf-t1--base.tfm \
tex-Alegreya-Regular-tlf-t1.tfm \
tex-Alegreya-Regular-tlf-t1.vf \
tex-Alegreya-Regular-tlf-ts1--base.tfm \
tex-Alegreya-Regular-tlf-ts1.tfm \
tex-Alegreya-Regular-tlf-ts1.vf \
tex-Alegreya-Regular-tosf-lgr--base.tfm \
tex-Alegreya-Regular-tosf-lgr.tfm \
tex-Alegreya-Regular-tosf-lgr.vf \
tex-Alegreya-Regular-tosf-ly1--base.tfm \
tex-Alegreya-Regular-tosf-ly1.tfm \
tex-Alegreya-Regular-tosf-ly1.vf \
tex-Alegreya-Regular-tosf-ot1.tfm \
tex-Alegreya-Regular-tosf-sc-lgr--base.tfm \
tex-Alegreya-Regular-tosf-sc-lgr.tfm \
tex-Alegreya-Regular-tosf-sc-lgr.vf \
tex-Alegreya-Regular-tosf-sc-ly1--base.tfm \
tex-Alegreya-Regular-tosf-sc-ly1.tfm \
tex-Alegreya-Regular-tosf-sc-ly1.vf \
tex-Alegreya-Regular-tosf-sc-ot1--base.tfm \
tex-Alegreya-Regular-tosf-sc-ot1.tfm \
tex-Alegreya-Regular-tosf-sc-ot1.vf \
tex-Alegreya-Regular-tosf-sc-t1--base.tfm \
tex-Alegreya-Regular-tosf-sc-t1.tfm \
tex-Alegreya-Regular-tosf-sc-t1.vf \
tex-Alegreya-Regular-tosf-t1--base.tfm \
tex-Alegreya-Regular-tosf-t1.tfm \
tex-Alegreya-Regular-tosf-t1.vf \
tex-Alegreya-Regular-tosf-ts1--base.tfm \
tex-Alegreya-Regular-tosf-ts1.tfm \
tex-Alegreya-Regular-tosf-ts1.vf \
tex-Alegreya.map \
tex-Alegreya.sty \
tex-AlegreyaSC-Black-inf-sc-lgr--base.tfm \
tex-AlegreyaSC-Black-inf-sc-lgr.tfm \
tex-AlegreyaSC-Black-inf-sc-lgr.vf \
tex-AlegreyaSC-Black-inf-sc-ly1--base.tfm \
tex-AlegreyaSC-Black-inf-sc-ly1.tfm \
tex-AlegreyaSC-Black-inf-sc-ly1.vf \
tex-AlegreyaSC-Black-inf-sc-ot1.tfm \
tex-AlegreyaSC-Black-inf-sc-t1--base.tfm \
tex-AlegreyaSC-Black-inf-sc-t1.tfm \
tex-AlegreyaSC-Black-inf-sc-t1.vf \
tex-AlegreyaSC-Black-lf-sc-lgr--base.tfm \
tex-AlegreyaSC-Black-lf-sc-lgr.tfm \
tex-AlegreyaSC-Black-lf-sc-lgr.vf \
tex-AlegreyaSC-Black-lf-sc-ly1--base.tfm \
tex-AlegreyaSC-Black-lf-sc-ly1.tfm \
tex-AlegreyaSC-Black-lf-sc-ly1.vf \
tex-AlegreyaSC-Black-lf-sc-ot1.tfm \
tex-AlegreyaSC-Black-lf-sc-t1--base.tfm \
tex-AlegreyaSC-Black-lf-sc-t1.tfm \
tex-AlegreyaSC-Black-lf-sc-t1.vf \
tex-AlegreyaSC-Black-osf-sc-lgr--base.tfm \
tex-AlegreyaSC-Black-osf-sc-lgr.tfm \
tex-AlegreyaSC-Black-osf-sc-lgr.vf \
tex-AlegreyaSC-Black-osf-sc-ly1--base.tfm \
tex-AlegreyaSC-Black-osf-sc-ly1.tfm \
tex-AlegreyaSC-Black-osf-sc-ly1.vf \
tex-AlegreyaSC-Black-osf-sc-ot1.tfm \
tex-AlegreyaSC-Black-osf-sc-t1--base.tfm \
tex-AlegreyaSC-Black-osf-sc-t1.tfm \
tex-AlegreyaSC-Black-osf-sc-t1.vf \
tex-AlegreyaSC-Black-sup-sc-lgr--base.tfm \
tex-AlegreyaSC-Black-sup-sc-lgr.tfm \
tex-AlegreyaSC-Black-sup-sc-lgr.vf \
tex-AlegreyaSC-Black-sup-sc-ly1--base.tfm \
tex-AlegreyaSC-Black-sup-sc-ly1.tfm \
tex-AlegreyaSC-Black-sup-sc-ly1.vf \
tex-AlegreyaSC-Black-sup-sc-ot1.tfm \
tex-AlegreyaSC-Black-sup-sc-t1--base.tfm \
tex-AlegreyaSC-Black-sup-sc-t1.tfm \
tex-AlegreyaSC-Black-sup-sc-t1.vf \
tex-AlegreyaSC-Black-tlf-sc-lgr--base.tfm \
tex-AlegreyaSC-Black-tlf-sc-lgr.tfm \
tex-AlegreyaSC-Black-tlf-sc-lgr.vf \
tex-AlegreyaSC-Black-tlf-sc-ly1--base.tfm \
tex-AlegreyaSC-Black-tlf-sc-ly1.tfm \
tex-AlegreyaSC-Black-tlf-sc-ly1.vf \
tex-AlegreyaSC-Black-tlf-sc-ot1.tfm \
tex-AlegreyaSC-Black-tlf-sc-t1--base.tfm \
tex-AlegreyaSC-Black-tlf-sc-t1.tfm \
tex-AlegreyaSC-Black-tlf-sc-t1.vf \
tex-AlegreyaSC-Black-tosf-sc-lgr--base.tfm \
tex-AlegreyaSC-Black-tosf-sc-lgr.tfm \
tex-AlegreyaSC-Black-tosf-sc-lgr.vf \
tex-AlegreyaSC-Black-tosf-sc-ly1--base.tfm \
tex-AlegreyaSC-Black-tosf-sc-ly1.tfm \
tex-AlegreyaSC-Black-tosf-sc-ly1.vf \
tex-AlegreyaSC-Black-tosf-sc-ot1.tfm \
tex-AlegreyaSC-Black-tosf-sc-t1--base.tfm \
tex-AlegreyaSC-Black-tosf-sc-t1.tfm \
tex-AlegreyaSC-Black-tosf-sc-t1.vf \
tex-AlegreyaSC-BlackItalic-inf-sc-lgr--base.tfm \
tex-AlegreyaSC-BlackItalic-inf-sc-lgr.tfm \
tex-AlegreyaSC-BlackItalic-inf-sc-lgr.vf \
tex-AlegreyaSC-BlackItalic-inf-sc-ly1--base.tfm \
tex-AlegreyaSC-BlackItalic-inf-sc-ly1.tfm \
tex-AlegreyaSC-BlackItalic-inf-sc-ly1.vf \
tex-AlegreyaSC-BlackItalic-inf-sc-ot1.tfm \
tex-AlegreyaSC-BlackItalic-inf-sc-t1--base.tfm \
tex-AlegreyaSC-BlackItalic-inf-sc-t1.tfm \
tex-AlegreyaSC-BlackItalic-inf-sc-t1.vf \
tex-AlegreyaSC-BlackItalic-lf-sc-lgr--base.tfm \
tex-AlegreyaSC-BlackItalic-lf-sc-lgr.tfm \
tex-AlegreyaSC-BlackItalic-lf-sc-lgr.vf \
tex-AlegreyaSC-BlackItalic-lf-sc-ly1--base.tfm \
tex-AlegreyaSC-BlackItalic-lf-sc-ly1.tfm \
tex-AlegreyaSC-BlackItalic-lf-sc-ly1.vf \
tex-AlegreyaSC-BlackItalic-lf-sc-ot1.tfm \
tex-AlegreyaSC-BlackItalic-lf-sc-t1--base.tfm \
tex-AlegreyaSC-BlackItalic-lf-sc-t1.tfm \
tex-AlegreyaSC-BlackItalic-lf-sc-t1.vf \
tex-AlegreyaSC-BlackItalic-osf-sc-lgr--base.tfm \
tex-AlegreyaSC-BlackItalic-osf-sc-lgr.tfm \
tex-AlegreyaSC-BlackItalic-osf-sc-lgr.vf \
tex-AlegreyaSC-BlackItalic-osf-sc-ly1--base.tfm \
tex-AlegreyaSC-BlackItalic-osf-sc-ly1.tfm \
tex-AlegreyaSC-BlackItalic-osf-sc-ly1.vf \
tex-AlegreyaSC-BlackItalic-osf-sc-ot1.tfm \
tex-AlegreyaSC-BlackItalic-osf-sc-t1--base.tfm \
tex-AlegreyaSC-BlackItalic-osf-sc-t1.tfm \
tex-AlegreyaSC-BlackItalic-osf-sc-t1.vf \
tex-AlegreyaSC-BlackItalic-sup-sc-lgr--base.tfm \
tex-AlegreyaSC-BlackItalic-sup-sc-lgr.tfm \
tex-AlegreyaSC-BlackItalic-sup-sc-lgr.vf \
tex-AlegreyaSC-BlackItalic-sup-sc-ly1--base.tfm \
tex-AlegreyaSC-BlackItalic-sup-sc-ly1.tfm \
tex-AlegreyaSC-BlackItalic-sup-sc-ly1.vf \
tex-AlegreyaSC-BlackItalic-sup-sc-ot1.tfm \
tex-AlegreyaSC-BlackItalic-sup-sc-t1--base.tfm \
tex-AlegreyaSC-BlackItalic-sup-sc-t1.tfm \
tex-AlegreyaSC-BlackItalic-sup-sc-t1.vf \
tex-AlegreyaSC-BlackItalic-tlf-sc-lgr--base.tfm \
tex-AlegreyaSC-BlackItalic-tlf-sc-lgr.tfm \
tex-AlegreyaSC-BlackItalic-tlf-sc-lgr.vf \
tex-AlegreyaSC-BlackItalic-tlf-sc-ly1--base.tfm \
tex-AlegreyaSC-BlackItalic-tlf-sc-ly1.tfm \
tex-AlegreyaSC-BlackItalic-tlf-sc-ly1.vf \
tex-AlegreyaSC-BlackItalic-tlf-sc-ot1.tfm \
tex-AlegreyaSC-BlackItalic-tlf-sc-t1--base.tfm \
tex-AlegreyaSC-BlackItalic-tlf-sc-t1.tfm \
tex-AlegreyaSC-BlackItalic-tlf-sc-t1.vf \
tex-AlegreyaSC-BlackItalic-tosf-sc-lgr--base.tfm \
tex-AlegreyaSC-BlackItalic-tosf-sc-lgr.tfm \
tex-AlegreyaSC-BlackItalic-tosf-sc-lgr.vf \
tex-AlegreyaSC-BlackItalic-tosf-sc-ly1--base.tfm \
tex-AlegreyaSC-BlackItalic-tosf-sc-ly1.tfm \
tex-AlegreyaSC-BlackItalic-tosf-sc-ly1.vf \
tex-AlegreyaSC-BlackItalic-tosf-sc-ot1.tfm \
tex-AlegreyaSC-BlackItalic-tosf-sc-t1--base.tfm \
tex-AlegreyaSC-BlackItalic-tosf-sc-t1.tfm \
tex-AlegreyaSC-BlackItalic-tosf-sc-t1.vf \
tex-AlegreyaSC-Bold-inf-sc-lgr--base.tfm \
tex-AlegreyaSC-Bold-inf-sc-lgr.tfm \
tex-AlegreyaSC-Bold-inf-sc-lgr.vf \
tex-AlegreyaSC-Bold-inf-sc-ly1--base.tfm \
tex-AlegreyaSC-Bold-inf-sc-ly1.tfm \
tex-AlegreyaSC-Bold-inf-sc-ly1.vf \
tex-AlegreyaSC-Bold-inf-sc-ot1.tfm \
tex-AlegreyaSC-Bold-inf-sc-t1--base.tfm \
tex-AlegreyaSC-Bold-inf-sc-t1.tfm \
tex-AlegreyaSC-Bold-inf-sc-t1.vf \
tex-AlegreyaSC-Bold-lf-sc-lgr--base.tfm \
tex-AlegreyaSC-Bold-lf-sc-lgr.tfm \
tex-AlegreyaSC-Bold-lf-sc-lgr.vf \
tex-AlegreyaSC-Bold-lf-sc-ly1--base.tfm \
tex-AlegreyaSC-Bold-lf-sc-ly1.tfm \
tex-AlegreyaSC-Bold-lf-sc-ly1.vf \
tex-AlegreyaSC-Bold-lf-sc-ot1.tfm \
tex-AlegreyaSC-Bold-lf-sc-t1--base.tfm \
tex-AlegreyaSC-Bold-lf-sc-t1.tfm \
tex-AlegreyaSC-Bold-lf-sc-t1.vf \
tex-AlegreyaSC-Bold-osf-sc-lgr--base.tfm \
tex-AlegreyaSC-Bold-osf-sc-lgr.tfm \
tex-AlegreyaSC-Bold-osf-sc-lgr.vf \
tex-AlegreyaSC-Bold-osf-sc-ly1--base.tfm \
tex-AlegreyaSC-Bold-osf-sc-ly1.tfm \
tex-AlegreyaSC-Bold-osf-sc-ly1.vf \
tex-AlegreyaSC-Bold-osf-sc-ot1.tfm \
tex-AlegreyaSC-Bold-osf-sc-t1--base.tfm \
tex-AlegreyaSC-Bold-osf-sc-t1.tfm \
tex-AlegreyaSC-Bold-osf-sc-t1.vf \
tex-AlegreyaSC-Bold-sup-sc-lgr--base.tfm \
tex-AlegreyaSC-Bold-sup-sc-lgr.tfm \
tex-AlegreyaSC-Bold-sup-sc-lgr.vf \
tex-AlegreyaSC-Bold-sup-sc-ly1--base.tfm \
tex-AlegreyaSC-Bold-sup-sc-ly1.tfm \
tex-AlegreyaSC-Bold-sup-sc-ly1.vf \
tex-AlegreyaSC-Bold-sup-sc-ot1.tfm \
tex-AlegreyaSC-Bold-sup-sc-t1--base.tfm \
tex-AlegreyaSC-Bold-sup-sc-t1.tfm \
tex-AlegreyaSC-Bold-sup-sc-t1.vf \
tex-AlegreyaSC-Bold-tlf-sc-lgr--base.tfm \
tex-AlegreyaSC-Bold-tlf-sc-lgr.tfm \
tex-AlegreyaSC-Bold-tlf-sc-lgr.vf \
tex-AlegreyaSC-Bold-tlf-sc-ly1--base.tfm \
tex-AlegreyaSC-Bold-tlf-sc-ly1.tfm \
tex-AlegreyaSC-Bold-tlf-sc-ly1.vf \
tex-AlegreyaSC-Bold-tlf-sc-ot1.tfm \
tex-AlegreyaSC-Bold-tlf-sc-t1--base.tfm \
tex-AlegreyaSC-Bold-tlf-sc-t1.tfm \
tex-AlegreyaSC-Bold-tlf-sc-t1.vf \
tex-AlegreyaSC-Bold-tosf-sc-lgr--base.tfm \
tex-AlegreyaSC-Bold-tosf-sc-lgr.tfm \
tex-AlegreyaSC-Bold-tosf-sc-lgr.vf \
tex-AlegreyaSC-Bold-tosf-sc-ly1--base.tfm \
tex-AlegreyaSC-Bold-tosf-sc-ly1.tfm \
tex-AlegreyaSC-Bold-tosf-sc-ly1.vf \
tex-AlegreyaSC-Bold-tosf-sc-ot1.tfm \
tex-AlegreyaSC-Bold-tosf-sc-t1--base.tfm \
tex-AlegreyaSC-Bold-tosf-sc-t1.tfm \
tex-AlegreyaSC-Bold-tosf-sc-t1.vf \
tex-AlegreyaSC-BoldItalic-inf-sc-lgr--base.tfm \
tex-AlegreyaSC-BoldItalic-inf-sc-lgr.tfm \
tex-AlegreyaSC-BoldItalic-inf-sc-lgr.vf \
tex-AlegreyaSC-BoldItalic-inf-sc-ly1--base.tfm \
tex-AlegreyaSC-BoldItalic-inf-sc-ly1.tfm \
tex-AlegreyaSC-BoldItalic-inf-sc-ly1.vf \
tex-AlegreyaSC-BoldItalic-inf-sc-ot1.tfm \
tex-AlegreyaSC-BoldItalic-inf-sc-t1--base.tfm \
tex-AlegreyaSC-BoldItalic-inf-sc-t1.tfm \
tex-AlegreyaSC-BoldItalic-inf-sc-t1.vf \
tex-AlegreyaSC-BoldItalic-lf-sc-lgr--base.tfm \
tex-AlegreyaSC-BoldItalic-lf-sc-lgr.tfm \
tex-AlegreyaSC-BoldItalic-lf-sc-lgr.vf \
tex-AlegreyaSC-BoldItalic-lf-sc-ly1--base.tfm \
tex-AlegreyaSC-BoldItalic-lf-sc-ly1.tfm \
tex-AlegreyaSC-BoldItalic-lf-sc-ly1.vf \
tex-AlegreyaSC-BoldItalic-lf-sc-ot1.tfm \
tex-AlegreyaSC-BoldItalic-lf-sc-t1--base.tfm \
tex-AlegreyaSC-BoldItalic-lf-sc-t1.tfm \
tex-AlegreyaSC-BoldItalic-lf-sc-t1.vf \
tex-AlegreyaSC-BoldItalic-osf-sc-lgr--base.tfm \
tex-AlegreyaSC-BoldItalic-osf-sc-lgr.tfm \
tex-AlegreyaSC-BoldItalic-osf-sc-lgr.vf \
tex-AlegreyaSC-BoldItalic-osf-sc-ly1--base.tfm \
tex-AlegreyaSC-BoldItalic-osf-sc-ly1.tfm \
tex-AlegreyaSC-BoldItalic-osf-sc-ly1.vf \
tex-AlegreyaSC-BoldItalic-osf-sc-ot1.tfm \
tex-AlegreyaSC-BoldItalic-osf-sc-t1--base.tfm \
tex-AlegreyaSC-BoldItalic-osf-sc-t1.tfm \
tex-AlegreyaSC-BoldItalic-osf-sc-t1.vf \
tex-AlegreyaSC-BoldItalic-sup-sc-lgr--base.tfm \
tex-AlegreyaSC-BoldItalic-sup-sc-lgr.tfm \
tex-AlegreyaSC-BoldItalic-sup-sc-lgr.vf \
tex-AlegreyaSC-BoldItalic-sup-sc-ly1--base.tfm \
tex-AlegreyaSC-BoldItalic-sup-sc-ly1.tfm \
tex-AlegreyaSC-BoldItalic-sup-sc-ly1.vf \
tex-AlegreyaSC-BoldItalic-sup-sc-ot1.tfm \
tex-AlegreyaSC-BoldItalic-sup-sc-t1--base.tfm \
tex-AlegreyaSC-BoldItalic-sup-sc-t1.tfm \
tex-AlegreyaSC-BoldItalic-sup-sc-t1.vf \
tex-AlegreyaSC-BoldItalic-tlf-sc-lgr--base.tfm \
tex-AlegreyaSC-BoldItalic-tlf-sc-lgr.tfm \
tex-AlegreyaSC-BoldItalic-tlf-sc-lgr.vf \
tex-AlegreyaSC-BoldItalic-tlf-sc-ly1--base.tfm \
tex-AlegreyaSC-BoldItalic-tlf-sc-ly1.tfm \
tex-AlegreyaSC-BoldItalic-tlf-sc-ly1.vf \
tex-AlegreyaSC-BoldItalic-tlf-sc-ot1.tfm \
tex-AlegreyaSC-BoldItalic-tlf-sc-t1--base.tfm \
tex-AlegreyaSC-BoldItalic-tlf-sc-t1.tfm \
tex-AlegreyaSC-BoldItalic-tlf-sc-t1.vf \
tex-AlegreyaSC-BoldItalic-tosf-sc-lgr--base.tfm \
tex-AlegreyaSC-BoldItalic-tosf-sc-lgr.tfm \
tex-AlegreyaSC-BoldItalic-tosf-sc-lgr.vf \
tex-AlegreyaSC-BoldItalic-tosf-sc-ly1--base.tfm \
tex-AlegreyaSC-BoldItalic-tosf-sc-ly1.tfm \
tex-AlegreyaSC-BoldItalic-tosf-sc-ly1.vf \
tex-AlegreyaSC-BoldItalic-tosf-sc-ot1.tfm \
tex-AlegreyaSC-BoldItalic-tosf-sc-t1--base.tfm \
tex-AlegreyaSC-BoldItalic-tosf-sc-t1.tfm \
tex-AlegreyaSC-BoldItalic-tosf-sc-t1.vf \
tex-AlegreyaSC-ExtraBold-inf-sc-lgr--base.tfm \
tex-AlegreyaSC-ExtraBold-inf-sc-lgr.tfm \
tex-AlegreyaSC-ExtraBold-inf-sc-lgr.vf \
tex-AlegreyaSC-ExtraBold-inf-sc-ly1--base.tfm \
tex-AlegreyaSC-ExtraBold-inf-sc-ly1.tfm \
tex-AlegreyaSC-ExtraBold-inf-sc-ly1.vf \
tex-AlegreyaSC-ExtraBold-inf-sc-ot1.tfm \
tex-AlegreyaSC-ExtraBold-inf-sc-t1--base.tfm \
tex-AlegreyaSC-ExtraBold-inf-sc-t1.tfm \
tex-AlegreyaSC-ExtraBold-inf-sc-t1.vf \
tex-AlegreyaSC-ExtraBold-lf-sc-lgr--base.tfm \
tex-AlegreyaSC-ExtraBold-lf-sc-lgr.tfm \
tex-AlegreyaSC-ExtraBold-lf-sc-lgr.vf \
tex-AlegreyaSC-ExtraBold-lf-sc-ly1--base.tfm \
tex-AlegreyaSC-ExtraBold-lf-sc-ly1.tfm \
tex-AlegreyaSC-ExtraBold-lf-sc-ly1.vf \
tex-AlegreyaSC-ExtraBold-lf-sc-ot1.tfm \
tex-AlegreyaSC-ExtraBold-lf-sc-t1--base.tfm \
tex-AlegreyaSC-ExtraBold-lf-sc-t1.tfm \
tex-AlegreyaSC-ExtraBold-lf-sc-t1.vf \
tex-AlegreyaSC-ExtraBold-osf-sc-lgr--base.tfm \
tex-AlegreyaSC-ExtraBold-osf-sc-lgr.tfm \
tex-AlegreyaSC-ExtraBold-osf-sc-lgr.vf \
tex-AlegreyaSC-ExtraBold-osf-sc-ly1--base.tfm \
tex-AlegreyaSC-ExtraBold-osf-sc-ly1.tfm \
tex-AlegreyaSC-ExtraBold-osf-sc-ly1.vf \
tex-AlegreyaSC-ExtraBold-osf-sc-ot1.tfm \
tex-AlegreyaSC-ExtraBold-osf-sc-t1--base.tfm \
tex-AlegreyaSC-ExtraBold-osf-sc-t1.tfm \
tex-AlegreyaSC-ExtraBold-osf-sc-t1.vf \
tex-AlegreyaSC-ExtraBold-sup-sc-lgr--base.tfm \
tex-AlegreyaSC-ExtraBold-sup-sc-lgr.tfm \
tex-AlegreyaSC-ExtraBold-sup-sc-lgr.vf \
tex-AlegreyaSC-ExtraBold-sup-sc-ly1--base.tfm \
tex-AlegreyaSC-ExtraBold-sup-sc-ly1.tfm \
tex-AlegreyaSC-ExtraBold-sup-sc-ly1.vf \
tex-AlegreyaSC-ExtraBold-sup-sc-ot1.tfm \
tex-AlegreyaSC-ExtraBold-sup-sc-t1--base.tfm \
tex-AlegreyaSC-ExtraBold-sup-sc-t1.tfm \
tex-AlegreyaSC-ExtraBold-sup-sc-t1.vf \
tex-AlegreyaSC-ExtraBold-tlf-sc-lgr--base.tfm \
tex-AlegreyaSC-ExtraBold-tlf-sc-lgr.tfm \
tex-AlegreyaSC-ExtraBold-tlf-sc-lgr.vf \
tex-AlegreyaSC-ExtraBold-tlf-sc-ly1--base.tfm \
tex-AlegreyaSC-ExtraBold-tlf-sc-ly1.tfm \
tex-AlegreyaSC-ExtraBold-tlf-sc-ly1.vf \
tex-AlegreyaSC-ExtraBold-tlf-sc-ot1.tfm \
tex-AlegreyaSC-ExtraBold-tlf-sc-t1--base.tfm \
tex-AlegreyaSC-ExtraBold-tlf-sc-t1.tfm \
tex-AlegreyaSC-ExtraBold-tlf-sc-t1.vf \
tex-AlegreyaSC-ExtraBold-tosf-sc-lgr--base.tfm \
tex-AlegreyaSC-ExtraBold-tosf-sc-lgr.tfm \
tex-AlegreyaSC-ExtraBold-tosf-sc-lgr.vf \
tex-AlegreyaSC-ExtraBold-tosf-sc-ly1--base.tfm \
tex-AlegreyaSC-ExtraBold-tosf-sc-ly1.tfm \
tex-AlegreyaSC-ExtraBold-tosf-sc-ly1.vf \
tex-AlegreyaSC-ExtraBold-tosf-sc-ot1.tfm \
tex-AlegreyaSC-ExtraBold-tosf-sc-t1--base.tfm \
tex-AlegreyaSC-ExtraBold-tosf-sc-t1.tfm \
tex-AlegreyaSC-ExtraBold-tosf-sc-t1.vf \
tex-AlegreyaSC-ExtraBoldItalic-inf-sc-lgr--base.tfm \
tex-AlegreyaSC-ExtraBoldItalic-inf-sc-lgr.tfm \
tex-AlegreyaSC-ExtraBoldItalic-inf-sc-lgr.vf \
tex-AlegreyaSC-ExtraBoldItalic-inf-sc-ly1--base.tfm \
tex-AlegreyaSC-ExtraBoldItalic-inf-sc-ly1.tfm \
tex-AlegreyaSC-ExtraBoldItalic-inf-sc-ly1.vf \
tex-AlegreyaSC-ExtraBoldItalic-inf-sc-ot1.tfm \
tex-AlegreyaSC-ExtraBoldItalic-inf-sc-t1--base.tfm \
tex-AlegreyaSC-ExtraBoldItalic-inf-sc-t1.tfm \
tex-AlegreyaSC-ExtraBoldItalic-inf-sc-t1.vf \
tex-AlegreyaSC-ExtraBoldItalic-lf-sc-lgr--base.tfm \
tex-AlegreyaSC-ExtraBoldItalic-lf-sc-lgr.tfm \
tex-AlegreyaSC-ExtraBoldItalic-lf-sc-lgr.vf \
tex-AlegreyaSC-ExtraBoldItalic-lf-sc-ly1--base.tfm \
tex-AlegreyaSC-ExtraBoldItalic-lf-sc-ly1.tfm \
tex-AlegreyaSC-ExtraBoldItalic-lf-sc-ly1.vf \
tex-AlegreyaSC-ExtraBoldItalic-lf-sc-ot1.tfm \
tex-AlegreyaSC-ExtraBoldItalic-lf-sc-t1--base.tfm \
tex-AlegreyaSC-ExtraBoldItalic-lf-sc-t1.tfm \
tex-AlegreyaSC-ExtraBoldItalic-lf-sc-t1.vf \
tex-AlegreyaSC-ExtraBoldItalic-osf-sc-lgr--base.tfm \
tex-AlegreyaSC-ExtraBoldItalic-osf-sc-lgr.tfm \
tex-AlegreyaSC-ExtraBoldItalic-osf-sc-lgr.vf \
tex-AlegreyaSC-ExtraBoldItalic-osf-sc-ly1--base.tfm \
tex-AlegreyaSC-ExtraBoldItalic-osf-sc-ly1.tfm \
tex-AlegreyaSC-ExtraBoldItalic-osf-sc-ly1.vf \
tex-AlegreyaSC-ExtraBoldItalic-osf-sc-ot1.tfm \
tex-AlegreyaSC-ExtraBoldItalic-osf-sc-t1--base.tfm \
tex-AlegreyaSC-ExtraBoldItalic-osf-sc-t1.tfm \
tex-AlegreyaSC-ExtraBoldItalic-osf-sc-t1.vf \
tex-AlegreyaSC-ExtraBoldItalic-sup-sc-lgr--base.tfm \
tex-AlegreyaSC-ExtraBoldItalic-sup-sc-lgr.tfm \
tex-AlegreyaSC-ExtraBoldItalic-sup-sc-lgr.vf \
tex-AlegreyaSC-ExtraBoldItalic-sup-sc-ly1--base.tfm \
tex-AlegreyaSC-ExtraBoldItalic-sup-sc-ly1.tfm \
tex-AlegreyaSC-ExtraBoldItalic-sup-sc-ly1.vf \
tex-AlegreyaSC-ExtraBoldItalic-sup-sc-ot1.tfm \
tex-AlegreyaSC-ExtraBoldItalic-sup-sc-t1--base.tfm \
tex-AlegreyaSC-ExtraBoldItalic-sup-sc-t1.tfm \
tex-AlegreyaSC-ExtraBoldItalic-sup-sc-t1.vf \
tex-AlegreyaSC-ExtraBoldItalic-tlf-sc-lgr--base.tfm \
tex-AlegreyaSC-ExtraBoldItalic-tlf-sc-lgr.tfm \
tex-AlegreyaSC-ExtraBoldItalic-tlf-sc-lgr.vf \
tex-AlegreyaSC-ExtraBoldItalic-tlf-sc-ly1--base.tfm \
tex-AlegreyaSC-ExtraBoldItalic-tlf-sc-ly1.tfm \
tex-AlegreyaSC-ExtraBoldItalic-tlf-sc-ly1.vf \
tex-AlegreyaSC-ExtraBoldItalic-tlf-sc-ot1.tfm \
tex-AlegreyaSC-ExtraBoldItalic-tlf-sc-t1--base.tfm \
tex-AlegreyaSC-ExtraBoldItalic-tlf-sc-t1.tfm \
tex-AlegreyaSC-ExtraBoldItalic-tlf-sc-t1.vf \
tex-AlegreyaSC-ExtraBoldItalic-tosf-sc-lgr--base.tfm \
tex-AlegreyaSC-ExtraBoldItalic-tosf-sc-lgr.tfm \
tex-AlegreyaSC-ExtraBoldItalic-tosf-sc-lgr.vf \
tex-AlegreyaSC-ExtraBoldItalic-tosf-sc-ly1--base.tfm \
tex-AlegreyaSC-ExtraBoldItalic-tosf-sc-ly1.tfm \
tex-AlegreyaSC-ExtraBoldItalic-tosf-sc-ly1.vf \
tex-AlegreyaSC-ExtraBoldItalic-tosf-sc-ot1.tfm \
tex-AlegreyaSC-ExtraBoldItalic-tosf-sc-t1--base.tfm \
tex-AlegreyaSC-ExtraBoldItalic-tosf-sc-t1.tfm \
tex-AlegreyaSC-ExtraBoldItalic-tosf-sc-t1.vf \
tex-AlegreyaSC-Italic-inf-sc-lgr--base.tfm \
tex-AlegreyaSC-Italic-inf-sc-lgr.tfm \
tex-AlegreyaSC-Italic-inf-sc-lgr.vf \
tex-AlegreyaSC-Italic-inf-sc-ly1--base.tfm \
tex-AlegreyaSC-Italic-inf-sc-ly1.tfm \
tex-AlegreyaSC-Italic-inf-sc-ly1.vf \
tex-AlegreyaSC-Italic-inf-sc-ot1.tfm \
tex-AlegreyaSC-Italic-inf-sc-t1--base.tfm \
tex-AlegreyaSC-Italic-inf-sc-t1.tfm \
tex-AlegreyaSC-Italic-inf-sc-t1.vf \
tex-AlegreyaSC-Italic-lf-sc-lgr--base.tfm \
tex-AlegreyaSC-Italic-lf-sc-lgr.tfm \
tex-AlegreyaSC-Italic-lf-sc-lgr.vf \
tex-AlegreyaSC-Italic-lf-sc-ly1--base.tfm \
tex-AlegreyaSC-Italic-lf-sc-ly1.tfm \
tex-AlegreyaSC-Italic-lf-sc-ly1.vf \
tex-AlegreyaSC-Italic-lf-sc-ot1.tfm \
tex-AlegreyaSC-Italic-lf-sc-t1--base.tfm \
tex-AlegreyaSC-Italic-lf-sc-t1.tfm \
tex-AlegreyaSC-Italic-lf-sc-t1.vf \
tex-AlegreyaSC-Italic-osf-sc-lgr--base.tfm \
tex-AlegreyaSC-Italic-osf-sc-lgr.tfm \
tex-AlegreyaSC-Italic-osf-sc-lgr.vf \
tex-AlegreyaSC-Italic-osf-sc-ly1--base.tfm \
tex-AlegreyaSC-Italic-osf-sc-ly1.tfm \
tex-AlegreyaSC-Italic-osf-sc-ly1.vf \
tex-AlegreyaSC-Italic-osf-sc-ot1.tfm \
tex-AlegreyaSC-Italic-osf-sc-t1--base.tfm \
tex-AlegreyaSC-Italic-osf-sc-t1.tfm \
tex-AlegreyaSC-Italic-osf-sc-t1.vf \
tex-AlegreyaSC-Italic-sup-sc-lgr--base.tfm \
tex-AlegreyaSC-Italic-sup-sc-lgr.tfm \
tex-AlegreyaSC-Italic-sup-sc-lgr.vf \
tex-AlegreyaSC-Italic-sup-sc-ly1--base.tfm \
tex-AlegreyaSC-Italic-sup-sc-ly1.tfm \
tex-AlegreyaSC-Italic-sup-sc-ly1.vf \
tex-AlegreyaSC-Italic-sup-sc-ot1.tfm \
tex-AlegreyaSC-Italic-sup-sc-t1--base.tfm \
tex-AlegreyaSC-Italic-sup-sc-t1.tfm \
tex-AlegreyaSC-Italic-sup-sc-t1.vf \
tex-AlegreyaSC-Italic-tlf-sc-lgr--base.tfm \
tex-AlegreyaSC-Italic-tlf-sc-lgr.tfm \
tex-AlegreyaSC-Italic-tlf-sc-lgr.vf \
tex-AlegreyaSC-Italic-tlf-sc-ly1--base.tfm \
tex-AlegreyaSC-Italic-tlf-sc-ly1.tfm \
tex-AlegreyaSC-Italic-tlf-sc-ly1.vf \
tex-AlegreyaSC-Italic-tlf-sc-ot1.tfm \
tex-AlegreyaSC-Italic-tlf-sc-t1--base.tfm \
tex-AlegreyaSC-Italic-tlf-sc-t1.tfm \
tex-AlegreyaSC-Italic-tlf-sc-t1.vf \
tex-AlegreyaSC-Italic-tosf-sc-lgr--base.tfm \
tex-AlegreyaSC-Italic-tosf-sc-lgr.tfm \
tex-AlegreyaSC-Italic-tosf-sc-lgr.vf \
tex-AlegreyaSC-Italic-tosf-sc-ly1--base.tfm \
tex-AlegreyaSC-Italic-tosf-sc-ly1.tfm \
tex-AlegreyaSC-Italic-tosf-sc-ly1.vf \
tex-AlegreyaSC-Italic-tosf-sc-ot1.tfm \
tex-AlegreyaSC-Italic-tosf-sc-t1--base.tfm \
tex-AlegreyaSC-Italic-tosf-sc-t1.tfm \
tex-AlegreyaSC-Italic-tosf-sc-t1.vf \
tex-AlegreyaSC-Medium-inf-sc-lgr--base.tfm \
tex-AlegreyaSC-Medium-inf-sc-lgr.tfm \
tex-AlegreyaSC-Medium-inf-sc-lgr.vf \
tex-AlegreyaSC-Medium-inf-sc-ly1--base.tfm \
tex-AlegreyaSC-Medium-inf-sc-ly1.tfm \
tex-AlegreyaSC-Medium-inf-sc-ly1.vf \
tex-AlegreyaSC-Medium-inf-sc-ot1.tfm \
tex-AlegreyaSC-Medium-inf-sc-t1--base.tfm \
tex-AlegreyaSC-Medium-inf-sc-t1.tfm \
tex-AlegreyaSC-Medium-inf-sc-t1.vf \
tex-AlegreyaSC-Medium-lf-sc-lgr--base.tfm \
tex-AlegreyaSC-Medium-lf-sc-lgr.tfm \
tex-AlegreyaSC-Medium-lf-sc-lgr.vf \
tex-AlegreyaSC-Medium-lf-sc-ly1--base.tfm \
tex-AlegreyaSC-Medium-lf-sc-ly1.tfm \
tex-AlegreyaSC-Medium-lf-sc-ly1.vf \
tex-AlegreyaSC-Medium-lf-sc-ot1.tfm \
tex-AlegreyaSC-Medium-lf-sc-t1--base.tfm \
tex-AlegreyaSC-Medium-lf-sc-t1.tfm \
tex-AlegreyaSC-Medium-lf-sc-t1.vf \
tex-AlegreyaSC-Medium-osf-sc-lgr--base.tfm \
tex-AlegreyaSC-Medium-osf-sc-lgr.tfm \
tex-AlegreyaSC-Medium-osf-sc-lgr.vf \
tex-AlegreyaSC-Medium-osf-sc-ly1--base.tfm \
tex-AlegreyaSC-Medium-osf-sc-ly1.tfm \
tex-AlegreyaSC-Medium-osf-sc-ly1.vf \
tex-AlegreyaSC-Medium-osf-sc-ot1.tfm \
tex-AlegreyaSC-Medium-osf-sc-t1--base.tfm \
tex-AlegreyaSC-Medium-osf-sc-t1.tfm \
tex-AlegreyaSC-Medium-osf-sc-t1.vf \
tex-AlegreyaSC-Medium-sup-sc-lgr--base.tfm \
tex-AlegreyaSC-Medium-sup-sc-lgr.tfm \
tex-AlegreyaSC-Medium-sup-sc-lgr.vf \
tex-AlegreyaSC-Medium-sup-sc-ly1--base.tfm \
tex-AlegreyaSC-Medium-sup-sc-ly1.tfm \
tex-AlegreyaSC-Medium-sup-sc-ly1.vf \
tex-AlegreyaSC-Medium-sup-sc-ot1.tfm \
tex-AlegreyaSC-Medium-sup-sc-t1--base.tfm \
tex-AlegreyaSC-Medium-sup-sc-t1.tfm \
tex-AlegreyaSC-Medium-sup-sc-t1.vf \
tex-AlegreyaSC-Medium-tlf-sc-lgr--base.tfm \
tex-AlegreyaSC-Medium-tlf-sc-lgr.tfm \
tex-AlegreyaSC-Medium-tlf-sc-lgr.vf \
tex-AlegreyaSC-Medium-tlf-sc-ly1--base.tfm \
tex-AlegreyaSC-Medium-tlf-sc-ly1.tfm \
tex-AlegreyaSC-Medium-tlf-sc-ly1.vf \
tex-AlegreyaSC-Medium-tlf-sc-ot1.tfm \
tex-AlegreyaSC-Medium-tlf-sc-t1--base.tfm \
tex-AlegreyaSC-Medium-tlf-sc-t1.tfm \
tex-AlegreyaSC-Medium-tlf-sc-t1.vf \
tex-AlegreyaSC-Medium-tosf-sc-lgr--base.tfm \
tex-AlegreyaSC-Medium-tosf-sc-lgr.tfm \
tex-AlegreyaSC-Medium-tosf-sc-lgr.vf \
tex-AlegreyaSC-Medium-tosf-sc-ly1--base.tfm \
tex-AlegreyaSC-Medium-tosf-sc-ly1.tfm \
tex-AlegreyaSC-Medium-tosf-sc-ly1.vf \
tex-AlegreyaSC-Medium-tosf-sc-ot1.tfm \
tex-AlegreyaSC-Medium-tosf-sc-t1--base.tfm \
tex-AlegreyaSC-Medium-tosf-sc-t1.tfm \
tex-AlegreyaSC-Medium-tosf-sc-t1.vf \
tex-AlegreyaSC-MediumItalic-inf-sc-lgr--base.tfm \
tex-AlegreyaSC-MediumItalic-inf-sc-lgr.tfm \
tex-AlegreyaSC-MediumItalic-inf-sc-lgr.vf \
tex-AlegreyaSC-MediumItalic-inf-sc-ly1--base.tfm \
tex-AlegreyaSC-MediumItalic-inf-sc-ly1.tfm \
tex-AlegreyaSC-MediumItalic-inf-sc-ly1.vf \
tex-AlegreyaSC-MediumItalic-inf-sc-ot1.tfm \
tex-AlegreyaSC-MediumItalic-inf-sc-t1--base.tfm \
tex-AlegreyaSC-MediumItalic-inf-sc-t1.tfm \
tex-AlegreyaSC-MediumItalic-inf-sc-t1.vf \
tex-AlegreyaSC-MediumItalic-lf-sc-lgr--base.tfm \
tex-AlegreyaSC-MediumItalic-lf-sc-lgr.tfm \
tex-AlegreyaSC-MediumItalic-lf-sc-lgr.vf \
tex-AlegreyaSC-MediumItalic-lf-sc-ly1--base.tfm \
tex-AlegreyaSC-MediumItalic-lf-sc-ly1.tfm \
tex-AlegreyaSC-MediumItalic-lf-sc-ly1.vf \
tex-AlegreyaSC-MediumItalic-lf-sc-ot1.tfm \
tex-AlegreyaSC-MediumItalic-lf-sc-t1--base.tfm \
tex-AlegreyaSC-MediumItalic-lf-sc-t1.tfm \
tex-AlegreyaSC-MediumItalic-lf-sc-t1.vf \
tex-AlegreyaSC-MediumItalic-osf-sc-lgr--base.tfm \
tex-AlegreyaSC-MediumItalic-osf-sc-lgr.tfm \
tex-AlegreyaSC-MediumItalic-osf-sc-lgr.vf \
tex-AlegreyaSC-MediumItalic-osf-sc-ly1--base.tfm \
tex-AlegreyaSC-MediumItalic-osf-sc-ly1.tfm \
tex-AlegreyaSC-MediumItalic-osf-sc-ly1.vf \
tex-AlegreyaSC-MediumItalic-osf-sc-ot1.tfm \
tex-AlegreyaSC-MediumItalic-osf-sc-t1--base.tfm \
tex-AlegreyaSC-MediumItalic-osf-sc-t1.tfm \
tex-AlegreyaSC-MediumItalic-osf-sc-t1.vf \
tex-AlegreyaSC-MediumItalic-sup-sc-lgr--base.tfm \
tex-AlegreyaSC-MediumItalic-sup-sc-lgr.tfm \
tex-AlegreyaSC-MediumItalic-sup-sc-lgr.vf \
tex-AlegreyaSC-MediumItalic-sup-sc-ly1--base.tfm \
tex-AlegreyaSC-MediumItalic-sup-sc-ly1.tfm \
tex-AlegreyaSC-MediumItalic-sup-sc-ly1.vf \
tex-AlegreyaSC-MediumItalic-sup-sc-ot1.tfm \
tex-AlegreyaSC-MediumItalic-sup-sc-t1--base.tfm \
tex-AlegreyaSC-MediumItalic-sup-sc-t1.tfm \
tex-AlegreyaSC-MediumItalic-sup-sc-t1.vf \
tex-AlegreyaSC-MediumItalic-tlf-sc-lgr--base.tfm \
tex-AlegreyaSC-MediumItalic-tlf-sc-lgr.tfm \
tex-AlegreyaSC-MediumItalic-tlf-sc-lgr.vf \
tex-AlegreyaSC-MediumItalic-tlf-sc-ly1--base.tfm \
tex-AlegreyaSC-MediumItalic-tlf-sc-ly1.tfm \
tex-AlegreyaSC-MediumItalic-tlf-sc-ly1.vf \
tex-AlegreyaSC-MediumItalic-tlf-sc-ot1.tfm \
tex-AlegreyaSC-MediumItalic-tlf-sc-t1--base.tfm \
tex-AlegreyaSC-MediumItalic-tlf-sc-t1.tfm \
tex-AlegreyaSC-MediumItalic-tlf-sc-t1.vf \
tex-AlegreyaSC-MediumItalic-tosf-sc-lgr--base.tfm \
tex-AlegreyaSC-MediumItalic-tosf-sc-lgr.tfm \
tex-AlegreyaSC-MediumItalic-tosf-sc-lgr.vf \
tex-AlegreyaSC-MediumItalic-tosf-sc-ly1--base.tfm \
tex-AlegreyaSC-MediumItalic-tosf-sc-ly1.tfm \
tex-AlegreyaSC-MediumItalic-tosf-sc-ly1.vf \
tex-AlegreyaSC-MediumItalic-tosf-sc-ot1.tfm \
tex-AlegreyaSC-MediumItalic-tosf-sc-t1--base.tfm \
tex-AlegreyaSC-MediumItalic-tosf-sc-t1.tfm \
tex-AlegreyaSC-MediumItalic-tosf-sc-t1.vf \
tex-AlegreyaSC-Regular-inf-sc-lgr--base.tfm \
tex-AlegreyaSC-Regular-inf-sc-lgr.tfm \
tex-AlegreyaSC-Regular-inf-sc-lgr.vf \
tex-AlegreyaSC-Regular-inf-sc-ly1--base.tfm \
tex-AlegreyaSC-Regular-inf-sc-ly1.tfm \
tex-AlegreyaSC-Regular-inf-sc-ly1.vf \
tex-AlegreyaSC-Regular-inf-sc-ot1.tfm \
tex-AlegreyaSC-Regular-inf-sc-t1--base.tfm \
tex-AlegreyaSC-Regular-inf-sc-t1.tfm \
tex-AlegreyaSC-Regular-inf-sc-t1.vf \
tex-AlegreyaSC-Regular-lf-sc-lgr--base.tfm \
tex-AlegreyaSC-Regular-lf-sc-lgr.tfm \
tex-AlegreyaSC-Regular-lf-sc-lgr.vf \
tex-AlegreyaSC-Regular-lf-sc-ly1--base.tfm \
tex-AlegreyaSC-Regular-lf-sc-ly1.tfm \
tex-AlegreyaSC-Regular-lf-sc-ly1.vf \
tex-AlegreyaSC-Regular-lf-sc-ot1.tfm \
tex-AlegreyaSC-Regular-lf-sc-t1--base.tfm \
tex-AlegreyaSC-Regular-lf-sc-t1.tfm \
tex-AlegreyaSC-Regular-lf-sc-t1.vf \
tex-AlegreyaSC-Regular-osf-sc-lgr--base.tfm \
tex-AlegreyaSC-Regular-osf-sc-lgr.tfm \
tex-AlegreyaSC-Regular-osf-sc-lgr.vf \
tex-AlegreyaSC-Regular-osf-sc-ly1--base.tfm \
tex-AlegreyaSC-Regular-osf-sc-ly1.tfm \
tex-AlegreyaSC-Regular-osf-sc-ly1.vf \
tex-AlegreyaSC-Regular-osf-sc-ot1.tfm \
tex-AlegreyaSC-Regular-osf-sc-t1--base.tfm \
tex-AlegreyaSC-Regular-osf-sc-t1.tfm \
tex-AlegreyaSC-Regular-osf-sc-t1.vf \
tex-AlegreyaSC-Regular-sup-sc-lgr--base.tfm \
tex-AlegreyaSC-Regular-sup-sc-lgr.tfm \
tex-AlegreyaSC-Regular-sup-sc-lgr.vf \
tex-AlegreyaSC-Regular-sup-sc-ly1--base.tfm \
tex-AlegreyaSC-Regular-sup-sc-ly1.tfm \
tex-AlegreyaSC-Regular-sup-sc-ly1.vf \
tex-AlegreyaSC-Regular-sup-sc-ot1.tfm \
tex-AlegreyaSC-Regular-sup-sc-t1--base.tfm \
tex-AlegreyaSC-Regular-sup-sc-t1.tfm \
tex-AlegreyaSC-Regular-sup-sc-t1.vf \
tex-AlegreyaSC-Regular-tlf-sc-lgr--base.tfm \
tex-AlegreyaSC-Regular-tlf-sc-lgr.tfm \
tex-AlegreyaSC-Regular-tlf-sc-lgr.vf \
tex-AlegreyaSC-Regular-tlf-sc-ly1--base.tfm \
tex-AlegreyaSC-Regular-tlf-sc-ly1.tfm \
tex-AlegreyaSC-Regular-tlf-sc-ly1.vf \
tex-AlegreyaSC-Regular-tlf-sc-ot1.tfm \
tex-AlegreyaSC-Regular-tlf-sc-t1--base.tfm \
tex-AlegreyaSC-Regular-tlf-sc-t1.tfm \
tex-AlegreyaSC-Regular-tlf-sc-t1.vf \
tex-AlegreyaSC-Regular-tosf-sc-lgr--base.tfm \
tex-AlegreyaSC-Regular-tosf-sc-lgr.tfm \
tex-AlegreyaSC-Regular-tosf-sc-lgr.vf \
tex-AlegreyaSC-Regular-tosf-sc-ly1--base.tfm \
tex-AlegreyaSC-Regular-tosf-sc-ly1.tfm \
tex-AlegreyaSC-Regular-tosf-sc-ly1.vf \
tex-AlegreyaSC-Regular-tosf-sc-ot1.tfm \
tex-AlegreyaSC-Regular-tosf-sc-t1--base.tfm \
tex-AlegreyaSC-Regular-tosf-sc-t1.tfm \
tex-AlegreyaSC-Regular-tosf-sc-t1.vf \
tex-AlegreyaSans-Black-inf-lgr--base.tfm \
tex-AlegreyaSans-Black-inf-lgr.tfm \
tex-AlegreyaSans-Black-inf-lgr.vf \
tex-AlegreyaSans-Black-inf-ly1--base.tfm \
tex-AlegreyaSans-Black-inf-ly1.tfm \
tex-AlegreyaSans-Black-inf-ly1.vf \
tex-AlegreyaSans-Black-inf-ot1.tfm \
tex-AlegreyaSans-Black-inf-t1--base.tfm \
tex-AlegreyaSans-Black-inf-t1.tfm \
tex-AlegreyaSans-Black-inf-t1.vf \
tex-AlegreyaSans-Black-lf-lgr--base.tfm \
tex-AlegreyaSans-Black-lf-lgr.tfm \
tex-AlegreyaSans-Black-lf-lgr.vf \
tex-AlegreyaSans-Black-lf-ly1--base.tfm \
tex-AlegreyaSans-Black-lf-ly1.tfm \
tex-AlegreyaSans-Black-lf-ly1.vf \
tex-AlegreyaSans-Black-lf-ot1.tfm \
tex-AlegreyaSans-Black-lf-sc-lgr--base.tfm \
tex-AlegreyaSans-Black-lf-sc-lgr.tfm \
tex-AlegreyaSans-Black-lf-sc-lgr.vf \
tex-AlegreyaSans-Black-lf-sc-ly1--base.tfm \
tex-AlegreyaSans-Black-lf-sc-ly1.tfm \
tex-AlegreyaSans-Black-lf-sc-ly1.vf \
tex-AlegreyaSans-Black-lf-sc-ot1--base.tfm \
tex-AlegreyaSans-Black-lf-sc-ot1.tfm \
tex-AlegreyaSans-Black-lf-sc-ot1.vf \
tex-AlegreyaSans-Black-lf-sc-t1--base.tfm \
tex-AlegreyaSans-Black-lf-sc-t1.tfm \
tex-AlegreyaSans-Black-lf-sc-t1.vf \
tex-AlegreyaSans-Black-lf-t1--base.tfm \
tex-AlegreyaSans-Black-lf-t1.tfm \
tex-AlegreyaSans-Black-lf-t1.vf \
tex-AlegreyaSans-Black-lf-ts1--base.tfm \
tex-AlegreyaSans-Black-lf-ts1.tfm \
tex-AlegreyaSans-Black-lf-ts1.vf \
tex-AlegreyaSans-Black-osf-lgr--base.tfm \
tex-AlegreyaSans-Black-osf-lgr.tfm \
tex-AlegreyaSans-Black-osf-lgr.vf \
tex-AlegreyaSans-Black-osf-ly1--base.tfm \
tex-AlegreyaSans-Black-osf-ly1.tfm \
tex-AlegreyaSans-Black-osf-ly1.vf \
tex-AlegreyaSans-Black-osf-ot1.tfm \
tex-AlegreyaSans-Black-osf-sc-lgr--base.tfm \
tex-AlegreyaSans-Black-osf-sc-lgr.tfm \
tex-AlegreyaSans-Black-osf-sc-lgr.vf \
tex-AlegreyaSans-Black-osf-sc-ly1--base.tfm \
tex-AlegreyaSans-Black-osf-sc-ly1.tfm \
tex-AlegreyaSans-Black-osf-sc-ly1.vf \
tex-AlegreyaSans-Black-osf-sc-ot1--base.tfm \
tex-AlegreyaSans-Black-osf-sc-ot1.tfm \
tex-AlegreyaSans-Black-osf-sc-ot1.vf \
tex-AlegreyaSans-Black-osf-sc-t1--base.tfm \
tex-AlegreyaSans-Black-osf-sc-t1.tfm \
tex-AlegreyaSans-Black-osf-sc-t1.vf \
tex-AlegreyaSans-Black-osf-t1--base.tfm \
tex-AlegreyaSans-Black-osf-t1.tfm \
tex-AlegreyaSans-Black-osf-t1.vf \
tex-AlegreyaSans-Black-osf-ts1--base.tfm \
tex-AlegreyaSans-Black-osf-ts1.tfm \
tex-AlegreyaSans-Black-osf-ts1.vf \
tex-AlegreyaSans-Black-sup-lgr--base.tfm \
tex-AlegreyaSans-Black-sup-lgr.tfm \
tex-AlegreyaSans-Black-sup-lgr.vf \
tex-AlegreyaSans-Black-sup-ly1--base.tfm \
tex-AlegreyaSans-Black-sup-ly1.tfm \
tex-AlegreyaSans-Black-sup-ly1.vf \
tex-AlegreyaSans-Black-sup-ot1.tfm \
tex-AlegreyaSans-Black-sup-t1--base.tfm \
tex-AlegreyaSans-Black-sup-t1.tfm \
tex-AlegreyaSans-Black-sup-t1.vf \
tex-AlegreyaSans-Black-tlf-lgr--base.tfm \
tex-AlegreyaSans-Black-tlf-lgr.tfm \
tex-AlegreyaSans-Black-tlf-lgr.vf \
tex-AlegreyaSans-Black-tlf-ly1--base.tfm \
tex-AlegreyaSans-Black-tlf-ly1.tfm \
tex-AlegreyaSans-Black-tlf-ly1.vf \
tex-AlegreyaSans-Black-tlf-ot1.tfm \
tex-AlegreyaSans-Black-tlf-sc-lgr--base.tfm \
tex-AlegreyaSans-Black-tlf-sc-lgr.tfm \
tex-AlegreyaSans-Black-tlf-sc-lgr.vf \
tex-AlegreyaSans-Black-tlf-sc-ly1--base.tfm \
tex-AlegreyaSans-Black-tlf-sc-ly1.tfm \
tex-AlegreyaSans-Black-tlf-sc-ly1.vf \
tex-AlegreyaSans-Black-tlf-sc-ot1--base.tfm \
tex-AlegreyaSans-Black-tlf-sc-ot1.tfm \
tex-AlegreyaSans-Black-tlf-sc-ot1.vf \
tex-AlegreyaSans-Black-tlf-sc-t1--base.tfm \
tex-AlegreyaSans-Black-tlf-sc-t1.tfm \
tex-AlegreyaSans-Black-tlf-sc-t1.vf \
tex-AlegreyaSans-Black-tlf-t1--base.tfm \
tex-AlegreyaSans-Black-tlf-t1.tfm \
tex-AlegreyaSans-Black-tlf-t1.vf \
tex-AlegreyaSans-Black-tlf-ts1--base.tfm \
tex-AlegreyaSans-Black-tlf-ts1.tfm \
tex-AlegreyaSans-Black-tlf-ts1.vf \
tex-AlegreyaSans-Black-tosf-lgr--base.tfm \
tex-AlegreyaSans-Black-tosf-lgr.tfm \
tex-AlegreyaSans-Black-tosf-lgr.vf \
tex-AlegreyaSans-Black-tosf-ly1--base.tfm \
tex-AlegreyaSans-Black-tosf-ly1.tfm \
tex-AlegreyaSans-Black-tosf-ly1.vf \
tex-AlegreyaSans-Black-tosf-ot1.tfm \
tex-AlegreyaSans-Black-tosf-sc-lgr--base.tfm \
tex-AlegreyaSans-Black-tosf-sc-lgr.tfm \
tex-AlegreyaSans-Black-tosf-sc-lgr.vf \
tex-AlegreyaSans-Black-tosf-sc-ly1--base.tfm \
tex-AlegreyaSans-Black-tosf-sc-ly1.tfm \
tex-AlegreyaSans-Black-tosf-sc-ly1.vf \
tex-AlegreyaSans-Black-tosf-sc-ot1--base.tfm \
tex-AlegreyaSans-Black-tosf-sc-ot1.tfm \
tex-AlegreyaSans-Black-tosf-sc-ot1.vf \
tex-AlegreyaSans-Black-tosf-sc-t1--base.tfm \
tex-AlegreyaSans-Black-tosf-sc-t1.tfm \
tex-AlegreyaSans-Black-tosf-sc-t1.vf \
tex-AlegreyaSans-Black-tosf-t1--base.tfm \
tex-AlegreyaSans-Black-tosf-t1.tfm \
tex-AlegreyaSans-Black-tosf-t1.vf \
tex-AlegreyaSans-Black-tosf-ts1--base.tfm \
tex-AlegreyaSans-Black-tosf-ts1.tfm \
tex-AlegreyaSans-Black-tosf-ts1.vf \
tex-AlegreyaSans-BlackItalic-inf-lgr--base.tfm \
tex-AlegreyaSans-BlackItalic-inf-lgr.tfm \
tex-AlegreyaSans-BlackItalic-inf-lgr.vf \
tex-AlegreyaSans-BlackItalic-inf-ly1--base.tfm \
tex-AlegreyaSans-BlackItalic-inf-ly1.tfm \
tex-AlegreyaSans-BlackItalic-inf-ly1.vf \
tex-AlegreyaSans-BlackItalic-inf-ot1.tfm \
tex-AlegreyaSans-BlackItalic-inf-t1--base.tfm \
tex-AlegreyaSans-BlackItalic-inf-t1.tfm \
tex-AlegreyaSans-BlackItalic-inf-t1.vf \
tex-AlegreyaSans-BlackItalic-lf-lgr--base.tfm \
tex-AlegreyaSans-BlackItalic-lf-lgr.tfm \
tex-AlegreyaSans-BlackItalic-lf-lgr.vf \
tex-AlegreyaSans-BlackItalic-lf-ly1--base.tfm \
tex-AlegreyaSans-BlackItalic-lf-ly1.tfm \
tex-AlegreyaSans-BlackItalic-lf-ly1.vf \
tex-AlegreyaSans-BlackItalic-lf-ot1.tfm \
tex-AlegreyaSans-BlackItalic-lf-sc-lgr--base.tfm \
tex-AlegreyaSans-BlackItalic-lf-sc-lgr.tfm \
tex-AlegreyaSans-BlackItalic-lf-sc-lgr.vf \
tex-AlegreyaSans-BlackItalic-lf-sc-ly1--base.tfm \
tex-AlegreyaSans-BlackItalic-lf-sc-ly1.tfm \
tex-AlegreyaSans-BlackItalic-lf-sc-ly1.vf \
tex-AlegreyaSans-BlackItalic-lf-sc-ot1--base.tfm \
tex-AlegreyaSans-BlackItalic-lf-sc-ot1.tfm \
tex-AlegreyaSans-BlackItalic-lf-sc-ot1.vf \
tex-AlegreyaSans-BlackItalic-lf-sc-t1--base.tfm \
tex-AlegreyaSans-BlackItalic-lf-sc-t1.tfm \
tex-AlegreyaSans-BlackItalic-lf-sc-t1.vf \
tex-AlegreyaSans-BlackItalic-lf-t1--base.tfm \
tex-AlegreyaSans-BlackItalic-lf-t1.tfm \
tex-AlegreyaSans-BlackItalic-lf-t1.vf \
tex-AlegreyaSans-BlackItalic-lf-ts1--base.tfm \
tex-AlegreyaSans-BlackItalic-lf-ts1.tfm \
tex-AlegreyaSans-BlackItalic-lf-ts1.vf \
tex-AlegreyaSans-BlackItalic-osf-lgr--base.tfm \
tex-AlegreyaSans-BlackItalic-osf-lgr.tfm \
tex-AlegreyaSans-BlackItalic-osf-lgr.vf \
tex-AlegreyaSans-BlackItalic-osf-ly1--base.tfm \
tex-AlegreyaSans-BlackItalic-osf-ly1.tfm \
tex-AlegreyaSans-BlackItalic-osf-ly1.vf \
tex-AlegreyaSans-BlackItalic-osf-ot1.tfm \
tex-AlegreyaSans-BlackItalic-osf-sc-lgr--base.tfm \
tex-AlegreyaSans-BlackItalic-osf-sc-lgr.tfm \
tex-AlegreyaSans-BlackItalic-osf-sc-lgr.vf \
tex-AlegreyaSans-BlackItalic-osf-sc-ly1--base.tfm \
tex-AlegreyaSans-BlackItalic-osf-sc-ly1.tfm \
tex-AlegreyaSans-BlackItalic-osf-sc-ly1.vf \
tex-AlegreyaSans-BlackItalic-osf-sc-ot1--base.tfm \
tex-AlegreyaSans-BlackItalic-osf-sc-ot1.tfm \
tex-AlegreyaSans-BlackItalic-osf-sc-ot1.vf \
tex-AlegreyaSans-BlackItalic-osf-sc-t1--base.tfm \
tex-AlegreyaSans-BlackItalic-osf-sc-t1.tfm \
tex-AlegreyaSans-BlackItalic-osf-sc-t1.vf \
tex-AlegreyaSans-BlackItalic-osf-t1--base.tfm \
tex-AlegreyaSans-BlackItalic-osf-t1.tfm \
tex-AlegreyaSans-BlackItalic-osf-t1.vf \
tex-AlegreyaSans-BlackItalic-osf-ts1--base.tfm \
tex-AlegreyaSans-BlackItalic-osf-ts1.tfm \
tex-AlegreyaSans-BlackItalic-osf-ts1.vf \
tex-AlegreyaSans-BlackItalic-sup-lgr--base.tfm \
tex-AlegreyaSans-BlackItalic-sup-lgr.tfm \
tex-AlegreyaSans-BlackItalic-sup-lgr.vf \
tex-AlegreyaSans-BlackItalic-sup-ly1--base.tfm \
tex-AlegreyaSans-BlackItalic-sup-ly1.tfm \
tex-AlegreyaSans-BlackItalic-sup-ly1.vf \
tex-AlegreyaSans-BlackItalic-sup-ot1.tfm \
tex-AlegreyaSans-BlackItalic-sup-t1--base.tfm \
tex-AlegreyaSans-BlackItalic-sup-t1.tfm \
tex-AlegreyaSans-BlackItalic-sup-t1.vf \
tex-AlegreyaSans-BlackItalic-tlf-lgr--base.tfm \
tex-AlegreyaSans-BlackItalic-tlf-lgr.tfm \
tex-AlegreyaSans-BlackItalic-tlf-lgr.vf \
tex-AlegreyaSans-BlackItalic-tlf-ly1--base.tfm \
tex-AlegreyaSans-BlackItalic-tlf-ly1.tfm \
tex-AlegreyaSans-BlackItalic-tlf-ly1.vf \
tex-AlegreyaSans-BlackItalic-tlf-ot1.tfm \
tex-AlegreyaSans-BlackItalic-tlf-sc-lgr--base.tfm \
tex-AlegreyaSans-BlackItalic-tlf-sc-lgr.tfm \
tex-AlegreyaSans-BlackItalic-tlf-sc-lgr.vf \
tex-AlegreyaSans-BlackItalic-tlf-sc-ly1--base.tfm \
tex-AlegreyaSans-BlackItalic-tlf-sc-ly1.tfm \
tex-AlegreyaSans-BlackItalic-tlf-sc-ly1.vf \
tex-AlegreyaSans-BlackItalic-tlf-sc-ot1--base.tfm \
tex-AlegreyaSans-BlackItalic-tlf-sc-ot1.tfm \
tex-AlegreyaSans-BlackItalic-tlf-sc-ot1.vf \
tex-AlegreyaSans-BlackItalic-tlf-sc-t1--base.tfm \
tex-AlegreyaSans-BlackItalic-tlf-sc-t1.tfm \
tex-AlegreyaSans-BlackItalic-tlf-sc-t1.vf \
tex-AlegreyaSans-BlackItalic-tlf-t1--base.tfm \
tex-AlegreyaSans-BlackItalic-tlf-t1.tfm \
tex-AlegreyaSans-BlackItalic-tlf-t1.vf \
tex-AlegreyaSans-BlackItalic-tlf-ts1--base.tfm \
tex-AlegreyaSans-BlackItalic-tlf-ts1.tfm \
tex-AlegreyaSans-BlackItalic-tlf-ts1.vf \
tex-AlegreyaSans-BlackItalic-tosf-lgr--base.tfm \
tex-AlegreyaSans-BlackItalic-tosf-lgr.tfm \
tex-AlegreyaSans-BlackItalic-tosf-lgr.vf \
tex-AlegreyaSans-BlackItalic-tosf-ly1--base.tfm \
tex-AlegreyaSans-BlackItalic-tosf-ly1.tfm \
tex-AlegreyaSans-BlackItalic-tosf-ly1.vf \
tex-AlegreyaSans-BlackItalic-tosf-ot1.tfm \
tex-AlegreyaSans-BlackItalic-tosf-sc-lgr--base.tfm \
tex-AlegreyaSans-BlackItalic-tosf-sc-lgr.tfm \
tex-AlegreyaSans-BlackItalic-tosf-sc-lgr.vf \
tex-AlegreyaSans-BlackItalic-tosf-sc-ly1--base.tfm \
tex-AlegreyaSans-BlackItalic-tosf-sc-ly1.tfm \
tex-AlegreyaSans-BlackItalic-tosf-sc-ly1.vf \
tex-AlegreyaSans-BlackItalic-tosf-sc-ot1--base.tfm \
tex-AlegreyaSans-BlackItalic-tosf-sc-ot1.tfm \
tex-AlegreyaSans-BlackItalic-tosf-sc-ot1.vf \
tex-AlegreyaSans-BlackItalic-tosf-sc-t1--base.tfm \
tex-AlegreyaSans-BlackItalic-tosf-sc-t1.tfm \
tex-AlegreyaSans-BlackItalic-tosf-sc-t1.vf \
tex-AlegreyaSans-BlackItalic-tosf-t1--base.tfm \
tex-AlegreyaSans-BlackItalic-tosf-t1.tfm \
tex-AlegreyaSans-BlackItalic-tosf-t1.vf \
tex-AlegreyaSans-BlackItalic-tosf-ts1--base.tfm \
tex-AlegreyaSans-BlackItalic-tosf-ts1.tfm \
tex-AlegreyaSans-BlackItalic-tosf-ts1.vf \
tex-AlegreyaSans-Bold-inf-lgr--base.tfm \
tex-AlegreyaSans-Bold-inf-lgr.tfm \
tex-AlegreyaSans-Bold-inf-lgr.vf \
tex-AlegreyaSans-Bold-inf-ly1--base.tfm \
tex-AlegreyaSans-Bold-inf-ly1.tfm \
tex-AlegreyaSans-Bold-inf-ly1.vf \
tex-AlegreyaSans-Bold-inf-ot1.tfm \
tex-AlegreyaSans-Bold-inf-t1--base.tfm \
tex-AlegreyaSans-Bold-inf-t1.tfm \
tex-AlegreyaSans-Bold-inf-t1.vf \
tex-AlegreyaSans-Bold-lf-lgr--base.tfm \
tex-AlegreyaSans-Bold-lf-lgr.tfm \
tex-AlegreyaSans-Bold-lf-lgr.vf \
tex-AlegreyaSans-Bold-lf-ly1--base.tfm \
tex-AlegreyaSans-Bold-lf-ly1.tfm \
tex-AlegreyaSans-Bold-lf-ly1.vf \
tex-AlegreyaSans-Bold-lf-ot1.tfm \
tex-AlegreyaSans-Bold-lf-sc-lgr--base.tfm \
tex-AlegreyaSans-Bold-lf-sc-lgr.tfm \
tex-AlegreyaSans-Bold-lf-sc-lgr.vf \
tex-AlegreyaSans-Bold-lf-sc-ly1--base.tfm \
tex-AlegreyaSans-Bold-lf-sc-ly1.tfm \
tex-AlegreyaSans-Bold-lf-sc-ly1.vf \
tex-AlegreyaSans-Bold-lf-sc-ot1--base.tfm \
tex-AlegreyaSans-Bold-lf-sc-ot1.tfm \
tex-AlegreyaSans-Bold-lf-sc-ot1.vf \
tex-AlegreyaSans-Bold-lf-sc-t1--base.tfm \
tex-AlegreyaSans-Bold-lf-sc-t1.tfm \
tex-AlegreyaSans-Bold-lf-sc-t1.vf \
tex-AlegreyaSans-Bold-lf-t1--base.tfm \
tex-AlegreyaSans-Bold-lf-t1.tfm \
tex-AlegreyaSans-Bold-lf-t1.vf \
tex-AlegreyaSans-Bold-lf-ts1--base.tfm \
tex-AlegreyaSans-Bold-lf-ts1.tfm \
tex-AlegreyaSans-Bold-lf-ts1.vf \
tex-AlegreyaSans-Bold-osf-lgr--base.tfm \
tex-AlegreyaSans-Bold-osf-lgr.tfm \
tex-AlegreyaSans-Bold-osf-lgr.vf \
tex-AlegreyaSans-Bold-osf-ly1--base.tfm \
tex-AlegreyaSans-Bold-osf-ly1.tfm \
tex-AlegreyaSans-Bold-osf-ly1.vf \
tex-AlegreyaSans-Bold-osf-ot1.tfm \
tex-AlegreyaSans-Bold-osf-sc-lgr--base.tfm \
tex-AlegreyaSans-Bold-osf-sc-lgr.tfm \
tex-AlegreyaSans-Bold-osf-sc-lgr.vf \
tex-AlegreyaSans-Bold-osf-sc-ly1--base.tfm \
tex-AlegreyaSans-Bold-osf-sc-ly1.tfm \
tex-AlegreyaSans-Bold-osf-sc-ly1.vf \
tex-AlegreyaSans-Bold-osf-sc-ot1--base.tfm \
tex-AlegreyaSans-Bold-osf-sc-ot1.tfm \
tex-AlegreyaSans-Bold-osf-sc-ot1.vf \
tex-AlegreyaSans-Bold-osf-sc-t1--base.tfm \
tex-AlegreyaSans-Bold-osf-sc-t1.tfm \
tex-AlegreyaSans-Bold-osf-sc-t1.vf \
tex-AlegreyaSans-Bold-osf-t1--base.tfm \
tex-AlegreyaSans-Bold-osf-t1.tfm \
tex-AlegreyaSans-Bold-osf-t1.vf \
tex-AlegreyaSans-Bold-osf-ts1--base.tfm \
tex-AlegreyaSans-Bold-osf-ts1.tfm \
tex-AlegreyaSans-Bold-osf-ts1.vf \
tex-AlegreyaSans-Bold-sup-lgr--base.tfm \
tex-AlegreyaSans-Bold-sup-lgr.tfm \
tex-AlegreyaSans-Bold-sup-lgr.vf \
tex-AlegreyaSans-Bold-sup-ly1--base.tfm \
tex-AlegreyaSans-Bold-sup-ly1.tfm \
tex-AlegreyaSans-Bold-sup-ly1.vf \
tex-AlegreyaSans-Bold-sup-ot1.tfm \
tex-AlegreyaSans-Bold-sup-t1--base.tfm \
tex-AlegreyaSans-Bold-sup-t1.tfm \
tex-AlegreyaSans-Bold-sup-t1.vf \
tex-AlegreyaSans-Bold-tlf-lgr--base.tfm \
tex-AlegreyaSans-Bold-tlf-lgr.tfm \
tex-AlegreyaSans-Bold-tlf-lgr.vf \
tex-AlegreyaSans-Bold-tlf-ly1--base.tfm \
tex-AlegreyaSans-Bold-tlf-ly1.tfm \
tex-AlegreyaSans-Bold-tlf-ly1.vf \
tex-AlegreyaSans-Bold-tlf-ot1.tfm \
tex-AlegreyaSans-Bold-tlf-sc-lgr--base.tfm \
tex-AlegreyaSans-Bold-tlf-sc-lgr.tfm \
tex-AlegreyaSans-Bold-tlf-sc-lgr.vf \
tex-AlegreyaSans-Bold-tlf-sc-ly1--base.tfm \
tex-AlegreyaSans-Bold-tlf-sc-ly1.tfm \
tex-AlegreyaSans-Bold-tlf-sc-ly1.vf \
tex-AlegreyaSans-Bold-tlf-sc-ot1--base.tfm \
tex-AlegreyaSans-Bold-tlf-sc-ot1.tfm \
tex-AlegreyaSans-Bold-tlf-sc-ot1.vf \
tex-AlegreyaSans-Bold-tlf-sc-t1--base.tfm \
tex-AlegreyaSans-Bold-tlf-sc-t1.tfm \
tex-AlegreyaSans-Bold-tlf-sc-t1.vf \
tex-AlegreyaSans-Bold-tlf-t1--base.tfm \
tex-AlegreyaSans-Bold-tlf-t1.tfm \
tex-AlegreyaSans-Bold-tlf-t1.vf \
tex-AlegreyaSans-Bold-tlf-ts1--base.tfm \
tex-AlegreyaSans-Bold-tlf-ts1.tfm \
tex-AlegreyaSans-Bold-tlf-ts1.vf \
tex-AlegreyaSans-Bold-tosf-lgr--base.tfm \
tex-AlegreyaSans-Bold-tosf-lgr.tfm \
tex-AlegreyaSans-Bold-tosf-lgr.vf \
tex-AlegreyaSans-Bold-tosf-ly1--base.tfm \
tex-AlegreyaSans-Bold-tosf-ly1.tfm \
tex-AlegreyaSans-Bold-tosf-ly1.vf \
tex-AlegreyaSans-Bold-tosf-ot1.tfm \
tex-AlegreyaSans-Bold-tosf-sc-lgr--base.tfm \
tex-AlegreyaSans-Bold-tosf-sc-lgr.tfm \
tex-AlegreyaSans-Bold-tosf-sc-lgr.vf \
tex-AlegreyaSans-Bold-tosf-sc-ly1--base.tfm \
tex-AlegreyaSans-Bold-tosf-sc-ly1.tfm \
tex-AlegreyaSans-Bold-tosf-sc-ly1.vf \
tex-AlegreyaSans-Bold-tosf-sc-ot1--base.tfm \
tex-AlegreyaSans-Bold-tosf-sc-ot1.tfm \
tex-AlegreyaSans-Bold-tosf-sc-ot1.vf \
tex-AlegreyaSans-Bold-tosf-sc-t1--base.tfm \
tex-AlegreyaSans-Bold-tosf-sc-t1.tfm \
tex-AlegreyaSans-Bold-tosf-sc-t1.vf \
tex-AlegreyaSans-Bold-tosf-t1--base.tfm \
tex-AlegreyaSans-Bold-tosf-t1.tfm \
tex-AlegreyaSans-Bold-tosf-t1.vf \
tex-AlegreyaSans-Bold-tosf-ts1--base.tfm \
tex-AlegreyaSans-Bold-tosf-ts1.tfm \
tex-AlegreyaSans-Bold-tosf-ts1.vf \
tex-AlegreyaSans-BoldItalic-inf-lgr--base.tfm \
tex-AlegreyaSans-BoldItalic-inf-lgr.tfm \
tex-AlegreyaSans-BoldItalic-inf-lgr.vf \
tex-AlegreyaSans-BoldItalic-inf-ly1--base.tfm \
tex-AlegreyaSans-BoldItalic-inf-ly1.tfm \
tex-AlegreyaSans-BoldItalic-inf-ly1.vf \
tex-AlegreyaSans-BoldItalic-inf-ot1.tfm \
tex-AlegreyaSans-BoldItalic-inf-t1--base.tfm \
tex-AlegreyaSans-BoldItalic-inf-t1.tfm \
tex-AlegreyaSans-BoldItalic-inf-t1.vf \
tex-AlegreyaSans-BoldItalic-lf-lgr--base.tfm \
tex-AlegreyaSans-BoldItalic-lf-lgr.tfm \
tex-AlegreyaSans-BoldItalic-lf-lgr.vf \
tex-AlegreyaSans-BoldItalic-lf-ly1--base.tfm \
tex-AlegreyaSans-BoldItalic-lf-ly1.tfm \
tex-AlegreyaSans-BoldItalic-lf-ly1.vf \
tex-AlegreyaSans-BoldItalic-lf-ot1.tfm \
tex-AlegreyaSans-BoldItalic-lf-sc-lgr--base.tfm \
tex-AlegreyaSans-BoldItalic-lf-sc-lgr.tfm \
tex-AlegreyaSans-BoldItalic-lf-sc-lgr.vf \
tex-AlegreyaSans-BoldItalic-lf-sc-ly1--base.tfm \
tex-AlegreyaSans-BoldItalic-lf-sc-ly1.tfm \
tex-AlegreyaSans-BoldItalic-lf-sc-ly1.vf \
tex-AlegreyaSans-BoldItalic-lf-sc-ot1--base.tfm \
tex-AlegreyaSans-BoldItalic-lf-sc-ot1.tfm \
tex-AlegreyaSans-BoldItalic-lf-sc-ot1.vf \
tex-AlegreyaSans-BoldItalic-lf-sc-t1--base.tfm \
tex-AlegreyaSans-BoldItalic-lf-sc-t1.tfm \
tex-AlegreyaSans-BoldItalic-lf-sc-t1.vf \
tex-AlegreyaSans-BoldItalic-lf-t1--base.tfm \
tex-AlegreyaSans-BoldItalic-lf-t1.tfm \
tex-AlegreyaSans-BoldItalic-lf-t1.vf \
tex-AlegreyaSans-BoldItalic-lf-ts1--base.tfm \
tex-AlegreyaSans-BoldItalic-lf-ts1.tfm \
tex-AlegreyaSans-BoldItalic-lf-ts1.vf \
tex-AlegreyaSans-BoldItalic-osf-lgr--base.tfm \
tex-AlegreyaSans-BoldItalic-osf-lgr.tfm \
tex-AlegreyaSans-BoldItalic-osf-lgr.vf \
tex-AlegreyaSans-BoldItalic-osf-ly1--base.tfm \
tex-AlegreyaSans-BoldItalic-osf-ly1.tfm \
tex-AlegreyaSans-BoldItalic-osf-ly1.vf \
tex-AlegreyaSans-BoldItalic-osf-ot1.tfm \
tex-AlegreyaSans-BoldItalic-osf-sc-lgr--base.tfm \
tex-AlegreyaSans-BoldItalic-osf-sc-lgr.tfm \
tex-AlegreyaSans-BoldItalic-osf-sc-lgr.vf \
tex-AlegreyaSans-BoldItalic-osf-sc-ly1--base.tfm \
tex-AlegreyaSans-BoldItalic-osf-sc-ly1.tfm \
tex-AlegreyaSans-BoldItalic-osf-sc-ly1.vf \
tex-AlegreyaSans-BoldItalic-osf-sc-ot1--base.tfm \
tex-AlegreyaSans-BoldItalic-osf-sc-ot1.tfm \
tex-AlegreyaSans-BoldItalic-osf-sc-ot1.vf \
tex-AlegreyaSans-BoldItalic-osf-sc-t1--base.tfm \
tex-AlegreyaSans-BoldItalic-osf-sc-t1.tfm \
tex-AlegreyaSans-BoldItalic-osf-sc-t1.vf \
tex-AlegreyaSans-BoldItalic-osf-t1--base.tfm \
tex-AlegreyaSans-BoldItalic-osf-t1.tfm \
tex-AlegreyaSans-BoldItalic-osf-t1.vf \
tex-AlegreyaSans-BoldItalic-osf-ts1--base.tfm \
tex-AlegreyaSans-BoldItalic-osf-ts1.tfm \
tex-AlegreyaSans-BoldItalic-osf-ts1.vf \
tex-AlegreyaSans-BoldItalic-sup-lgr--base.tfm \
tex-AlegreyaSans-BoldItalic-sup-lgr.tfm \
tex-AlegreyaSans-BoldItalic-sup-lgr.vf \
tex-AlegreyaSans-BoldItalic-sup-ly1--base.tfm \
tex-AlegreyaSans-BoldItalic-sup-ly1.tfm \
tex-AlegreyaSans-BoldItalic-sup-ly1.vf \
tex-AlegreyaSans-BoldItalic-sup-ot1.tfm \
tex-AlegreyaSans-BoldItalic-sup-t1--base.tfm \
tex-AlegreyaSans-BoldItalic-sup-t1.tfm \
tex-AlegreyaSans-BoldItalic-sup-t1.vf \
tex-AlegreyaSans-BoldItalic-tlf-lgr--base.tfm \
tex-AlegreyaSans-BoldItalic-tlf-lgr.tfm \
tex-AlegreyaSans-BoldItalic-tlf-lgr.vf \
tex-AlegreyaSans-BoldItalic-tlf-ly1--base.tfm \
tex-AlegreyaSans-BoldItalic-tlf-ly1.tfm \
tex-AlegreyaSans-BoldItalic-tlf-ly1.vf \
tex-AlegreyaSans-BoldItalic-tlf-ot1.tfm \
tex-AlegreyaSans-BoldItalic-tlf-sc-lgr--base.tfm \
tex-AlegreyaSans-BoldItalic-tlf-sc-lgr.tfm \
tex-AlegreyaSans-BoldItalic-tlf-sc-lgr.vf \
tex-AlegreyaSans-BoldItalic-tlf-sc-ly1--base.tfm \
tex-AlegreyaSans-BoldItalic-tlf-sc-ly1.tfm \
tex-AlegreyaSans-BoldItalic-tlf-sc-ly1.vf \
tex-AlegreyaSans-BoldItalic-tlf-sc-ot1--base.tfm \
tex-AlegreyaSans-BoldItalic-tlf-sc-ot1.tfm \
tex-AlegreyaSans-BoldItalic-tlf-sc-ot1.vf \
tex-AlegreyaSans-BoldItalic-tlf-sc-t1--base.tfm \
tex-AlegreyaSans-BoldItalic-tlf-sc-t1.tfm \
tex-AlegreyaSans-BoldItalic-tlf-sc-t1.vf \
tex-AlegreyaSans-BoldItalic-tlf-t1--base.tfm \
tex-AlegreyaSans-BoldItalic-tlf-t1.tfm \
tex-AlegreyaSans-BoldItalic-tlf-t1.vf \
tex-AlegreyaSans-BoldItalic-tlf-ts1--base.tfm \
tex-AlegreyaSans-BoldItalic-tlf-ts1.tfm \
tex-AlegreyaSans-BoldItalic-tlf-ts1.vf \
tex-AlegreyaSans-BoldItalic-tosf-lgr--base.tfm \
tex-AlegreyaSans-BoldItalic-tosf-lgr.tfm \
tex-AlegreyaSans-BoldItalic-tosf-lgr.vf \
tex-AlegreyaSans-BoldItalic-tosf-ly1--base.tfm \
tex-AlegreyaSans-BoldItalic-tosf-ly1.tfm \
tex-AlegreyaSans-BoldItalic-tosf-ly1.vf \
tex-AlegreyaSans-BoldItalic-tosf-ot1.tfm \
tex-AlegreyaSans-BoldItalic-tosf-sc-lgr--base.tfm \
tex-AlegreyaSans-BoldItalic-tosf-sc-lgr.tfm \
tex-AlegreyaSans-BoldItalic-tosf-sc-lgr.vf \
tex-AlegreyaSans-BoldItalic-tosf-sc-ly1--base.tfm \
tex-AlegreyaSans-BoldItalic-tosf-sc-ly1.tfm \
tex-AlegreyaSans-BoldItalic-tosf-sc-ly1.vf \
tex-AlegreyaSans-BoldItalic-tosf-sc-ot1--base.tfm \
tex-AlegreyaSans-BoldItalic-tosf-sc-ot1.tfm \
tex-AlegreyaSans-BoldItalic-tosf-sc-ot1.vf \
tex-AlegreyaSans-BoldItalic-tosf-sc-t1--base.tfm \
tex-AlegreyaSans-BoldItalic-tosf-sc-t1.tfm \
tex-AlegreyaSans-BoldItalic-tosf-sc-t1.vf \
tex-AlegreyaSans-BoldItalic-tosf-t1--base.tfm \
tex-AlegreyaSans-BoldItalic-tosf-t1.tfm \
tex-AlegreyaSans-BoldItalic-tosf-t1.vf \
tex-AlegreyaSans-BoldItalic-tosf-ts1--base.tfm \
tex-AlegreyaSans-BoldItalic-tosf-ts1.tfm \
tex-AlegreyaSans-BoldItalic-tosf-ts1.vf \
tex-AlegreyaSans-ExtraBold-inf-lgr--base.tfm \
tex-AlegreyaSans-ExtraBold-inf-lgr.tfm \
tex-AlegreyaSans-ExtraBold-inf-lgr.vf \
tex-AlegreyaSans-ExtraBold-inf-ly1--base.tfm \
tex-AlegreyaSans-ExtraBold-inf-ly1.tfm \
tex-AlegreyaSans-ExtraBold-inf-ly1.vf \
tex-AlegreyaSans-ExtraBold-inf-ot1.tfm \
tex-AlegreyaSans-ExtraBold-inf-t1--base.tfm \
tex-AlegreyaSans-ExtraBold-inf-t1.tfm \
tex-AlegreyaSans-ExtraBold-inf-t1.vf \
tex-AlegreyaSans-ExtraBold-lf-lgr--base.tfm \
tex-AlegreyaSans-ExtraBold-lf-lgr.tfm \
tex-AlegreyaSans-ExtraBold-lf-lgr.vf \
tex-AlegreyaSans-ExtraBold-lf-ly1--base.tfm \
tex-AlegreyaSans-ExtraBold-lf-ly1.tfm \
tex-AlegreyaSans-ExtraBold-lf-ly1.vf \
tex-AlegreyaSans-ExtraBold-lf-ot1.tfm \
tex-AlegreyaSans-ExtraBold-lf-sc-lgr--base.tfm \
tex-AlegreyaSans-ExtraBold-lf-sc-lgr.tfm \
tex-AlegreyaSans-ExtraBold-lf-sc-lgr.vf \
tex-AlegreyaSans-ExtraBold-lf-sc-ly1--base.tfm \
tex-AlegreyaSans-ExtraBold-lf-sc-ly1.tfm \
tex-AlegreyaSans-ExtraBold-lf-sc-ly1.vf \
tex-AlegreyaSans-ExtraBold-lf-sc-ot1--base.tfm \
tex-AlegreyaSans-ExtraBold-lf-sc-ot1.tfm \
tex-AlegreyaSans-ExtraBold-lf-sc-ot1.vf \
tex-AlegreyaSans-ExtraBold-lf-sc-t1--base.tfm \
tex-AlegreyaSans-ExtraBold-lf-sc-t1.tfm \
tex-AlegreyaSans-ExtraBold-lf-sc-t1.vf \
tex-AlegreyaSans-ExtraBold-lf-t1--base.tfm \
tex-AlegreyaSans-ExtraBold-lf-t1.tfm \
tex-AlegreyaSans-ExtraBold-lf-t1.vf \
tex-AlegreyaSans-ExtraBold-lf-ts1--base.tfm \
tex-AlegreyaSans-ExtraBold-lf-ts1.tfm \
tex-AlegreyaSans-ExtraBold-lf-ts1.vf \
tex-AlegreyaSans-ExtraBold-osf-lgr--base.tfm \
tex-AlegreyaSans-ExtraBold-osf-lgr.tfm \
tex-AlegreyaSans-ExtraBold-osf-lgr.vf \
tex-AlegreyaSans-ExtraBold-osf-ly1--base.tfm \
tex-AlegreyaSans-ExtraBold-osf-ly1.tfm \
tex-AlegreyaSans-ExtraBold-osf-ly1.vf \
tex-AlegreyaSans-ExtraBold-osf-ot1.tfm \
tex-AlegreyaSans-ExtraBold-osf-sc-lgr--base.tfm \
tex-AlegreyaSans-ExtraBold-osf-sc-lgr.tfm \
tex-AlegreyaSans-ExtraBold-osf-sc-lgr.vf \
tex-AlegreyaSans-ExtraBold-osf-sc-ly1--base.tfm \
tex-AlegreyaSans-ExtraBold-osf-sc-ly1.tfm \
tex-AlegreyaSans-ExtraBold-osf-sc-ly1.vf \
tex-AlegreyaSans-ExtraBold-osf-sc-ot1--base.tfm \
tex-AlegreyaSans-ExtraBold-osf-sc-ot1.tfm \
tex-AlegreyaSans-ExtraBold-osf-sc-ot1.vf \
tex-AlegreyaSans-ExtraBold-osf-sc-t1--base.tfm \
tex-AlegreyaSans-ExtraBold-osf-sc-t1.tfm \
tex-AlegreyaSans-ExtraBold-osf-sc-t1.vf \
tex-AlegreyaSans-ExtraBold-osf-t1--base.tfm \
tex-AlegreyaSans-ExtraBold-osf-t1.tfm \
tex-AlegreyaSans-ExtraBold-osf-t1.vf \
tex-AlegreyaSans-ExtraBold-osf-ts1--base.tfm \
tex-AlegreyaSans-ExtraBold-osf-ts1.tfm \
tex-AlegreyaSans-ExtraBold-osf-ts1.vf \
tex-AlegreyaSans-ExtraBold-sup-lgr--base.tfm \
tex-AlegreyaSans-ExtraBold-sup-lgr.tfm \
tex-AlegreyaSans-ExtraBold-sup-lgr.vf \
tex-AlegreyaSans-ExtraBold-sup-ly1--base.tfm \
tex-AlegreyaSans-ExtraBold-sup-ly1.tfm \
tex-AlegreyaSans-ExtraBold-sup-ly1.vf \
tex-AlegreyaSans-ExtraBold-sup-ot1.tfm \
tex-AlegreyaSans-ExtraBold-sup-t1--base.tfm \
tex-AlegreyaSans-ExtraBold-sup-t1.tfm \
tex-AlegreyaSans-ExtraBold-sup-t1.vf \
tex-AlegreyaSans-ExtraBold-tlf-lgr--base.tfm \
tex-AlegreyaSans-ExtraBold-tlf-lgr.tfm \
tex-AlegreyaSans-ExtraBold-tlf-lgr.vf \
tex-AlegreyaSans-ExtraBold-tlf-ly1--base.tfm \
tex-AlegreyaSans-ExtraBold-tlf-ly1.tfm \
tex-AlegreyaSans-ExtraBold-tlf-ly1.vf \
tex-AlegreyaSans-ExtraBold-tlf-ot1.tfm \
tex-AlegreyaSans-ExtraBold-tlf-sc-lgr--base.tfm \
tex-AlegreyaSans-ExtraBold-tlf-sc-lgr.tfm \
tex-AlegreyaSans-ExtraBold-tlf-sc-lgr.vf \
tex-AlegreyaSans-ExtraBold-tlf-sc-ly1--base.tfm \
tex-AlegreyaSans-ExtraBold-tlf-sc-ly1.tfm \
tex-AlegreyaSans-ExtraBold-tlf-sc-ly1.vf \
tex-AlegreyaSans-ExtraBold-tlf-sc-ot1--base.tfm \
tex-AlegreyaSans-ExtraBold-tlf-sc-ot1.tfm \
tex-AlegreyaSans-ExtraBold-tlf-sc-ot1.vf \
tex-AlegreyaSans-ExtraBold-tlf-sc-t1--base.tfm \
tex-AlegreyaSans-ExtraBold-tlf-sc-t1.tfm \
tex-AlegreyaSans-ExtraBold-tlf-sc-t1.vf \
tex-AlegreyaSans-ExtraBold-tlf-t1--base.tfm \
tex-AlegreyaSans-ExtraBold-tlf-t1.tfm \
tex-AlegreyaSans-ExtraBold-tlf-t1.vf \
tex-AlegreyaSans-ExtraBold-tlf-ts1--base.tfm \
tex-AlegreyaSans-ExtraBold-tlf-ts1.tfm \
tex-AlegreyaSans-ExtraBold-tlf-ts1.vf \
tex-AlegreyaSans-ExtraBold-tosf-lgr--base.tfm \
tex-AlegreyaSans-ExtraBold-tosf-lgr.tfm \
tex-AlegreyaSans-ExtraBold-tosf-lgr.vf \
tex-AlegreyaSans-ExtraBold-tosf-ly1--base.tfm \
tex-AlegreyaSans-ExtraBold-tosf-ly1.tfm \
tex-AlegreyaSans-ExtraBold-tosf-ly1.vf \
tex-AlegreyaSans-ExtraBold-tosf-ot1.tfm \
tex-AlegreyaSans-ExtraBold-tosf-sc-lgr--base.tfm \
tex-AlegreyaSans-ExtraBold-tosf-sc-lgr.tfm \
tex-AlegreyaSans-ExtraBold-tosf-sc-lgr.vf \
tex-AlegreyaSans-ExtraBold-tosf-sc-ly1--base.tfm \
tex-AlegreyaSans-ExtraBold-tosf-sc-ly1.tfm \
tex-AlegreyaSans-ExtraBold-tosf-sc-ly1.vf \
tex-AlegreyaSans-ExtraBold-tosf-sc-ot1--base.tfm \
tex-AlegreyaSans-ExtraBold-tosf-sc-ot1.tfm \
tex-AlegreyaSans-ExtraBold-tosf-sc-ot1.vf \
tex-AlegreyaSans-ExtraBold-tosf-sc-t1--base.tfm \
tex-AlegreyaSans-ExtraBold-tosf-sc-t1.tfm \
tex-AlegreyaSans-ExtraBold-tosf-sc-t1.vf \
tex-AlegreyaSans-ExtraBold-tosf-t1--base.tfm \
tex-AlegreyaSans-ExtraBold-tosf-t1.tfm \
tex-AlegreyaSans-ExtraBold-tosf-t1.vf \
tex-AlegreyaSans-ExtraBold-tosf-ts1--base.tfm \
tex-AlegreyaSans-ExtraBold-tosf-ts1.tfm \
tex-AlegreyaSans-ExtraBold-tosf-ts1.vf \
tex-AlegreyaSans-ExtraBoldItalic-inf-lgr--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-inf-lgr.tfm \
tex-AlegreyaSans-ExtraBoldItalic-inf-lgr.vf \
tex-AlegreyaSans-ExtraBoldItalic-inf-ly1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-inf-ly1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-inf-ly1.vf \
tex-AlegreyaSans-ExtraBoldItalic-inf-ot1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-inf-t1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-inf-t1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-inf-t1.vf \
tex-AlegreyaSans-ExtraBoldItalic-lf-lgr--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-lf-lgr.tfm \
tex-AlegreyaSans-ExtraBoldItalic-lf-lgr.vf \
tex-AlegreyaSans-ExtraBoldItalic-lf-ly1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-lf-ly1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-lf-ly1.vf \
tex-AlegreyaSans-ExtraBoldItalic-lf-ot1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-lf-sc-lgr--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-lf-sc-lgr.tfm \
tex-AlegreyaSans-ExtraBoldItalic-lf-sc-lgr.vf \
tex-AlegreyaSans-ExtraBoldItalic-lf-sc-ly1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-lf-sc-ly1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-lf-sc-ly1.vf \
tex-AlegreyaSans-ExtraBoldItalic-lf-sc-ot1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-lf-sc-ot1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-lf-sc-ot1.vf \
tex-AlegreyaSans-ExtraBoldItalic-lf-sc-t1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-lf-sc-t1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-lf-sc-t1.vf \
tex-AlegreyaSans-ExtraBoldItalic-lf-t1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-lf-t1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-lf-t1.vf \
tex-AlegreyaSans-ExtraBoldItalic-lf-ts1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-lf-ts1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-lf-ts1.vf \
tex-AlegreyaSans-ExtraBoldItalic-osf-lgr--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-osf-lgr.tfm \
tex-AlegreyaSans-ExtraBoldItalic-osf-lgr.vf \
tex-AlegreyaSans-ExtraBoldItalic-osf-ly1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-osf-ly1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-osf-ly1.vf \
tex-AlegreyaSans-ExtraBoldItalic-osf-ot1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-osf-sc-lgr--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-osf-sc-lgr.tfm \
tex-AlegreyaSans-ExtraBoldItalic-osf-sc-lgr.vf \
tex-AlegreyaSans-ExtraBoldItalic-osf-sc-ly1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-osf-sc-ly1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-osf-sc-ly1.vf \
tex-AlegreyaSans-ExtraBoldItalic-osf-sc-ot1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-osf-sc-ot1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-osf-sc-ot1.vf \
tex-AlegreyaSans-ExtraBoldItalic-osf-sc-t1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-osf-sc-t1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-osf-sc-t1.vf \
tex-AlegreyaSans-ExtraBoldItalic-osf-t1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-osf-t1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-osf-t1.vf \
tex-AlegreyaSans-ExtraBoldItalic-osf-ts1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-osf-ts1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-osf-ts1.vf \
tex-AlegreyaSans-ExtraBoldItalic-sup-lgr--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-sup-lgr.tfm \
tex-AlegreyaSans-ExtraBoldItalic-sup-lgr.vf \
tex-AlegreyaSans-ExtraBoldItalic-sup-ly1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-sup-ly1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-sup-ly1.vf \
tex-AlegreyaSans-ExtraBoldItalic-sup-ot1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-sup-t1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-sup-t1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-sup-t1.vf \
tex-AlegreyaSans-ExtraBoldItalic-tlf-lgr--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tlf-lgr.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tlf-lgr.vf \
tex-AlegreyaSans-ExtraBoldItalic-tlf-ly1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tlf-ly1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tlf-ly1.vf \
tex-AlegreyaSans-ExtraBoldItalic-tlf-ot1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tlf-sc-lgr--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tlf-sc-lgr.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tlf-sc-lgr.vf \
tex-AlegreyaSans-ExtraBoldItalic-tlf-sc-ly1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tlf-sc-ly1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tlf-sc-ly1.vf \
tex-AlegreyaSans-ExtraBoldItalic-tlf-sc-ot1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tlf-sc-ot1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tlf-sc-ot1.vf \
tex-AlegreyaSans-ExtraBoldItalic-tlf-sc-t1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tlf-sc-t1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tlf-sc-t1.vf \
tex-AlegreyaSans-ExtraBoldItalic-tlf-t1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tlf-t1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tlf-t1.vf \
tex-AlegreyaSans-ExtraBoldItalic-tlf-ts1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tlf-ts1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tlf-ts1.vf \
tex-AlegreyaSans-ExtraBoldItalic-tosf-lgr--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tosf-lgr.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tosf-lgr.vf \
tex-AlegreyaSans-ExtraBoldItalic-tosf-ly1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tosf-ly1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tosf-ly1.vf \
tex-AlegreyaSans-ExtraBoldItalic-tosf-ot1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tosf-sc-lgr--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tosf-sc-lgr.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tosf-sc-lgr.vf \
tex-AlegreyaSans-ExtraBoldItalic-tosf-sc-ly1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tosf-sc-ly1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tosf-sc-ly1.vf \
tex-AlegreyaSans-ExtraBoldItalic-tosf-sc-ot1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tosf-sc-ot1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tosf-sc-ot1.vf \
tex-AlegreyaSans-ExtraBoldItalic-tosf-sc-t1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tosf-sc-t1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tosf-sc-t1.vf \
tex-AlegreyaSans-ExtraBoldItalic-tosf-t1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tosf-t1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tosf-t1.vf \
tex-AlegreyaSans-ExtraBoldItalic-tosf-ts1--base.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tosf-ts1.tfm \
tex-AlegreyaSans-ExtraBoldItalic-tosf-ts1.vf \
tex-AlegreyaSans-Italic-inf-lgr--base.tfm \
tex-AlegreyaSans-Italic-inf-lgr.tfm \
tex-AlegreyaSans-Italic-inf-lgr.vf \
tex-AlegreyaSans-Italic-inf-ly1--base.tfm \
tex-AlegreyaSans-Italic-inf-ly1.tfm \
tex-AlegreyaSans-Italic-inf-ly1.vf \
tex-AlegreyaSans-Italic-inf-ot1.tfm \
tex-AlegreyaSans-Italic-inf-t1--base.tfm \
tex-AlegreyaSans-Italic-inf-t1.tfm \
tex-AlegreyaSans-Italic-inf-t1.vf \
tex-AlegreyaSans-Italic-lf-lgr--base.tfm \
tex-AlegreyaSans-Italic-lf-lgr.tfm \
tex-AlegreyaSans-Italic-lf-lgr.vf \
tex-AlegreyaSans-Italic-lf-ly1--base.tfm \
tex-AlegreyaSans-Italic-lf-ly1.tfm \
tex-AlegreyaSans-Italic-lf-ly1.vf \
tex-AlegreyaSans-Italic-lf-ot1.tfm \
tex-AlegreyaSans-Italic-lf-sc-lgr--base.tfm \
tex-AlegreyaSans-Italic-lf-sc-lgr.tfm \
tex-AlegreyaSans-Italic-lf-sc-lgr.vf \
tex-AlegreyaSans-Italic-lf-sc-ly1--base.tfm \
tex-AlegreyaSans-Italic-lf-sc-ly1.tfm \
tex-AlegreyaSans-Italic-lf-sc-ly1.vf \
tex-AlegreyaSans-Italic-lf-sc-ot1--base.tfm \
tex-AlegreyaSans-Italic-lf-sc-ot1.tfm \
tex-AlegreyaSans-Italic-lf-sc-ot1.vf \
tex-AlegreyaSans-Italic-lf-sc-t1--base.tfm \
tex-AlegreyaSans-Italic-lf-sc-t1.tfm \
tex-AlegreyaSans-Italic-lf-sc-t1.vf \
tex-AlegreyaSans-Italic-lf-t1--base.tfm \
tex-AlegreyaSans-Italic-lf-t1.tfm \
tex-AlegreyaSans-Italic-lf-t1.vf \
tex-AlegreyaSans-Italic-lf-ts1--base.tfm \
tex-AlegreyaSans-Italic-lf-ts1.tfm \
tex-AlegreyaSans-Italic-lf-ts1.vf \
tex-AlegreyaSans-Italic-osf-lgr--base.tfm \
tex-AlegreyaSans-Italic-osf-lgr.tfm \
tex-AlegreyaSans-Italic-osf-lgr.vf \
tex-AlegreyaSans-Italic-osf-ly1--base.tfm \
tex-AlegreyaSans-Italic-osf-ly1.tfm \
tex-AlegreyaSans-Italic-osf-ly1.vf \
tex-AlegreyaSans-Italic-osf-ot1.tfm \
tex-AlegreyaSans-Italic-osf-sc-lgr--base.tfm \
tex-AlegreyaSans-Italic-osf-sc-lgr.tfm \
tex-AlegreyaSans-Italic-osf-sc-lgr.vf \
tex-AlegreyaSans-Italic-osf-sc-ly1--base.tfm \
tex-AlegreyaSans-Italic-osf-sc-ly1.tfm \
tex-AlegreyaSans-Italic-osf-sc-ly1.vf \
tex-AlegreyaSans-Italic-osf-sc-ot1--base.tfm \
tex-AlegreyaSans-Italic-osf-sc-ot1.tfm \
tex-AlegreyaSans-Italic-osf-sc-ot1.vf \
tex-AlegreyaSans-Italic-osf-sc-t1--base.tfm \
tex-AlegreyaSans-Italic-osf-sc-t1.tfm \
tex-AlegreyaSans-Italic-osf-sc-t1.vf \
tex-AlegreyaSans-Italic-osf-t1--base.tfm \
tex-AlegreyaSans-Italic-osf-t1.tfm \
tex-AlegreyaSans-Italic-osf-t1.vf \
tex-AlegreyaSans-Italic-osf-ts1--base.tfm \
tex-AlegreyaSans-Italic-osf-ts1.tfm \
tex-AlegreyaSans-Italic-osf-ts1.vf \
tex-AlegreyaSans-Italic-sup-lgr--base.tfm \
tex-AlegreyaSans-Italic-sup-lgr.tfm \
tex-AlegreyaSans-Italic-sup-lgr.vf \
tex-AlegreyaSans-Italic-sup-ly1--base.tfm \
tex-AlegreyaSans-Italic-sup-ly1.tfm \
tex-AlegreyaSans-Italic-sup-ly1.vf \
tex-AlegreyaSans-Italic-sup-ot1.tfm \
tex-AlegreyaSans-Italic-sup-t1--base.tfm \
tex-AlegreyaSans-Italic-sup-t1.tfm \
tex-AlegreyaSans-Italic-sup-t1.vf \
tex-AlegreyaSans-Italic-tlf-lgr--base.tfm \
tex-AlegreyaSans-Italic-tlf-lgr.tfm \
tex-AlegreyaSans-Italic-tlf-lgr.vf \
tex-AlegreyaSans-Italic-tlf-ly1--base.tfm \
tex-AlegreyaSans-Italic-tlf-ly1.tfm \
tex-AlegreyaSans-Italic-tlf-ly1.vf \
tex-AlegreyaSans-Italic-tlf-ot1.tfm \
tex-AlegreyaSans-Italic-tlf-sc-lgr--base.tfm \
tex-AlegreyaSans-Italic-tlf-sc-lgr.tfm \
tex-AlegreyaSans-Italic-tlf-sc-lgr.vf \
tex-AlegreyaSans-Italic-tlf-sc-ly1--base.tfm \
tex-AlegreyaSans-Italic-tlf-sc-ly1.tfm \
tex-AlegreyaSans-Italic-tlf-sc-ly1.vf \
tex-AlegreyaSans-Italic-tlf-sc-ot1--base.tfm \
tex-AlegreyaSans-Italic-tlf-sc-ot1.tfm \
tex-AlegreyaSans-Italic-tlf-sc-ot1.vf \
tex-AlegreyaSans-Italic-tlf-sc-t1--base.tfm \
tex-AlegreyaSans-Italic-tlf-sc-t1.tfm \
tex-AlegreyaSans-Italic-tlf-sc-t1.vf \
tex-AlegreyaSans-Italic-tlf-t1--base.tfm \
tex-AlegreyaSans-Italic-tlf-t1.tfm \
tex-AlegreyaSans-Italic-tlf-t1.vf \
tex-AlegreyaSans-Italic-tlf-ts1--base.tfm \
tex-AlegreyaSans-Italic-tlf-ts1.tfm \
tex-AlegreyaSans-Italic-tlf-ts1.vf \
tex-AlegreyaSans-Italic-tosf-lgr--base.tfm \
tex-AlegreyaSans-Italic-tosf-lgr.tfm \
tex-AlegreyaSans-Italic-tosf-lgr.vf \
tex-AlegreyaSans-Italic-tosf-ly1--base.tfm \
tex-AlegreyaSans-Italic-tosf-ly1.tfm \
tex-AlegreyaSans-Italic-tosf-ly1.vf \
tex-AlegreyaSans-Italic-tosf-ot1.tfm \
tex-AlegreyaSans-Italic-tosf-sc-lgr--base.tfm \
tex-AlegreyaSans-Italic-tosf-sc-lgr.tfm \
tex-AlegreyaSans-Italic-tosf-sc-lgr.vf \
tex-AlegreyaSans-Italic-tosf-sc-ly1--base.tfm \
tex-AlegreyaSans-Italic-tosf-sc-ly1.tfm \
tex-AlegreyaSans-Italic-tosf-sc-ly1.vf \
tex-AlegreyaSans-Italic-tosf-sc-ot1--base.tfm \
tex-AlegreyaSans-Italic-tosf-sc-ot1.tfm \
tex-AlegreyaSans-Italic-tosf-sc-ot1.vf \
tex-AlegreyaSans-Italic-tosf-sc-t1--base.tfm \
tex-AlegreyaSans-Italic-tosf-sc-t1.tfm \
tex-AlegreyaSans-Italic-tosf-sc-t1.vf \
tex-AlegreyaSans-Italic-tosf-t1--base.tfm \
tex-AlegreyaSans-Italic-tosf-t1.tfm \
tex-AlegreyaSans-Italic-tosf-t1.vf \
tex-AlegreyaSans-Italic-tosf-ts1--base.tfm \
tex-AlegreyaSans-Italic-tosf-ts1.tfm \
tex-AlegreyaSans-Italic-tosf-ts1.vf \
tex-AlegreyaSans-Light-inf-lgr--base.tfm \
tex-AlegreyaSans-Light-inf-lgr.tfm \
tex-AlegreyaSans-Light-inf-lgr.vf \
tex-AlegreyaSans-Light-inf-ly1--base.tfm \
tex-AlegreyaSans-Light-inf-ly1.tfm \
tex-AlegreyaSans-Light-inf-ly1.vf \
tex-AlegreyaSans-Light-inf-ot1.tfm \
tex-AlegreyaSans-Light-inf-t1--base.tfm \
tex-AlegreyaSans-Light-inf-t1.tfm \
tex-AlegreyaSans-Light-inf-t1.vf \
tex-AlegreyaSans-Light-lf-lgr--base.tfm \
tex-AlegreyaSans-Light-lf-lgr.tfm \
tex-AlegreyaSans-Light-lf-lgr.vf \
tex-AlegreyaSans-Light-lf-ly1--base.tfm \
tex-AlegreyaSans-Light-lf-ly1.tfm \
tex-AlegreyaSans-Light-lf-ly1.vf \
tex-AlegreyaSans-Light-lf-ot1.tfm \
tex-AlegreyaSans-Light-lf-sc-lgr--base.tfm \
tex-AlegreyaSans-Light-lf-sc-lgr.tfm \
tex-AlegreyaSans-Light-lf-sc-lgr.vf \
tex-AlegreyaSans-Light-lf-sc-ly1--base.tfm \
tex-AlegreyaSans-Light-lf-sc-ly1.tfm \
tex-AlegreyaSans-Light-lf-sc-ly1.vf \
tex-AlegreyaSans-Light-lf-sc-ot1--base.tfm \
tex-AlegreyaSans-Light-lf-sc-ot1.tfm \
tex-AlegreyaSans-Light-lf-sc-ot1.vf \
tex-AlegreyaSans-Light-lf-sc-t1--base.tfm \
tex-AlegreyaSans-Light-lf-sc-t1.tfm \
tex-AlegreyaSans-Light-lf-sc-t1.vf \
tex-AlegreyaSans-Light-lf-t1--base.tfm \
tex-AlegreyaSans-Light-lf-t1.tfm \
tex-AlegreyaSans-Light-lf-t1.vf \
tex-AlegreyaSans-Light-lf-ts1--base.tfm \
tex-AlegreyaSans-Light-lf-ts1.tfm \
tex-AlegreyaSans-Light-lf-ts1.vf \
tex-AlegreyaSans-Light-osf-lgr--base.tfm \
tex-AlegreyaSans-Light-osf-lgr.tfm \
tex-AlegreyaSans-Light-osf-lgr.vf \
tex-AlegreyaSans-Light-osf-ly1--base.tfm \
tex-AlegreyaSans-Light-osf-ly1.tfm \
tex-AlegreyaSans-Light-osf-ly1.vf \
tex-AlegreyaSans-Light-osf-ot1.tfm \
tex-AlegreyaSans-Light-osf-sc-lgr--base.tfm \
tex-AlegreyaSans-Light-osf-sc-lgr.tfm \
tex-AlegreyaSans-Light-osf-sc-lgr.vf \
tex-AlegreyaSans-Light-osf-sc-ly1--base.tfm \
tex-AlegreyaSans-Light-osf-sc-ly1.tfm \
tex-AlegreyaSans-Light-osf-sc-ly1.vf \
tex-AlegreyaSans-Light-osf-sc-ot1--base.tfm \
tex-AlegreyaSans-Light-osf-sc-ot1.tfm \
tex-AlegreyaSans-Light-osf-sc-ot1.vf \
tex-AlegreyaSans-Light-osf-sc-t1--base.tfm \
tex-AlegreyaSans-Light-osf-sc-t1.tfm \
tex-AlegreyaSans-Light-osf-sc-t1.vf \
tex-AlegreyaSans-Light-osf-t1--base.tfm \
tex-AlegreyaSans-Light-osf-t1.tfm \
tex-AlegreyaSans-Light-osf-t1.vf \
tex-AlegreyaSans-Light-osf-ts1--base.tfm \
tex-AlegreyaSans-Light-osf-ts1.tfm \
tex-AlegreyaSans-Light-osf-ts1.vf \
tex-AlegreyaSans-Light-sup-lgr--base.tfm \
tex-AlegreyaSans-Light-sup-lgr.tfm \
tex-AlegreyaSans-Light-sup-lgr.vf \
tex-AlegreyaSans-Light-sup-ly1--base.tfm \
tex-AlegreyaSans-Light-sup-ly1.tfm \
tex-AlegreyaSans-Light-sup-ly1.vf \
tex-AlegreyaSans-Light-sup-ot1.tfm \
tex-AlegreyaSans-Light-sup-t1--base.tfm \
tex-AlegreyaSans-Light-sup-t1.tfm \
tex-AlegreyaSans-Light-sup-t1.vf \
tex-AlegreyaSans-Light-tlf-lgr--base.tfm \
tex-AlegreyaSans-Light-tlf-lgr.tfm \
tex-AlegreyaSans-Light-tlf-lgr.vf \
tex-AlegreyaSans-Light-tlf-ly1--base.tfm \
tex-AlegreyaSans-Light-tlf-ly1.tfm \
tex-AlegreyaSans-Light-tlf-ly1.vf \
tex-AlegreyaSans-Light-tlf-ot1.tfm \
tex-AlegreyaSans-Light-tlf-sc-lgr--base.tfm \
tex-AlegreyaSans-Light-tlf-sc-lgr.tfm \
tex-AlegreyaSans-Light-tlf-sc-lgr.vf \
tex-AlegreyaSans-Light-tlf-sc-ly1--base.tfm \
tex-AlegreyaSans-Light-tlf-sc-ly1.tfm \
tex-AlegreyaSans-Light-tlf-sc-ly1.vf \
tex-AlegreyaSans-Light-tlf-sc-ot1--base.tfm \
tex-AlegreyaSans-Light-tlf-sc-ot1.tfm \
tex-AlegreyaSans-Light-tlf-sc-ot1.vf \
tex-AlegreyaSans-Light-tlf-sc-t1--base.tfm \
tex-AlegreyaSans-Light-tlf-sc-t1.tfm \
tex-AlegreyaSans-Light-tlf-sc-t1.vf \
tex-AlegreyaSans-Light-tlf-t1--base.tfm \
tex-AlegreyaSans-Light-tlf-t1.tfm \
tex-AlegreyaSans-Light-tlf-t1.vf \
tex-AlegreyaSans-Light-tlf-ts1--base.tfm \
tex-AlegreyaSans-Light-tlf-ts1.tfm \
tex-AlegreyaSans-Light-tlf-ts1.vf \
tex-AlegreyaSans-Light-tosf-lgr--base.tfm \
tex-AlegreyaSans-Light-tosf-lgr.tfm \
tex-AlegreyaSans-Light-tosf-lgr.vf \
tex-AlegreyaSans-Light-tosf-ly1--base.tfm \
tex-AlegreyaSans-Light-tosf-ly1.tfm \
tex-AlegreyaSans-Light-tosf-ly1.vf \
tex-AlegreyaSans-Light-tosf-ot1.tfm \
tex-AlegreyaSans-Light-tosf-sc-lgr--base.tfm \
tex-AlegreyaSans-Light-tosf-sc-lgr.tfm \
tex-AlegreyaSans-Light-tosf-sc-lgr.vf \
tex-AlegreyaSans-Light-tosf-sc-ly1--base.tfm \
tex-AlegreyaSans-Light-tosf-sc-ly1.tfm \
tex-AlegreyaSans-Light-tosf-sc-ly1.vf \
tex-AlegreyaSans-Light-tosf-sc-ot1--base.tfm \
tex-AlegreyaSans-Light-tosf-sc-ot1.tfm \
tex-AlegreyaSans-Light-tosf-sc-ot1.vf \
tex-AlegreyaSans-Light-tosf-sc-t1--base.tfm \
tex-AlegreyaSans-Light-tosf-sc-t1.tfm \
tex-AlegreyaSans-Light-tosf-sc-t1.vf \
tex-AlegreyaSans-Light-tosf-t1--base.tfm \
tex-AlegreyaSans-Light-tosf-t1.tfm \
tex-AlegreyaSans-Light-tosf-t1.vf \
tex-AlegreyaSans-Light-tosf-ts1--base.tfm \
tex-AlegreyaSans-Light-tosf-ts1.tfm \
tex-AlegreyaSans-Light-tosf-ts1.vf \
tex-AlegreyaSans-LightItalic-inf-lgr--base.tfm \
tex-AlegreyaSans-LightItalic-inf-lgr.tfm \
tex-AlegreyaSans-LightItalic-inf-lgr.vf \
tex-AlegreyaSans-LightItalic-inf-ly1--base.tfm \
tex-AlegreyaSans-LightItalic-inf-ly1.tfm \
tex-AlegreyaSans-LightItalic-inf-ly1.vf \
tex-AlegreyaSans-LightItalic-inf-ot1.tfm \
tex-AlegreyaSans-LightItalic-inf-t1--base.tfm \
tex-AlegreyaSans-LightItalic-inf-t1.tfm \
tex-AlegreyaSans-LightItalic-inf-t1.vf \
tex-AlegreyaSans-LightItalic-lf-lgr--base.tfm \
tex-AlegreyaSans-LightItalic-lf-lgr.tfm \
tex-AlegreyaSans-LightItalic-lf-lgr.vf \
tex-AlegreyaSans-LightItalic-lf-ly1--base.tfm \
tex-AlegreyaSans-LightItalic-lf-ly1.tfm \
tex-AlegreyaSans-LightItalic-lf-ly1.vf \
tex-AlegreyaSans-LightItalic-lf-ot1.tfm \
tex-AlegreyaSans-LightItalic-lf-sc-lgr--base.tfm \
tex-AlegreyaSans-LightItalic-lf-sc-lgr.tfm \
tex-AlegreyaSans-LightItalic-lf-sc-lgr.vf \
tex-AlegreyaSans-LightItalic-lf-sc-ly1--base.tfm \
tex-AlegreyaSans-LightItalic-lf-sc-ly1.tfm \
tex-AlegreyaSans-LightItalic-lf-sc-ly1.vf \
tex-AlegreyaSans-LightItalic-lf-sc-ot1--base.tfm \
tex-AlegreyaSans-LightItalic-lf-sc-ot1.tfm \
tex-AlegreyaSans-LightItalic-lf-sc-ot1.vf \
tex-AlegreyaSans-LightItalic-lf-sc-t1--base.tfm \
tex-AlegreyaSans-LightItalic-lf-sc-t1.tfm \
tex-AlegreyaSans-LightItalic-lf-sc-t1.vf \
tex-AlegreyaSans-LightItalic-lf-t1--base.tfm \
tex-AlegreyaSans-LightItalic-lf-t1.tfm \
tex-AlegreyaSans-LightItalic-lf-t1.vf \
tex-AlegreyaSans-LightItalic-lf-ts1--base.tfm \
tex-AlegreyaSans-LightItalic-lf-ts1.tfm \
tex-AlegreyaSans-LightItalic-lf-ts1.vf \
tex-AlegreyaSans-LightItalic-osf-lgr--base.tfm \
tex-AlegreyaSans-LightItalic-osf-lgr.tfm \
tex-AlegreyaSans-LightItalic-osf-lgr.vf \
tex-AlegreyaSans-LightItalic-osf-ly1--base.tfm \
tex-AlegreyaSans-LightItalic-osf-ly1.tfm \
tex-AlegreyaSans-LightItalic-osf-ly1.vf \
tex-AlegreyaSans-LightItalic-osf-ot1.tfm \
tex-AlegreyaSans-LightItalic-osf-sc-lgr--base.tfm \
tex-AlegreyaSans-LightItalic-osf-sc-lgr.tfm \
tex-AlegreyaSans-LightItalic-osf-sc-lgr.vf \
tex-AlegreyaSans-LightItalic-osf-sc-ly1--base.tfm \
tex-AlegreyaSans-LightItalic-osf-sc-ly1.tfm \
tex-AlegreyaSans-LightItalic-osf-sc-ly1.vf \
tex-AlegreyaSans-LightItalic-osf-sc-ot1--base.tfm \
tex-AlegreyaSans-LightItalic-osf-sc-ot1.tfm \
tex-AlegreyaSans-LightItalic-osf-sc-ot1.vf \
tex-AlegreyaSans-LightItalic-osf-sc-t1--base.tfm \
tex-AlegreyaSans-LightItalic-osf-sc-t1.tfm \
tex-AlegreyaSans-LightItalic-osf-sc-t1.vf \
tex-AlegreyaSans-LightItalic-osf-t1--base.tfm \
tex-AlegreyaSans-LightItalic-osf-t1.tfm \
tex-AlegreyaSans-LightItalic-osf-t1.vf \
tex-AlegreyaSans-LightItalic-osf-ts1--base.tfm \
tex-AlegreyaSans-LightItalic-osf-ts1.tfm \
tex-AlegreyaSans-LightItalic-osf-ts1.vf \
tex-AlegreyaSans-LightItalic-sup-lgr--base.tfm \
tex-AlegreyaSans-LightItalic-sup-lgr.tfm \
tex-AlegreyaSans-LightItalic-sup-lgr.vf \
tex-AlegreyaSans-LightItalic-sup-ly1--base.tfm \
tex-AlegreyaSans-LightItalic-sup-ly1.tfm \
tex-AlegreyaSans-LightItalic-sup-ly1.vf \
tex-AlegreyaSans-LightItalic-sup-ot1.tfm \
tex-AlegreyaSans-LightItalic-sup-t1--base.tfm \
tex-AlegreyaSans-LightItalic-sup-t1.tfm \
tex-AlegreyaSans-LightItalic-sup-t1.vf \
tex-AlegreyaSans-LightItalic-tlf-lgr--base.tfm \
tex-AlegreyaSans-LightItalic-tlf-lgr.tfm \
tex-AlegreyaSans-LightItalic-tlf-lgr.vf \
tex-AlegreyaSans-LightItalic-tlf-ly1--base.tfm \
tex-AlegreyaSans-LightItalic-tlf-ly1.tfm \
tex-AlegreyaSans-LightItalic-tlf-ly1.vf \
tex-AlegreyaSans-LightItalic-tlf-ot1.tfm \
tex-AlegreyaSans-LightItalic-tlf-sc-lgr--base.tfm \
tex-AlegreyaSans-LightItalic-tlf-sc-lgr.tfm \
tex-AlegreyaSans-LightItalic-tlf-sc-lgr.vf \
tex-AlegreyaSans-LightItalic-tlf-sc-ly1--base.tfm \
tex-AlegreyaSans-LightItalic-tlf-sc-ly1.tfm \
tex-AlegreyaSans-LightItalic-tlf-sc-ly1.vf \
tex-AlegreyaSans-LightItalic-tlf-sc-ot1--base.tfm \
tex-AlegreyaSans-LightItalic-tlf-sc-ot1.tfm \
tex-AlegreyaSans-LightItalic-tlf-sc-ot1.vf \
tex-AlegreyaSans-LightItalic-tlf-sc-t1--base.tfm \
tex-AlegreyaSans-LightItalic-tlf-sc-t1.tfm \
tex-AlegreyaSans-LightItalic-tlf-sc-t1.vf \
tex-AlegreyaSans-LightItalic-tlf-t1--base.tfm \
tex-AlegreyaSans-LightItalic-tlf-t1.tfm \
tex-AlegreyaSans-LightItalic-tlf-t1.vf \
tex-AlegreyaSans-LightItalic-tlf-ts1--base.tfm \
tex-AlegreyaSans-LightItalic-tlf-ts1.tfm \
tex-AlegreyaSans-LightItalic-tlf-ts1.vf \
tex-AlegreyaSans-LightItalic-tosf-lgr--base.tfm \
tex-AlegreyaSans-LightItalic-tosf-lgr.tfm \
tex-AlegreyaSans-LightItalic-tosf-lgr.vf \
tex-AlegreyaSans-LightItalic-tosf-ly1--base.tfm \
tex-AlegreyaSans-LightItalic-tosf-ly1.tfm \
tex-AlegreyaSans-LightItalic-tosf-ly1.vf \
tex-AlegreyaSans-LightItalic-tosf-ot1.tfm \
tex-AlegreyaSans-LightItalic-tosf-sc-lgr--base.tfm \
tex-AlegreyaSans-LightItalic-tosf-sc-lgr.tfm \
tex-AlegreyaSans-LightItalic-tosf-sc-lgr.vf \
tex-AlegreyaSans-LightItalic-tosf-sc-ly1--base.tfm \
tex-AlegreyaSans-LightItalic-tosf-sc-ly1.tfm \
tex-AlegreyaSans-LightItalic-tosf-sc-ly1.vf \
tex-AlegreyaSans-LightItalic-tosf-sc-ot1--base.tfm \
tex-AlegreyaSans-LightItalic-tosf-sc-ot1.tfm \
tex-AlegreyaSans-LightItalic-tosf-sc-ot1.vf \
tex-AlegreyaSans-LightItalic-tosf-sc-t1--base.tfm \
tex-AlegreyaSans-LightItalic-tosf-sc-t1.tfm \
tex-AlegreyaSans-LightItalic-tosf-sc-t1.vf \
tex-AlegreyaSans-LightItalic-tosf-t1--base.tfm \
tex-AlegreyaSans-LightItalic-tosf-t1.tfm \
tex-AlegreyaSans-LightItalic-tosf-t1.vf \
tex-AlegreyaSans-LightItalic-tosf-ts1--base.tfm \
tex-AlegreyaSans-LightItalic-tosf-ts1.tfm \
tex-AlegreyaSans-LightItalic-tosf-ts1.vf \
tex-AlegreyaSans-Medium-inf-lgr--base.tfm \
tex-AlegreyaSans-Medium-inf-lgr.tfm \
tex-AlegreyaSans-Medium-inf-lgr.vf \
tex-AlegreyaSans-Medium-inf-ly1--base.tfm \
tex-AlegreyaSans-Medium-inf-ly1.tfm \
tex-AlegreyaSans-Medium-inf-ly1.vf \
tex-AlegreyaSans-Medium-inf-ot1.tfm \
tex-AlegreyaSans-Medium-inf-t1--base.tfm \
tex-AlegreyaSans-Medium-inf-t1.tfm \
tex-AlegreyaSans-Medium-inf-t1.vf \
tex-AlegreyaSans-Medium-lf-lgr--base.tfm \
tex-AlegreyaSans-Medium-lf-lgr.tfm \
tex-AlegreyaSans-Medium-lf-lgr.vf \
tex-AlegreyaSans-Medium-lf-ly1--base.tfm \
tex-AlegreyaSans-Medium-lf-ly1.tfm \
tex-AlegreyaSans-Medium-lf-ly1.vf \
tex-AlegreyaSans-Medium-lf-ot1.tfm \
tex-AlegreyaSans-Medium-lf-sc-lgr--base.tfm \
tex-AlegreyaSans-Medium-lf-sc-lgr.tfm \
tex-AlegreyaSans-Medium-lf-sc-lgr.vf \
tex-AlegreyaSans-Medium-lf-sc-ly1--base.tfm \
tex-AlegreyaSans-Medium-lf-sc-ly1.tfm \
tex-AlegreyaSans-Medium-lf-sc-ly1.vf \
tex-AlegreyaSans-Medium-lf-sc-ot1--base.tfm \
tex-AlegreyaSans-Medium-lf-sc-ot1.tfm \
tex-AlegreyaSans-Medium-lf-sc-ot1.vf \
tex-AlegreyaSans-Medium-lf-sc-t1--base.tfm \
tex-AlegreyaSans-Medium-lf-sc-t1.tfm \
tex-AlegreyaSans-Medium-lf-sc-t1.vf \
tex-AlegreyaSans-Medium-lf-t1--base.tfm \
tex-AlegreyaSans-Medium-lf-t1.tfm \
tex-AlegreyaSans-Medium-lf-t1.vf \
tex-AlegreyaSans-Medium-lf-ts1--base.tfm \
tex-AlegreyaSans-Medium-lf-ts1.tfm \
tex-AlegreyaSans-Medium-lf-ts1.vf \
tex-AlegreyaSans-Medium-osf-lgr--base.tfm \
tex-AlegreyaSans-Medium-osf-lgr.tfm \
tex-AlegreyaSans-Medium-osf-lgr.vf \
tex-AlegreyaSans-Medium-osf-ly1--base.tfm \
tex-AlegreyaSans-Medium-osf-ly1.tfm \
tex-AlegreyaSans-Medium-osf-ly1.vf \
tex-AlegreyaSans-Medium-osf-ot1.tfm \
tex-AlegreyaSans-Medium-osf-sc-lgr--base.tfm \
tex-AlegreyaSans-Medium-osf-sc-lgr.tfm \
tex-AlegreyaSans-Medium-osf-sc-lgr.vf \
tex-AlegreyaSans-Medium-osf-sc-ly1--base.tfm \
tex-AlegreyaSans-Medium-osf-sc-ly1.tfm \
tex-AlegreyaSans-Medium-osf-sc-ly1.vf \
tex-AlegreyaSans-Medium-osf-sc-ot1--base.tfm \
tex-AlegreyaSans-Medium-osf-sc-ot1.tfm \
tex-AlegreyaSans-Medium-osf-sc-ot1.vf \
tex-AlegreyaSans-Medium-osf-sc-t1--base.tfm \
tex-AlegreyaSans-Medium-osf-sc-t1.tfm \
tex-AlegreyaSans-Medium-osf-sc-t1.vf \
tex-AlegreyaSans-Medium-osf-t1--base.tfm \
tex-AlegreyaSans-Medium-osf-t1.tfm \
tex-AlegreyaSans-Medium-osf-t1.vf \
tex-AlegreyaSans-Medium-osf-ts1--base.tfm \
tex-AlegreyaSans-Medium-osf-ts1.tfm \
tex-AlegreyaSans-Medium-osf-ts1.vf \
tex-AlegreyaSans-Medium-sup-lgr--base.tfm \
tex-AlegreyaSans-Medium-sup-lgr.tfm \
tex-AlegreyaSans-Medium-sup-lgr.vf \
tex-AlegreyaSans-Medium-sup-ly1--base.tfm \
tex-AlegreyaSans-Medium-sup-ly1.tfm \
tex-AlegreyaSans-Medium-sup-ly1.vf \
tex-AlegreyaSans-Medium-sup-ot1.tfm \
tex-AlegreyaSans-Medium-sup-t1--base.tfm \
tex-AlegreyaSans-Medium-sup-t1.tfm \
tex-AlegreyaSans-Medium-sup-t1.vf \
tex-AlegreyaSans-Medium-tlf-lgr--base.tfm \
tex-AlegreyaSans-Medium-tlf-lgr.tfm \
tex-AlegreyaSans-Medium-tlf-lgr.vf \
tex-AlegreyaSans-Medium-tlf-ly1--base.tfm \
tex-AlegreyaSans-Medium-tlf-ly1.tfm \
tex-AlegreyaSans-Medium-tlf-ly1.vf \
tex-AlegreyaSans-Medium-tlf-ot1.tfm \
tex-AlegreyaSans-Medium-tlf-sc-lgr--base.tfm \
tex-AlegreyaSans-Medium-tlf-sc-lgr.tfm \
tex-AlegreyaSans-Medium-tlf-sc-lgr.vf \
tex-AlegreyaSans-Medium-tlf-sc-ly1--base.tfm \
tex-AlegreyaSans-Medium-tlf-sc-ly1.tfm \
tex-AlegreyaSans-Medium-tlf-sc-ly1.vf \
tex-AlegreyaSans-Medium-tlf-sc-ot1--base.tfm \
tex-AlegreyaSans-Medium-tlf-sc-ot1.tfm \
tex-AlegreyaSans-Medium-tlf-sc-ot1.vf \
tex-AlegreyaSans-Medium-tlf-sc-t1--base.tfm \
tex-AlegreyaSans-Medium-tlf-sc-t1.tfm \
tex-AlegreyaSans-Medium-tlf-sc-t1.vf \
tex-AlegreyaSans-Medium-tlf-t1--base.tfm \
tex-AlegreyaSans-Medium-tlf-t1.tfm \
tex-AlegreyaSans-Medium-tlf-t1.vf \
tex-AlegreyaSans-Medium-tlf-ts1--base.tfm \
tex-AlegreyaSans-Medium-tlf-ts1.tfm \
tex-AlegreyaSans-Medium-tlf-ts1.vf \
tex-AlegreyaSans-Medium-tosf-lgr--base.tfm \
tex-AlegreyaSans-Medium-tosf-lgr.tfm \
tex-AlegreyaSans-Medium-tosf-lgr.vf \
tex-AlegreyaSans-Medium-tosf-ly1--base.tfm \
tex-AlegreyaSans-Medium-tosf-ly1.tfm \
tex-AlegreyaSans-Medium-tosf-ly1.vf \
tex-AlegreyaSans-Medium-tosf-ot1.tfm \
tex-AlegreyaSans-Medium-tosf-sc-lgr--base.tfm \
tex-AlegreyaSans-Medium-tosf-sc-lgr.tfm \
tex-AlegreyaSans-Medium-tosf-sc-lgr.vf \
tex-AlegreyaSans-Medium-tosf-sc-ly1--base.tfm \
tex-AlegreyaSans-Medium-tosf-sc-ly1.tfm \
tex-AlegreyaSans-Medium-tosf-sc-ly1.vf \
tex-AlegreyaSans-Medium-tosf-sc-ot1--base.tfm \
tex-AlegreyaSans-Medium-tosf-sc-ot1.tfm \
tex-AlegreyaSans-Medium-tosf-sc-ot1.vf \
tex-AlegreyaSans-Medium-tosf-sc-t1--base.tfm \
tex-AlegreyaSans-Medium-tosf-sc-t1.tfm \
tex-AlegreyaSans-Medium-tosf-sc-t1.vf \
tex-AlegreyaSans-Medium-tosf-t1--base.tfm \
tex-AlegreyaSans-Medium-tosf-t1.tfm \
tex-AlegreyaSans-Medium-tosf-t1.vf \
tex-AlegreyaSans-Medium-tosf-ts1--base.tfm \
tex-AlegreyaSans-Medium-tosf-ts1.tfm \
tex-AlegreyaSans-Medium-tosf-ts1.vf \
tex-AlegreyaSans-MediumItalic-inf-lgr--base.tfm \
tex-AlegreyaSans-MediumItalic-inf-lgr.tfm \
tex-AlegreyaSans-MediumItalic-inf-lgr.vf \
tex-AlegreyaSans-MediumItalic-inf-ly1--base.tfm \
tex-AlegreyaSans-MediumItalic-inf-ly1.tfm \
tex-AlegreyaSans-MediumItalic-inf-ly1.vf \
tex-AlegreyaSans-MediumItalic-inf-ot1.tfm \
tex-AlegreyaSans-MediumItalic-inf-t1--base.tfm \
tex-AlegreyaSans-MediumItalic-inf-t1.tfm \
tex-AlegreyaSans-MediumItalic-inf-t1.vf \
tex-AlegreyaSans-MediumItalic-lf-lgr--base.tfm \
tex-AlegreyaSans-MediumItalic-lf-lgr.tfm \
tex-AlegreyaSans-MediumItalic-lf-lgr.vf \
tex-AlegreyaSans-MediumItalic-lf-ly1--base.tfm \
tex-AlegreyaSans-MediumItalic-lf-ly1.tfm \
tex-AlegreyaSans-MediumItalic-lf-ly1.vf \
tex-AlegreyaSans-MediumItalic-lf-ot1.tfm \
tex-AlegreyaSans-MediumItalic-lf-sc-lgr--base.tfm \
tex-AlegreyaSans-MediumItalic-lf-sc-lgr.tfm \
tex-AlegreyaSans-MediumItalic-lf-sc-lgr.vf \
tex-AlegreyaSans-MediumItalic-lf-sc-ly1--base.tfm \
tex-AlegreyaSans-MediumItalic-lf-sc-ly1.tfm \
tex-AlegreyaSans-MediumItalic-lf-sc-ly1.vf \
tex-AlegreyaSans-MediumItalic-lf-sc-ot1--base.tfm \
tex-AlegreyaSans-MediumItalic-lf-sc-ot1.tfm \
tex-AlegreyaSans-MediumItalic-lf-sc-ot1.vf \
tex-AlegreyaSans-MediumItalic-lf-sc-t1--base.tfm \
tex-AlegreyaSans-MediumItalic-lf-sc-t1.tfm \
tex-AlegreyaSans-MediumItalic-lf-sc-t1.vf \
tex-AlegreyaSans-MediumItalic-lf-t1--base.tfm \
tex-AlegreyaSans-MediumItalic-lf-t1.tfm \
tex-AlegreyaSans-MediumItalic-lf-t1.vf \
tex-AlegreyaSans-MediumItalic-lf-ts1--base.tfm \
tex-AlegreyaSans-MediumItalic-lf-ts1.tfm \
tex-AlegreyaSans-MediumItalic-lf-ts1.vf \
tex-AlegreyaSans-MediumItalic-osf-lgr--base.tfm \
tex-AlegreyaSans-MediumItalic-osf-lgr.tfm \
tex-AlegreyaSans-MediumItalic-osf-lgr.vf \
tex-AlegreyaSans-MediumItalic-osf-ly1--base.tfm \
tex-AlegreyaSans-MediumItalic-osf-ly1.tfm \
tex-AlegreyaSans-MediumItalic-osf-ly1.vf \
tex-AlegreyaSans-MediumItalic-osf-ot1.tfm \
tex-AlegreyaSans-MediumItalic-osf-sc-lgr--base.tfm \
tex-AlegreyaSans-MediumItalic-osf-sc-lgr.tfm \
tex-AlegreyaSans-MediumItalic-osf-sc-lgr.vf \
tex-AlegreyaSans-MediumItalic-osf-sc-ly1--base.tfm \
tex-AlegreyaSans-MediumItalic-osf-sc-ly1.tfm \
tex-AlegreyaSans-MediumItalic-osf-sc-ly1.vf \
tex-AlegreyaSans-MediumItalic-osf-sc-ot1--base.tfm \
tex-AlegreyaSans-MediumItalic-osf-sc-ot1.tfm \
tex-AlegreyaSans-MediumItalic-osf-sc-ot1.vf \
tex-AlegreyaSans-MediumItalic-osf-sc-t1--base.tfm \
tex-AlegreyaSans-MediumItalic-osf-sc-t1.tfm \
tex-AlegreyaSans-MediumItalic-osf-sc-t1.vf \
tex-AlegreyaSans-MediumItalic-osf-t1--base.tfm \
tex-AlegreyaSans-MediumItalic-osf-t1.tfm \
tex-AlegreyaSans-MediumItalic-osf-t1.vf \
tex-AlegreyaSans-MediumItalic-osf-ts1--base.tfm \
tex-AlegreyaSans-MediumItalic-osf-ts1.tfm \
tex-AlegreyaSans-MediumItalic-osf-ts1.vf \
tex-AlegreyaSans-MediumItalic-sup-lgr--base.tfm \
tex-AlegreyaSans-MediumItalic-sup-lgr.tfm \
tex-AlegreyaSans-MediumItalic-sup-lgr.vf \
tex-AlegreyaSans-MediumItalic-sup-ly1--base.tfm \
tex-AlegreyaSans-MediumItalic-sup-ly1.tfm \
tex-AlegreyaSans-MediumItalic-sup-ly1.vf \
tex-AlegreyaSans-MediumItalic-sup-ot1.tfm \
tex-AlegreyaSans-MediumItalic-sup-t1--base.tfm \
tex-AlegreyaSans-MediumItalic-sup-t1.tfm \
tex-AlegreyaSans-MediumItalic-sup-t1.vf \
tex-AlegreyaSans-MediumItalic-tlf-lgr--base.tfm \
tex-AlegreyaSans-MediumItalic-tlf-lgr.tfm \
tex-AlegreyaSans-MediumItalic-tlf-lgr.vf \
tex-AlegreyaSans-MediumItalic-tlf-ly1--base.tfm \
tex-AlegreyaSans-MediumItalic-tlf-ly1.tfm \
tex-AlegreyaSans-MediumItalic-tlf-ly1.vf \
tex-AlegreyaSans-MediumItalic-tlf-ot1.tfm \
tex-AlegreyaSans-MediumItalic-tlf-sc-lgr--base.tfm \
tex-AlegreyaSans-MediumItalic-tlf-sc-lgr.tfm \
tex-AlegreyaSans-MediumItalic-tlf-sc-lgr.vf \
tex-AlegreyaSans-MediumItalic-tlf-sc-ly1--base.tfm \
tex-AlegreyaSans-MediumItalic-tlf-sc-ly1.tfm \
tex-AlegreyaSans-MediumItalic-tlf-sc-ly1.vf \
tex-AlegreyaSans-MediumItalic-tlf-sc-ot1--base.tfm \
tex-AlegreyaSans-MediumItalic-tlf-sc-ot1.tfm \
tex-AlegreyaSans-MediumItalic-tlf-sc-ot1.vf \
tex-AlegreyaSans-MediumItalic-tlf-sc-t1--base.tfm \
tex-AlegreyaSans-MediumItalic-tlf-sc-t1.tfm \
tex-AlegreyaSans-MediumItalic-tlf-sc-t1.vf \
tex-AlegreyaSans-MediumItalic-tlf-t1--base.tfm \
tex-AlegreyaSans-MediumItalic-tlf-t1.tfm \
tex-AlegreyaSans-MediumItalic-tlf-t1.vf \
tex-AlegreyaSans-MediumItalic-tlf-ts1--base.tfm \
tex-AlegreyaSans-MediumItalic-tlf-ts1.tfm \
tex-AlegreyaSans-MediumItalic-tlf-ts1.vf \
tex-AlegreyaSans-MediumItalic-tosf-lgr--base.tfm \
tex-AlegreyaSans-MediumItalic-tosf-lgr.tfm \
tex-AlegreyaSans-MediumItalic-tosf-lgr.vf \
tex-AlegreyaSans-MediumItalic-tosf-ly1--base.tfm \
tex-AlegreyaSans-MediumItalic-tosf-ly1.tfm \
tex-AlegreyaSans-MediumItalic-tosf-ly1.vf \
tex-AlegreyaSans-MediumItalic-tosf-ot1.tfm \
tex-AlegreyaSans-MediumItalic-tosf-sc-lgr--base.tfm \
tex-AlegreyaSans-MediumItalic-tosf-sc-lgr.tfm \
tex-AlegreyaSans-MediumItalic-tosf-sc-lgr.vf \
tex-AlegreyaSans-MediumItalic-tosf-sc-ly1--base.tfm \
tex-AlegreyaSans-MediumItalic-tosf-sc-ly1.tfm \
tex-AlegreyaSans-MediumItalic-tosf-sc-ly1.vf \
tex-AlegreyaSans-MediumItalic-tosf-sc-ot1--base.tfm \
tex-AlegreyaSans-MediumItalic-tosf-sc-ot1.tfm \
tex-AlegreyaSans-MediumItalic-tosf-sc-ot1.vf \
tex-AlegreyaSans-MediumItalic-tosf-sc-t1--base.tfm \
tex-AlegreyaSans-MediumItalic-tosf-sc-t1.tfm \
tex-AlegreyaSans-MediumItalic-tosf-sc-t1.vf \
tex-AlegreyaSans-MediumItalic-tosf-t1--base.tfm \
tex-AlegreyaSans-MediumItalic-tosf-t1.tfm \
tex-AlegreyaSans-MediumItalic-tosf-t1.vf \
tex-AlegreyaSans-MediumItalic-tosf-ts1--base.tfm \
tex-AlegreyaSans-MediumItalic-tosf-ts1.tfm \
tex-AlegreyaSans-MediumItalic-tosf-ts1.vf \
tex-AlegreyaSans-Regular-inf-lgr--base.tfm \
tex-AlegreyaSans-Regular-inf-lgr.tfm \
tex-AlegreyaSans-Regular-inf-lgr.vf \
tex-AlegreyaSans-Regular-inf-ly1--base.tfm \
tex-AlegreyaSans-Regular-inf-ly1.tfm \
tex-AlegreyaSans-Regular-inf-ly1.vf \
tex-AlegreyaSans-Regular-inf-ot1.tfm \
tex-AlegreyaSans-Regular-inf-t1--base.tfm \
tex-AlegreyaSans-Regular-inf-t1.tfm \
tex-AlegreyaSans-Regular-inf-t1.vf \
tex-AlegreyaSans-Regular-lf-lgr--base.tfm \
tex-AlegreyaSans-Regular-lf-lgr.tfm \
tex-AlegreyaSans-Regular-lf-lgr.vf \
tex-AlegreyaSans-Regular-lf-ly1--base.tfm \
tex-AlegreyaSans-Regular-lf-ly1.tfm \
tex-AlegreyaSans-Regular-lf-ly1.vf \
tex-AlegreyaSans-Regular-lf-ot1.tfm \
tex-AlegreyaSans-Regular-lf-sc-lgr--base.tfm \
tex-AlegreyaSans-Regular-lf-sc-lgr.tfm \
tex-AlegreyaSans-Regular-lf-sc-lgr.vf \
tex-AlegreyaSans-Regular-lf-sc-ly1--base.tfm \
tex-AlegreyaSans-Regular-lf-sc-ly1.tfm \
tex-AlegreyaSans-Regular-lf-sc-ly1.vf \
tex-AlegreyaSans-Regular-lf-sc-ot1--base.tfm \
tex-AlegreyaSans-Regular-lf-sc-ot1.tfm \
tex-AlegreyaSans-Regular-lf-sc-ot1.vf \
tex-AlegreyaSans-Regular-lf-sc-t1--base.tfm \
tex-AlegreyaSans-Regular-lf-sc-t1.tfm \
tex-AlegreyaSans-Regular-lf-sc-t1.vf \
tex-AlegreyaSans-Regular-lf-t1--base.tfm \
tex-AlegreyaSans-Regular-lf-t1.tfm \
tex-AlegreyaSans-Regular-lf-t1.vf \
tex-AlegreyaSans-Regular-lf-ts1--base.tfm \
tex-AlegreyaSans-Regular-lf-ts1.tfm \
tex-AlegreyaSans-Regular-lf-ts1.vf \
tex-AlegreyaSans-Regular-osf-lgr--base.tfm \
tex-AlegreyaSans-Regular-osf-lgr.tfm \
tex-AlegreyaSans-Regular-osf-lgr.vf \
tex-AlegreyaSans-Regular-osf-ly1--base.tfm \
tex-AlegreyaSans-Regular-osf-ly1.tfm \
tex-AlegreyaSans-Regular-osf-ly1.vf \
tex-AlegreyaSans-Regular-osf-ot1.tfm \
tex-AlegreyaSans-Regular-osf-sc-lgr--base.tfm \
tex-AlegreyaSans-Regular-osf-sc-lgr.tfm \
tex-AlegreyaSans-Regular-osf-sc-lgr.vf \
tex-AlegreyaSans-Regular-osf-sc-ly1--base.tfm \
tex-AlegreyaSans-Regular-osf-sc-ly1.tfm \
tex-AlegreyaSans-Regular-osf-sc-ly1.vf \
tex-AlegreyaSans-Regular-osf-sc-ot1--base.tfm \
tex-AlegreyaSans-Regular-osf-sc-ot1.tfm \
tex-AlegreyaSans-Regular-osf-sc-ot1.vf \
tex-AlegreyaSans-Regular-osf-sc-t1--base.tfm \
tex-AlegreyaSans-Regular-osf-sc-t1.tfm \
tex-AlegreyaSans-Regular-osf-sc-t1.vf \
tex-AlegreyaSans-Regular-osf-t1--base.tfm \
tex-AlegreyaSans-Regular-osf-t1.tfm \
tex-AlegreyaSans-Regular-osf-t1.vf \
tex-AlegreyaSans-Regular-osf-ts1--base.tfm \
tex-AlegreyaSans-Regular-osf-ts1.tfm \
tex-AlegreyaSans-Regular-osf-ts1.vf \
tex-AlegreyaSans-Regular-sup-lgr--base.tfm \
tex-AlegreyaSans-Regular-sup-lgr.tfm \
tex-AlegreyaSans-Regular-sup-lgr.vf \
tex-AlegreyaSans-Regular-sup-ly1--base.tfm \
tex-AlegreyaSans-Regular-sup-ly1.tfm \
tex-AlegreyaSans-Regular-sup-ly1.vf \
tex-AlegreyaSans-Regular-sup-ot1.tfm \
tex-AlegreyaSans-Regular-sup-t1--base.tfm \
tex-AlegreyaSans-Regular-sup-t1.tfm \
tex-AlegreyaSans-Regular-sup-t1.vf \
tex-AlegreyaSans-Regular-tlf-lgr--base.tfm \
tex-AlegreyaSans-Regular-tlf-lgr.tfm \
tex-AlegreyaSans-Regular-tlf-lgr.vf \
tex-AlegreyaSans-Regular-tlf-ly1--base.tfm \
tex-AlegreyaSans-Regular-tlf-ly1.tfm \
tex-AlegreyaSans-Regular-tlf-ly1.vf \
tex-AlegreyaSans-Regular-tlf-ot1.tfm \
tex-AlegreyaSans-Regular-tlf-sc-lgr--base.tfm \
tex-AlegreyaSans-Regular-tlf-sc-lgr.tfm \
tex-AlegreyaSans-Regular-tlf-sc-lgr.vf \
tex-AlegreyaSans-Regular-tlf-sc-ly1--base.tfm \
tex-AlegreyaSans-Regular-tlf-sc-ly1.tfm \
tex-AlegreyaSans-Regular-tlf-sc-ly1.vf \
tex-AlegreyaSans-Regular-tlf-sc-ot1--base.tfm \
tex-AlegreyaSans-Regular-tlf-sc-ot1.tfm \
tex-AlegreyaSans-Regular-tlf-sc-ot1.vf \
tex-AlegreyaSans-Regular-tlf-sc-t1--base.tfm \
tex-AlegreyaSans-Regular-tlf-sc-t1.tfm \
tex-AlegreyaSans-Regular-tlf-sc-t1.vf \
tex-AlegreyaSans-Regular-tlf-t1--base.tfm \
tex-AlegreyaSans-Regular-tlf-t1.tfm \
tex-AlegreyaSans-Regular-tlf-t1.vf \
tex-AlegreyaSans-Regular-tlf-ts1--base.tfm \
tex-AlegreyaSans-Regular-tlf-ts1.tfm \
tex-AlegreyaSans-Regular-tlf-ts1.vf \
tex-AlegreyaSans-Regular-tosf-lgr--base.tfm \
tex-AlegreyaSans-Regular-tosf-lgr.tfm \
tex-AlegreyaSans-Regular-tosf-lgr.vf \
tex-AlegreyaSans-Regular-tosf-ly1--base.tfm \
tex-AlegreyaSans-Regular-tosf-ly1.tfm \
tex-AlegreyaSans-Regular-tosf-ly1.vf \
tex-AlegreyaSans-Regular-tosf-ot1.tfm \
tex-AlegreyaSans-Regular-tosf-sc-lgr--base.tfm \
tex-AlegreyaSans-Regular-tosf-sc-lgr.tfm \
tex-AlegreyaSans-Regular-tosf-sc-lgr.vf \
tex-AlegreyaSans-Regular-tosf-sc-ly1--base.tfm \
tex-AlegreyaSans-Regular-tosf-sc-ly1.tfm \
tex-AlegreyaSans-Regular-tosf-sc-ly1.vf \
tex-AlegreyaSans-Regular-tosf-sc-ot1--base.tfm \
tex-AlegreyaSans-Regular-tosf-sc-ot1.tfm \
tex-AlegreyaSans-Regular-tosf-sc-ot1.vf \
tex-AlegreyaSans-Regular-tosf-sc-t1--base.tfm \
tex-AlegreyaSans-Regular-tosf-sc-t1.tfm \
tex-AlegreyaSans-Regular-tosf-sc-t1.vf \
tex-AlegreyaSans-Regular-tosf-t1--base.tfm \
tex-AlegreyaSans-Regular-tosf-t1.tfm \
tex-AlegreyaSans-Regular-tosf-t1.vf \
tex-AlegreyaSans-Regular-tosf-ts1--base.tfm \
tex-AlegreyaSans-Regular-tosf-ts1.tfm \
tex-AlegreyaSans-Regular-tosf-ts1.vf \
tex-AlegreyaSans-Thin-inf-lgr--base.tfm \
tex-AlegreyaSans-Thin-inf-lgr.tfm \
tex-AlegreyaSans-Thin-inf-lgr.vf \
tex-AlegreyaSans-Thin-inf-ly1--base.tfm \
tex-AlegreyaSans-Thin-inf-ly1.tfm \
tex-AlegreyaSans-Thin-inf-ly1.vf \
tex-AlegreyaSans-Thin-inf-ot1.tfm \
tex-AlegreyaSans-Thin-inf-t1--base.tfm \
tex-AlegreyaSans-Thin-inf-t1.tfm \
tex-AlegreyaSans-Thin-inf-t1.vf \
tex-AlegreyaSans-Thin-lf-lgr--base.tfm \
tex-AlegreyaSans-Thin-lf-lgr.tfm \
tex-AlegreyaSans-Thin-lf-lgr.vf \
tex-AlegreyaSans-Thin-lf-ly1--base.tfm \
tex-AlegreyaSans-Thin-lf-ly1.tfm \
tex-AlegreyaSans-Thin-lf-ly1.vf \
tex-AlegreyaSans-Thin-lf-ot1.tfm \
tex-AlegreyaSans-Thin-lf-sc-lgr--base.tfm \
tex-AlegreyaSans-Thin-lf-sc-lgr.tfm \
tex-AlegreyaSans-Thin-lf-sc-lgr.vf \
tex-AlegreyaSans-Thin-lf-sc-ly1--base.tfm \
tex-AlegreyaSans-Thin-lf-sc-ly1.tfm \
tex-AlegreyaSans-Thin-lf-sc-ly1.vf \
tex-AlegreyaSans-Thin-lf-sc-ot1--base.tfm \
tex-AlegreyaSans-Thin-lf-sc-ot1.tfm \
tex-AlegreyaSans-Thin-lf-sc-ot1.vf \
tex-AlegreyaSans-Thin-lf-sc-t1--base.tfm \
tex-AlegreyaSans-Thin-lf-sc-t1.tfm \
tex-AlegreyaSans-Thin-lf-sc-t1.vf \
tex-AlegreyaSans-Thin-lf-t1--base.tfm \
tex-AlegreyaSans-Thin-lf-t1.tfm \
tex-AlegreyaSans-Thin-lf-t1.vf \
tex-AlegreyaSans-Thin-lf-ts1--base.tfm \
tex-AlegreyaSans-Thin-lf-ts1.tfm \
tex-AlegreyaSans-Thin-lf-ts1.vf \
tex-AlegreyaSans-Thin-osf-lgr--base.tfm \
tex-AlegreyaSans-Thin-osf-lgr.tfm \
tex-AlegreyaSans-Thin-osf-lgr.vf \
tex-AlegreyaSans-Thin-osf-ly1--base.tfm \
tex-AlegreyaSans-Thin-osf-ly1.tfm \
tex-AlegreyaSans-Thin-osf-ly1.vf \
tex-AlegreyaSans-Thin-osf-ot1.tfm \
tex-AlegreyaSans-Thin-osf-sc-lgr--base.tfm \
tex-AlegreyaSans-Thin-osf-sc-lgr.tfm \
tex-AlegreyaSans-Thin-osf-sc-lgr.vf \
tex-AlegreyaSans-Thin-osf-sc-ly1--base.tfm \
tex-AlegreyaSans-Thin-osf-sc-ly1.tfm \
tex-AlegreyaSans-Thin-osf-sc-ly1.vf \
tex-AlegreyaSans-Thin-osf-sc-ot1--base.tfm \
tex-AlegreyaSans-Thin-osf-sc-ot1.tfm \
tex-AlegreyaSans-Thin-osf-sc-ot1.vf \
tex-AlegreyaSans-Thin-osf-sc-t1--base.tfm \
tex-AlegreyaSans-Thin-osf-sc-t1.tfm \
tex-AlegreyaSans-Thin-osf-sc-t1.vf \
tex-AlegreyaSans-Thin-osf-t1--base.tfm \
tex-AlegreyaSans-Thin-osf-t1.tfm \
tex-AlegreyaSans-Thin-osf-t1.vf \
tex-AlegreyaSans-Thin-osf-ts1--base.tfm \
tex-AlegreyaSans-Thin-osf-ts1.tfm \
tex-AlegreyaSans-Thin-osf-ts1.vf \
tex-AlegreyaSans-Thin-sup-lgr--base.tfm \
tex-AlegreyaSans-Thin-sup-lgr.tfm \
tex-AlegreyaSans-Thin-sup-lgr.vf \
tex-AlegreyaSans-Thin-sup-ly1--base.tfm \
tex-AlegreyaSans-Thin-sup-ly1.tfm \
tex-AlegreyaSans-Thin-sup-ly1.vf \
tex-AlegreyaSans-Thin-sup-ot1.tfm \
tex-AlegreyaSans-Thin-sup-t1--base.tfm \
tex-AlegreyaSans-Thin-sup-t1.tfm \
tex-AlegreyaSans-Thin-sup-t1.vf \
tex-AlegreyaSans-Thin-tlf-lgr--base.tfm \
tex-AlegreyaSans-Thin-tlf-lgr.tfm \
tex-AlegreyaSans-Thin-tlf-lgr.vf \
tex-AlegreyaSans-Thin-tlf-ly1--base.tfm \
tex-AlegreyaSans-Thin-tlf-ly1.tfm \
tex-AlegreyaSans-Thin-tlf-ly1.vf \
tex-AlegreyaSans-Thin-tlf-ot1.tfm \
tex-AlegreyaSans-Thin-tlf-sc-lgr--base.tfm \
tex-AlegreyaSans-Thin-tlf-sc-lgr.tfm \
tex-AlegreyaSans-Thin-tlf-sc-lgr.vf \
tex-AlegreyaSans-Thin-tlf-sc-ly1--base.tfm \
tex-AlegreyaSans-Thin-tlf-sc-ly1.tfm \
tex-AlegreyaSans-Thin-tlf-sc-ly1.vf \
tex-AlegreyaSans-Thin-tlf-sc-ot1--base.tfm \
tex-AlegreyaSans-Thin-tlf-sc-ot1.tfm \
tex-AlegreyaSans-Thin-tlf-sc-ot1.vf \
tex-AlegreyaSans-Thin-tlf-sc-t1--base.tfm \
tex-AlegreyaSans-Thin-tlf-sc-t1.tfm \
tex-AlegreyaSans-Thin-tlf-sc-t1.vf \
tex-AlegreyaSans-Thin-tlf-t1--base.tfm \
tex-AlegreyaSans-Thin-tlf-t1.tfm \
tex-AlegreyaSans-Thin-tlf-t1.vf \
tex-AlegreyaSans-Thin-tlf-ts1--base.tfm \
tex-AlegreyaSans-Thin-tlf-ts1.tfm \
tex-AlegreyaSans-Thin-tlf-ts1.vf \
tex-AlegreyaSans-Thin-tosf-lgr--base.tfm \
tex-AlegreyaSans-Thin-tosf-lgr.tfm \
tex-AlegreyaSans-Thin-tosf-lgr.vf \
tex-AlegreyaSans-Thin-tosf-ly1--base.tfm \
tex-AlegreyaSans-Thin-tosf-ly1.tfm \
tex-AlegreyaSans-Thin-tosf-ly1.vf \
tex-AlegreyaSans-Thin-tosf-ot1.tfm \
tex-AlegreyaSans-Thin-tosf-sc-lgr--base.tfm \
tex-AlegreyaSans-Thin-tosf-sc-lgr.tfm \
tex-AlegreyaSans-Thin-tosf-sc-lgr.vf \
tex-AlegreyaSans-Thin-tosf-sc-ly1--base.tfm \
tex-AlegreyaSans-Thin-tosf-sc-ly1.tfm \
tex-AlegreyaSans-Thin-tosf-sc-ly1.vf \
tex-AlegreyaSans-Thin-tosf-sc-ot1--base.tfm \
tex-AlegreyaSans-Thin-tosf-sc-ot1.tfm \
tex-AlegreyaSans-Thin-tosf-sc-ot1.vf \
tex-AlegreyaSans-Thin-tosf-sc-t1--base.tfm \
tex-AlegreyaSans-Thin-tosf-sc-t1.tfm \
tex-AlegreyaSans-Thin-tosf-sc-t1.vf \
tex-AlegreyaSans-Thin-tosf-t1--base.tfm \
tex-AlegreyaSans-Thin-tosf-t1.tfm \
tex-AlegreyaSans-Thin-tosf-t1.vf \
tex-AlegreyaSans-Thin-tosf-ts1--base.tfm \
tex-AlegreyaSans-Thin-tosf-ts1.tfm \
tex-AlegreyaSans-Thin-tosf-ts1.vf \
tex-AlegreyaSans-ThinItalic-inf-lgr--base.tfm \
tex-AlegreyaSans-ThinItalic-inf-lgr.tfm \
tex-AlegreyaSans-ThinItalic-inf-lgr.vf \
tex-AlegreyaSans-ThinItalic-inf-ly1--base.tfm \
tex-AlegreyaSans-ThinItalic-inf-ly1.tfm \
tex-AlegreyaSans-ThinItalic-inf-ly1.vf \
tex-AlegreyaSans-ThinItalic-inf-ot1.tfm \
tex-AlegreyaSans-ThinItalic-inf-t1--base.tfm \
tex-AlegreyaSans-ThinItalic-inf-t1.tfm \
tex-AlegreyaSans-ThinItalic-inf-t1.vf \
tex-AlegreyaSans-ThinItalic-lf-lgr--base.tfm \
tex-AlegreyaSans-ThinItalic-lf-lgr.tfm \
tex-AlegreyaSans-ThinItalic-lf-lgr.vf \
tex-AlegreyaSans-ThinItalic-lf-ly1--base.tfm \
tex-AlegreyaSans-ThinItalic-lf-ly1.tfm \
tex-AlegreyaSans-ThinItalic-lf-ly1.vf \
tex-AlegreyaSans-ThinItalic-lf-ot1.tfm \
tex-AlegreyaSans-ThinItalic-lf-sc-lgr--base.tfm \
tex-AlegreyaSans-ThinItalic-lf-sc-lgr.tfm \
tex-AlegreyaSans-ThinItalic-lf-sc-lgr.vf \
tex-AlegreyaSans-ThinItalic-lf-sc-ly1--base.tfm \
tex-AlegreyaSans-ThinItalic-lf-sc-ly1.tfm \
tex-AlegreyaSans-ThinItalic-lf-sc-ly1.vf \
tex-AlegreyaSans-ThinItalic-lf-sc-ot1--base.tfm \
tex-AlegreyaSans-ThinItalic-lf-sc-ot1.tfm \
tex-AlegreyaSans-ThinItalic-lf-sc-ot1.vf \
tex-AlegreyaSans-ThinItalic-lf-sc-t1--base.tfm \
tex-AlegreyaSans-ThinItalic-lf-sc-t1.tfm \
tex-AlegreyaSans-ThinItalic-lf-sc-t1.vf \
tex-AlegreyaSans-ThinItalic-lf-t1--base.tfm \
tex-AlegreyaSans-ThinItalic-lf-t1.tfm \
tex-AlegreyaSans-ThinItalic-lf-t1.vf \
tex-AlegreyaSans-ThinItalic-lf-ts1--base.tfm \
tex-AlegreyaSans-ThinItalic-lf-ts1.tfm \
tex-AlegreyaSans-ThinItalic-lf-ts1.vf \
tex-AlegreyaSans-ThinItalic-osf-lgr--base.tfm \
tex-AlegreyaSans-ThinItalic-osf-lgr.tfm \
tex-AlegreyaSans-ThinItalic-osf-lgr.vf \
tex-AlegreyaSans-ThinItalic-osf-ly1--base.tfm \
tex-AlegreyaSans-ThinItalic-osf-ly1.tfm \
tex-AlegreyaSans-ThinItalic-osf-ly1.vf \
tex-AlegreyaSans-ThinItalic-osf-ot1.tfm \
tex-AlegreyaSans-ThinItalic-osf-sc-lgr--base.tfm \
tex-AlegreyaSans-ThinItalic-osf-sc-lgr.tfm \
tex-AlegreyaSans-ThinItalic-osf-sc-lgr.vf \
tex-AlegreyaSans-ThinItalic-osf-sc-ly1--base.tfm \
tex-AlegreyaSans-ThinItalic-osf-sc-ly1.tfm \
tex-AlegreyaSans-ThinItalic-osf-sc-ly1.vf \
tex-AlegreyaSans-ThinItalic-osf-sc-ot1--base.tfm \
tex-AlegreyaSans-ThinItalic-osf-sc-ot1.tfm \
tex-AlegreyaSans-ThinItalic-osf-sc-ot1.vf \
tex-AlegreyaSans-ThinItalic-osf-sc-t1--base.tfm \
tex-AlegreyaSans-ThinItalic-osf-sc-t1.tfm \
tex-AlegreyaSans-ThinItalic-osf-sc-t1.vf \
tex-AlegreyaSans-ThinItalic-osf-t1--base.tfm \
tex-AlegreyaSans-ThinItalic-osf-t1.tfm \
tex-AlegreyaSans-ThinItalic-osf-t1.vf \
tex-AlegreyaSans-ThinItalic-osf-ts1--base.tfm \
tex-AlegreyaSans-ThinItalic-osf-ts1.tfm \
tex-AlegreyaSans-ThinItalic-osf-ts1.vf \
tex-AlegreyaSans-ThinItalic-sup-lgr--base.tfm \
tex-AlegreyaSans-ThinItalic-sup-lgr.tfm \
tex-AlegreyaSans-ThinItalic-sup-lgr.vf \
tex-AlegreyaSans-ThinItalic-sup-ly1--base.tfm \
tex-AlegreyaSans-ThinItalic-sup-ly1.tfm \
tex-AlegreyaSans-ThinItalic-sup-ly1.vf \
tex-AlegreyaSans-ThinItalic-sup-ot1.tfm \
tex-AlegreyaSans-ThinItalic-sup-t1--base.tfm \
tex-AlegreyaSans-ThinItalic-sup-t1.tfm \
tex-AlegreyaSans-ThinItalic-sup-t1.vf \
tex-AlegreyaSans-ThinItalic-tlf-lgr--base.tfm \
tex-AlegreyaSans-ThinItalic-tlf-lgr.tfm \
tex-AlegreyaSans-ThinItalic-tlf-lgr.vf \
tex-AlegreyaSans-ThinItalic-tlf-ly1--base.tfm \
tex-AlegreyaSans-ThinItalic-tlf-ly1.tfm \
tex-AlegreyaSans-ThinItalic-tlf-ly1.vf \
tex-AlegreyaSans-ThinItalic-tlf-ot1.tfm \
tex-AlegreyaSans-ThinItalic-tlf-sc-lgr--base.tfm \
tex-AlegreyaSans-ThinItalic-tlf-sc-lgr.tfm \
tex-AlegreyaSans-ThinItalic-tlf-sc-lgr.vf \
tex-AlegreyaSans-ThinItalic-tlf-sc-ly1--base.tfm \
tex-AlegreyaSans-ThinItalic-tlf-sc-ly1.tfm \
tex-AlegreyaSans-ThinItalic-tlf-sc-ly1.vf \
tex-AlegreyaSans-ThinItalic-tlf-sc-ot1--base.tfm \
tex-AlegreyaSans-ThinItalic-tlf-sc-ot1.tfm \
tex-AlegreyaSans-ThinItalic-tlf-sc-ot1.vf \
tex-AlegreyaSans-ThinItalic-tlf-sc-t1--base.tfm \
tex-AlegreyaSans-ThinItalic-tlf-sc-t1.tfm \
tex-AlegreyaSans-ThinItalic-tlf-sc-t1.vf \
tex-AlegreyaSans-ThinItalic-tlf-t1--base.tfm \
tex-AlegreyaSans-ThinItalic-tlf-t1.tfm \
tex-AlegreyaSans-ThinItalic-tlf-t1.vf \
tex-AlegreyaSans-ThinItalic-tlf-ts1--base.tfm \
tex-AlegreyaSans-ThinItalic-tlf-ts1.tfm \
tex-AlegreyaSans-ThinItalic-tlf-ts1.vf \
tex-AlegreyaSans-ThinItalic-tosf-lgr--base.tfm \
tex-AlegreyaSans-ThinItalic-tosf-lgr.tfm \
tex-AlegreyaSans-ThinItalic-tosf-lgr.vf \
tex-AlegreyaSans-ThinItalic-tosf-ly1--base.tfm \
tex-AlegreyaSans-ThinItalic-tosf-ly1.tfm \
tex-AlegreyaSans-ThinItalic-tosf-ly1.vf \
tex-AlegreyaSans-ThinItalic-tosf-ot1.tfm \
tex-AlegreyaSans-ThinItalic-tosf-sc-lgr--base.tfm \
tex-AlegreyaSans-ThinItalic-tosf-sc-lgr.tfm \
tex-AlegreyaSans-ThinItalic-tosf-sc-lgr.vf \
tex-AlegreyaSans-ThinItalic-tosf-sc-ly1--base.tfm \
tex-AlegreyaSans-ThinItalic-tosf-sc-ly1.tfm \
tex-AlegreyaSans-ThinItalic-tosf-sc-ly1.vf \
tex-AlegreyaSans-ThinItalic-tosf-sc-ot1--base.tfm \
tex-AlegreyaSans-ThinItalic-tosf-sc-ot1.tfm \
tex-AlegreyaSans-ThinItalic-tosf-sc-ot1.vf \
tex-AlegreyaSans-ThinItalic-tosf-sc-t1--base.tfm \
tex-AlegreyaSans-ThinItalic-tosf-sc-t1.tfm \
tex-AlegreyaSans-ThinItalic-tosf-sc-t1.vf \
tex-AlegreyaSans-ThinItalic-tosf-t1--base.tfm \
tex-AlegreyaSans-ThinItalic-tosf-t1.tfm \
tex-AlegreyaSans-ThinItalic-tosf-t1.vf \
tex-AlegreyaSans-ThinItalic-tosf-ts1--base.tfm \
tex-AlegreyaSans-ThinItalic-tosf-ts1.tfm \
tex-AlegreyaSans-ThinItalic-tosf-ts1.vf \
tex-AlegreyaSans.sty \
tex-AlegreyaSansSC-Black-inf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Black-inf-sc-lgr.tfm \
tex-AlegreyaSansSC-Black-inf-sc-lgr.vf \
tex-AlegreyaSansSC-Black-inf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Black-inf-sc-ly1.tfm \
tex-AlegreyaSansSC-Black-inf-sc-ly1.vf \
tex-AlegreyaSansSC-Black-inf-sc-ot1.tfm \
tex-AlegreyaSansSC-Black-inf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Black-inf-sc-t1.tfm \
tex-AlegreyaSansSC-Black-inf-sc-t1.vf \
tex-AlegreyaSansSC-Black-lf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Black-lf-sc-lgr.tfm \
tex-AlegreyaSansSC-Black-lf-sc-lgr.vf \
tex-AlegreyaSansSC-Black-lf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Black-lf-sc-ly1.tfm \
tex-AlegreyaSansSC-Black-lf-sc-ly1.vf \
tex-AlegreyaSansSC-Black-lf-sc-ot1.tfm \
tex-AlegreyaSansSC-Black-lf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Black-lf-sc-t1.tfm \
tex-AlegreyaSansSC-Black-lf-sc-t1.vf \
tex-AlegreyaSansSC-Black-osf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Black-osf-sc-lgr.tfm \
tex-AlegreyaSansSC-Black-osf-sc-lgr.vf \
tex-AlegreyaSansSC-Black-osf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Black-osf-sc-ly1.tfm \
tex-AlegreyaSansSC-Black-osf-sc-ly1.vf \
tex-AlegreyaSansSC-Black-osf-sc-ot1.tfm \
tex-AlegreyaSansSC-Black-osf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Black-osf-sc-t1.tfm \
tex-AlegreyaSansSC-Black-osf-sc-t1.vf \
tex-AlegreyaSansSC-Black-sup-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Black-sup-sc-lgr.tfm \
tex-AlegreyaSansSC-Black-sup-sc-lgr.vf \
tex-AlegreyaSansSC-Black-sup-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Black-sup-sc-ly1.tfm \
tex-AlegreyaSansSC-Black-sup-sc-ly1.vf \
tex-AlegreyaSansSC-Black-sup-sc-ot1.tfm \
tex-AlegreyaSansSC-Black-sup-sc-t1--base.tfm \
tex-AlegreyaSansSC-Black-sup-sc-t1.tfm \
tex-AlegreyaSansSC-Black-sup-sc-t1.vf \
tex-AlegreyaSansSC-Black-tlf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Black-tlf-sc-lgr.tfm \
tex-AlegreyaSansSC-Black-tlf-sc-lgr.vf \
tex-AlegreyaSansSC-Black-tlf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Black-tlf-sc-ly1.tfm \
tex-AlegreyaSansSC-Black-tlf-sc-ly1.vf \
tex-AlegreyaSansSC-Black-tlf-sc-ot1.tfm \
tex-AlegreyaSansSC-Black-tlf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Black-tlf-sc-t1.tfm \
tex-AlegreyaSansSC-Black-tlf-sc-t1.vf \
tex-AlegreyaSansSC-Black-tosf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Black-tosf-sc-lgr.tfm \
tex-AlegreyaSansSC-Black-tosf-sc-lgr.vf \
tex-AlegreyaSansSC-Black-tosf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Black-tosf-sc-ly1.tfm \
tex-AlegreyaSansSC-Black-tosf-sc-ly1.vf \
tex-AlegreyaSansSC-Black-tosf-sc-ot1.tfm \
tex-AlegreyaSansSC-Black-tosf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Black-tosf-sc-t1.tfm \
tex-AlegreyaSansSC-Black-tosf-sc-t1.vf \
tex-AlegreyaSansSC-BlackItalic-inf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-BlackItalic-inf-sc-lgr.tfm \
tex-AlegreyaSansSC-BlackItalic-inf-sc-lgr.vf \
tex-AlegreyaSansSC-BlackItalic-inf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-BlackItalic-inf-sc-ly1.tfm \
tex-AlegreyaSansSC-BlackItalic-inf-sc-ly1.vf \
tex-AlegreyaSansSC-BlackItalic-inf-sc-ot1.tfm \
tex-AlegreyaSansSC-BlackItalic-inf-sc-t1--base.tfm \
tex-AlegreyaSansSC-BlackItalic-inf-sc-t1.tfm \
tex-AlegreyaSansSC-BlackItalic-inf-sc-t1.vf \
tex-AlegreyaSansSC-BlackItalic-lf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-BlackItalic-lf-sc-lgr.tfm \
tex-AlegreyaSansSC-BlackItalic-lf-sc-lgr.vf \
tex-AlegreyaSansSC-BlackItalic-lf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-BlackItalic-lf-sc-ly1.tfm \
tex-AlegreyaSansSC-BlackItalic-lf-sc-ly1.vf \
tex-AlegreyaSansSC-BlackItalic-lf-sc-ot1.tfm \
tex-AlegreyaSansSC-BlackItalic-lf-sc-t1--base.tfm \
tex-AlegreyaSansSC-BlackItalic-lf-sc-t1.tfm \
tex-AlegreyaSansSC-BlackItalic-lf-sc-t1.vf \
tex-AlegreyaSansSC-BlackItalic-osf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-BlackItalic-osf-sc-lgr.tfm \
tex-AlegreyaSansSC-BlackItalic-osf-sc-lgr.vf \
tex-AlegreyaSansSC-BlackItalic-osf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-BlackItalic-osf-sc-ly1.tfm \
tex-AlegreyaSansSC-BlackItalic-osf-sc-ly1.vf \
tex-AlegreyaSansSC-BlackItalic-osf-sc-ot1.tfm \
tex-AlegreyaSansSC-BlackItalic-osf-sc-t1--base.tfm \
tex-AlegreyaSansSC-BlackItalic-osf-sc-t1.tfm \
tex-AlegreyaSansSC-BlackItalic-osf-sc-t1.vf \
tex-AlegreyaSansSC-BlackItalic-sup-sc-lgr--base.tfm \
tex-AlegreyaSansSC-BlackItalic-sup-sc-lgr.tfm \
tex-AlegreyaSansSC-BlackItalic-sup-sc-lgr.vf \
tex-AlegreyaSansSC-BlackItalic-sup-sc-ly1--base.tfm \
tex-AlegreyaSansSC-BlackItalic-sup-sc-ly1.tfm \
tex-AlegreyaSansSC-BlackItalic-sup-sc-ly1.vf \
tex-AlegreyaSansSC-BlackItalic-sup-sc-ot1.tfm \
tex-AlegreyaSansSC-BlackItalic-sup-sc-t1--base.tfm \
tex-AlegreyaSansSC-BlackItalic-sup-sc-t1.tfm \
tex-AlegreyaSansSC-BlackItalic-sup-sc-t1.vf \
tex-AlegreyaSansSC-BlackItalic-tlf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-BlackItalic-tlf-sc-lgr.tfm \
tex-AlegreyaSansSC-BlackItalic-tlf-sc-lgr.vf \
tex-AlegreyaSansSC-BlackItalic-tlf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-BlackItalic-tlf-sc-ly1.tfm \
tex-AlegreyaSansSC-BlackItalic-tlf-sc-ly1.vf \
tex-AlegreyaSansSC-BlackItalic-tlf-sc-ot1.tfm \
tex-AlegreyaSansSC-BlackItalic-tlf-sc-t1--base.tfm \
tex-AlegreyaSansSC-BlackItalic-tlf-sc-t1.tfm \
tex-AlegreyaSansSC-BlackItalic-tlf-sc-t1.vf \
tex-AlegreyaSansSC-BlackItalic-tosf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-BlackItalic-tosf-sc-lgr.tfm \
tex-AlegreyaSansSC-BlackItalic-tosf-sc-lgr.vf \
tex-AlegreyaSansSC-BlackItalic-tosf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-BlackItalic-tosf-sc-ly1.tfm \
tex-AlegreyaSansSC-BlackItalic-tosf-sc-ly1.vf \
tex-AlegreyaSansSC-BlackItalic-tosf-sc-ot1.tfm \
tex-AlegreyaSansSC-BlackItalic-tosf-sc-t1--base.tfm \
tex-AlegreyaSansSC-BlackItalic-tosf-sc-t1.tfm \
tex-AlegreyaSansSC-BlackItalic-tosf-sc-t1.vf \
tex-AlegreyaSansSC-Bold-inf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Bold-inf-sc-lgr.tfm \
tex-AlegreyaSansSC-Bold-inf-sc-lgr.vf \
tex-AlegreyaSansSC-Bold-inf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Bold-inf-sc-ly1.tfm \
tex-AlegreyaSansSC-Bold-inf-sc-ly1.vf \
tex-AlegreyaSansSC-Bold-inf-sc-ot1.tfm \
tex-AlegreyaSansSC-Bold-inf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Bold-inf-sc-t1.tfm \
tex-AlegreyaSansSC-Bold-inf-sc-t1.vf \
tex-AlegreyaSansSC-Bold-lf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Bold-lf-sc-lgr.tfm \
tex-AlegreyaSansSC-Bold-lf-sc-lgr.vf \
tex-AlegreyaSansSC-Bold-lf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Bold-lf-sc-ly1.tfm \
tex-AlegreyaSansSC-Bold-lf-sc-ly1.vf \
tex-AlegreyaSansSC-Bold-lf-sc-ot1.tfm \
tex-AlegreyaSansSC-Bold-lf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Bold-lf-sc-t1.tfm \
tex-AlegreyaSansSC-Bold-lf-sc-t1.vf \
tex-AlegreyaSansSC-Bold-osf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Bold-osf-sc-lgr.tfm \
tex-AlegreyaSansSC-Bold-osf-sc-lgr.vf \
tex-AlegreyaSansSC-Bold-osf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Bold-osf-sc-ly1.tfm \
tex-AlegreyaSansSC-Bold-osf-sc-ly1.vf \
tex-AlegreyaSansSC-Bold-osf-sc-ot1.tfm \
tex-AlegreyaSansSC-Bold-osf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Bold-osf-sc-t1.tfm \
tex-AlegreyaSansSC-Bold-osf-sc-t1.vf \
tex-AlegreyaSansSC-Bold-sup-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Bold-sup-sc-lgr.tfm \
tex-AlegreyaSansSC-Bold-sup-sc-lgr.vf \
tex-AlegreyaSansSC-Bold-sup-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Bold-sup-sc-ly1.tfm \
tex-AlegreyaSansSC-Bold-sup-sc-ly1.vf \
tex-AlegreyaSansSC-Bold-sup-sc-ot1.tfm \
tex-AlegreyaSansSC-Bold-sup-sc-t1--base.tfm \
tex-AlegreyaSansSC-Bold-sup-sc-t1.tfm \
tex-AlegreyaSansSC-Bold-sup-sc-t1.vf \
tex-AlegreyaSansSC-Bold-tlf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Bold-tlf-sc-lgr.tfm \
tex-AlegreyaSansSC-Bold-tlf-sc-lgr.vf \
tex-AlegreyaSansSC-Bold-tlf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Bold-tlf-sc-ly1.tfm \
tex-AlegreyaSansSC-Bold-tlf-sc-ly1.vf \
tex-AlegreyaSansSC-Bold-tlf-sc-ot1.tfm \
tex-AlegreyaSansSC-Bold-tlf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Bold-tlf-sc-t1.tfm \
tex-AlegreyaSansSC-Bold-tlf-sc-t1.vf \
tex-AlegreyaSansSC-Bold-tosf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Bold-tosf-sc-lgr.tfm \
tex-AlegreyaSansSC-Bold-tosf-sc-lgr.vf \
tex-AlegreyaSansSC-Bold-tosf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Bold-tosf-sc-ly1.tfm \
tex-AlegreyaSansSC-Bold-tosf-sc-ly1.vf \
tex-AlegreyaSansSC-Bold-tosf-sc-ot1.tfm \
tex-AlegreyaSansSC-Bold-tosf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Bold-tosf-sc-t1.tfm \
tex-AlegreyaSansSC-Bold-tosf-sc-t1.vf \
tex-AlegreyaSansSC-BoldItalic-inf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-BoldItalic-inf-sc-lgr.tfm \
tex-AlegreyaSansSC-BoldItalic-inf-sc-lgr.vf \
tex-AlegreyaSansSC-BoldItalic-inf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-BoldItalic-inf-sc-ly1.tfm \
tex-AlegreyaSansSC-BoldItalic-inf-sc-ly1.vf \
tex-AlegreyaSansSC-BoldItalic-inf-sc-ot1.tfm \
tex-AlegreyaSansSC-BoldItalic-inf-sc-t1--base.tfm \
tex-AlegreyaSansSC-BoldItalic-inf-sc-t1.tfm \
tex-AlegreyaSansSC-BoldItalic-inf-sc-t1.vf \
tex-AlegreyaSansSC-BoldItalic-lf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-BoldItalic-lf-sc-lgr.tfm \
tex-AlegreyaSansSC-BoldItalic-lf-sc-lgr.vf \
tex-AlegreyaSansSC-BoldItalic-lf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-BoldItalic-lf-sc-ly1.tfm \
tex-AlegreyaSansSC-BoldItalic-lf-sc-ly1.vf \
tex-AlegreyaSansSC-BoldItalic-lf-sc-ot1.tfm \
tex-AlegreyaSansSC-BoldItalic-lf-sc-t1--base.tfm \
tex-AlegreyaSansSC-BoldItalic-lf-sc-t1.tfm \
tex-AlegreyaSansSC-BoldItalic-lf-sc-t1.vf \
tex-AlegreyaSansSC-BoldItalic-osf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-BoldItalic-osf-sc-lgr.tfm \
tex-AlegreyaSansSC-BoldItalic-osf-sc-lgr.vf \
tex-AlegreyaSansSC-BoldItalic-osf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-BoldItalic-osf-sc-ly1.tfm \
tex-AlegreyaSansSC-BoldItalic-osf-sc-ly1.vf \
tex-AlegreyaSansSC-BoldItalic-osf-sc-ot1.tfm \
tex-AlegreyaSansSC-BoldItalic-osf-sc-t1--base.tfm \
tex-AlegreyaSansSC-BoldItalic-osf-sc-t1.tfm \
tex-AlegreyaSansSC-BoldItalic-osf-sc-t1.vf \
tex-AlegreyaSansSC-BoldItalic-sup-sc-lgr--base.tfm \
tex-AlegreyaSansSC-BoldItalic-sup-sc-lgr.tfm \
tex-AlegreyaSansSC-BoldItalic-sup-sc-lgr.vf \
tex-AlegreyaSansSC-BoldItalic-sup-sc-ly1--base.tfm \
tex-AlegreyaSansSC-BoldItalic-sup-sc-ly1.tfm \
tex-AlegreyaSansSC-BoldItalic-sup-sc-ly1.vf \
tex-AlegreyaSansSC-BoldItalic-sup-sc-ot1.tfm \
tex-AlegreyaSansSC-BoldItalic-sup-sc-t1--base.tfm \
tex-AlegreyaSansSC-BoldItalic-sup-sc-t1.tfm \
tex-AlegreyaSansSC-BoldItalic-sup-sc-t1.vf \
tex-AlegreyaSansSC-BoldItalic-tlf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-BoldItalic-tlf-sc-lgr.tfm \
tex-AlegreyaSansSC-BoldItalic-tlf-sc-lgr.vf \
tex-AlegreyaSansSC-BoldItalic-tlf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-BoldItalic-tlf-sc-ly1.tfm \
tex-AlegreyaSansSC-BoldItalic-tlf-sc-ly1.vf \
tex-AlegreyaSansSC-BoldItalic-tlf-sc-ot1.tfm \
tex-AlegreyaSansSC-BoldItalic-tlf-sc-t1--base.tfm \
tex-AlegreyaSansSC-BoldItalic-tlf-sc-t1.tfm \
tex-AlegreyaSansSC-BoldItalic-tlf-sc-t1.vf \
tex-AlegreyaSansSC-BoldItalic-tosf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-BoldItalic-tosf-sc-lgr.tfm \
tex-AlegreyaSansSC-BoldItalic-tosf-sc-lgr.vf \
tex-AlegreyaSansSC-BoldItalic-tosf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-BoldItalic-tosf-sc-ly1.tfm \
tex-AlegreyaSansSC-BoldItalic-tosf-sc-ly1.vf \
tex-AlegreyaSansSC-BoldItalic-tosf-sc-ot1.tfm \
tex-AlegreyaSansSC-BoldItalic-tosf-sc-t1--base.tfm \
tex-AlegreyaSansSC-BoldItalic-tosf-sc-t1.tfm \
tex-AlegreyaSansSC-BoldItalic-tosf-sc-t1.vf \
tex-AlegreyaSansSC-ExtraBold-inf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-ExtraBold-inf-sc-lgr.tfm \
tex-AlegreyaSansSC-ExtraBold-inf-sc-lgr.vf \
tex-AlegreyaSansSC-ExtraBold-inf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-ExtraBold-inf-sc-ly1.tfm \
tex-AlegreyaSansSC-ExtraBold-inf-sc-ly1.vf \
tex-AlegreyaSansSC-ExtraBold-inf-sc-ot1.tfm \
tex-AlegreyaSansSC-ExtraBold-inf-sc-t1--base.tfm \
tex-AlegreyaSansSC-ExtraBold-inf-sc-t1.tfm \
tex-AlegreyaSansSC-ExtraBold-inf-sc-t1.vf \
tex-AlegreyaSansSC-ExtraBold-lf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-ExtraBold-lf-sc-lgr.tfm \
tex-AlegreyaSansSC-ExtraBold-lf-sc-lgr.vf \
tex-AlegreyaSansSC-ExtraBold-lf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-ExtraBold-lf-sc-ly1.tfm \
tex-AlegreyaSansSC-ExtraBold-lf-sc-ly1.vf \
tex-AlegreyaSansSC-ExtraBold-lf-sc-ot1.tfm \
tex-AlegreyaSansSC-ExtraBold-lf-sc-t1--base.tfm \
tex-AlegreyaSansSC-ExtraBold-lf-sc-t1.tfm \
tex-AlegreyaSansSC-ExtraBold-lf-sc-t1.vf \
tex-AlegreyaSansSC-ExtraBold-osf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-ExtraBold-osf-sc-lgr.tfm \
tex-AlegreyaSansSC-ExtraBold-osf-sc-lgr.vf \
tex-AlegreyaSansSC-ExtraBold-osf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-ExtraBold-osf-sc-ly1.tfm \
tex-AlegreyaSansSC-ExtraBold-osf-sc-ly1.vf \
tex-AlegreyaSansSC-ExtraBold-osf-sc-ot1.tfm \
tex-AlegreyaSansSC-ExtraBold-osf-sc-t1--base.tfm \
tex-AlegreyaSansSC-ExtraBold-osf-sc-t1.tfm \
tex-AlegreyaSansSC-ExtraBold-osf-sc-t1.vf \
tex-AlegreyaSansSC-ExtraBold-sup-sc-lgr--base.tfm \
tex-AlegreyaSansSC-ExtraBold-sup-sc-lgr.tfm \
tex-AlegreyaSansSC-ExtraBold-sup-sc-lgr.vf \
tex-AlegreyaSansSC-ExtraBold-sup-sc-ly1--base.tfm \
tex-AlegreyaSansSC-ExtraBold-sup-sc-ly1.tfm \
tex-AlegreyaSansSC-ExtraBold-sup-sc-ly1.vf \
tex-AlegreyaSansSC-ExtraBold-sup-sc-ot1.tfm \
tex-AlegreyaSansSC-ExtraBold-sup-sc-t1--base.tfm \
tex-AlegreyaSansSC-ExtraBold-sup-sc-t1.tfm \
tex-AlegreyaSansSC-ExtraBold-sup-sc-t1.vf \
tex-AlegreyaSansSC-ExtraBold-tlf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-ExtraBold-tlf-sc-lgr.tfm \
tex-AlegreyaSansSC-ExtraBold-tlf-sc-lgr.vf \
tex-AlegreyaSansSC-ExtraBold-tlf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-ExtraBold-tlf-sc-ly1.tfm \
tex-AlegreyaSansSC-ExtraBold-tlf-sc-ly1.vf \
tex-AlegreyaSansSC-ExtraBold-tlf-sc-ot1.tfm \
tex-AlegreyaSansSC-ExtraBold-tlf-sc-t1--base.tfm \
tex-AlegreyaSansSC-ExtraBold-tlf-sc-t1.tfm \
tex-AlegreyaSansSC-ExtraBold-tlf-sc-t1.vf \
tex-AlegreyaSansSC-ExtraBold-tosf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-ExtraBold-tosf-sc-lgr.tfm \
tex-AlegreyaSansSC-ExtraBold-tosf-sc-lgr.vf \
tex-AlegreyaSansSC-ExtraBold-tosf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-ExtraBold-tosf-sc-ly1.tfm \
tex-AlegreyaSansSC-ExtraBold-tosf-sc-ly1.vf \
tex-AlegreyaSansSC-ExtraBold-tosf-sc-ot1.tfm \
tex-AlegreyaSansSC-ExtraBold-tosf-sc-t1--base.tfm \
tex-AlegreyaSansSC-ExtraBold-tosf-sc-t1.tfm \
tex-AlegreyaSansSC-ExtraBold-tosf-sc-t1.vf \
tex-AlegreyaSansSC-ExtraBoldItalic-inf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-inf-sc-lgr.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-inf-sc-lgr.vf \
tex-AlegreyaSansSC-ExtraBoldItalic-inf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-inf-sc-ly1.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-inf-sc-ly1.vf \
tex-AlegreyaSansSC-ExtraBoldItalic-inf-sc-ot1.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-inf-sc-t1--base.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-inf-sc-t1.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-inf-sc-t1.vf \
tex-AlegreyaSansSC-ExtraBoldItalic-lf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-lf-sc-lgr.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-lf-sc-lgr.vf \
tex-AlegreyaSansSC-ExtraBoldItalic-lf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-lf-sc-ly1.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-lf-sc-ly1.vf \
tex-AlegreyaSansSC-ExtraBoldItalic-lf-sc-ot1.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-lf-sc-t1--base.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-lf-sc-t1.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-lf-sc-t1.vf \
tex-AlegreyaSansSC-ExtraBoldItalic-osf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-osf-sc-lgr.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-osf-sc-lgr.vf \
tex-AlegreyaSansSC-ExtraBoldItalic-osf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-osf-sc-ly1.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-osf-sc-ly1.vf \
tex-AlegreyaSansSC-ExtraBoldItalic-osf-sc-ot1.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-osf-sc-t1--base.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-osf-sc-t1.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-osf-sc-t1.vf \
tex-AlegreyaSansSC-ExtraBoldItalic-sup-sc-lgr--base.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-sup-sc-lgr.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-sup-sc-lgr.vf \
tex-AlegreyaSansSC-ExtraBoldItalic-sup-sc-ly1--base.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-sup-sc-ly1.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-sup-sc-ly1.vf \
tex-AlegreyaSansSC-ExtraBoldItalic-sup-sc-ot1.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-sup-sc-t1--base.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-sup-sc-t1.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-sup-sc-t1.vf \
tex-AlegreyaSansSC-ExtraBoldItalic-tlf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-tlf-sc-lgr.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-tlf-sc-lgr.vf \
tex-AlegreyaSansSC-ExtraBoldItalic-tlf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-tlf-sc-ly1.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-tlf-sc-ly1.vf \
tex-AlegreyaSansSC-ExtraBoldItalic-tlf-sc-ot1.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-tlf-sc-t1--base.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-tlf-sc-t1.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-tlf-sc-t1.vf \
tex-AlegreyaSansSC-ExtraBoldItalic-tosf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-tosf-sc-lgr.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-tosf-sc-lgr.vf \
tex-AlegreyaSansSC-ExtraBoldItalic-tosf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-tosf-sc-ly1.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-tosf-sc-ly1.vf \
tex-AlegreyaSansSC-ExtraBoldItalic-tosf-sc-ot1.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-tosf-sc-t1--base.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-tosf-sc-t1.tfm \
tex-AlegreyaSansSC-ExtraBoldItalic-tosf-sc-t1.vf \
tex-AlegreyaSansSC-Italic-inf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Italic-inf-sc-lgr.tfm \
tex-AlegreyaSansSC-Italic-inf-sc-lgr.vf \
tex-AlegreyaSansSC-Italic-inf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Italic-inf-sc-ly1.tfm \
tex-AlegreyaSansSC-Italic-inf-sc-ly1.vf \
tex-AlegreyaSansSC-Italic-inf-sc-ot1.tfm \
tex-AlegreyaSansSC-Italic-inf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Italic-inf-sc-t1.tfm \
tex-AlegreyaSansSC-Italic-inf-sc-t1.vf \
tex-AlegreyaSansSC-Italic-lf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Italic-lf-sc-lgr.tfm \
tex-AlegreyaSansSC-Italic-lf-sc-lgr.vf \
tex-AlegreyaSansSC-Italic-lf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Italic-lf-sc-ly1.tfm \
tex-AlegreyaSansSC-Italic-lf-sc-ly1.vf \
tex-AlegreyaSansSC-Italic-lf-sc-ot1.tfm \
tex-AlegreyaSansSC-Italic-lf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Italic-lf-sc-t1.tfm \
tex-AlegreyaSansSC-Italic-lf-sc-t1.vf \
tex-AlegreyaSansSC-Italic-osf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Italic-osf-sc-lgr.tfm \
tex-AlegreyaSansSC-Italic-osf-sc-lgr.vf \
tex-AlegreyaSansSC-Italic-osf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Italic-osf-sc-ly1.tfm \
tex-AlegreyaSansSC-Italic-osf-sc-ly1.vf \
tex-AlegreyaSansSC-Italic-osf-sc-ot1.tfm \
tex-AlegreyaSansSC-Italic-osf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Italic-osf-sc-t1.tfm \
tex-AlegreyaSansSC-Italic-osf-sc-t1.vf \
tex-AlegreyaSansSC-Italic-sup-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Italic-sup-sc-lgr.tfm \
tex-AlegreyaSansSC-Italic-sup-sc-lgr.vf \
tex-AlegreyaSansSC-Italic-sup-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Italic-sup-sc-ly1.tfm \
tex-AlegreyaSansSC-Italic-sup-sc-ly1.vf \
tex-AlegreyaSansSC-Italic-sup-sc-ot1.tfm \
tex-AlegreyaSansSC-Italic-sup-sc-t1--base.tfm \
tex-AlegreyaSansSC-Italic-sup-sc-t1.tfm \
tex-AlegreyaSansSC-Italic-sup-sc-t1.vf \
tex-AlegreyaSansSC-Italic-tlf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Italic-tlf-sc-lgr.tfm \
tex-AlegreyaSansSC-Italic-tlf-sc-lgr.vf \
tex-AlegreyaSansSC-Italic-tlf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Italic-tlf-sc-ly1.tfm \
tex-AlegreyaSansSC-Italic-tlf-sc-ly1.vf \
tex-AlegreyaSansSC-Italic-tlf-sc-ot1.tfm \
tex-AlegreyaSansSC-Italic-tlf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Italic-tlf-sc-t1.tfm \
tex-AlegreyaSansSC-Italic-tlf-sc-t1.vf \
tex-AlegreyaSansSC-Italic-tosf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Italic-tosf-sc-lgr.tfm \
tex-AlegreyaSansSC-Italic-tosf-sc-lgr.vf \
tex-AlegreyaSansSC-Italic-tosf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Italic-tosf-sc-ly1.tfm \
tex-AlegreyaSansSC-Italic-tosf-sc-ly1.vf \
tex-AlegreyaSansSC-Italic-tosf-sc-ot1.tfm \
tex-AlegreyaSansSC-Italic-tosf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Italic-tosf-sc-t1.tfm \
tex-AlegreyaSansSC-Italic-tosf-sc-t1.vf \
tex-AlegreyaSansSC-Light-inf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Light-inf-sc-lgr.tfm \
tex-AlegreyaSansSC-Light-inf-sc-lgr.vf \
tex-AlegreyaSansSC-Light-inf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Light-inf-sc-ly1.tfm \
tex-AlegreyaSansSC-Light-inf-sc-ly1.vf \
tex-AlegreyaSansSC-Light-inf-sc-ot1.tfm \
tex-AlegreyaSansSC-Light-inf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Light-inf-sc-t1.tfm \
tex-AlegreyaSansSC-Light-inf-sc-t1.vf \
tex-AlegreyaSansSC-Light-lf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Light-lf-sc-lgr.tfm \
tex-AlegreyaSansSC-Light-lf-sc-lgr.vf \
tex-AlegreyaSansSC-Light-lf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Light-lf-sc-ly1.tfm \
tex-AlegreyaSansSC-Light-lf-sc-ly1.vf \
tex-AlegreyaSansSC-Light-lf-sc-ot1.tfm \
tex-AlegreyaSansSC-Light-lf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Light-lf-sc-t1.tfm \
tex-AlegreyaSansSC-Light-lf-sc-t1.vf \
tex-AlegreyaSansSC-Light-osf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Light-osf-sc-lgr.tfm \
tex-AlegreyaSansSC-Light-osf-sc-lgr.vf \
tex-AlegreyaSansSC-Light-osf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Light-osf-sc-ly1.tfm \
tex-AlegreyaSansSC-Light-osf-sc-ly1.vf \
tex-AlegreyaSansSC-Light-osf-sc-ot1.tfm \
tex-AlegreyaSansSC-Light-osf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Light-osf-sc-t1.tfm \
tex-AlegreyaSansSC-Light-osf-sc-t1.vf \
tex-AlegreyaSansSC-Light-sup-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Light-sup-sc-lgr.tfm \
tex-AlegreyaSansSC-Light-sup-sc-lgr.vf \
tex-AlegreyaSansSC-Light-sup-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Light-sup-sc-ly1.tfm \
tex-AlegreyaSansSC-Light-sup-sc-ly1.vf \
tex-AlegreyaSansSC-Light-sup-sc-ot1.tfm \
tex-AlegreyaSansSC-Light-sup-sc-t1--base.tfm \
tex-AlegreyaSansSC-Light-sup-sc-t1.tfm \
tex-AlegreyaSansSC-Light-sup-sc-t1.vf \
tex-AlegreyaSansSC-Light-tlf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Light-tlf-sc-lgr.tfm \
tex-AlegreyaSansSC-Light-tlf-sc-lgr.vf \
tex-AlegreyaSansSC-Light-tlf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Light-tlf-sc-ly1.tfm \
tex-AlegreyaSansSC-Light-tlf-sc-ly1.vf \
tex-AlegreyaSansSC-Light-tlf-sc-ot1.tfm \
tex-AlegreyaSansSC-Light-tlf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Light-tlf-sc-t1.tfm \
tex-AlegreyaSansSC-Light-tlf-sc-t1.vf \
tex-AlegreyaSansSC-Light-tosf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Light-tosf-sc-lgr.tfm \
tex-AlegreyaSansSC-Light-tosf-sc-lgr.vf \
tex-AlegreyaSansSC-Light-tosf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Light-tosf-sc-ly1.tfm \
tex-AlegreyaSansSC-Light-tosf-sc-ly1.vf \
tex-AlegreyaSansSC-Light-tosf-sc-ot1.tfm \
tex-AlegreyaSansSC-Light-tosf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Light-tosf-sc-t1.tfm \
tex-AlegreyaSansSC-Light-tosf-sc-t1.vf \
tex-AlegreyaSansSC-LightItalic-inf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-LightItalic-inf-sc-lgr.tfm \
tex-AlegreyaSansSC-LightItalic-inf-sc-lgr.vf \
tex-AlegreyaSansSC-LightItalic-inf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-LightItalic-inf-sc-ly1.tfm \
tex-AlegreyaSansSC-LightItalic-inf-sc-ly1.vf \
tex-AlegreyaSansSC-LightItalic-inf-sc-ot1.tfm \
tex-AlegreyaSansSC-LightItalic-inf-sc-t1--base.tfm \
tex-AlegreyaSansSC-LightItalic-inf-sc-t1.tfm \
tex-AlegreyaSansSC-LightItalic-inf-sc-t1.vf \
tex-AlegreyaSansSC-LightItalic-lf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-LightItalic-lf-sc-lgr.tfm \
tex-AlegreyaSansSC-LightItalic-lf-sc-lgr.vf \
tex-AlegreyaSansSC-LightItalic-lf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-LightItalic-lf-sc-ly1.tfm \
tex-AlegreyaSansSC-LightItalic-lf-sc-ly1.vf \
tex-AlegreyaSansSC-LightItalic-lf-sc-ot1.tfm \
tex-AlegreyaSansSC-LightItalic-lf-sc-t1--base.tfm \
tex-AlegreyaSansSC-LightItalic-lf-sc-t1.tfm \
tex-AlegreyaSansSC-LightItalic-lf-sc-t1.vf \
tex-AlegreyaSansSC-LightItalic-osf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-LightItalic-osf-sc-lgr.tfm \
tex-AlegreyaSansSC-LightItalic-osf-sc-lgr.vf \
tex-AlegreyaSansSC-LightItalic-osf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-LightItalic-osf-sc-ly1.tfm \
tex-AlegreyaSansSC-LightItalic-osf-sc-ly1.vf \
tex-AlegreyaSansSC-LightItalic-osf-sc-ot1.tfm \
tex-AlegreyaSansSC-LightItalic-osf-sc-t1--base.tfm \
tex-AlegreyaSansSC-LightItalic-osf-sc-t1.tfm \
tex-AlegreyaSansSC-LightItalic-osf-sc-t1.vf \
tex-AlegreyaSansSC-LightItalic-sup-sc-lgr--base.tfm \
tex-AlegreyaSansSC-LightItalic-sup-sc-lgr.tfm \
tex-AlegreyaSansSC-LightItalic-sup-sc-lgr.vf \
tex-AlegreyaSansSC-LightItalic-sup-sc-ly1--base.tfm \
tex-AlegreyaSansSC-LightItalic-sup-sc-ly1.tfm \
tex-AlegreyaSansSC-LightItalic-sup-sc-ly1.vf \
tex-AlegreyaSansSC-LightItalic-sup-sc-ot1.tfm \
tex-AlegreyaSansSC-LightItalic-sup-sc-t1--base.tfm \
tex-AlegreyaSansSC-LightItalic-sup-sc-t1.tfm \
tex-AlegreyaSansSC-LightItalic-sup-sc-t1.vf \
tex-AlegreyaSansSC-LightItalic-tlf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-LightItalic-tlf-sc-lgr.tfm \
tex-AlegreyaSansSC-LightItalic-tlf-sc-lgr.vf \
tex-AlegreyaSansSC-LightItalic-tlf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-LightItalic-tlf-sc-ly1.tfm \
tex-AlegreyaSansSC-LightItalic-tlf-sc-ly1.vf \
tex-AlegreyaSansSC-LightItalic-tlf-sc-ot1.tfm \
tex-AlegreyaSansSC-LightItalic-tlf-sc-t1--base.tfm \
tex-AlegreyaSansSC-LightItalic-tlf-sc-t1.tfm \
tex-AlegreyaSansSC-LightItalic-tlf-sc-t1.vf \
tex-AlegreyaSansSC-LightItalic-tosf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-LightItalic-tosf-sc-lgr.tfm \
tex-AlegreyaSansSC-LightItalic-tosf-sc-lgr.vf \
tex-AlegreyaSansSC-LightItalic-tosf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-LightItalic-tosf-sc-ly1.tfm \
tex-AlegreyaSansSC-LightItalic-tosf-sc-ly1.vf \
tex-AlegreyaSansSC-LightItalic-tosf-sc-ot1.tfm \
tex-AlegreyaSansSC-LightItalic-tosf-sc-t1--base.tfm \
tex-AlegreyaSansSC-LightItalic-tosf-sc-t1.tfm \
tex-AlegreyaSansSC-LightItalic-tosf-sc-t1.vf \
tex-AlegreyaSansSC-Medium-inf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Medium-inf-sc-lgr.tfm \
tex-AlegreyaSansSC-Medium-inf-sc-lgr.vf \
tex-AlegreyaSansSC-Medium-inf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Medium-inf-sc-ly1.tfm \
tex-AlegreyaSansSC-Medium-inf-sc-ly1.vf \
tex-AlegreyaSansSC-Medium-inf-sc-ot1.tfm \
tex-AlegreyaSansSC-Medium-inf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Medium-inf-sc-t1.tfm \
tex-AlegreyaSansSC-Medium-inf-sc-t1.vf \
tex-AlegreyaSansSC-Medium-lf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Medium-lf-sc-lgr.tfm \
tex-AlegreyaSansSC-Medium-lf-sc-lgr.vf \
tex-AlegreyaSansSC-Medium-lf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Medium-lf-sc-ly1.tfm \
tex-AlegreyaSansSC-Medium-lf-sc-ly1.vf \
tex-AlegreyaSansSC-Medium-lf-sc-ot1.tfm \
tex-AlegreyaSansSC-Medium-lf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Medium-lf-sc-t1.tfm \
tex-AlegreyaSansSC-Medium-lf-sc-t1.vf \
tex-AlegreyaSansSC-Medium-osf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Medium-osf-sc-lgr.tfm \
tex-AlegreyaSansSC-Medium-osf-sc-lgr.vf \
tex-AlegreyaSansSC-Medium-osf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Medium-osf-sc-ly1.tfm \
tex-AlegreyaSansSC-Medium-osf-sc-ly1.vf \
tex-AlegreyaSansSC-Medium-osf-sc-ot1.tfm \
tex-AlegreyaSansSC-Medium-osf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Medium-osf-sc-t1.tfm \
tex-AlegreyaSansSC-Medium-osf-sc-t1.vf \
tex-AlegreyaSansSC-Medium-sup-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Medium-sup-sc-lgr.tfm \
tex-AlegreyaSansSC-Medium-sup-sc-lgr.vf \
tex-AlegreyaSansSC-Medium-sup-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Medium-sup-sc-ly1.tfm \
tex-AlegreyaSansSC-Medium-sup-sc-ly1.vf \
tex-AlegreyaSansSC-Medium-sup-sc-ot1.tfm \
tex-AlegreyaSansSC-Medium-sup-sc-t1--base.tfm \
tex-AlegreyaSansSC-Medium-sup-sc-t1.tfm \
tex-AlegreyaSansSC-Medium-sup-sc-t1.vf \
tex-AlegreyaSansSC-Medium-tlf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Medium-tlf-sc-lgr.tfm \
tex-AlegreyaSansSC-Medium-tlf-sc-lgr.vf \
tex-AlegreyaSansSC-Medium-tlf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Medium-tlf-sc-ly1.tfm \
tex-AlegreyaSansSC-Medium-tlf-sc-ly1.vf \
tex-AlegreyaSansSC-Medium-tlf-sc-ot1.tfm \
tex-AlegreyaSansSC-Medium-tlf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Medium-tlf-sc-t1.tfm \
tex-AlegreyaSansSC-Medium-tlf-sc-t1.vf \
tex-AlegreyaSansSC-Medium-tosf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Medium-tosf-sc-lgr.tfm \
tex-AlegreyaSansSC-Medium-tosf-sc-lgr.vf \
tex-AlegreyaSansSC-Medium-tosf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Medium-tosf-sc-ly1.tfm \
tex-AlegreyaSansSC-Medium-tosf-sc-ly1.vf \
tex-AlegreyaSansSC-Medium-tosf-sc-ot1.tfm \
tex-AlegreyaSansSC-Medium-tosf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Medium-tosf-sc-t1.tfm \
tex-AlegreyaSansSC-Medium-tosf-sc-t1.vf \
tex-AlegreyaSansSC-MediumItalic-inf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-MediumItalic-inf-sc-lgr.tfm \
tex-AlegreyaSansSC-MediumItalic-inf-sc-lgr.vf \
tex-AlegreyaSansSC-MediumItalic-inf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-MediumItalic-inf-sc-ly1.tfm \
tex-AlegreyaSansSC-MediumItalic-inf-sc-ly1.vf \
tex-AlegreyaSansSC-MediumItalic-inf-sc-ot1.tfm \
tex-AlegreyaSansSC-MediumItalic-inf-sc-t1--base.tfm \
tex-AlegreyaSansSC-MediumItalic-inf-sc-t1.tfm \
tex-AlegreyaSansSC-MediumItalic-inf-sc-t1.vf \
tex-AlegreyaSansSC-MediumItalic-lf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-MediumItalic-lf-sc-lgr.tfm \
tex-AlegreyaSansSC-MediumItalic-lf-sc-lgr.vf \
tex-AlegreyaSansSC-MediumItalic-lf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-MediumItalic-lf-sc-ly1.tfm \
tex-AlegreyaSansSC-MediumItalic-lf-sc-ly1.vf \
tex-AlegreyaSansSC-MediumItalic-lf-sc-ot1.tfm \
tex-AlegreyaSansSC-MediumItalic-lf-sc-t1--base.tfm \
tex-AlegreyaSansSC-MediumItalic-lf-sc-t1.tfm \
tex-AlegreyaSansSC-MediumItalic-lf-sc-t1.vf \
tex-AlegreyaSansSC-MediumItalic-osf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-MediumItalic-osf-sc-lgr.tfm \
tex-AlegreyaSansSC-MediumItalic-osf-sc-lgr.vf \
tex-AlegreyaSansSC-MediumItalic-osf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-MediumItalic-osf-sc-ly1.tfm \
tex-AlegreyaSansSC-MediumItalic-osf-sc-ly1.vf \
tex-AlegreyaSansSC-MediumItalic-osf-sc-ot1.tfm \
tex-AlegreyaSansSC-MediumItalic-osf-sc-t1--base.tfm \
tex-AlegreyaSansSC-MediumItalic-osf-sc-t1.tfm \
tex-AlegreyaSansSC-MediumItalic-osf-sc-t1.vf \
tex-AlegreyaSansSC-MediumItalic-sup-sc-lgr--base.tfm \
tex-AlegreyaSansSC-MediumItalic-sup-sc-lgr.tfm \
tex-AlegreyaSansSC-MediumItalic-sup-sc-lgr.vf \
tex-AlegreyaSansSC-MediumItalic-sup-sc-ly1--base.tfm \
tex-AlegreyaSansSC-MediumItalic-sup-sc-ly1.tfm \
tex-AlegreyaSansSC-MediumItalic-sup-sc-ly1.vf \
tex-AlegreyaSansSC-MediumItalic-sup-sc-ot1.tfm \
tex-AlegreyaSansSC-MediumItalic-sup-sc-t1--base.tfm \
tex-AlegreyaSansSC-MediumItalic-sup-sc-t1.tfm \
tex-AlegreyaSansSC-MediumItalic-sup-sc-t1.vf \
tex-AlegreyaSansSC-MediumItalic-tlf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-MediumItalic-tlf-sc-lgr.tfm \
tex-AlegreyaSansSC-MediumItalic-tlf-sc-lgr.vf \
tex-AlegreyaSansSC-MediumItalic-tlf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-MediumItalic-tlf-sc-ly1.tfm \
tex-AlegreyaSansSC-MediumItalic-tlf-sc-ly1.vf \
tex-AlegreyaSansSC-MediumItalic-tlf-sc-ot1.tfm \
tex-AlegreyaSansSC-MediumItalic-tlf-sc-t1--base.tfm \
tex-AlegreyaSansSC-MediumItalic-tlf-sc-t1.tfm \
tex-AlegreyaSansSC-MediumItalic-tlf-sc-t1.vf \
tex-AlegreyaSansSC-MediumItalic-tosf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-MediumItalic-tosf-sc-lgr.tfm \
tex-AlegreyaSansSC-MediumItalic-tosf-sc-lgr.vf \
tex-AlegreyaSansSC-MediumItalic-tosf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-MediumItalic-tosf-sc-ly1.tfm \
tex-AlegreyaSansSC-MediumItalic-tosf-sc-ly1.vf \
tex-AlegreyaSansSC-MediumItalic-tosf-sc-ot1.tfm \
tex-AlegreyaSansSC-MediumItalic-tosf-sc-t1--base.tfm \
tex-AlegreyaSansSC-MediumItalic-tosf-sc-t1.tfm \
tex-AlegreyaSansSC-MediumItalic-tosf-sc-t1.vf \
tex-AlegreyaSansSC-Regular-inf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Regular-inf-sc-lgr.tfm \
tex-AlegreyaSansSC-Regular-inf-sc-lgr.vf \
tex-AlegreyaSansSC-Regular-inf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Regular-inf-sc-ly1.tfm \
tex-AlegreyaSansSC-Regular-inf-sc-ly1.vf \
tex-AlegreyaSansSC-Regular-inf-sc-ot1.tfm \
tex-AlegreyaSansSC-Regular-inf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Regular-inf-sc-t1.tfm \
tex-AlegreyaSansSC-Regular-inf-sc-t1.vf \
tex-AlegreyaSansSC-Regular-lf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Regular-lf-sc-lgr.tfm \
tex-AlegreyaSansSC-Regular-lf-sc-lgr.vf \
tex-AlegreyaSansSC-Regular-lf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Regular-lf-sc-ly1.tfm \
tex-AlegreyaSansSC-Regular-lf-sc-ly1.vf \
tex-AlegreyaSansSC-Regular-lf-sc-ot1.tfm \
tex-AlegreyaSansSC-Regular-lf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Regular-lf-sc-t1.tfm \
tex-AlegreyaSansSC-Regular-lf-sc-t1.vf \
tex-AlegreyaSansSC-Regular-osf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Regular-osf-sc-lgr.tfm \
tex-AlegreyaSansSC-Regular-osf-sc-lgr.vf \
tex-AlegreyaSansSC-Regular-osf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Regular-osf-sc-ly1.tfm \
tex-AlegreyaSansSC-Regular-osf-sc-ly1.vf \
tex-AlegreyaSansSC-Regular-osf-sc-ot1.tfm \
tex-AlegreyaSansSC-Regular-osf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Regular-osf-sc-t1.tfm \
tex-AlegreyaSansSC-Regular-osf-sc-t1.vf \
tex-AlegreyaSansSC-Regular-sup-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Regular-sup-sc-lgr.tfm \
tex-AlegreyaSansSC-Regular-sup-sc-lgr.vf \
tex-AlegreyaSansSC-Regular-sup-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Regular-sup-sc-ly1.tfm \
tex-AlegreyaSansSC-Regular-sup-sc-ly1.vf \
tex-AlegreyaSansSC-Regular-sup-sc-ot1.tfm \
tex-AlegreyaSansSC-Regular-sup-sc-t1--base.tfm \
tex-AlegreyaSansSC-Regular-sup-sc-t1.tfm \
tex-AlegreyaSansSC-Regular-sup-sc-t1.vf \
tex-AlegreyaSansSC-Regular-tlf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Regular-tlf-sc-lgr.tfm \
tex-AlegreyaSansSC-Regular-tlf-sc-lgr.vf \
tex-AlegreyaSansSC-Regular-tlf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Regular-tlf-sc-ly1.tfm \
tex-AlegreyaSansSC-Regular-tlf-sc-ly1.vf \
tex-AlegreyaSansSC-Regular-tlf-sc-ot1.tfm \
tex-AlegreyaSansSC-Regular-tlf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Regular-tlf-sc-t1.tfm \
tex-AlegreyaSansSC-Regular-tlf-sc-t1.vf \
tex-AlegreyaSansSC-Regular-tosf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Regular-tosf-sc-lgr.tfm \
tex-AlegreyaSansSC-Regular-tosf-sc-lgr.vf \
tex-AlegreyaSansSC-Regular-tosf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Regular-tosf-sc-ly1.tfm \
tex-AlegreyaSansSC-Regular-tosf-sc-ly1.vf \
tex-AlegreyaSansSC-Regular-tosf-sc-ot1.tfm \
tex-AlegreyaSansSC-Regular-tosf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Regular-tosf-sc-t1.tfm \
tex-AlegreyaSansSC-Regular-tosf-sc-t1.vf \
tex-AlegreyaSansSC-Thin-inf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Thin-inf-sc-lgr.tfm \
tex-AlegreyaSansSC-Thin-inf-sc-lgr.vf \
tex-AlegreyaSansSC-Thin-inf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Thin-inf-sc-ly1.tfm \
tex-AlegreyaSansSC-Thin-inf-sc-ly1.vf \
tex-AlegreyaSansSC-Thin-inf-sc-ot1.tfm \
tex-AlegreyaSansSC-Thin-inf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Thin-inf-sc-t1.tfm \
tex-AlegreyaSansSC-Thin-inf-sc-t1.vf \
tex-AlegreyaSansSC-Thin-lf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Thin-lf-sc-lgr.tfm \
tex-AlegreyaSansSC-Thin-lf-sc-lgr.vf \
tex-AlegreyaSansSC-Thin-lf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Thin-lf-sc-ly1.tfm \
tex-AlegreyaSansSC-Thin-lf-sc-ly1.vf \
tex-AlegreyaSansSC-Thin-lf-sc-ot1.tfm \
tex-AlegreyaSansSC-Thin-lf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Thin-lf-sc-t1.tfm \
tex-AlegreyaSansSC-Thin-lf-sc-t1.vf \
tex-AlegreyaSansSC-Thin-osf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Thin-osf-sc-lgr.tfm \
tex-AlegreyaSansSC-Thin-osf-sc-lgr.vf \
tex-AlegreyaSansSC-Thin-osf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Thin-osf-sc-ly1.tfm \
tex-AlegreyaSansSC-Thin-osf-sc-ly1.vf \
tex-AlegreyaSansSC-Thin-osf-sc-ot1.tfm \
tex-AlegreyaSansSC-Thin-osf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Thin-osf-sc-t1.tfm \
tex-AlegreyaSansSC-Thin-osf-sc-t1.vf \
tex-AlegreyaSansSC-Thin-sup-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Thin-sup-sc-lgr.tfm \
tex-AlegreyaSansSC-Thin-sup-sc-lgr.vf \
tex-AlegreyaSansSC-Thin-sup-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Thin-sup-sc-ly1.tfm \
tex-AlegreyaSansSC-Thin-sup-sc-ly1.vf \
tex-AlegreyaSansSC-Thin-sup-sc-ot1.tfm \
tex-AlegreyaSansSC-Thin-sup-sc-t1--base.tfm \
tex-AlegreyaSansSC-Thin-sup-sc-t1.tfm \
tex-AlegreyaSansSC-Thin-sup-sc-t1.vf \
tex-AlegreyaSansSC-Thin-tlf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Thin-tlf-sc-lgr.tfm \
tex-AlegreyaSansSC-Thin-tlf-sc-lgr.vf \
tex-AlegreyaSansSC-Thin-tlf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Thin-tlf-sc-ly1.tfm \
tex-AlegreyaSansSC-Thin-tlf-sc-ly1.vf \
tex-AlegreyaSansSC-Thin-tlf-sc-ot1.tfm \
tex-AlegreyaSansSC-Thin-tlf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Thin-tlf-sc-t1.tfm \
tex-AlegreyaSansSC-Thin-tlf-sc-t1.vf \
tex-AlegreyaSansSC-Thin-tosf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-Thin-tosf-sc-lgr.tfm \
tex-AlegreyaSansSC-Thin-tosf-sc-lgr.vf \
tex-AlegreyaSansSC-Thin-tosf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-Thin-tosf-sc-ly1.tfm \
tex-AlegreyaSansSC-Thin-tosf-sc-ly1.vf \
tex-AlegreyaSansSC-Thin-tosf-sc-ot1.tfm \
tex-AlegreyaSansSC-Thin-tosf-sc-t1--base.tfm \
tex-AlegreyaSansSC-Thin-tosf-sc-t1.tfm \
tex-AlegreyaSansSC-Thin-tosf-sc-t1.vf \
tex-AlegreyaSansSC-ThinItalic-inf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-ThinItalic-inf-sc-lgr.tfm \
tex-AlegreyaSansSC-ThinItalic-inf-sc-lgr.vf \
tex-AlegreyaSansSC-ThinItalic-inf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-ThinItalic-inf-sc-ly1.tfm \
tex-AlegreyaSansSC-ThinItalic-inf-sc-ly1.vf \
tex-AlegreyaSansSC-ThinItalic-inf-sc-ot1.tfm \
tex-AlegreyaSansSC-ThinItalic-inf-sc-t1--base.tfm \
tex-AlegreyaSansSC-ThinItalic-inf-sc-t1.tfm \
tex-AlegreyaSansSC-ThinItalic-inf-sc-t1.vf \
tex-AlegreyaSansSC-ThinItalic-lf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-ThinItalic-lf-sc-lgr.tfm \
tex-AlegreyaSansSC-ThinItalic-lf-sc-lgr.vf \
tex-AlegreyaSansSC-ThinItalic-lf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-ThinItalic-lf-sc-ly1.tfm \
tex-AlegreyaSansSC-ThinItalic-lf-sc-ly1.vf \
tex-AlegreyaSansSC-ThinItalic-lf-sc-ot1.tfm \
tex-AlegreyaSansSC-ThinItalic-lf-sc-t1--base.tfm \
tex-AlegreyaSansSC-ThinItalic-lf-sc-t1.tfm \
tex-AlegreyaSansSC-ThinItalic-lf-sc-t1.vf \
tex-AlegreyaSansSC-ThinItalic-osf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-ThinItalic-osf-sc-lgr.tfm \
tex-AlegreyaSansSC-ThinItalic-osf-sc-lgr.vf \
tex-AlegreyaSansSC-ThinItalic-osf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-ThinItalic-osf-sc-ly1.tfm \
tex-AlegreyaSansSC-ThinItalic-osf-sc-ly1.vf \
tex-AlegreyaSansSC-ThinItalic-osf-sc-ot1.tfm \
tex-AlegreyaSansSC-ThinItalic-osf-sc-t1--base.tfm \
tex-AlegreyaSansSC-ThinItalic-osf-sc-t1.tfm \
tex-AlegreyaSansSC-ThinItalic-osf-sc-t1.vf \
tex-AlegreyaSansSC-ThinItalic-sup-sc-lgr--base.tfm \
tex-AlegreyaSansSC-ThinItalic-sup-sc-lgr.tfm \
tex-AlegreyaSansSC-ThinItalic-sup-sc-lgr.vf \
tex-AlegreyaSansSC-ThinItalic-sup-sc-ly1--base.tfm \
tex-AlegreyaSansSC-ThinItalic-sup-sc-ly1.tfm \
tex-AlegreyaSansSC-ThinItalic-sup-sc-ly1.vf \
tex-AlegreyaSansSC-ThinItalic-sup-sc-ot1.tfm \
tex-AlegreyaSansSC-ThinItalic-sup-sc-t1--base.tfm \
tex-AlegreyaSansSC-ThinItalic-sup-sc-t1.tfm \
tex-AlegreyaSansSC-ThinItalic-sup-sc-t1.vf \
tex-AlegreyaSansSC-ThinItalic-tlf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-ThinItalic-tlf-sc-lgr.tfm \
tex-AlegreyaSansSC-ThinItalic-tlf-sc-lgr.vf \
tex-AlegreyaSansSC-ThinItalic-tlf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-ThinItalic-tlf-sc-ly1.tfm \
tex-AlegreyaSansSC-ThinItalic-tlf-sc-ly1.vf \
tex-AlegreyaSansSC-ThinItalic-tlf-sc-ot1.tfm \
tex-AlegreyaSansSC-ThinItalic-tlf-sc-t1--base.tfm \
tex-AlegreyaSansSC-ThinItalic-tlf-sc-t1.tfm \
tex-AlegreyaSansSC-ThinItalic-tlf-sc-t1.vf \
tex-AlegreyaSansSC-ThinItalic-tosf-sc-lgr--base.tfm \
tex-AlegreyaSansSC-ThinItalic-tosf-sc-lgr.tfm \
tex-AlegreyaSansSC-ThinItalic-tosf-sc-lgr.vf \
tex-AlegreyaSansSC-ThinItalic-tosf-sc-ly1--base.tfm \
tex-AlegreyaSansSC-ThinItalic-tosf-sc-ly1.tfm \
tex-AlegreyaSansSC-ThinItalic-tosf-sc-ly1.vf \
tex-AlegreyaSansSC-ThinItalic-tosf-sc-ot1.tfm \
tex-AlegreyaSansSC-ThinItalic-tosf-sc-t1--base.tfm \
tex-AlegreyaSansSC-ThinItalic-tosf-sc-t1.tfm \
tex-AlegreyaSansSC-ThinItalic-tosf-sc-t1.vf \
tex-LGRAlegreya-Inf.fd \
tex-LGRAlegreya-LF.fd \
tex-LGRAlegreya-OsF.fd \
tex-LGRAlegreya-Sup.fd \
tex-LGRAlegreya-TLF.fd \
tex-LGRAlegreya-TOsF.fd \
tex-LGRAlegreyaSans-Inf.fd \
tex-LGRAlegreyaSans-LF.fd \
tex-LGRAlegreyaSans-OsF.fd \
tex-LGRAlegreyaSans-Sup.fd \
tex-LGRAlegreyaSans-TLF.fd \
tex-LGRAlegreyaSans-TOsF.fd \
tex-LY1Alegreya-Inf.fd \
tex-LY1Alegreya-LF.fd \
tex-LY1Alegreya-OsF.fd \
tex-LY1Alegreya-Sup.fd \
tex-LY1Alegreya-TLF.fd \
tex-LY1Alegreya-TOsF.fd \
tex-LY1AlegreyaSans-Inf.fd \
tex-LY1AlegreyaSans-LF.fd \
tex-LY1AlegreyaSans-OsF.fd \
tex-LY1AlegreyaSans-Sup.fd \
tex-LY1AlegreyaSans-TLF.fd \
tex-LY1AlegreyaSans-TOsF.fd \
tex-OT1Alegreya-Inf.fd \
tex-OT1Alegreya-LF.fd \
tex-OT1Alegreya-OsF.fd \
tex-OT1Alegreya-Sup.fd \
tex-OT1Alegreya-TLF.fd \
tex-OT1Alegreya-TOsF.fd \
tex-OT1AlegreyaSans-Inf.fd \
tex-OT1AlegreyaSans-LF.fd \
tex-OT1AlegreyaSans-OsF.fd \
tex-OT1AlegreyaSans-Sup.fd \
tex-OT1AlegreyaSans-TLF.fd \
tex-OT1AlegreyaSans-TOsF.fd \
tex-T1Alegreya-Inf.fd \
tex-T1Alegreya-LF.fd \
tex-T1Alegreya-OsF.fd \
tex-T1Alegreya-Sup.fd \
tex-T1Alegreya-TLF.fd \
tex-T1Alegreya-TOsF.fd \
tex-T1AlegreyaSans-Inf.fd \
tex-T1AlegreyaSans-LF.fd \
tex-T1AlegreyaSans-OsF.fd \
tex-T1AlegreyaSans-Sup.fd \
tex-T1AlegreyaSans-TLF.fd \
tex-T1AlegreyaSans-TOsF.fd \
tex-TS1Alegreya-LF.fd \
tex-TS1Alegreya-OsF.fd \
tex-TS1Alegreya-TLF.fd \
tex-TS1Alegreya-TOsF.fd \
tex-TS1AlegreyaSans-LF.fd \
tex-TS1AlegreyaSans-OsF.fd \
tex-TS1AlegreyaSans-TLF.fd \
tex-TS1AlegreyaSans-TOsF.fd \
tex-algr-226fyf.enc \
tex-algr-2vgxay.enc \
tex-algr-32il6z.enc \
tex-algr-3ej7ja.enc \
tex-algr-3j6zf7.enc \
tex-algr-3w755y.enc \
tex-algr-4ns4wz.enc \
tex-algr-4v37z4.enc \
tex-algr-5gibri.enc \
tex-algr-5io2mf.enc \
tex-algr-5rsmqe.enc \
tex-algr-62cj7n.enc \
tex-algr-66zd6s.enc \
tex-algr-6jp7bb.enc \
tex-algr-6lq5ex.enc \
tex-algr-6q4car.enc \
tex-algr-6wvqta.enc \
tex-algr-7cbt5m.enc \
tex-algr-7jzpyg.enc \
tex-algr-b53fje.enc \
tex-algr-bwwxle.enc \
tex-algr-chmses.enc \
tex-algr-ck23qu.enc \
tex-algr-dfcgiv.enc \
tex-algr-dokm3m.enc \
tex-algr-dte76s.enc \
tex-algr-ec6aae.enc \
tex-algr-eltpie.enc \
tex-algr-es2wca.enc \
tex-algr-evb22y.enc \
tex-algr-f7lt35.enc \
tex-algr-fbntfe.enc \
tex-algr-fi2sgn.enc \
tex-algr-g3cfdt.enc \
tex-algr-h4wxrq.enc \
tex-algr-hnbre7.enc \
tex-algr-hxyeky.enc \
tex-algr-hzbvjz.enc \
tex-algr-isiobp.enc \
tex-algr-iszm25.enc \
tex-algr-jfvu45.enc \
tex-algr-jmly6e.enc \
tex-algr-kvnvnq.enc \
tex-algr-l3q2fl.enc \
tex-algr-mlgxyz.enc \
tex-algr-n26fs4.enc \
tex-algr-nwaz6g.enc \
tex-algr-oq6qvg.enc \
tex-algr-oqh4wu.enc \
tex-algr-orkgok.enc \
tex-algr-oum7q3.enc \
tex-algr-p7kywn.enc \
tex-algr-phmojf.enc \
tex-algr-qizth5.enc \
tex-algr-qy2xvu.enc \
tex-algr-r57u46.enc \
tex-algr-rpkba2.enc \
tex-algr-rxhb6t.enc \
tex-algr-su2s7h.enc \
tex-algr-te6qwy.enc \
tex-algr-tf5zvx.enc \
tex-algr-u7nq5p.enc \
tex-algr-unkqzs.enc \
tex-algr-v7kvmg.enc \
tex-algr-v7zz7p.enc \
tex-algr-vbs4kl.enc \
tex-algr-vwfggt.enc \
tex-algr-w4wd2e.enc \
tex-algr-wbb64e.enc \
tex-algr-wnb4kq.enc \
tex-algr-xyef6o.enc \
tex-algr-y2uq4q.enc \
tex-algr-ywnyo5.enc \
tex-algr-zbisw7.enc \
tex-algr-zgz46n.enc \
tex-algr-zsorhr.enc \
tex-algr-zt4bhv.enc \
texlive-alegreya"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontaxes.sty \
tex-fontenc.sty \
tex-fontspec.sty \
tex-ifluatex.sty \
tex-ifxetex.sty \
tex-mweights.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-alegreya-fonts \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
