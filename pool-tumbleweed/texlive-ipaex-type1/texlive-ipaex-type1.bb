SUMMARY = "IPAex fonts converted to Type-1 format Unicode subfonts"
DESCRIPTION = "The package contains the IPAex Fonts converted into Unicode \
subfonts in Type1 format, which is most suitable for use with \
the CJK package. Font conversion was done with ttf2pt1."
LICENSE = "LPPL-1.0"

PV = "2023.201.0.0.5svn47700"

RPM_NAME = "texlive-ipaex-type1-2023.201.0.0.5svn47700-55.1.noarch.rpm"
RPM_HASH = "cd08922c6790d47663ee10ab5047a37fe8f84f96073ec497fd23b4235077f1eb5f576abe536f66c6e4c28b7ce00f5edb9660c2231ad8d20cc75eb27169661e12"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-c70ipxg.fd \
tex-c70ipxga.fd \
tex-c70ipxm.fd \
tex-c70ipxma.fd \
tex-ipaex-type1.map \
tex-ipaex-type1.sty \
tex-ipxg-r-ly1.tfm \
tex-ipxg-r-ot1.tfm \
tex-ipxg-r-t1.tfm \
tex-ipxg-r-ts1.tfm \
tex-ipxg-r-u00.tfm \
tex-ipxg-r-u01.tfm \
tex-ipxg-r-u02.tfm \
tex-ipxg-r-u0200.tfm \
tex-ipxg-r-u0201.tfm \
tex-ipxg-r-u0202.tfm \
tex-ipxg-r-u0203.tfm \
tex-ipxg-r-u0204.tfm \
tex-ipxg-r-u0205.tfm \
tex-ipxg-r-u0206.tfm \
tex-ipxg-r-u0207.tfm \
tex-ipxg-r-u0208.tfm \
tex-ipxg-r-u0209.tfm \
tex-ipxg-r-u020a.tfm \
tex-ipxg-r-u020b.tfm \
tex-ipxg-r-u020d.tfm \
tex-ipxg-r-u020e.tfm \
tex-ipxg-r-u020f.tfm \
tex-ipxg-r-u0212.tfm \
tex-ipxg-r-u0213.tfm \
tex-ipxg-r-u0214.tfm \
tex-ipxg-r-u0215.tfm \
tex-ipxg-r-u0216.tfm \
tex-ipxg-r-u0217.tfm \
tex-ipxg-r-u0218.tfm \
tex-ipxg-r-u0219.tfm \
tex-ipxg-r-u021c.tfm \
tex-ipxg-r-u021d.tfm \
tex-ipxg-r-u021e.tfm \
tex-ipxg-r-u021f.tfm \
tex-ipxg-r-u0221.tfm \
tex-ipxg-r-u0222.tfm \
tex-ipxg-r-u0223.tfm \
tex-ipxg-r-u0226.tfm \
tex-ipxg-r-u0228.tfm \
tex-ipxg-r-u0229.tfm \
tex-ipxg-r-u022a.tfm \
tex-ipxg-r-u022b.tfm \
tex-ipxg-r-u022c.tfm \
tex-ipxg-r-u022d.tfm \
tex-ipxg-r-u0231.tfm \
tex-ipxg-r-u0233.tfm \
tex-ipxg-r-u0234.tfm \
tex-ipxg-r-u0235.tfm \
tex-ipxg-r-u0236.tfm \
tex-ipxg-r-u0237.tfm \
tex-ipxg-r-u0238.tfm \
tex-ipxg-r-u023a.tfm \
tex-ipxg-r-u023c.tfm \
tex-ipxg-r-u023d.tfm \
tex-ipxg-r-u023f.tfm \
tex-ipxg-r-u0240.tfm \
tex-ipxg-r-u0241.tfm \
tex-ipxg-r-u0243.tfm \
tex-ipxg-r-u0246.tfm \
tex-ipxg-r-u0247.tfm \
tex-ipxg-r-u0248.tfm \
tex-ipxg-r-u024a.tfm \
tex-ipxg-r-u024b.tfm \
tex-ipxg-r-u024c.tfm \
tex-ipxg-r-u024d.tfm \
tex-ipxg-r-u024e.tfm \
tex-ipxg-r-u0250.tfm \
tex-ipxg-r-u0251.tfm \
tex-ipxg-r-u0252.tfm \
tex-ipxg-r-u0254.tfm \
tex-ipxg-r-u0255.tfm \
tex-ipxg-r-u0257.tfm \
tex-ipxg-r-u0259.tfm \
tex-ipxg-r-u025a.tfm \
tex-ipxg-r-u025b.tfm \
tex-ipxg-r-u025c.tfm \
tex-ipxg-r-u025d.tfm \
tex-ipxg-r-u025e.tfm \
tex-ipxg-r-u025f.tfm \
tex-ipxg-r-u0260.tfm \
tex-ipxg-r-u0262.tfm \
tex-ipxg-r-u0263.tfm \
tex-ipxg-r-u0264.tfm \
tex-ipxg-r-u0266.tfm \
tex-ipxg-r-u0267.tfm \
tex-ipxg-r-u0268.tfm \
tex-ipxg-r-u0269.tfm \
tex-ipxg-r-u026a.tfm \
tex-ipxg-r-u026c.tfm \
tex-ipxg-r-u026e.tfm \
tex-ipxg-r-u026f.tfm \
tex-ipxg-r-u0270.tfm \
tex-ipxg-r-u0271.tfm \
tex-ipxg-r-u0273.tfm \
tex-ipxg-r-u0274.tfm \
tex-ipxg-r-u0276.tfm \
tex-ipxg-r-u0277.tfm \
tex-ipxg-r-u0279.tfm \
tex-ipxg-r-u027a.tfm \
tex-ipxg-r-u027b.tfm \
tex-ipxg-r-u027c.tfm \
tex-ipxg-r-u027d.tfm \
tex-ipxg-r-u027e.tfm \
tex-ipxg-r-u027f.tfm \
tex-ipxg-r-u0280.tfm \
tex-ipxg-r-u0282.tfm \
tex-ipxg-r-u0283.tfm \
tex-ipxg-r-u0284.tfm \
tex-ipxg-r-u0285.tfm \
tex-ipxg-r-u0286.tfm \
tex-ipxg-r-u0289.tfm \
tex-ipxg-r-u028a.tfm \
tex-ipxg-r-u028b.tfm \
tex-ipxg-r-u028d.tfm \
tex-ipxg-r-u028e.tfm \
tex-ipxg-r-u028f.tfm \
tex-ipxg-r-u0292.tfm \
tex-ipxg-r-u0294.tfm \
tex-ipxg-r-u0295.tfm \
tex-ipxg-r-u0296.tfm \
tex-ipxg-r-u0297.tfm \
tex-ipxg-r-u0298.tfm \
tex-ipxg-r-u029a.tfm \
tex-ipxg-r-u029d.tfm \
tex-ipxg-r-u029e.tfm \
tex-ipxg-r-u029f.tfm \
tex-ipxg-r-u02a0.tfm \
tex-ipxg-r-u02a1.tfm \
tex-ipxg-r-u02a3.tfm \
tex-ipxg-r-u02a4.tfm \
tex-ipxg-r-u02a5.tfm \
tex-ipxg-r-u02a6.tfm \
tex-ipxg-r-u02f8.tfm \
tex-ipxg-r-u03.tfm \
tex-ipxg-r-u04.tfm \
tex-ipxg-r-u1e.tfm \
tex-ipxg-r-u1f.tfm \
tex-ipxg-r-u20.tfm \
tex-ipxg-r-u21.tfm \
tex-ipxg-r-u22.tfm \
tex-ipxg-r-u23.tfm \
tex-ipxg-r-u24.tfm \
tex-ipxg-r-u25.tfm \
tex-ipxg-r-u26.tfm \
tex-ipxg-r-u27.tfm \
tex-ipxg-r-u29.tfm \
tex-ipxg-r-u2e.tfm \
tex-ipxg-r-u2f.tfm \
tex-ipxg-r-u30.tfm \
tex-ipxg-r-u31.tfm \
tex-ipxg-r-u32.tfm \
tex-ipxg-r-u33.tfm \
tex-ipxg-r-u34.tfm \
tex-ipxg-r-u35.tfm \
tex-ipxg-r-u36.tfm \
tex-ipxg-r-u37.tfm \
tex-ipxg-r-u38.tfm \
tex-ipxg-r-u39.tfm \
tex-ipxg-r-u3a.tfm \
tex-ipxg-r-u3b.tfm \
tex-ipxg-r-u3c.tfm \
tex-ipxg-r-u3d.tfm \
tex-ipxg-r-u3e.tfm \
tex-ipxg-r-u3f.tfm \
tex-ipxg-r-u40.tfm \
tex-ipxg-r-u41.tfm \
tex-ipxg-r-u42.tfm \
tex-ipxg-r-u43.tfm \
tex-ipxg-r-u44.tfm \
tex-ipxg-r-u45.tfm \
tex-ipxg-r-u46.tfm \
tex-ipxg-r-u47.tfm \
tex-ipxg-r-u48.tfm \
tex-ipxg-r-u49.tfm \
tex-ipxg-r-u4a.tfm \
tex-ipxg-r-u4b.tfm \
tex-ipxg-r-u4c.tfm \
tex-ipxg-r-u4d.tfm \
tex-ipxg-r-u4e.tfm \
tex-ipxg-r-u4f.tfm \
tex-ipxg-r-u50.tfm \
tex-ipxg-r-u51.tfm \
tex-ipxg-r-u52.tfm \
tex-ipxg-r-u53.tfm \
tex-ipxg-r-u54.tfm \
tex-ipxg-r-u55.tfm \
tex-ipxg-r-u56.tfm \
tex-ipxg-r-u57.tfm \
tex-ipxg-r-u58.tfm \
tex-ipxg-r-u59.tfm \
tex-ipxg-r-u5a.tfm \
tex-ipxg-r-u5b.tfm \
tex-ipxg-r-u5c.tfm \
tex-ipxg-r-u5d.tfm \
tex-ipxg-r-u5e.tfm \
tex-ipxg-r-u5f.tfm \
tex-ipxg-r-u60.tfm \
tex-ipxg-r-u61.tfm \
tex-ipxg-r-u62.tfm \
tex-ipxg-r-u63.tfm \
tex-ipxg-r-u64.tfm \
tex-ipxg-r-u65.tfm \
tex-ipxg-r-u66.tfm \
tex-ipxg-r-u67.tfm \
tex-ipxg-r-u68.tfm \
tex-ipxg-r-u69.tfm \
tex-ipxg-r-u6a.tfm \
tex-ipxg-r-u6b.tfm \
tex-ipxg-r-u6c.tfm \
tex-ipxg-r-u6d.tfm \
tex-ipxg-r-u6e.tfm \
tex-ipxg-r-u6f.tfm \
tex-ipxg-r-u70.tfm \
tex-ipxg-r-u71.tfm \
tex-ipxg-r-u72.tfm \
tex-ipxg-r-u73.tfm \
tex-ipxg-r-u74.tfm \
tex-ipxg-r-u75.tfm \
tex-ipxg-r-u76.tfm \
tex-ipxg-r-u77.tfm \
tex-ipxg-r-u78.tfm \
tex-ipxg-r-u79.tfm \
tex-ipxg-r-u7a.tfm \
tex-ipxg-r-u7b.tfm \
tex-ipxg-r-u7c.tfm \
tex-ipxg-r-u7d.tfm \
tex-ipxg-r-u7e.tfm \
tex-ipxg-r-u7f.tfm \
tex-ipxg-r-u80.tfm \
tex-ipxg-r-u81.tfm \
tex-ipxg-r-u82.tfm \
tex-ipxg-r-u83.tfm \
tex-ipxg-r-u84.tfm \
tex-ipxg-r-u85.tfm \
tex-ipxg-r-u86.tfm \
tex-ipxg-r-u87.tfm \
tex-ipxg-r-u88.tfm \
tex-ipxg-r-u89.tfm \
tex-ipxg-r-u8a.tfm \
tex-ipxg-r-u8b.tfm \
tex-ipxg-r-u8c.tfm \
tex-ipxg-r-u8d.tfm \
tex-ipxg-r-u8e.tfm \
tex-ipxg-r-u8f.tfm \
tex-ipxg-r-u90.tfm \
tex-ipxg-r-u91.tfm \
tex-ipxg-r-u92.tfm \
tex-ipxg-r-u93.tfm \
tex-ipxg-r-u94.tfm \
tex-ipxg-r-u95.tfm \
tex-ipxg-r-u96.tfm \
tex-ipxg-r-u97.tfm \
tex-ipxg-r-u98.tfm \
tex-ipxg-r-u99.tfm \
tex-ipxg-r-u9a.tfm \
tex-ipxg-r-u9b.tfm \
tex-ipxg-r-u9c.tfm \
tex-ipxg-r-u9d.tfm \
tex-ipxg-r-u9e.tfm \
tex-ipxg-r-u9f.tfm \
tex-ipxg-r-uf0.tfm \
tex-ipxg-r-uf8.tfm \
tex-ipxg-r-uf9.tfm \
tex-ipxg-r-ufa.tfm \
tex-ipxg-r-ufe.tfm \
tex-ipxg-r-uff.tfm \
tex-ipxg-ro-ly1.tfm \
tex-ipxg-ro-ot1.tfm \
tex-ipxg-ro-t1.tfm \
tex-ipxg-ro-ts1.tfm \
tex-ipxg-ro-u00.tfm \
tex-ipxg-ro-u01.tfm \
tex-ipxg-ro-u02.tfm \
tex-ipxg-ro-u0200.tfm \
tex-ipxg-ro-u0201.tfm \
tex-ipxg-ro-u0202.tfm \
tex-ipxg-ro-u0203.tfm \
tex-ipxg-ro-u0204.tfm \
tex-ipxg-ro-u0205.tfm \
tex-ipxg-ro-u0206.tfm \
tex-ipxg-ro-u0207.tfm \
tex-ipxg-ro-u0208.tfm \
tex-ipxg-ro-u0209.tfm \
tex-ipxg-ro-u020a.tfm \
tex-ipxg-ro-u020b.tfm \
tex-ipxg-ro-u020d.tfm \
tex-ipxg-ro-u020e.tfm \
tex-ipxg-ro-u020f.tfm \
tex-ipxg-ro-u0212.tfm \
tex-ipxg-ro-u0213.tfm \
tex-ipxg-ro-u0214.tfm \
tex-ipxg-ro-u0215.tfm \
tex-ipxg-ro-u0216.tfm \
tex-ipxg-ro-u0217.tfm \
tex-ipxg-ro-u0218.tfm \
tex-ipxg-ro-u0219.tfm \
tex-ipxg-ro-u021c.tfm \
tex-ipxg-ro-u021d.tfm \
tex-ipxg-ro-u021e.tfm \
tex-ipxg-ro-u021f.tfm \
tex-ipxg-ro-u0221.tfm \
tex-ipxg-ro-u0222.tfm \
tex-ipxg-ro-u0223.tfm \
tex-ipxg-ro-u0226.tfm \
tex-ipxg-ro-u0228.tfm \
tex-ipxg-ro-u0229.tfm \
tex-ipxg-ro-u022a.tfm \
tex-ipxg-ro-u022b.tfm \
tex-ipxg-ro-u022c.tfm \
tex-ipxg-ro-u022d.tfm \
tex-ipxg-ro-u0231.tfm \
tex-ipxg-ro-u0233.tfm \
tex-ipxg-ro-u0234.tfm \
tex-ipxg-ro-u0235.tfm \
tex-ipxg-ro-u0236.tfm \
tex-ipxg-ro-u0237.tfm \
tex-ipxg-ro-u0238.tfm \
tex-ipxg-ro-u023a.tfm \
tex-ipxg-ro-u023c.tfm \
tex-ipxg-ro-u023d.tfm \
tex-ipxg-ro-u023f.tfm \
tex-ipxg-ro-u0240.tfm \
tex-ipxg-ro-u0241.tfm \
tex-ipxg-ro-u0243.tfm \
tex-ipxg-ro-u0246.tfm \
tex-ipxg-ro-u0247.tfm \
tex-ipxg-ro-u0248.tfm \
tex-ipxg-ro-u024a.tfm \
tex-ipxg-ro-u024b.tfm \
tex-ipxg-ro-u024c.tfm \
tex-ipxg-ro-u024d.tfm \
tex-ipxg-ro-u024e.tfm \
tex-ipxg-ro-u0250.tfm \
tex-ipxg-ro-u0251.tfm \
tex-ipxg-ro-u0252.tfm \
tex-ipxg-ro-u0254.tfm \
tex-ipxg-ro-u0255.tfm \
tex-ipxg-ro-u0257.tfm \
tex-ipxg-ro-u0259.tfm \
tex-ipxg-ro-u025a.tfm \
tex-ipxg-ro-u025b.tfm \
tex-ipxg-ro-u025c.tfm \
tex-ipxg-ro-u025d.tfm \
tex-ipxg-ro-u025e.tfm \
tex-ipxg-ro-u025f.tfm \
tex-ipxg-ro-u0260.tfm \
tex-ipxg-ro-u0262.tfm \
tex-ipxg-ro-u0263.tfm \
tex-ipxg-ro-u0264.tfm \
tex-ipxg-ro-u0266.tfm \
tex-ipxg-ro-u0267.tfm \
tex-ipxg-ro-u0268.tfm \
tex-ipxg-ro-u0269.tfm \
tex-ipxg-ro-u026a.tfm \
tex-ipxg-ro-u026c.tfm \
tex-ipxg-ro-u026e.tfm \
tex-ipxg-ro-u026f.tfm \
tex-ipxg-ro-u0270.tfm \
tex-ipxg-ro-u0271.tfm \
tex-ipxg-ro-u0273.tfm \
tex-ipxg-ro-u0274.tfm \
tex-ipxg-ro-u0276.tfm \
tex-ipxg-ro-u0277.tfm \
tex-ipxg-ro-u0279.tfm \
tex-ipxg-ro-u027a.tfm \
tex-ipxg-ro-u027b.tfm \
tex-ipxg-ro-u027c.tfm \
tex-ipxg-ro-u027d.tfm \
tex-ipxg-ro-u027e.tfm \
tex-ipxg-ro-u027f.tfm \
tex-ipxg-ro-u0280.tfm \
tex-ipxg-ro-u0282.tfm \
tex-ipxg-ro-u0283.tfm \
tex-ipxg-ro-u0284.tfm \
tex-ipxg-ro-u0285.tfm \
tex-ipxg-ro-u0286.tfm \
tex-ipxg-ro-u0289.tfm \
tex-ipxg-ro-u028a.tfm \
tex-ipxg-ro-u028b.tfm \
tex-ipxg-ro-u028d.tfm \
tex-ipxg-ro-u028e.tfm \
tex-ipxg-ro-u028f.tfm \
tex-ipxg-ro-u0292.tfm \
tex-ipxg-ro-u0294.tfm \
tex-ipxg-ro-u0295.tfm \
tex-ipxg-ro-u0296.tfm \
tex-ipxg-ro-u0297.tfm \
tex-ipxg-ro-u0298.tfm \
tex-ipxg-ro-u029a.tfm \
tex-ipxg-ro-u029d.tfm \
tex-ipxg-ro-u029e.tfm \
tex-ipxg-ro-u029f.tfm \
tex-ipxg-ro-u02a0.tfm \
tex-ipxg-ro-u02a1.tfm \
tex-ipxg-ro-u02a3.tfm \
tex-ipxg-ro-u02a4.tfm \
tex-ipxg-ro-u02a5.tfm \
tex-ipxg-ro-u02a6.tfm \
tex-ipxg-ro-u02f8.tfm \
tex-ipxg-ro-u03.tfm \
tex-ipxg-ro-u04.tfm \
tex-ipxg-ro-u1e.tfm \
tex-ipxg-ro-u1f.tfm \
tex-ipxg-ro-u20.tfm \
tex-ipxg-ro-u21.tfm \
tex-ipxg-ro-u22.tfm \
tex-ipxg-ro-u23.tfm \
tex-ipxg-ro-u24.tfm \
tex-ipxg-ro-u25.tfm \
tex-ipxg-ro-u26.tfm \
tex-ipxg-ro-u27.tfm \
tex-ipxg-ro-u29.tfm \
tex-ipxg-ro-u2e.tfm \
tex-ipxg-ro-u2f.tfm \
tex-ipxg-ro-u30.tfm \
tex-ipxg-ro-u31.tfm \
tex-ipxg-ro-u32.tfm \
tex-ipxg-ro-u33.tfm \
tex-ipxg-ro-u34.tfm \
tex-ipxg-ro-u35.tfm \
tex-ipxg-ro-u36.tfm \
tex-ipxg-ro-u37.tfm \
tex-ipxg-ro-u38.tfm \
tex-ipxg-ro-u39.tfm \
tex-ipxg-ro-u3a.tfm \
tex-ipxg-ro-u3b.tfm \
tex-ipxg-ro-u3c.tfm \
tex-ipxg-ro-u3d.tfm \
tex-ipxg-ro-u3e.tfm \
tex-ipxg-ro-u3f.tfm \
tex-ipxg-ro-u40.tfm \
tex-ipxg-ro-u41.tfm \
tex-ipxg-ro-u42.tfm \
tex-ipxg-ro-u43.tfm \
tex-ipxg-ro-u44.tfm \
tex-ipxg-ro-u45.tfm \
tex-ipxg-ro-u46.tfm \
tex-ipxg-ro-u47.tfm \
tex-ipxg-ro-u48.tfm \
tex-ipxg-ro-u49.tfm \
tex-ipxg-ro-u4a.tfm \
tex-ipxg-ro-u4b.tfm \
tex-ipxg-ro-u4c.tfm \
tex-ipxg-ro-u4d.tfm \
tex-ipxg-ro-u4e.tfm \
tex-ipxg-ro-u4f.tfm \
tex-ipxg-ro-u50.tfm \
tex-ipxg-ro-u51.tfm \
tex-ipxg-ro-u52.tfm \
tex-ipxg-ro-u53.tfm \
tex-ipxg-ro-u54.tfm \
tex-ipxg-ro-u55.tfm \
tex-ipxg-ro-u56.tfm \
tex-ipxg-ro-u57.tfm \
tex-ipxg-ro-u58.tfm \
tex-ipxg-ro-u59.tfm \
tex-ipxg-ro-u5a.tfm \
tex-ipxg-ro-u5b.tfm \
tex-ipxg-ro-u5c.tfm \
tex-ipxg-ro-u5d.tfm \
tex-ipxg-ro-u5e.tfm \
tex-ipxg-ro-u5f.tfm \
tex-ipxg-ro-u60.tfm \
tex-ipxg-ro-u61.tfm \
tex-ipxg-ro-u62.tfm \
tex-ipxg-ro-u63.tfm \
tex-ipxg-ro-u64.tfm \
tex-ipxg-ro-u65.tfm \
tex-ipxg-ro-u66.tfm \
tex-ipxg-ro-u67.tfm \
tex-ipxg-ro-u68.tfm \
tex-ipxg-ro-u69.tfm \
tex-ipxg-ro-u6a.tfm \
tex-ipxg-ro-u6b.tfm \
tex-ipxg-ro-u6c.tfm \
tex-ipxg-ro-u6d.tfm \
tex-ipxg-ro-u6e.tfm \
tex-ipxg-ro-u6f.tfm \
tex-ipxg-ro-u70.tfm \
tex-ipxg-ro-u71.tfm \
tex-ipxg-ro-u72.tfm \
tex-ipxg-ro-u73.tfm \
tex-ipxg-ro-u74.tfm \
tex-ipxg-ro-u75.tfm \
tex-ipxg-ro-u76.tfm \
tex-ipxg-ro-u77.tfm \
tex-ipxg-ro-u78.tfm \
tex-ipxg-ro-u79.tfm \
tex-ipxg-ro-u7a.tfm \
tex-ipxg-ro-u7b.tfm \
tex-ipxg-ro-u7c.tfm \
tex-ipxg-ro-u7d.tfm \
tex-ipxg-ro-u7e.tfm \
tex-ipxg-ro-u7f.tfm \
tex-ipxg-ro-u80.tfm \
tex-ipxg-ro-u81.tfm \
tex-ipxg-ro-u82.tfm \
tex-ipxg-ro-u83.tfm \
tex-ipxg-ro-u84.tfm \
tex-ipxg-ro-u85.tfm \
tex-ipxg-ro-u86.tfm \
tex-ipxg-ro-u87.tfm \
tex-ipxg-ro-u88.tfm \
tex-ipxg-ro-u89.tfm \
tex-ipxg-ro-u8a.tfm \
tex-ipxg-ro-u8b.tfm \
tex-ipxg-ro-u8c.tfm \
tex-ipxg-ro-u8d.tfm \
tex-ipxg-ro-u8e.tfm \
tex-ipxg-ro-u8f.tfm \
tex-ipxg-ro-u90.tfm \
tex-ipxg-ro-u91.tfm \
tex-ipxg-ro-u92.tfm \
tex-ipxg-ro-u93.tfm \
tex-ipxg-ro-u94.tfm \
tex-ipxg-ro-u95.tfm \
tex-ipxg-ro-u96.tfm \
tex-ipxg-ro-u97.tfm \
tex-ipxg-ro-u98.tfm \
tex-ipxg-ro-u99.tfm \
tex-ipxg-ro-u9a.tfm \
tex-ipxg-ro-u9b.tfm \
tex-ipxg-ro-u9c.tfm \
tex-ipxg-ro-u9d.tfm \
tex-ipxg-ro-u9e.tfm \
tex-ipxg-ro-u9f.tfm \
tex-ipxg-ro-uf8.tfm \
tex-ipxg-ro-uf9.tfm \
tex-ipxg-ro-ufa.tfm \
tex-ipxg-ro-ufe.tfm \
tex-ipxg-ro-uff.tfm \
tex-ipxm-r-ly1.tfm \
tex-ipxm-r-ot1.tfm \
tex-ipxm-r-t1.tfm \
tex-ipxm-r-ts1.tfm \
tex-ipxm-r-u00.tfm \
tex-ipxm-r-u01.tfm \
tex-ipxm-r-u02.tfm \
tex-ipxm-r-u0200.tfm \
tex-ipxm-r-u0201.tfm \
tex-ipxm-r-u0202.tfm \
tex-ipxm-r-u0203.tfm \
tex-ipxm-r-u0204.tfm \
tex-ipxm-r-u0205.tfm \
tex-ipxm-r-u0206.tfm \
tex-ipxm-r-u0207.tfm \
tex-ipxm-r-u0208.tfm \
tex-ipxm-r-u0209.tfm \
tex-ipxm-r-u020a.tfm \
tex-ipxm-r-u020b.tfm \
tex-ipxm-r-u020d.tfm \
tex-ipxm-r-u020e.tfm \
tex-ipxm-r-u020f.tfm \
tex-ipxm-r-u0212.tfm \
tex-ipxm-r-u0213.tfm \
tex-ipxm-r-u0214.tfm \
tex-ipxm-r-u0215.tfm \
tex-ipxm-r-u0216.tfm \
tex-ipxm-r-u0217.tfm \
tex-ipxm-r-u0218.tfm \
tex-ipxm-r-u0219.tfm \
tex-ipxm-r-u021c.tfm \
tex-ipxm-r-u021d.tfm \
tex-ipxm-r-u021e.tfm \
tex-ipxm-r-u021f.tfm \
tex-ipxm-r-u0221.tfm \
tex-ipxm-r-u0222.tfm \
tex-ipxm-r-u0223.tfm \
tex-ipxm-r-u0226.tfm \
tex-ipxm-r-u0228.tfm \
tex-ipxm-r-u0229.tfm \
tex-ipxm-r-u022a.tfm \
tex-ipxm-r-u022b.tfm \
tex-ipxm-r-u022c.tfm \
tex-ipxm-r-u022d.tfm \
tex-ipxm-r-u0231.tfm \
tex-ipxm-r-u0233.tfm \
tex-ipxm-r-u0234.tfm \
tex-ipxm-r-u0235.tfm \
tex-ipxm-r-u0236.tfm \
tex-ipxm-r-u0237.tfm \
tex-ipxm-r-u0238.tfm \
tex-ipxm-r-u023a.tfm \
tex-ipxm-r-u023c.tfm \
tex-ipxm-r-u023d.tfm \
tex-ipxm-r-u023f.tfm \
tex-ipxm-r-u0240.tfm \
tex-ipxm-r-u0241.tfm \
tex-ipxm-r-u0243.tfm \
tex-ipxm-r-u0246.tfm \
tex-ipxm-r-u0247.tfm \
tex-ipxm-r-u0248.tfm \
tex-ipxm-r-u024a.tfm \
tex-ipxm-r-u024b.tfm \
tex-ipxm-r-u024c.tfm \
tex-ipxm-r-u024d.tfm \
tex-ipxm-r-u024e.tfm \
tex-ipxm-r-u0250.tfm \
tex-ipxm-r-u0251.tfm \
tex-ipxm-r-u0252.tfm \
tex-ipxm-r-u0254.tfm \
tex-ipxm-r-u0255.tfm \
tex-ipxm-r-u0257.tfm \
tex-ipxm-r-u0259.tfm \
tex-ipxm-r-u025a.tfm \
tex-ipxm-r-u025b.tfm \
tex-ipxm-r-u025c.tfm \
tex-ipxm-r-u025d.tfm \
tex-ipxm-r-u025e.tfm \
tex-ipxm-r-u025f.tfm \
tex-ipxm-r-u0260.tfm \
tex-ipxm-r-u0262.tfm \
tex-ipxm-r-u0263.tfm \
tex-ipxm-r-u0264.tfm \
tex-ipxm-r-u0266.tfm \
tex-ipxm-r-u0267.tfm \
tex-ipxm-r-u0268.tfm \
tex-ipxm-r-u0269.tfm \
tex-ipxm-r-u026a.tfm \
tex-ipxm-r-u026c.tfm \
tex-ipxm-r-u026e.tfm \
tex-ipxm-r-u026f.tfm \
tex-ipxm-r-u0270.tfm \
tex-ipxm-r-u0271.tfm \
tex-ipxm-r-u0273.tfm \
tex-ipxm-r-u0274.tfm \
tex-ipxm-r-u0276.tfm \
tex-ipxm-r-u0277.tfm \
tex-ipxm-r-u0279.tfm \
tex-ipxm-r-u027a.tfm \
tex-ipxm-r-u027b.tfm \
tex-ipxm-r-u027c.tfm \
tex-ipxm-r-u027d.tfm \
tex-ipxm-r-u027e.tfm \
tex-ipxm-r-u027f.tfm \
tex-ipxm-r-u0280.tfm \
tex-ipxm-r-u0282.tfm \
tex-ipxm-r-u0283.tfm \
tex-ipxm-r-u0284.tfm \
tex-ipxm-r-u0285.tfm \
tex-ipxm-r-u0286.tfm \
tex-ipxm-r-u0289.tfm \
tex-ipxm-r-u028a.tfm \
tex-ipxm-r-u028b.tfm \
tex-ipxm-r-u028d.tfm \
tex-ipxm-r-u028e.tfm \
tex-ipxm-r-u028f.tfm \
tex-ipxm-r-u0292.tfm \
tex-ipxm-r-u0294.tfm \
tex-ipxm-r-u0295.tfm \
tex-ipxm-r-u0296.tfm \
tex-ipxm-r-u0297.tfm \
tex-ipxm-r-u0298.tfm \
tex-ipxm-r-u029a.tfm \
tex-ipxm-r-u029d.tfm \
tex-ipxm-r-u029e.tfm \
tex-ipxm-r-u029f.tfm \
tex-ipxm-r-u02a0.tfm \
tex-ipxm-r-u02a1.tfm \
tex-ipxm-r-u02a3.tfm \
tex-ipxm-r-u02a4.tfm \
tex-ipxm-r-u02a5.tfm \
tex-ipxm-r-u02a6.tfm \
tex-ipxm-r-u02f8.tfm \
tex-ipxm-r-u03.tfm \
tex-ipxm-r-u04.tfm \
tex-ipxm-r-u1e.tfm \
tex-ipxm-r-u1f.tfm \
tex-ipxm-r-u20.tfm \
tex-ipxm-r-u21.tfm \
tex-ipxm-r-u22.tfm \
tex-ipxm-r-u23.tfm \
tex-ipxm-r-u24.tfm \
tex-ipxm-r-u25.tfm \
tex-ipxm-r-u26.tfm \
tex-ipxm-r-u27.tfm \
tex-ipxm-r-u29.tfm \
tex-ipxm-r-u2e.tfm \
tex-ipxm-r-u2f.tfm \
tex-ipxm-r-u30.tfm \
tex-ipxm-r-u31.tfm \
tex-ipxm-r-u32.tfm \
tex-ipxm-r-u33.tfm \
tex-ipxm-r-u34.tfm \
tex-ipxm-r-u35.tfm \
tex-ipxm-r-u36.tfm \
tex-ipxm-r-u37.tfm \
tex-ipxm-r-u38.tfm \
tex-ipxm-r-u39.tfm \
tex-ipxm-r-u3a.tfm \
tex-ipxm-r-u3b.tfm \
tex-ipxm-r-u3c.tfm \
tex-ipxm-r-u3d.tfm \
tex-ipxm-r-u3e.tfm \
tex-ipxm-r-u3f.tfm \
tex-ipxm-r-u40.tfm \
tex-ipxm-r-u41.tfm \
tex-ipxm-r-u42.tfm \
tex-ipxm-r-u43.tfm \
tex-ipxm-r-u44.tfm \
tex-ipxm-r-u45.tfm \
tex-ipxm-r-u46.tfm \
tex-ipxm-r-u47.tfm \
tex-ipxm-r-u48.tfm \
tex-ipxm-r-u49.tfm \
tex-ipxm-r-u4a.tfm \
tex-ipxm-r-u4b.tfm \
tex-ipxm-r-u4c.tfm \
tex-ipxm-r-u4d.tfm \
tex-ipxm-r-u4e.tfm \
tex-ipxm-r-u4f.tfm \
tex-ipxm-r-u50.tfm \
tex-ipxm-r-u51.tfm \
tex-ipxm-r-u52.tfm \
tex-ipxm-r-u53.tfm \
tex-ipxm-r-u54.tfm \
tex-ipxm-r-u55.tfm \
tex-ipxm-r-u56.tfm \
tex-ipxm-r-u57.tfm \
tex-ipxm-r-u58.tfm \
tex-ipxm-r-u59.tfm \
tex-ipxm-r-u5a.tfm \
tex-ipxm-r-u5b.tfm \
tex-ipxm-r-u5c.tfm \
tex-ipxm-r-u5d.tfm \
tex-ipxm-r-u5e.tfm \
tex-ipxm-r-u5f.tfm \
tex-ipxm-r-u60.tfm \
tex-ipxm-r-u61.tfm \
tex-ipxm-r-u62.tfm \
tex-ipxm-r-u63.tfm \
tex-ipxm-r-u64.tfm \
tex-ipxm-r-u65.tfm \
tex-ipxm-r-u66.tfm \
tex-ipxm-r-u67.tfm \
tex-ipxm-r-u68.tfm \
tex-ipxm-r-u69.tfm \
tex-ipxm-r-u6a.tfm \
tex-ipxm-r-u6b.tfm \
tex-ipxm-r-u6c.tfm \
tex-ipxm-r-u6d.tfm \
tex-ipxm-r-u6e.tfm \
tex-ipxm-r-u6f.tfm \
tex-ipxm-r-u70.tfm \
tex-ipxm-r-u71.tfm \
tex-ipxm-r-u72.tfm \
tex-ipxm-r-u73.tfm \
tex-ipxm-r-u74.tfm \
tex-ipxm-r-u75.tfm \
tex-ipxm-r-u76.tfm \
tex-ipxm-r-u77.tfm \
tex-ipxm-r-u78.tfm \
tex-ipxm-r-u79.tfm \
tex-ipxm-r-u7a.tfm \
tex-ipxm-r-u7b.tfm \
tex-ipxm-r-u7c.tfm \
tex-ipxm-r-u7d.tfm \
tex-ipxm-r-u7e.tfm \
tex-ipxm-r-u7f.tfm \
tex-ipxm-r-u80.tfm \
tex-ipxm-r-u81.tfm \
tex-ipxm-r-u82.tfm \
tex-ipxm-r-u83.tfm \
tex-ipxm-r-u84.tfm \
tex-ipxm-r-u85.tfm \
tex-ipxm-r-u86.tfm \
tex-ipxm-r-u87.tfm \
tex-ipxm-r-u88.tfm \
tex-ipxm-r-u89.tfm \
tex-ipxm-r-u8a.tfm \
tex-ipxm-r-u8b.tfm \
tex-ipxm-r-u8c.tfm \
tex-ipxm-r-u8d.tfm \
tex-ipxm-r-u8e.tfm \
tex-ipxm-r-u8f.tfm \
tex-ipxm-r-u90.tfm \
tex-ipxm-r-u91.tfm \
tex-ipxm-r-u92.tfm \
tex-ipxm-r-u93.tfm \
tex-ipxm-r-u94.tfm \
tex-ipxm-r-u95.tfm \
tex-ipxm-r-u96.tfm \
tex-ipxm-r-u97.tfm \
tex-ipxm-r-u98.tfm \
tex-ipxm-r-u99.tfm \
tex-ipxm-r-u9a.tfm \
tex-ipxm-r-u9b.tfm \
tex-ipxm-r-u9c.tfm \
tex-ipxm-r-u9d.tfm \
tex-ipxm-r-u9e.tfm \
tex-ipxm-r-u9f.tfm \
tex-ipxm-r-uf0.tfm \
tex-ipxm-r-uf8.tfm \
tex-ipxm-r-uf9.tfm \
tex-ipxm-r-ufa.tfm \
tex-ipxm-r-ufe.tfm \
tex-ipxm-r-uff.tfm \
tex-ipxm-ro-ly1.tfm \
tex-ipxm-ro-ot1.tfm \
tex-ipxm-ro-t1.tfm \
tex-ipxm-ro-ts1.tfm \
tex-ipxm-ro-u00.tfm \
tex-ipxm-ro-u01.tfm \
tex-ipxm-ro-u02.tfm \
tex-ipxm-ro-u0200.tfm \
tex-ipxm-ro-u0201.tfm \
tex-ipxm-ro-u0202.tfm \
tex-ipxm-ro-u0203.tfm \
tex-ipxm-ro-u0204.tfm \
tex-ipxm-ro-u0205.tfm \
tex-ipxm-ro-u0206.tfm \
tex-ipxm-ro-u0207.tfm \
tex-ipxm-ro-u0208.tfm \
tex-ipxm-ro-u0209.tfm \
tex-ipxm-ro-u020a.tfm \
tex-ipxm-ro-u020b.tfm \
tex-ipxm-ro-u020d.tfm \
tex-ipxm-ro-u020e.tfm \
tex-ipxm-ro-u020f.tfm \
tex-ipxm-ro-u0212.tfm \
tex-ipxm-ro-u0213.tfm \
tex-ipxm-ro-u0214.tfm \
tex-ipxm-ro-u0215.tfm \
tex-ipxm-ro-u0216.tfm \
tex-ipxm-ro-u0217.tfm \
tex-ipxm-ro-u0218.tfm \
tex-ipxm-ro-u0219.tfm \
tex-ipxm-ro-u021c.tfm \
tex-ipxm-ro-u021d.tfm \
tex-ipxm-ro-u021e.tfm \
tex-ipxm-ro-u021f.tfm \
tex-ipxm-ro-u0221.tfm \
tex-ipxm-ro-u0222.tfm \
tex-ipxm-ro-u0223.tfm \
tex-ipxm-ro-u0226.tfm \
tex-ipxm-ro-u0228.tfm \
tex-ipxm-ro-u0229.tfm \
tex-ipxm-ro-u022a.tfm \
tex-ipxm-ro-u022b.tfm \
tex-ipxm-ro-u022c.tfm \
tex-ipxm-ro-u022d.tfm \
tex-ipxm-ro-u0231.tfm \
tex-ipxm-ro-u0233.tfm \
tex-ipxm-ro-u0234.tfm \
tex-ipxm-ro-u0235.tfm \
tex-ipxm-ro-u0236.tfm \
tex-ipxm-ro-u0237.tfm \
tex-ipxm-ro-u0238.tfm \
tex-ipxm-ro-u023a.tfm \
tex-ipxm-ro-u023c.tfm \
tex-ipxm-ro-u023d.tfm \
tex-ipxm-ro-u023f.tfm \
tex-ipxm-ro-u0240.tfm \
tex-ipxm-ro-u0241.tfm \
tex-ipxm-ro-u0243.tfm \
tex-ipxm-ro-u0246.tfm \
tex-ipxm-ro-u0247.tfm \
tex-ipxm-ro-u0248.tfm \
tex-ipxm-ro-u024a.tfm \
tex-ipxm-ro-u024b.tfm \
tex-ipxm-ro-u024c.tfm \
tex-ipxm-ro-u024d.tfm \
tex-ipxm-ro-u024e.tfm \
tex-ipxm-ro-u0250.tfm \
tex-ipxm-ro-u0251.tfm \
tex-ipxm-ro-u0252.tfm \
tex-ipxm-ro-u0254.tfm \
tex-ipxm-ro-u0255.tfm \
tex-ipxm-ro-u0257.tfm \
tex-ipxm-ro-u0259.tfm \
tex-ipxm-ro-u025a.tfm \
tex-ipxm-ro-u025b.tfm \
tex-ipxm-ro-u025c.tfm \
tex-ipxm-ro-u025d.tfm \
tex-ipxm-ro-u025e.tfm \
tex-ipxm-ro-u025f.tfm \
tex-ipxm-ro-u0260.tfm \
tex-ipxm-ro-u0262.tfm \
tex-ipxm-ro-u0263.tfm \
tex-ipxm-ro-u0264.tfm \
tex-ipxm-ro-u0266.tfm \
tex-ipxm-ro-u0267.tfm \
tex-ipxm-ro-u0268.tfm \
tex-ipxm-ro-u0269.tfm \
tex-ipxm-ro-u026a.tfm \
tex-ipxm-ro-u026c.tfm \
tex-ipxm-ro-u026e.tfm \
tex-ipxm-ro-u026f.tfm \
tex-ipxm-ro-u0270.tfm \
tex-ipxm-ro-u0271.tfm \
tex-ipxm-ro-u0273.tfm \
tex-ipxm-ro-u0274.tfm \
tex-ipxm-ro-u0276.tfm \
tex-ipxm-ro-u0277.tfm \
tex-ipxm-ro-u0279.tfm \
tex-ipxm-ro-u027a.tfm \
tex-ipxm-ro-u027b.tfm \
tex-ipxm-ro-u027c.tfm \
tex-ipxm-ro-u027d.tfm \
tex-ipxm-ro-u027e.tfm \
tex-ipxm-ro-u027f.tfm \
tex-ipxm-ro-u0280.tfm \
tex-ipxm-ro-u0282.tfm \
tex-ipxm-ro-u0283.tfm \
tex-ipxm-ro-u0284.tfm \
tex-ipxm-ro-u0285.tfm \
tex-ipxm-ro-u0286.tfm \
tex-ipxm-ro-u0289.tfm \
tex-ipxm-ro-u028a.tfm \
tex-ipxm-ro-u028b.tfm \
tex-ipxm-ro-u028d.tfm \
tex-ipxm-ro-u028e.tfm \
tex-ipxm-ro-u028f.tfm \
tex-ipxm-ro-u0292.tfm \
tex-ipxm-ro-u0294.tfm \
tex-ipxm-ro-u0295.tfm \
tex-ipxm-ro-u0296.tfm \
tex-ipxm-ro-u0297.tfm \
tex-ipxm-ro-u0298.tfm \
tex-ipxm-ro-u029a.tfm \
tex-ipxm-ro-u029d.tfm \
tex-ipxm-ro-u029e.tfm \
tex-ipxm-ro-u029f.tfm \
tex-ipxm-ro-u02a0.tfm \
tex-ipxm-ro-u02a1.tfm \
tex-ipxm-ro-u02a3.tfm \
tex-ipxm-ro-u02a4.tfm \
tex-ipxm-ro-u02a5.tfm \
tex-ipxm-ro-u02a6.tfm \
tex-ipxm-ro-u02f8.tfm \
tex-ipxm-ro-u03.tfm \
tex-ipxm-ro-u04.tfm \
tex-ipxm-ro-u1e.tfm \
tex-ipxm-ro-u1f.tfm \
tex-ipxm-ro-u20.tfm \
tex-ipxm-ro-u21.tfm \
tex-ipxm-ro-u22.tfm \
tex-ipxm-ro-u23.tfm \
tex-ipxm-ro-u24.tfm \
tex-ipxm-ro-u25.tfm \
tex-ipxm-ro-u26.tfm \
tex-ipxm-ro-u27.tfm \
tex-ipxm-ro-u29.tfm \
tex-ipxm-ro-u2e.tfm \
tex-ipxm-ro-u2f.tfm \
tex-ipxm-ro-u30.tfm \
tex-ipxm-ro-u31.tfm \
tex-ipxm-ro-u32.tfm \
tex-ipxm-ro-u33.tfm \
tex-ipxm-ro-u34.tfm \
tex-ipxm-ro-u35.tfm \
tex-ipxm-ro-u36.tfm \
tex-ipxm-ro-u37.tfm \
tex-ipxm-ro-u38.tfm \
tex-ipxm-ro-u39.tfm \
tex-ipxm-ro-u3a.tfm \
tex-ipxm-ro-u3b.tfm \
tex-ipxm-ro-u3c.tfm \
tex-ipxm-ro-u3d.tfm \
tex-ipxm-ro-u3e.tfm \
tex-ipxm-ro-u3f.tfm \
tex-ipxm-ro-u40.tfm \
tex-ipxm-ro-u41.tfm \
tex-ipxm-ro-u42.tfm \
tex-ipxm-ro-u43.tfm \
tex-ipxm-ro-u44.tfm \
tex-ipxm-ro-u45.tfm \
tex-ipxm-ro-u46.tfm \
tex-ipxm-ro-u47.tfm \
tex-ipxm-ro-u48.tfm \
tex-ipxm-ro-u49.tfm \
tex-ipxm-ro-u4a.tfm \
tex-ipxm-ro-u4b.tfm \
tex-ipxm-ro-u4c.tfm \
tex-ipxm-ro-u4d.tfm \
tex-ipxm-ro-u4e.tfm \
tex-ipxm-ro-u4f.tfm \
tex-ipxm-ro-u50.tfm \
tex-ipxm-ro-u51.tfm \
tex-ipxm-ro-u52.tfm \
tex-ipxm-ro-u53.tfm \
tex-ipxm-ro-u54.tfm \
tex-ipxm-ro-u55.tfm \
tex-ipxm-ro-u56.tfm \
tex-ipxm-ro-u57.tfm \
tex-ipxm-ro-u58.tfm \
tex-ipxm-ro-u59.tfm \
tex-ipxm-ro-u5a.tfm \
tex-ipxm-ro-u5b.tfm \
tex-ipxm-ro-u5c.tfm \
tex-ipxm-ro-u5d.tfm \
tex-ipxm-ro-u5e.tfm \
tex-ipxm-ro-u5f.tfm \
tex-ipxm-ro-u60.tfm \
tex-ipxm-ro-u61.tfm \
tex-ipxm-ro-u62.tfm \
tex-ipxm-ro-u63.tfm \
tex-ipxm-ro-u64.tfm \
tex-ipxm-ro-u65.tfm \
tex-ipxm-ro-u66.tfm \
tex-ipxm-ro-u67.tfm \
tex-ipxm-ro-u68.tfm \
tex-ipxm-ro-u69.tfm \
tex-ipxm-ro-u6a.tfm \
tex-ipxm-ro-u6b.tfm \
tex-ipxm-ro-u6c.tfm \
tex-ipxm-ro-u6d.tfm \
tex-ipxm-ro-u6e.tfm \
tex-ipxm-ro-u6f.tfm \
tex-ipxm-ro-u70.tfm \
tex-ipxm-ro-u71.tfm \
tex-ipxm-ro-u72.tfm \
tex-ipxm-ro-u73.tfm \
tex-ipxm-ro-u74.tfm \
tex-ipxm-ro-u75.tfm \
tex-ipxm-ro-u76.tfm \
tex-ipxm-ro-u77.tfm \
tex-ipxm-ro-u78.tfm \
tex-ipxm-ro-u79.tfm \
tex-ipxm-ro-u7a.tfm \
tex-ipxm-ro-u7b.tfm \
tex-ipxm-ro-u7c.tfm \
tex-ipxm-ro-u7d.tfm \
tex-ipxm-ro-u7e.tfm \
tex-ipxm-ro-u7f.tfm \
tex-ipxm-ro-u80.tfm \
tex-ipxm-ro-u81.tfm \
tex-ipxm-ro-u82.tfm \
tex-ipxm-ro-u83.tfm \
tex-ipxm-ro-u84.tfm \
tex-ipxm-ro-u85.tfm \
tex-ipxm-ro-u86.tfm \
tex-ipxm-ro-u87.tfm \
tex-ipxm-ro-u88.tfm \
tex-ipxm-ro-u89.tfm \
tex-ipxm-ro-u8a.tfm \
tex-ipxm-ro-u8b.tfm \
tex-ipxm-ro-u8c.tfm \
tex-ipxm-ro-u8d.tfm \
tex-ipxm-ro-u8e.tfm \
tex-ipxm-ro-u8f.tfm \
tex-ipxm-ro-u90.tfm \
tex-ipxm-ro-u91.tfm \
tex-ipxm-ro-u92.tfm \
tex-ipxm-ro-u93.tfm \
tex-ipxm-ro-u94.tfm \
tex-ipxm-ro-u95.tfm \
tex-ipxm-ro-u96.tfm \
tex-ipxm-ro-u97.tfm \
tex-ipxm-ro-u98.tfm \
tex-ipxm-ro-u99.tfm \
tex-ipxm-ro-u9a.tfm \
tex-ipxm-ro-u9b.tfm \
tex-ipxm-ro-u9c.tfm \
tex-ipxm-ro-u9d.tfm \
tex-ipxm-ro-u9e.tfm \
tex-ipxm-ro-u9f.tfm \
tex-ipxm-ro-uf8.tfm \
tex-ipxm-ro-uf9.tfm \
tex-ipxm-ro-ufa.tfm \
tex-ipxm-ro-ufe.tfm \
tex-ipxm-ro-uff.tfm \
tex-ipxt1-ly1.enc \
tex-ipxt1-ot1.enc \
tex-ipxt1-t1.enc \
tex-ipxt1-ts1.enc \
tex-ipxt1-u00.enc \
tex-ipxt1-u01.enc \
tex-ipxt1-u02.enc \
tex-ipxt1-u0200.enc \
tex-ipxt1-u0201.enc \
tex-ipxt1-u0202.enc \
tex-ipxt1-u0203.enc \
tex-ipxt1-u0204.enc \
tex-ipxt1-u0205.enc \
tex-ipxt1-u0206.enc \
tex-ipxt1-u0207.enc \
tex-ipxt1-u0208.enc \
tex-ipxt1-u0209.enc \
tex-ipxt1-u020a.enc \
tex-ipxt1-u020b.enc \
tex-ipxt1-u020d.enc \
tex-ipxt1-u020e.enc \
tex-ipxt1-u020f.enc \
tex-ipxt1-u0212.enc \
tex-ipxt1-u0213.enc \
tex-ipxt1-u0214.enc \
tex-ipxt1-u0215.enc \
tex-ipxt1-u0216.enc \
tex-ipxt1-u0217.enc \
tex-ipxt1-u0218.enc \
tex-ipxt1-u0219.enc \
tex-ipxt1-u021c.enc \
tex-ipxt1-u021d.enc \
tex-ipxt1-u021e.enc \
tex-ipxt1-u021f.enc \
tex-ipxt1-u0221.enc \
tex-ipxt1-u0222.enc \
tex-ipxt1-u0223.enc \
tex-ipxt1-u0226.enc \
tex-ipxt1-u0228.enc \
tex-ipxt1-u0229.enc \
tex-ipxt1-u022a.enc \
tex-ipxt1-u022b.enc \
tex-ipxt1-u022c.enc \
tex-ipxt1-u022d.enc \
tex-ipxt1-u0231.enc \
tex-ipxt1-u0233.enc \
tex-ipxt1-u0234.enc \
tex-ipxt1-u0235.enc \
tex-ipxt1-u0236.enc \
tex-ipxt1-u0237.enc \
tex-ipxt1-u0238.enc \
tex-ipxt1-u023a.enc \
tex-ipxt1-u023c.enc \
tex-ipxt1-u023d.enc \
tex-ipxt1-u023f.enc \
tex-ipxt1-u0240.enc \
tex-ipxt1-u0241.enc \
tex-ipxt1-u0243.enc \
tex-ipxt1-u0246.enc \
tex-ipxt1-u0247.enc \
tex-ipxt1-u0248.enc \
tex-ipxt1-u024a.enc \
tex-ipxt1-u024b.enc \
tex-ipxt1-u024c.enc \
tex-ipxt1-u024d.enc \
tex-ipxt1-u024e.enc \
tex-ipxt1-u0250.enc \
tex-ipxt1-u0251.enc \
tex-ipxt1-u0252.enc \
tex-ipxt1-u0254.enc \
tex-ipxt1-u0255.enc \
tex-ipxt1-u0257.enc \
tex-ipxt1-u0259.enc \
tex-ipxt1-u025a.enc \
tex-ipxt1-u025b.enc \
tex-ipxt1-u025c.enc \
tex-ipxt1-u025d.enc \
tex-ipxt1-u025e.enc \
tex-ipxt1-u025f.enc \
tex-ipxt1-u0260.enc \
tex-ipxt1-u0262.enc \
tex-ipxt1-u0263.enc \
tex-ipxt1-u0264.enc \
tex-ipxt1-u0266.enc \
tex-ipxt1-u0267.enc \
tex-ipxt1-u0268.enc \
tex-ipxt1-u0269.enc \
tex-ipxt1-u026a.enc \
tex-ipxt1-u026c.enc \
tex-ipxt1-u026e.enc \
tex-ipxt1-u026f.enc \
tex-ipxt1-u0270.enc \
tex-ipxt1-u0271.enc \
tex-ipxt1-u0273.enc \
tex-ipxt1-u0274.enc \
tex-ipxt1-u0276.enc \
tex-ipxt1-u0277.enc \
tex-ipxt1-u0279.enc \
tex-ipxt1-u027a.enc \
tex-ipxt1-u027b.enc \
tex-ipxt1-u027c.enc \
tex-ipxt1-u027d.enc \
tex-ipxt1-u027e.enc \
tex-ipxt1-u027f.enc \
tex-ipxt1-u0280.enc \
tex-ipxt1-u0282.enc \
tex-ipxt1-u0283.enc \
tex-ipxt1-u0284.enc \
tex-ipxt1-u0285.enc \
tex-ipxt1-u0286.enc \
tex-ipxt1-u0289.enc \
tex-ipxt1-u028a.enc \
tex-ipxt1-u028b.enc \
tex-ipxt1-u028d.enc \
tex-ipxt1-u028e.enc \
tex-ipxt1-u028f.enc \
tex-ipxt1-u0292.enc \
tex-ipxt1-u0294.enc \
tex-ipxt1-u0295.enc \
tex-ipxt1-u0296.enc \
tex-ipxt1-u0297.enc \
tex-ipxt1-u0298.enc \
tex-ipxt1-u029a.enc \
tex-ipxt1-u029d.enc \
tex-ipxt1-u029e.enc \
tex-ipxt1-u029f.enc \
tex-ipxt1-u02a0.enc \
tex-ipxt1-u02a1.enc \
tex-ipxt1-u02a3.enc \
tex-ipxt1-u02a4.enc \
tex-ipxt1-u02a5.enc \
tex-ipxt1-u02a6.enc \
tex-ipxt1-u02f8.enc \
tex-ipxt1-u03.enc \
tex-ipxt1-u04.enc \
tex-ipxt1-u1e.enc \
tex-ipxt1-u1f.enc \
tex-ipxt1-u20.enc \
tex-ipxt1-u21.enc \
tex-ipxt1-u22.enc \
tex-ipxt1-u23.enc \
tex-ipxt1-u24.enc \
tex-ipxt1-u25.enc \
tex-ipxt1-u26.enc \
tex-ipxt1-u27.enc \
tex-ipxt1-u29.enc \
tex-ipxt1-u2e.enc \
tex-ipxt1-u2f.enc \
tex-ipxt1-u30.enc \
tex-ipxt1-u31.enc \
tex-ipxt1-u32.enc \
tex-ipxt1-u33.enc \
tex-ipxt1-u34.enc \
tex-ipxt1-u35.enc \
tex-ipxt1-u36.enc \
tex-ipxt1-u37.enc \
tex-ipxt1-u38.enc \
tex-ipxt1-u39.enc \
tex-ipxt1-u3a.enc \
tex-ipxt1-u3b.enc \
tex-ipxt1-u3c.enc \
tex-ipxt1-u3d.enc \
tex-ipxt1-u3e.enc \
tex-ipxt1-u3f.enc \
tex-ipxt1-u40.enc \
tex-ipxt1-u41.enc \
tex-ipxt1-u42.enc \
tex-ipxt1-u43.enc \
tex-ipxt1-u44.enc \
tex-ipxt1-u45.enc \
tex-ipxt1-u46.enc \
tex-ipxt1-u47.enc \
tex-ipxt1-u48.enc \
tex-ipxt1-u49.enc \
tex-ipxt1-u4a.enc \
tex-ipxt1-u4b.enc \
tex-ipxt1-u4c.enc \
tex-ipxt1-u4d.enc \
tex-ipxt1-u4e.enc \
tex-ipxt1-u4f.enc \
tex-ipxt1-u50.enc \
tex-ipxt1-u51.enc \
tex-ipxt1-u52.enc \
tex-ipxt1-u53.enc \
tex-ipxt1-u54.enc \
tex-ipxt1-u55.enc \
tex-ipxt1-u56.enc \
tex-ipxt1-u57.enc \
tex-ipxt1-u58.enc \
tex-ipxt1-u59.enc \
tex-ipxt1-u5a.enc \
tex-ipxt1-u5b.enc \
tex-ipxt1-u5c.enc \
tex-ipxt1-u5d.enc \
tex-ipxt1-u5e.enc \
tex-ipxt1-u5f.enc \
tex-ipxt1-u60.enc \
tex-ipxt1-u61.enc \
tex-ipxt1-u62.enc \
tex-ipxt1-u63.enc \
tex-ipxt1-u64.enc \
tex-ipxt1-u65.enc \
tex-ipxt1-u66.enc \
tex-ipxt1-u67.enc \
tex-ipxt1-u68.enc \
tex-ipxt1-u69.enc \
tex-ipxt1-u6a.enc \
tex-ipxt1-u6b.enc \
tex-ipxt1-u6c.enc \
tex-ipxt1-u6d.enc \
tex-ipxt1-u6e.enc \
tex-ipxt1-u6f.enc \
tex-ipxt1-u70.enc \
tex-ipxt1-u71.enc \
tex-ipxt1-u72.enc \
tex-ipxt1-u73.enc \
tex-ipxt1-u74.enc \
tex-ipxt1-u75.enc \
tex-ipxt1-u76.enc \
tex-ipxt1-u77.enc \
tex-ipxt1-u78.enc \
tex-ipxt1-u79.enc \
tex-ipxt1-u7a.enc \
tex-ipxt1-u7b.enc \
tex-ipxt1-u7c.enc \
tex-ipxt1-u7d.enc \
tex-ipxt1-u7e.enc \
tex-ipxt1-u7f.enc \
tex-ipxt1-u80.enc \
tex-ipxt1-u81.enc \
tex-ipxt1-u82.enc \
tex-ipxt1-u83.enc \
tex-ipxt1-u84.enc \
tex-ipxt1-u85.enc \
tex-ipxt1-u86.enc \
tex-ipxt1-u87.enc \
tex-ipxt1-u88.enc \
tex-ipxt1-u89.enc \
tex-ipxt1-u8a.enc \
tex-ipxt1-u8b.enc \
tex-ipxt1-u8c.enc \
tex-ipxt1-u8d.enc \
tex-ipxt1-u8e.enc \
tex-ipxt1-u8f.enc \
tex-ipxt1-u90.enc \
tex-ipxt1-u91.enc \
tex-ipxt1-u92.enc \
tex-ipxt1-u93.enc \
tex-ipxt1-u94.enc \
tex-ipxt1-u95.enc \
tex-ipxt1-u96.enc \
tex-ipxt1-u97.enc \
tex-ipxt1-u98.enc \
tex-ipxt1-u99.enc \
tex-ipxt1-u9a.enc \
tex-ipxt1-u9b.enc \
tex-ipxt1-u9c.enc \
tex-ipxt1-u9d.enc \
tex-ipxt1-u9e.enc \
tex-ipxt1-u9f.enc \
tex-ipxt1-uf0.enc \
tex-ipxt1-uf8.enc \
tex-ipxt1-uf9.enc \
tex-ipxt1-ufa.enc \
tex-ipxt1-ufe.enc \
tex-ipxt1-uff.enc \
tex-ly1ipxg.fd \
tex-ly1ipxm.fd \
tex-ot1ipxg.fd \
tex-ot1ipxm.fd \
tex-t1ipxg.fd \
tex-t1ipxm.fd \
tex-ts1ipxg.fd \
tex-ts1ipxm.fd \
texlive-ipaex-type1"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-updmap.cfg \
texlive \
texlive-filesystem \
texlive-ipaex-type1-fonts \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
