SUMMARY = "Wadalab (Japanese) font packages"
DESCRIPTION = "These are font bundles for the Japanese Wadalab fonts which \
work with the CJK package. All subfonts now have glyph names \
compliant to the Adobe Glyph List, making ToUnicode CMaps in \
PDF documents (created automatically by dvipdfmx) work \
correctly. All font bundles now contain virtual Unicode \
subfonts."
LICENSE = "LPPL-1.0"

PV = "2023.201.svn42428"

RPM_NAME = "texlive-wadalab-2023.201.svn42428-53.1.noarch.rpm"
RPM_HASH = "8db883d1b5c13e05417483944c79a59733f22907f7c9d24f58dc6afe48736b5531fb623c582b036ca7c3f77386a2142722347c234f6f3c4a9fca112aa8d6272a"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-dgj.map \
tex-dgjgreek.tfm \
tex-dgjhira.tfm \
tex-dgjhw.tfm \
tex-dgjka.tfm \
tex-dgjkata.tfm \
tex-dgjkb.tfm \
tex-dgjkc.tfm \
tex-dgjkd.tfm \
tex-dgjke.tfm \
tex-dgjkeisen.tfm \
tex-dgjkf.tfm \
tex-dgjkg.tfm \
tex-dgjkh.tfm \
tex-dgjki.tfm \
tex-dgjkj.tfm \
tex-dgjkk.tfm \
tex-dgjkl.tfm \
tex-dgjkm.tfm \
tex-dgjkn.tfm \
tex-dgjko.tfm \
tex-dgjkp.tfm \
tex-dgjkq.tfm \
tex-dgjkr.tfm \
tex-dgjks.tfm \
tex-dgjkt.tfm \
tex-dgjku.tfm \
tex-dgjkv.tfm \
tex-dgjkw.tfm \
tex-dgjkx.tfm \
tex-dgjky.tfm \
tex-dgjkz.tfm \
tex-dgjroma.tfm \
tex-dgjrussian.tfm \
tex-dgjsy.tfm \
tex-dmj.map \
tex-dmjgreek.tfm \
tex-dmjhira.tfm \
tex-dmjhw.tfm \
tex-dmjka.tfm \
tex-dmjkata.tfm \
tex-dmjkb.tfm \
tex-dmjkc.tfm \
tex-dmjkd.tfm \
tex-dmjke.tfm \
tex-dmjkeisen.tfm \
tex-dmjkf.tfm \
tex-dmjkg.tfm \
tex-dmjkh.tfm \
tex-dmjki.tfm \
tex-dmjkj.tfm \
tex-dmjkk.tfm \
tex-dmjkl.tfm \
tex-dmjkm.tfm \
tex-dmjkn.tfm \
tex-dmjko.tfm \
tex-dmjkp.tfm \
tex-dmjkq.tfm \
tex-dmjkr.tfm \
tex-dmjks.tfm \
tex-dmjkt.tfm \
tex-dmjku.tfm \
tex-dmjkv.tfm \
tex-dmjkw.tfm \
tex-dmjkx.tfm \
tex-dmjky.tfm \
tex-dmjkz.tfm \
tex-dmjroma.tfm \
tex-dmjrussian.tfm \
tex-dmjsy.tfm \
tex-mc2j.map \
tex-mc2jka.tfm \
tex-mc2jkb.tfm \
tex-mc2jkc.tfm \
tex-mc2jkd.tfm \
tex-mc2jke.tfm \
tex-mc2jkf.tfm \
tex-mc2jkg.tfm \
tex-mc2jkh.tfm \
tex-mc2jki.tfm \
tex-mc2jkj.tfm \
tex-mc2jkk.tfm \
tex-mc2jkl.tfm \
tex-mc2jkm.tfm \
tex-mc2jkn.tfm \
tex-mc2jko.tfm \
tex-mc2jkp.tfm \
tex-mc2jkq.tfm \
tex-mc2jkr.tfm \
tex-mc2jks.tfm \
tex-mc2jkt.tfm \
tex-mc2jku.tfm \
tex-mc2jkv.tfm \
tex-mc2jkw.tfm \
tex-mcj.map \
tex-mcjgreek.tfm \
tex-mcjhira.tfm \
tex-mcjhw.tfm \
tex-mcjka.tfm \
tex-mcjkata.tfm \
tex-mcjkb.tfm \
tex-mcjkc.tfm \
tex-mcjkd.tfm \
tex-mcjke.tfm \
tex-mcjkeisen.tfm \
tex-mcjkf.tfm \
tex-mcjkg.tfm \
tex-mcjkh.tfm \
tex-mcjki.tfm \
tex-mcjkj.tfm \
tex-mcjkk.tfm \
tex-mcjkl.tfm \
tex-mcjkm.tfm \
tex-mcjkn.tfm \
tex-mcjko.tfm \
tex-mcjkp.tfm \
tex-mcjkq.tfm \
tex-mcjkr.tfm \
tex-mcjks.tfm \
tex-mcjkt.tfm \
tex-mcjku.tfm \
tex-mcjkv.tfm \
tex-mcjkw.tfm \
tex-mcjkx.tfm \
tex-mcjky.tfm \
tex-mcjkz.tfm \
tex-mcjroma.tfm \
tex-mcjrussian.tfm \
tex-mcjsy.tfm \
tex-mr2j.map \
tex-mr2jka.tfm \
tex-mr2jkb.tfm \
tex-mr2jkc.tfm \
tex-mr2jkd.tfm \
tex-mr2jke.tfm \
tex-mr2jkf.tfm \
tex-mr2jkg.tfm \
tex-mr2jkh.tfm \
tex-mr2jki.tfm \
tex-mr2jkj.tfm \
tex-mr2jkk.tfm \
tex-mr2jkl.tfm \
tex-mr2jkm.tfm \
tex-mr2jkn.tfm \
tex-mr2jko.tfm \
tex-mr2jkp.tfm \
tex-mr2jkq.tfm \
tex-mr2jkr.tfm \
tex-mr2jks.tfm \
tex-mr2jkt.tfm \
tex-mr2jku.tfm \
tex-mr2jkv.tfm \
tex-mr2jkw.tfm \
tex-mrj.map \
tex-mrjgreek.tfm \
tex-mrjhira.tfm \
tex-mrjhw.tfm \
tex-mrjka.tfm \
tex-mrjkata.tfm \
tex-mrjkb.tfm \
tex-mrjkc.tfm \
tex-mrjkd.tfm \
tex-mrjke.tfm \
tex-mrjkeisen.tfm \
tex-mrjkf.tfm \
tex-mrjkg.tfm \
tex-mrjkh.tfm \
tex-mrjki.tfm \
tex-mrjkj.tfm \
tex-mrjkk.tfm \
tex-mrjkl.tfm \
tex-mrjkm.tfm \
tex-mrjkn.tfm \
tex-mrjko.tfm \
tex-mrjkp.tfm \
tex-mrjkq.tfm \
tex-mrjkr.tfm \
tex-mrjks.tfm \
tex-mrjkt.tfm \
tex-mrjku.tfm \
tex-mrjkv.tfm \
tex-mrjkw.tfm \
tex-mrjkx.tfm \
tex-mrjky.tfm \
tex-mrjkz.tfm \
tex-mrjroma.tfm \
tex-mrjrussian.tfm \
tex-mrjsy.tfm \
tex-udgj00.tfm \
tex-udgj00.vf \
tex-udgj03.tfm \
tex-udgj03.vf \
tex-udgj04.tfm \
tex-udgj04.vf \
tex-udgj20.tfm \
tex-udgj20.vf \
tex-udgj21.tfm \
tex-udgj21.vf \
tex-udgj22.tfm \
tex-udgj22.vf \
tex-udgj23.tfm \
tex-udgj23.vf \
tex-udgj25.tfm \
tex-udgj25.vf \
tex-udgj26.tfm \
tex-udgj26.vf \
tex-udgj30.tfm \
tex-udgj30.vf \
tex-udgj4e.tfm \
tex-udgj4e.vf \
tex-udgj4f.tfm \
tex-udgj4f.vf \
tex-udgj50.tfm \
tex-udgj50.vf \
tex-udgj51.tfm \
tex-udgj51.vf \
tex-udgj52.tfm \
tex-udgj52.vf \
tex-udgj53.tfm \
tex-udgj53.vf \
tex-udgj54.tfm \
tex-udgj54.vf \
tex-udgj55.tfm \
tex-udgj55.vf \
tex-udgj56.tfm \
tex-udgj56.vf \
tex-udgj57.tfm \
tex-udgj57.vf \
tex-udgj58.tfm \
tex-udgj58.vf \
tex-udgj59.tfm \
tex-udgj59.vf \
tex-udgj5a.tfm \
tex-udgj5a.vf \
tex-udgj5b.tfm \
tex-udgj5b.vf \
tex-udgj5c.tfm \
tex-udgj5c.vf \
tex-udgj5d.tfm \
tex-udgj5d.vf \
tex-udgj5e.tfm \
tex-udgj5e.vf \
tex-udgj5f.tfm \
tex-udgj5f.vf \
tex-udgj60.tfm \
tex-udgj60.vf \
tex-udgj61.tfm \
tex-udgj61.vf \
tex-udgj62.tfm \
tex-udgj62.vf \
tex-udgj63.tfm \
tex-udgj63.vf \
tex-udgj64.tfm \
tex-udgj64.vf \
tex-udgj65.tfm \
tex-udgj65.vf \
tex-udgj66.tfm \
tex-udgj66.vf \
tex-udgj67.tfm \
tex-udgj67.vf \
tex-udgj68.tfm \
tex-udgj68.vf \
tex-udgj69.tfm \
tex-udgj69.vf \
tex-udgj6a.tfm \
tex-udgj6a.vf \
tex-udgj6b.tfm \
tex-udgj6b.vf \
tex-udgj6c.tfm \
tex-udgj6c.vf \
tex-udgj6d.tfm \
tex-udgj6d.vf \
tex-udgj6e.tfm \
tex-udgj6e.vf \
tex-udgj6f.tfm \
tex-udgj6f.vf \
tex-udgj70.tfm \
tex-udgj70.vf \
tex-udgj71.tfm \
tex-udgj71.vf \
tex-udgj72.tfm \
tex-udgj72.vf \
tex-udgj73.tfm \
tex-udgj73.vf \
tex-udgj74.tfm \
tex-udgj74.vf \
tex-udgj75.tfm \
tex-udgj75.vf \
tex-udgj76.tfm \
tex-udgj76.vf \
tex-udgj77.tfm \
tex-udgj77.vf \
tex-udgj78.tfm \
tex-udgj78.vf \
tex-udgj79.tfm \
tex-udgj79.vf \
tex-udgj7a.tfm \
tex-udgj7a.vf \
tex-udgj7b.tfm \
tex-udgj7b.vf \
tex-udgj7c.tfm \
tex-udgj7c.vf \
tex-udgj7d.tfm \
tex-udgj7d.vf \
tex-udgj7e.tfm \
tex-udgj7e.vf \
tex-udgj7f.tfm \
tex-udgj7f.vf \
tex-udgj80.tfm \
tex-udgj80.vf \
tex-udgj81.tfm \
tex-udgj81.vf \
tex-udgj82.tfm \
tex-udgj82.vf \
tex-udgj83.tfm \
tex-udgj83.vf \
tex-udgj84.tfm \
tex-udgj84.vf \
tex-udgj85.tfm \
tex-udgj85.vf \
tex-udgj86.tfm \
tex-udgj86.vf \
tex-udgj87.tfm \
tex-udgj87.vf \
tex-udgj88.tfm \
tex-udgj88.vf \
tex-udgj89.tfm \
tex-udgj89.vf \
tex-udgj8a.tfm \
tex-udgj8a.vf \
tex-udgj8b.tfm \
tex-udgj8b.vf \
tex-udgj8c.tfm \
tex-udgj8c.vf \
tex-udgj8d.tfm \
tex-udgj8d.vf \
tex-udgj8e.tfm \
tex-udgj8e.vf \
tex-udgj8f.tfm \
tex-udgj8f.vf \
tex-udgj90.tfm \
tex-udgj90.vf \
tex-udgj91.tfm \
tex-udgj91.vf \
tex-udgj92.tfm \
tex-udgj92.vf \
tex-udgj93.tfm \
tex-udgj93.vf \
tex-udgj94.tfm \
tex-udgj94.vf \
tex-udgj95.tfm \
tex-udgj95.vf \
tex-udgj96.tfm \
tex-udgj96.vf \
tex-udgj97.tfm \
tex-udgj97.vf \
tex-udgj98.tfm \
tex-udgj98.vf \
tex-udgj99.tfm \
tex-udgj99.vf \
tex-udgj9a.tfm \
tex-udgj9a.vf \
tex-udgj9b.tfm \
tex-udgj9b.vf \
tex-udgj9c.tfm \
tex-udgj9c.vf \
tex-udgj9d.tfm \
tex-udgj9d.vf \
tex-udgj9e.tfm \
tex-udgj9e.vf \
tex-udgj9f.tfm \
tex-udgj9f.vf \
tex-udgjff.tfm \
tex-udgjff.vf \
tex-udmj00.tfm \
tex-udmj00.vf \
tex-udmj03.tfm \
tex-udmj03.vf \
tex-udmj04.tfm \
tex-udmj04.vf \
tex-udmj20.tfm \
tex-udmj20.vf \
tex-udmj21.tfm \
tex-udmj21.vf \
tex-udmj22.tfm \
tex-udmj22.vf \
tex-udmj23.tfm \
tex-udmj23.vf \
tex-udmj25.tfm \
tex-udmj25.vf \
tex-udmj26.tfm \
tex-udmj26.vf \
tex-udmj30.tfm \
tex-udmj30.vf \
tex-udmj4e.tfm \
tex-udmj4e.vf \
tex-udmj4f.tfm \
tex-udmj4f.vf \
tex-udmj50.tfm \
tex-udmj50.vf \
tex-udmj51.tfm \
tex-udmj51.vf \
tex-udmj52.tfm \
tex-udmj52.vf \
tex-udmj53.tfm \
tex-udmj53.vf \
tex-udmj54.tfm \
tex-udmj54.vf \
tex-udmj55.tfm \
tex-udmj55.vf \
tex-udmj56.tfm \
tex-udmj56.vf \
tex-udmj57.tfm \
tex-udmj57.vf \
tex-udmj58.tfm \
tex-udmj58.vf \
tex-udmj59.tfm \
tex-udmj59.vf \
tex-udmj5a.tfm \
tex-udmj5a.vf \
tex-udmj5b.tfm \
tex-udmj5b.vf \
tex-udmj5c.tfm \
tex-udmj5c.vf \
tex-udmj5d.tfm \
tex-udmj5d.vf \
tex-udmj5e.tfm \
tex-udmj5e.vf \
tex-udmj5f.tfm \
tex-udmj5f.vf \
tex-udmj60.tfm \
tex-udmj60.vf \
tex-udmj61.tfm \
tex-udmj61.vf \
tex-udmj62.tfm \
tex-udmj62.vf \
tex-udmj63.tfm \
tex-udmj63.vf \
tex-udmj64.tfm \
tex-udmj64.vf \
tex-udmj65.tfm \
tex-udmj65.vf \
tex-udmj66.tfm \
tex-udmj66.vf \
tex-udmj67.tfm \
tex-udmj67.vf \
tex-udmj68.tfm \
tex-udmj68.vf \
tex-udmj69.tfm \
tex-udmj69.vf \
tex-udmj6a.tfm \
tex-udmj6a.vf \
tex-udmj6b.tfm \
tex-udmj6b.vf \
tex-udmj6c.tfm \
tex-udmj6c.vf \
tex-udmj6d.tfm \
tex-udmj6d.vf \
tex-udmj6e.tfm \
tex-udmj6e.vf \
tex-udmj6f.tfm \
tex-udmj6f.vf \
tex-udmj70.tfm \
tex-udmj70.vf \
tex-udmj71.tfm \
tex-udmj71.vf \
tex-udmj72.tfm \
tex-udmj72.vf \
tex-udmj73.tfm \
tex-udmj73.vf \
tex-udmj74.tfm \
tex-udmj74.vf \
tex-udmj75.tfm \
tex-udmj75.vf \
tex-udmj76.tfm \
tex-udmj76.vf \
tex-udmj77.tfm \
tex-udmj77.vf \
tex-udmj78.tfm \
tex-udmj78.vf \
tex-udmj79.tfm \
tex-udmj79.vf \
tex-udmj7a.tfm \
tex-udmj7a.vf \
tex-udmj7b.tfm \
tex-udmj7b.vf \
tex-udmj7c.tfm \
tex-udmj7c.vf \
tex-udmj7d.tfm \
tex-udmj7d.vf \
tex-udmj7e.tfm \
tex-udmj7e.vf \
tex-udmj7f.tfm \
tex-udmj7f.vf \
tex-udmj80.tfm \
tex-udmj80.vf \
tex-udmj81.tfm \
tex-udmj81.vf \
tex-udmj82.tfm \
tex-udmj82.vf \
tex-udmj83.tfm \
tex-udmj83.vf \
tex-udmj84.tfm \
tex-udmj84.vf \
tex-udmj85.tfm \
tex-udmj85.vf \
tex-udmj86.tfm \
tex-udmj86.vf \
tex-udmj87.tfm \
tex-udmj87.vf \
tex-udmj88.tfm \
tex-udmj88.vf \
tex-udmj89.tfm \
tex-udmj89.vf \
tex-udmj8a.tfm \
tex-udmj8a.vf \
tex-udmj8b.tfm \
tex-udmj8b.vf \
tex-udmj8c.tfm \
tex-udmj8c.vf \
tex-udmj8d.tfm \
tex-udmj8d.vf \
tex-udmj8e.tfm \
tex-udmj8e.vf \
tex-udmj8f.tfm \
tex-udmj8f.vf \
tex-udmj90.tfm \
tex-udmj90.vf \
tex-udmj91.tfm \
tex-udmj91.vf \
tex-udmj92.tfm \
tex-udmj92.vf \
tex-udmj93.tfm \
tex-udmj93.vf \
tex-udmj94.tfm \
tex-udmj94.vf \
tex-udmj95.tfm \
tex-udmj95.vf \
tex-udmj96.tfm \
tex-udmj96.vf \
tex-udmj97.tfm \
tex-udmj97.vf \
tex-udmj98.tfm \
tex-udmj98.vf \
tex-udmj99.tfm \
tex-udmj99.vf \
tex-udmj9a.tfm \
tex-udmj9a.vf \
tex-udmj9b.tfm \
tex-udmj9b.vf \
tex-udmj9c.tfm \
tex-udmj9c.vf \
tex-udmj9d.tfm \
tex-udmj9d.vf \
tex-udmj9e.tfm \
tex-udmj9e.vf \
tex-udmj9f.tfm \
tex-udmj9f.vf \
tex-udmjff.tfm \
tex-udmjff.vf \
tex-umcj00.tfm \
tex-umcj00.vf \
tex-umcj03.tfm \
tex-umcj03.vf \
tex-umcj04.tfm \
tex-umcj04.vf \
tex-umcj20.tfm \
tex-umcj20.vf \
tex-umcj21.tfm \
tex-umcj21.vf \
tex-umcj22.tfm \
tex-umcj22.vf \
tex-umcj23.tfm \
tex-umcj23.vf \
tex-umcj25.tfm \
tex-umcj25.vf \
tex-umcj26.tfm \
tex-umcj26.vf \
tex-umcj30.tfm \
tex-umcj30.vf \
tex-umcj4e.tfm \
tex-umcj4e.vf \
tex-umcj4f.tfm \
tex-umcj4f.vf \
tex-umcj50.tfm \
tex-umcj50.vf \
tex-umcj51.tfm \
tex-umcj51.vf \
tex-umcj52.tfm \
tex-umcj52.vf \
tex-umcj53.tfm \
tex-umcj53.vf \
tex-umcj54.tfm \
tex-umcj54.vf \
tex-umcj55.tfm \
tex-umcj55.vf \
tex-umcj56.tfm \
tex-umcj56.vf \
tex-umcj57.tfm \
tex-umcj57.vf \
tex-umcj58.tfm \
tex-umcj58.vf \
tex-umcj59.tfm \
tex-umcj59.vf \
tex-umcj5a.tfm \
tex-umcj5a.vf \
tex-umcj5b.tfm \
tex-umcj5b.vf \
tex-umcj5c.tfm \
tex-umcj5c.vf \
tex-umcj5d.tfm \
tex-umcj5d.vf \
tex-umcj5e.tfm \
tex-umcj5e.vf \
tex-umcj5f.tfm \
tex-umcj5f.vf \
tex-umcj60.tfm \
tex-umcj60.vf \
tex-umcj61.tfm \
tex-umcj61.vf \
tex-umcj62.tfm \
tex-umcj62.vf \
tex-umcj63.tfm \
tex-umcj63.vf \
tex-umcj64.tfm \
tex-umcj64.vf \
tex-umcj65.tfm \
tex-umcj65.vf \
tex-umcj66.tfm \
tex-umcj66.vf \
tex-umcj67.tfm \
tex-umcj67.vf \
tex-umcj68.tfm \
tex-umcj68.vf \
tex-umcj69.tfm \
tex-umcj69.vf \
tex-umcj6a.tfm \
tex-umcj6a.vf \
tex-umcj6b.tfm \
tex-umcj6b.vf \
tex-umcj6c.tfm \
tex-umcj6c.vf \
tex-umcj6d.tfm \
tex-umcj6d.vf \
tex-umcj6e.tfm \
tex-umcj6e.vf \
tex-umcj6f.tfm \
tex-umcj6f.vf \
tex-umcj70.tfm \
tex-umcj70.vf \
tex-umcj71.tfm \
tex-umcj71.vf \
tex-umcj72.tfm \
tex-umcj72.vf \
tex-umcj73.tfm \
tex-umcj73.vf \
tex-umcj74.tfm \
tex-umcj74.vf \
tex-umcj75.tfm \
tex-umcj75.vf \
tex-umcj76.tfm \
tex-umcj76.vf \
tex-umcj77.tfm \
tex-umcj77.vf \
tex-umcj78.tfm \
tex-umcj78.vf \
tex-umcj79.tfm \
tex-umcj79.vf \
tex-umcj7a.tfm \
tex-umcj7a.vf \
tex-umcj7b.tfm \
tex-umcj7b.vf \
tex-umcj7c.tfm \
tex-umcj7c.vf \
tex-umcj7d.tfm \
tex-umcj7d.vf \
tex-umcj7e.tfm \
tex-umcj7e.vf \
tex-umcj7f.tfm \
tex-umcj7f.vf \
tex-umcj80.tfm \
tex-umcj80.vf \
tex-umcj81.tfm \
tex-umcj81.vf \
tex-umcj82.tfm \
tex-umcj82.vf \
tex-umcj83.tfm \
tex-umcj83.vf \
tex-umcj84.tfm \
tex-umcj84.vf \
tex-umcj85.tfm \
tex-umcj85.vf \
tex-umcj86.tfm \
tex-umcj86.vf \
tex-umcj87.tfm \
tex-umcj87.vf \
tex-umcj88.tfm \
tex-umcj88.vf \
tex-umcj89.tfm \
tex-umcj89.vf \
tex-umcj8a.tfm \
tex-umcj8a.vf \
tex-umcj8b.tfm \
tex-umcj8b.vf \
tex-umcj8c.tfm \
tex-umcj8c.vf \
tex-umcj8d.tfm \
tex-umcj8d.vf \
tex-umcj8e.tfm \
tex-umcj8e.vf \
tex-umcj8f.tfm \
tex-umcj8f.vf \
tex-umcj90.tfm \
tex-umcj90.vf \
tex-umcj91.tfm \
tex-umcj91.vf \
tex-umcj92.tfm \
tex-umcj92.vf \
tex-umcj93.tfm \
tex-umcj93.vf \
tex-umcj94.tfm \
tex-umcj94.vf \
tex-umcj95.tfm \
tex-umcj95.vf \
tex-umcj96.tfm \
tex-umcj96.vf \
tex-umcj97.tfm \
tex-umcj97.vf \
tex-umcj98.tfm \
tex-umcj98.vf \
tex-umcj99.tfm \
tex-umcj99.vf \
tex-umcj9a.tfm \
tex-umcj9a.vf \
tex-umcj9b.tfm \
tex-umcj9b.vf \
tex-umcj9c.tfm \
tex-umcj9c.vf \
tex-umcj9d.tfm \
tex-umcj9d.vf \
tex-umcj9e.tfm \
tex-umcj9e.vf \
tex-umcj9f.tfm \
tex-umcj9f.vf \
tex-umcjff.tfm \
tex-umcjff.vf \
tex-umrj00.tfm \
tex-umrj00.vf \
tex-umrj03.tfm \
tex-umrj03.vf \
tex-umrj04.tfm \
tex-umrj04.vf \
tex-umrj20.tfm \
tex-umrj20.vf \
tex-umrj21.tfm \
tex-umrj21.vf \
tex-umrj22.tfm \
tex-umrj22.vf \
tex-umrj23.tfm \
tex-umrj23.vf \
tex-umrj25.tfm \
tex-umrj25.vf \
tex-umrj26.tfm \
tex-umrj26.vf \
tex-umrj30.tfm \
tex-umrj30.vf \
tex-umrj4e.tfm \
tex-umrj4e.vf \
tex-umrj4f.tfm \
tex-umrj4f.vf \
tex-umrj50.tfm \
tex-umrj50.vf \
tex-umrj51.tfm \
tex-umrj51.vf \
tex-umrj52.tfm \
tex-umrj52.vf \
tex-umrj53.tfm \
tex-umrj53.vf \
tex-umrj54.tfm \
tex-umrj54.vf \
tex-umrj55.tfm \
tex-umrj55.vf \
tex-umrj56.tfm \
tex-umrj56.vf \
tex-umrj57.tfm \
tex-umrj57.vf \
tex-umrj58.tfm \
tex-umrj58.vf \
tex-umrj59.tfm \
tex-umrj59.vf \
tex-umrj5a.tfm \
tex-umrj5a.vf \
tex-umrj5b.tfm \
tex-umrj5b.vf \
tex-umrj5c.tfm \
tex-umrj5c.vf \
tex-umrj5d.tfm \
tex-umrj5d.vf \
tex-umrj5e.tfm \
tex-umrj5e.vf \
tex-umrj5f.tfm \
tex-umrj5f.vf \
tex-umrj60.tfm \
tex-umrj60.vf \
tex-umrj61.tfm \
tex-umrj61.vf \
tex-umrj62.tfm \
tex-umrj62.vf \
tex-umrj63.tfm \
tex-umrj63.vf \
tex-umrj64.tfm \
tex-umrj64.vf \
tex-umrj65.tfm \
tex-umrj65.vf \
tex-umrj66.tfm \
tex-umrj66.vf \
tex-umrj67.tfm \
tex-umrj67.vf \
tex-umrj68.tfm \
tex-umrj68.vf \
tex-umrj69.tfm \
tex-umrj69.vf \
tex-umrj6a.tfm \
tex-umrj6a.vf \
tex-umrj6b.tfm \
tex-umrj6b.vf \
tex-umrj6c.tfm \
tex-umrj6c.vf \
tex-umrj6d.tfm \
tex-umrj6d.vf \
tex-umrj6e.tfm \
tex-umrj6e.vf \
tex-umrj6f.tfm \
tex-umrj6f.vf \
tex-umrj70.tfm \
tex-umrj70.vf \
tex-umrj71.tfm \
tex-umrj71.vf \
tex-umrj72.tfm \
tex-umrj72.vf \
tex-umrj73.tfm \
tex-umrj73.vf \
tex-umrj74.tfm \
tex-umrj74.vf \
tex-umrj75.tfm \
tex-umrj75.vf \
tex-umrj76.tfm \
tex-umrj76.vf \
tex-umrj77.tfm \
tex-umrj77.vf \
tex-umrj78.tfm \
tex-umrj78.vf \
tex-umrj79.tfm \
tex-umrj79.vf \
tex-umrj7a.tfm \
tex-umrj7a.vf \
tex-umrj7b.tfm \
tex-umrj7b.vf \
tex-umrj7c.tfm \
tex-umrj7c.vf \
tex-umrj7d.tfm \
tex-umrj7d.vf \
tex-umrj7e.tfm \
tex-umrj7e.vf \
tex-umrj7f.tfm \
tex-umrj7f.vf \
tex-umrj80.tfm \
tex-umrj80.vf \
tex-umrj81.tfm \
tex-umrj81.vf \
tex-umrj82.tfm \
tex-umrj82.vf \
tex-umrj83.tfm \
tex-umrj83.vf \
tex-umrj84.tfm \
tex-umrj84.vf \
tex-umrj85.tfm \
tex-umrj85.vf \
tex-umrj86.tfm \
tex-umrj86.vf \
tex-umrj87.tfm \
tex-umrj87.vf \
tex-umrj88.tfm \
tex-umrj88.vf \
tex-umrj89.tfm \
tex-umrj89.vf \
tex-umrj8a.tfm \
tex-umrj8a.vf \
tex-umrj8b.tfm \
tex-umrj8b.vf \
tex-umrj8c.tfm \
tex-umrj8c.vf \
tex-umrj8d.tfm \
tex-umrj8d.vf \
tex-umrj8e.tfm \
tex-umrj8e.vf \
tex-umrj8f.tfm \
tex-umrj8f.vf \
tex-umrj90.tfm \
tex-umrj90.vf \
tex-umrj91.tfm \
tex-umrj91.vf \
tex-umrj92.tfm \
tex-umrj92.vf \
tex-umrj93.tfm \
tex-umrj93.vf \
tex-umrj94.tfm \
tex-umrj94.vf \
tex-umrj95.tfm \
tex-umrj95.vf \
tex-umrj96.tfm \
tex-umrj96.vf \
tex-umrj97.tfm \
tex-umrj97.vf \
tex-umrj98.tfm \
tex-umrj98.vf \
tex-umrj99.tfm \
tex-umrj99.vf \
tex-umrj9a.tfm \
tex-umrj9a.vf \
tex-umrj9b.tfm \
tex-umrj9b.vf \
tex-umrj9c.tfm \
tex-umrj9c.vf \
tex-umrj9d.tfm \
tex-umrj9d.vf \
tex-umrj9e.tfm \
tex-umrj9e.vf \
tex-umrj9f.tfm \
tex-umrj9f.vf \
tex-umrjff.tfm \
tex-umrjff.vf \
texlive-wadalab"

RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-updmap.cfg \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin \
texlive-wadalab-fonts"

inherit rpm
