SUMMARY = "HP's Printing, Scanning, and Faxing Software"
DESCRIPTION = "The Hewlett-Packard Linux Imaging and Printing project (HPLIP) provides \
a unified single and multifunction connectivity solution for HP \
printers, scanners, and all-in-one devices. \
 \
This package contains command line and UI front-ends for HPLIP, and tools \
for extra functionality such as status and supply information. It is \
not required for basic printing and scanning with HP hardware, except \
for those devices that need the proprietary hplip plugin, see \
https://developers.hp.com/hp-linux-imaging-and-printing/binary_plugin.html"
LICENSE = "BSD-3-Clause & GPL-2.0-or-later & MIT"

PV = "3.22.10"

RPM_NAME = "hplip-3.22.10-2.1.aarch64.rpm"
RPM_HASH = "608bb59d19d89a28c40461ad884a7f85694c917987d12fa717f671d6b57363f259762648fe995b1fc12ccf15671a981ac6d426752aea82d2c4ac01683d05fc6c"

RPROVIDES:${PN} += "config-hplip \
hplip \
hplip3 \
postscriptdriver-hewlett-packard;hp-cm8050-mfp-with-edgeline; \
postscriptdriver-hewlett-packard;hp-cm8060-mfp-with-edgeline; \
postscriptdriver-hewlett-packard;hp-color-laserjet-1600; \
postscriptdriver-hewlett-packard;hp-color-laserjet-2600n; \
postscriptdriver-hewlett-packard;hp-color-laserjet-3000; \
postscriptdriver-hewlett-packard;hp-color-laserjet-3500; \
postscriptdriver-hewlett-packard;hp-color-laserjet-3500n; \
postscriptdriver-hewlett-packard;hp-color-laserjet-3550; \
postscriptdriver-hewlett-packard;hp-color-laserjet-3550n; \
postscriptdriver-hewlett-packard;hp-color-laserjet-3600; \
postscriptdriver-hewlett-packard;hp-color-laserjet-3800; \
postscriptdriver-hewlett-packard;hp-color-laserjet-4700; \
postscriptdriver-hewlett-packard;hp-color-laserjet-4730mfp; \
postscriptdriver-hewlett-packard;hp-color-laserjet-5550; \
postscriptdriver-hewlett-packard;hp-color-laserjet-9500-mfp; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cm1312-mfp; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cm1312nfi-mfp; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cm2320-mfp; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cm2320fxi-mfp; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cm2320n-mfp; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cm2320nf-mfp; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cm3530-mfp; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cm4540-mfp; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cm4730-mfp; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cm6030-mfp; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cm6040-mfp; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cm6049-mfp; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp1215; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp1514n; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp1515n; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp1518ni; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp2025; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp2025dn; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp2025n; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp2025x; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp3505; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp3525; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp4020-series; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp4520-series; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp5225; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp5225dn; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp5225n; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp5520-series; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp6015; \
postscriptdriver-hewlett-packard;hp-color-laserjet-e45028; \
postscriptdriver-hewlett-packard;hp-color-laserjet-e55040; \
postscriptdriver-hewlett-packard;hp-color-laserjet-e65050-e65060; \
postscriptdriver-hewlett-packard;hp-color-laserjet-e65150-e65160; \
postscriptdriver-hewlett-packard;hp-color-laserjet-e67550-e67560; \
postscriptdriver-hewlett-packard;hp-color-laserjet-e67650-e67660; \
postscriptdriver-hewlett-packard;hp-color-laserjet-e75245; \
postscriptdriver-hewlett-packard;hp-color-laserjet-e85055.ppd; \
postscriptdriver-hewlett-packard;hp-color-laserjet-flow-e57540; \
postscriptdriver-hewlett-packard;hp-color-laserjet-flow-mfp-m577; \
postscriptdriver-hewlett-packard;hp-color-laserjet-flow-mfp-m680; \
postscriptdriver-hewlett-packard;hp-color-laserjet-flow-mfp-m776; \
postscriptdriver-hewlett-packard;hp-color-laserjet-flow-mfp-m880; \
postscriptdriver-hewlett-packard;hp-color-laserjet-flowmfp-m578; \
postscriptdriver-hewlett-packard;hp-color-laserjet-m153-m154; \
postscriptdriver-hewlett-packard;hp-color-laserjet-m155-m156; \
postscriptdriver-hewlett-packard;hp-color-laserjet-m253-m254; \
postscriptdriver-hewlett-packard;hp-color-laserjet-m255-m256; \
postscriptdriver-hewlett-packard;hp-color-laserjet-m452; \
postscriptdriver-hewlett-packard;hp-color-laserjet-m455; \
postscriptdriver-hewlett-packard;hp-color-laserjet-m552; \
postscriptdriver-hewlett-packard;hp-color-laserjet-m553; \
postscriptdriver-hewlett-packard;hp-color-laserjet-m554; \
postscriptdriver-hewlett-packard;hp-color-laserjet-m555; \
postscriptdriver-hewlett-packard;hp-color-laserjet-m651; \
postscriptdriver-hewlett-packard;hp-color-laserjet-m652-m653; \
postscriptdriver-hewlett-packard;hp-color-laserjet-m750; \
postscriptdriver-hewlett-packard;hp-color-laserjet-m751; \
postscriptdriver-hewlett-packard;hp-color-laserjet-m855; \
postscriptdriver-hewlett-packard;hp-color-laserjet-m856.ppd; \
postscriptdriver-hewlett-packard;hp-color-laserjet-mfp-e47528; \
postscriptdriver-hewlett-packard;hp-color-laserjet-mfp-e57540; \
postscriptdriver-hewlett-packard;hp-color-laserjet-mfp-e77422; \
postscriptdriver-hewlett-packard;hp-color-laserjet-mfp-e77428; \
postscriptdriver-hewlett-packard;hp-color-laserjet-mfp-e78223; \
postscriptdriver-hewlett-packard;hp-color-laserjet-mfp-e78228; \
postscriptdriver-hewlett-packard;hp-color-laserjet-mfp-e78323-25-30; \
postscriptdriver-hewlett-packard;hp-color-laserjet-mfp-e78523; \
postscriptdriver-hewlett-packard;hp-color-laserjet-mfp-e78528; \
postscriptdriver-hewlett-packard;hp-color-laserjet-mfp-e785; \
postscriptdriver-hewlett-packard;hp-color-laserjet-mfp-m178-m181; \
postscriptdriver-hewlett-packard;hp-color-laserjet-mfp-m182-m185; \
postscriptdriver-hewlett-packard;hp-color-laserjet-mfp-m274n; \
postscriptdriver-hewlett-packard;hp-color-laserjet-mfp-m278-m281; \
postscriptdriver-hewlett-packard;hp-color-laserjet-mfp-m282-m285; \
postscriptdriver-hewlett-packard;hp-color-laserjet-mfp-m476nw; \
postscriptdriver-hewlett-packard;hp-color-laserjet-mfp-m480; \
postscriptdriver-hewlett-packard;hp-color-laserjet-mfp-m578; \
postscriptdriver-hewlett-packard;hp-color-laserjet-mfp-m680; \
postscriptdriver-hewlett-packard;hp-color-laserjet-mfp-m681-m682; \
postscriptdriver-hewlett-packard;hp-color-laserjet-mfp-m776; \
postscriptdriver-hewlett-packard;hp-color-laserjet-pro-m252; \
postscriptdriver-hewlett-packard;hp-color-laserjet-pro-m453-4; \
postscriptdriver-hewlett-packard;hp-color-laserjet-pro-m478f-9f; \
postscriptdriver-hewlett-packard;hp-color-laserjet-pro-m479; \
postscriptdriver-hewlett-packard;hp-color-laserjet-pro-mfp-m176n; \
postscriptdriver-hewlett-packard;hp-color-laserjet-pro-mfp-m277; \
postscriptdriver-hewlett-packard;hp-color-laserjet-pro-mfp-m377; \
postscriptdriver-hewlett-packard;hp-color-laserjet-pro-mfp-m477; \
postscriptdriver-hewlett-packard;hp-designjet-t1700-ps; \
postscriptdriver-hewlett-packard;hp-designjet-t1700dr-ps; \
postscriptdriver-hewlett-packard;hp-designjet-t1708-postscript; \
postscriptdriver-hewlett-packard;hp-designjet-t1708dr-postscript; \
postscriptdriver-hewlett-packard;hp-designjet-t3500ps; \
postscriptdriver-hewlett-packard;hp-designjet-t920-postscript; \
postscriptdriver-hewlett-packard;hp-designjet-z5200-postscript; \
postscriptdriver-hewlett-packard;hp-designjet-z6-24in; \
postscriptdriver-hewlett-packard;hp-designjet-z6-44in; \
postscriptdriver-hewlett-packard;hp-designjet-z6dr-44in; \
postscriptdriver-hewlett-packard;hp-laserjet-100-colormfp-m175nw; \
postscriptdriver-hewlett-packard;hp-laserjet-1000; \
postscriptdriver-hewlett-packard;hp-laserjet-1005-series; \
postscriptdriver-hewlett-packard;hp-laserjet-1018; \
postscriptdriver-hewlett-packard;hp-laserjet-1020; \
postscriptdriver-hewlett-packard;hp-laserjet-1022; \
postscriptdriver-hewlett-packard;hp-laserjet-1022n; \
postscriptdriver-hewlett-packard;hp-laserjet-1022nw; \
postscriptdriver-hewlett-packard;hp-laserjet-200-color-m251n; \
postscriptdriver-hewlett-packard;hp-laserjet-200-colormfp-m275s; \
postscriptdriver-hewlett-packard;hp-laserjet-200-colormfp-m276nw; \
postscriptdriver-hewlett-packard;hp-laserjet-300-color-m351a; \
postscriptdriver-hewlett-packard;hp-laserjet-300-colormfp-m375nw; \
postscriptdriver-hewlett-packard;hp-laserjet-400-m401a; \
postscriptdriver-hewlett-packard;hp-laserjet-400-m401dne; \
postscriptdriver-hewlett-packard;hp-laserjet-400-mfp-m425dw; \
postscriptdriver-hewlett-packard;hp-laserjet-4345-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-500-color-m551; \
postscriptdriver-hewlett-packard;hp-laserjet-500-color-mfp-m575; \
postscriptdriver-hewlett-packard;hp-laserjet-500-colormfp-m570dn; \
postscriptdriver-hewlett-packard;hp-laserjet-500-mfp-m525; \
postscriptdriver-hewlett-packard;hp-laserjet-600-m601; \
postscriptdriver-hewlett-packard;hp-laserjet-700-color-mfp-m775; \
postscriptdriver-hewlett-packard;hp-laserjet-700-m712; \
postscriptdriver-hewlett-packard;hp-laserjet-cm1411fn; \
postscriptdriver-hewlett-packard;hp-laserjet-color-flow-mfp-m575; \
postscriptdriver-hewlett-packard;hp-laserjet-cp-1025nw; \
postscriptdriver-hewlett-packard;hp-laserjet-cp1025nw; \
postscriptdriver-hewlett-packard;hp-laserjet-cp1521n; \
postscriptdriver-hewlett-packard;hp-laserjet-e40040; \
postscriptdriver-hewlett-packard;hp-laserjet-e50145; \
postscriptdriver-hewlett-packard;hp-laserjet-e60055-e60075; \
postscriptdriver-hewlett-packard;hp-laserjet-e60155; \
postscriptdriver-hewlett-packard;hp-laserjet-e60165; \
postscriptdriver-hewlett-packard;hp-laserjet-e60175; \
postscriptdriver-hewlett-packard;hp-laserjet-e62555-e62575; \
postscriptdriver-hewlett-packard;hp-laserjet-e62655-e62675; \
postscriptdriver-hewlett-packard;hp-laserjet-flow-e73130; \
postscriptdriver-hewlett-packard;hp-laserjet-flow-e73135; \
postscriptdriver-hewlett-packard;hp-laserjet-flow-e73140; \
postscriptdriver-hewlett-packard;hp-laserjet-flow-e82650; \
postscriptdriver-hewlett-packard;hp-laserjet-flow-e82660; \
postscriptdriver-hewlett-packard;hp-laserjet-flow-e82670; \
postscriptdriver-hewlett-packard;hp-laserjet-flow-mfp-e52645; \
postscriptdriver-hewlett-packard;hp-laserjet-flow-mfp-e731; \
postscriptdriver-hewlett-packard;hp-laserjet-flow-mfp-e826; \
postscriptdriver-hewlett-packard;hp-laserjet-flow-mfp-m525; \
postscriptdriver-hewlett-packard;hp-laserjet-flow-mfp-m528; \
postscriptdriver-hewlett-packard;hp-laserjet-flow-mfp-m630; \
postscriptdriver-hewlett-packard;hp-laserjet-flow-mfp-m830; \
postscriptdriver-hewlett-packard;hp-laserjet-m1005; \
postscriptdriver-hewlett-packard;hp-laserjet-m1120-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m1120n-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m1319f-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m1522-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m1522n-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m1522nf-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m1536dnf-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m2727-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m3035-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m402-m403-n; \
postscriptdriver-hewlett-packard;hp-laserjet-m402-m403; \
postscriptdriver-hewlett-packard;hp-laserjet-m406; \
postscriptdriver-hewlett-packard;hp-laserjet-m407; \
postscriptdriver-hewlett-packard;hp-laserjet-m4345-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m4555-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m5035-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m506; \
postscriptdriver-hewlett-packard;hp-laserjet-m507; \
postscriptdriver-hewlett-packard;hp-laserjet-m604-m605-m606; \
postscriptdriver-hewlett-packard;hp-laserjet-m607-m608-m609; \
postscriptdriver-hewlett-packard;hp-laserjet-m610-m611-m612; \
postscriptdriver-hewlett-packard;hp-laserjet-m806; \
postscriptdriver-hewlett-packard;hp-laserjet-m9040-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m9050-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m9059-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-3001-3008; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-e42540; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-e72425; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-e72430; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-e72525-25-30-35; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-e73025; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-e73030; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-e730; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-e73130; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-e73135; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-e73140; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-e731; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-e77822-25-30; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-e82540-50-60; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-e82650; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-e82660; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-e82670; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-e826; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-e87640-50-60; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-m426-m427; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-m430; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-m431; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-m527; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-m630; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-m631-m632-m633; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-m634-m635-m636; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-m725; \
postscriptdriver-hewlett-packard;hp-laserjet-p1005; \
postscriptdriver-hewlett-packard;hp-laserjet-p1006; \
postscriptdriver-hewlett-packard;hp-laserjet-p1007; \
postscriptdriver-hewlett-packard;hp-laserjet-p1008; \
postscriptdriver-hewlett-packard;hp-laserjet-p1505; \
postscriptdriver-hewlett-packard;hp-laserjet-p1505n; \
postscriptdriver-hewlett-packard;hp-laserjet-p2014; \
postscriptdriver-hewlett-packard;hp-laserjet-p2014n; \
postscriptdriver-hewlett-packard;hp-laserjet-p2035; \
postscriptdriver-hewlett-packard;hp-laserjet-p2035n; \
postscriptdriver-hewlett-packard;hp-laserjet-p3010-series; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-4001; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-4002; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-4003; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-4004; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-m118-m119; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-m148-m149; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-m148f-m149f; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-m201n; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-m203-m206; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-m304-m305; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-m404-m405; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-m428-m429; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-m428f-m429f; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-m501; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-m701a; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-m706n; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-3101-3108; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-4101; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-4102; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-4103; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-4104; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-m127fw; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-m225dn; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-m227-m231; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-m329; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-m435nw; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-m521dn; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-m1217nfw-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-p-1102w; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-p1102; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-p1566; \
postscriptdriver-hp;hp-color-laserjet-flow-e78625; \
postscriptdriver-hp;hp-color-laserjet-flow-e78630; \
postscriptdriver-hp;hp-color-laserjet-flow-e78635; \
postscriptdriver-hp;hp-color-laserjet-flow-e87740; \
postscriptdriver-hp;hp-color-laserjet-flow-e87750; \
postscriptdriver-hp;hp-color-laserjet-flow-e87760; \
postscriptdriver-hp;hp-color-laserjet-flow-e87770; \
postscriptdriver-hp;hp-color-laserjet-flow-mfp-e786; \
postscriptdriver-hp;hp-color-laserjet-flow-mfp-e877; \
postscriptdriver-hp;hp-color-laserjet-mfp-e78625; \
postscriptdriver-hp;hp-color-laserjet-mfp-e78630; \
postscriptdriver-hp;hp-color-laserjet-mfp-e786; \
postscriptdriver-hp;hp-color-laserjet-mfp-e87740; \
postscriptdriver-hp;hp-color-laserjet-mfp-e87750; \
postscriptdriver-hp;hp-color-laserjet-mfp-e87760; \
postscriptdriver-hp;hp-color-laserjet-mfp-e87770; \
postscriptdriver-hp;hp-color-laserjet-mfp-e877; \
postscriptdriver-hp;hp-officejet-color-mfp-x585; \
postscriptdriver-hp;hp-officejet-color-x555; \
postscriptdriver-hp;hp-officejet-pro-251dw-printer; \
postscriptdriver-hp;hp-officejet-pro-276dw-mfp; \
postscriptdriver-hp;hp-officejet-pro-8210; \
postscriptdriver-hp;hp-officejet-pro-8730; \
postscriptdriver-hp;hp-officejet-pro-8732m; \
postscriptdriver-hp;hp-officejet-pro-8740; \
postscriptdriver-hp;hp-officejet-pro-x451dn-printer; \
postscriptdriver-hp;hp-officejet-pro-x476dn-mfp; \
postscriptdriver-hp;hp-officejet-pro-x551dw-printer; \
postscriptdriver-hp;hp-pagewide-color-556; \
postscriptdriver-hp;hp-pagewide-color-755; \
postscriptdriver-hp;hp-pagewide-color-765; \
postscriptdriver-hp;hp-pagewide-color-e55650; \
postscriptdriver-hp;hp-pagewide-color-e75160; \
postscriptdriver-hp;hp-pagewide-color-e77650-e77660; \
postscriptdriver-hp;hp-pagewide-color-flow-mfp-586; \
postscriptdriver-hp;hp-pagewide-color-mfp-586; \
postscriptdriver-hp;hp-pagewide-color-mfp-774-779; \
postscriptdriver-hp;hp-pagewide-color-mfp-780-785; \
postscriptdriver-hp;hp-pagewide-color-mfp-e58650; \
postscriptdriver-hp;hp-pagewide-color-p75250; \
postscriptdriver-hp;hp-pagewide-mfp-p57750; \
postscriptdriver-hp;hp-pagewide-mfp-p77740-60zs; \
postscriptdriver-hp;hp-pagewide-p55250; \
postscriptdriver-hp;hp-pagewide-p75050-60; \
postscriptdriver-hp;hp-pagewide-p77440-p77940-60; \
postscriptdriver-hp;hp-pagewide-pro-352-printer; \
postscriptdriver-hp;hp-pagewide-pro-377-mfp; \
postscriptdriver-hp;hp-pagewide-pro-452-printer; \
postscriptdriver-hp;hp-pagewide-pro-477-mfp; \
postscriptdriver-hp;hp-pagewide-pro-552-printer; \
postscriptdriver-hp;hp-pagewide-pro-577-mfp; \
postscriptdriver-hp;hp-pagewide-pro-750; \
postscriptdriver-hp;hp-pagewide-pro-mfp-772-777; \
postscriptdriver-hp;hp-pagewide-xl-5000ps-blueprinter; \
postscriptdriver-hp;hp-pagewide-xl-5100ps-mfp-blueprinter; \
postscriptdriver-hp;hp-pagewide-xl-8000ps-blueprinter; \
postscriptdriver-hp;officejet-pro-8000-enterprise-a811a;"

RDEPENDS:${PN} += "/usr/bin/bash \
/usr/bin/find \
/usr/bin/grep \
/usr/bin/python3 \
/usr/bin/sed \
coreutils \
cups \
foomatic-filters \
ghostscript \
hplip-hpijs \
hplip-sane \
ld-linux-aarch64.so.1 \
libc.so.6 \
libcups.so.2 \
libgcc-s.so.1 \
libhpdiscovery.so.0 \
libhpipp.so.0 \
libhpmud.so.0 \
libstdc++.so.6 \
lsb-release \
python-abi \
python3-dbus-python \
python3-gobject \
python3-qt5"

inherit rpm
