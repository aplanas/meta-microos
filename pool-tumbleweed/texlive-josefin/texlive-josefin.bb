SUMMARY = "Josefin fonts with LaTeX support"
DESCRIPTION = "This package provides LaTeX, pdfLaTeX, XeLaTeX and LuaLaTeX \
support for the Josefin Sans family of fonts, designed by \
Santiago Orozco of the Typemade foundry in Monterey, Mexico. \
Josefin Sans is available in seven weights, with corresponding \
italics."
LICENSE = "OFL-1.1"

PV = "2023.209.svn64569"

RPM_NAME = "texlive-josefin-2023.209.svn64569-56.1.noarch.rpm"
RPM_HASH = "51dfe82d7eb11efa9a1079b6b39bd1cf1b78f653854d3e6724b14633bd2c519862e9f82e608e526bdf71f3f1667d1cbe23cd4124bb72d17ce2c07f519e5e5539"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-JosefinSans-Bold-lf-ly1--base.tfm \
tex-JosefinSans-Bold-lf-ly1.tfm \
tex-JosefinSans-Bold-lf-ly1.vf \
tex-JosefinSans-Bold-lf-ot1.tfm \
tex-JosefinSans-Bold-lf-t1--base.tfm \
tex-JosefinSans-Bold-lf-t1.tfm \
tex-JosefinSans-Bold-lf-t1.vf \
tex-JosefinSans-Bold-lf-ts1--base.tfm \
tex-JosefinSans-Bold-lf-ts1.tfm \
tex-JosefinSans-Bold-lf-ts1.vf \
tex-JosefinSans-BoldItalic-lf-ly1--base.tfm \
tex-JosefinSans-BoldItalic-lf-ly1.tfm \
tex-JosefinSans-BoldItalic-lf-ly1.vf \
tex-JosefinSans-BoldItalic-lf-ot1.tfm \
tex-JosefinSans-BoldItalic-lf-t1--base.tfm \
tex-JosefinSans-BoldItalic-lf-t1.tfm \
tex-JosefinSans-BoldItalic-lf-t1.vf \
tex-JosefinSans-BoldItalic-lf-ts1--base.tfm \
tex-JosefinSans-BoldItalic-lf-ts1.tfm \
tex-JosefinSans-BoldItalic-lf-ts1.vf \
tex-JosefinSans-ExtraLight-lf-ly1--base.tfm \
tex-JosefinSans-ExtraLight-lf-ly1.tfm \
tex-JosefinSans-ExtraLight-lf-ly1.vf \
tex-JosefinSans-ExtraLight-lf-ot1.tfm \
tex-JosefinSans-ExtraLight-lf-t1--base.tfm \
tex-JosefinSans-ExtraLight-lf-t1.tfm \
tex-JosefinSans-ExtraLight-lf-t1.vf \
tex-JosefinSans-ExtraLight-lf-ts1--base.tfm \
tex-JosefinSans-ExtraLight-lf-ts1.tfm \
tex-JosefinSans-ExtraLight-lf-ts1.vf \
tex-JosefinSans-ExtraLightItalic-lf-ly1--base.tfm \
tex-JosefinSans-ExtraLightItalic-lf-ly1.tfm \
tex-JosefinSans-ExtraLightItalic-lf-ly1.vf \
tex-JosefinSans-ExtraLightItalic-lf-ot1.tfm \
tex-JosefinSans-ExtraLightItalic-lf-t1--base.tfm \
tex-JosefinSans-ExtraLightItalic-lf-t1.tfm \
tex-JosefinSans-ExtraLightItalic-lf-t1.vf \
tex-JosefinSans-ExtraLightItalic-lf-ts1--base.tfm \
tex-JosefinSans-ExtraLightItalic-lf-ts1.tfm \
tex-JosefinSans-ExtraLightItalic-lf-ts1.vf \
tex-JosefinSans-Italic-lf-ly1--base.tfm \
tex-JosefinSans-Italic-lf-ly1.tfm \
tex-JosefinSans-Italic-lf-ly1.vf \
tex-JosefinSans-Italic-lf-ot1.tfm \
tex-JosefinSans-Italic-lf-t1--base.tfm \
tex-JosefinSans-Italic-lf-t1.tfm \
tex-JosefinSans-Italic-lf-t1.vf \
tex-JosefinSans-Italic-lf-ts1--base.tfm \
tex-JosefinSans-Italic-lf-ts1.tfm \
tex-JosefinSans-Italic-lf-ts1.vf \
tex-JosefinSans-Light-lf-ly1--base.tfm \
tex-JosefinSans-Light-lf-ly1.tfm \
tex-JosefinSans-Light-lf-ly1.vf \
tex-JosefinSans-Light-lf-ot1.tfm \
tex-JosefinSans-Light-lf-t1--base.tfm \
tex-JosefinSans-Light-lf-t1.tfm \
tex-JosefinSans-Light-lf-t1.vf \
tex-JosefinSans-Light-lf-ts1--base.tfm \
tex-JosefinSans-Light-lf-ts1.tfm \
tex-JosefinSans-Light-lf-ts1.vf \
tex-JosefinSans-LightItalic-lf-ly1--base.tfm \
tex-JosefinSans-LightItalic-lf-ly1.tfm \
tex-JosefinSans-LightItalic-lf-ly1.vf \
tex-JosefinSans-LightItalic-lf-ot1.tfm \
tex-JosefinSans-LightItalic-lf-t1--base.tfm \
tex-JosefinSans-LightItalic-lf-t1.tfm \
tex-JosefinSans-LightItalic-lf-t1.vf \
tex-JosefinSans-LightItalic-lf-ts1--base.tfm \
tex-JosefinSans-LightItalic-lf-ts1.tfm \
tex-JosefinSans-LightItalic-lf-ts1.vf \
tex-JosefinSans-Medium-lf-ly1--base.tfm \
tex-JosefinSans-Medium-lf-ly1.tfm \
tex-JosefinSans-Medium-lf-ly1.vf \
tex-JosefinSans-Medium-lf-ot1.tfm \
tex-JosefinSans-Medium-lf-t1--base.tfm \
tex-JosefinSans-Medium-lf-t1.tfm \
tex-JosefinSans-Medium-lf-t1.vf \
tex-JosefinSans-Medium-lf-ts1--base.tfm \
tex-JosefinSans-Medium-lf-ts1.tfm \
tex-JosefinSans-Medium-lf-ts1.vf \
tex-JosefinSans-MediumItalic-lf-ly1--base.tfm \
tex-JosefinSans-MediumItalic-lf-ly1.tfm \
tex-JosefinSans-MediumItalic-lf-ly1.vf \
tex-JosefinSans-MediumItalic-lf-ot1.tfm \
tex-JosefinSans-MediumItalic-lf-t1--base.tfm \
tex-JosefinSans-MediumItalic-lf-t1.tfm \
tex-JosefinSans-MediumItalic-lf-t1.vf \
tex-JosefinSans-MediumItalic-lf-ts1--base.tfm \
tex-JosefinSans-MediumItalic-lf-ts1.tfm \
tex-JosefinSans-MediumItalic-lf-ts1.vf \
tex-JosefinSans-Regular-lf-ly1--base.tfm \
tex-JosefinSans-Regular-lf-ly1.tfm \
tex-JosefinSans-Regular-lf-ly1.vf \
tex-JosefinSans-Regular-lf-ot1.tfm \
tex-JosefinSans-Regular-lf-t1--base.tfm \
tex-JosefinSans-Regular-lf-t1.tfm \
tex-JosefinSans-Regular-lf-t1.vf \
tex-JosefinSans-Regular-lf-ts1--base.tfm \
tex-JosefinSans-Regular-lf-ts1.tfm \
tex-JosefinSans-Regular-lf-ts1.vf \
tex-JosefinSans-SemiBold-lf-ly1--base.tfm \
tex-JosefinSans-SemiBold-lf-ly1.tfm \
tex-JosefinSans-SemiBold-lf-ly1.vf \
tex-JosefinSans-SemiBold-lf-ot1.tfm \
tex-JosefinSans-SemiBold-lf-t1--base.tfm \
tex-JosefinSans-SemiBold-lf-t1.tfm \
tex-JosefinSans-SemiBold-lf-t1.vf \
tex-JosefinSans-SemiBold-lf-ts1--base.tfm \
tex-JosefinSans-SemiBold-lf-ts1.tfm \
tex-JosefinSans-SemiBold-lf-ts1.vf \
tex-JosefinSans-SemiBoldItalic-lf-ly1--base.tfm \
tex-JosefinSans-SemiBoldItalic-lf-ly1.tfm \
tex-JosefinSans-SemiBoldItalic-lf-ly1.vf \
tex-JosefinSans-SemiBoldItalic-lf-ot1.tfm \
tex-JosefinSans-SemiBoldItalic-lf-t1--base.tfm \
tex-JosefinSans-SemiBoldItalic-lf-t1.tfm \
tex-JosefinSans-SemiBoldItalic-lf-t1.vf \
tex-JosefinSans-SemiBoldItalic-lf-ts1--base.tfm \
tex-JosefinSans-SemiBoldItalic-lf-ts1.tfm \
tex-JosefinSans-SemiBoldItalic-lf-ts1.vf \
tex-JosefinSans-Thin-lf-ly1--base.tfm \
tex-JosefinSans-Thin-lf-ly1.tfm \
tex-JosefinSans-Thin-lf-ly1.vf \
tex-JosefinSans-Thin-lf-ot1.tfm \
tex-JosefinSans-Thin-lf-t1--base.tfm \
tex-JosefinSans-Thin-lf-t1.tfm \
tex-JosefinSans-Thin-lf-t1.vf \
tex-JosefinSans-Thin-lf-ts1--base.tfm \
tex-JosefinSans-Thin-lf-ts1.tfm \
tex-JosefinSans-Thin-lf-ts1.vf \
tex-JosefinSans-ThinItalic-lf-ly1--base.tfm \
tex-JosefinSans-ThinItalic-lf-ly1.tfm \
tex-JosefinSans-ThinItalic-lf-ly1.vf \
tex-JosefinSans-ThinItalic-lf-ot1.tfm \
tex-JosefinSans-ThinItalic-lf-t1--base.tfm \
tex-JosefinSans-ThinItalic-lf-t1.tfm \
tex-JosefinSans-ThinItalic-lf-t1.vf \
tex-JosefinSans-ThinItalic-lf-ts1--base.tfm \
tex-JosefinSans-ThinItalic-lf-ts1.tfm \
tex-JosefinSans-ThinItalic-lf-ts1.vf \
tex-LY1JosefinSans-LF.fd \
tex-OT1JosefinSans-LF.fd \
tex-T1JosefinSans-LF.fd \
tex-TS1JosefinSans-LF.fd \
tex-jfn-2p3jiy.enc \
tex-jfn-adz5lu.enc \
tex-jfn-d2anrk.enc \
tex-jfn-ehgfhq.enc \
tex-jfn-hf4msv.enc \
tex-jfn-ti63qo.enc \
tex-jfn-umrhwx.enc \
tex-jfn-w4rwtq.enc \
tex-josefin.map \
tex-josefin.sty \
texlive-josefin"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontaxes.sty \
tex-fontspec.sty \
tex-ifluatex.sty \
tex-ifxetex.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-filesystem \
texlive-josefin-fonts \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
