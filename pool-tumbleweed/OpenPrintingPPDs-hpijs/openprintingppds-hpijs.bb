SUMMARY = "PPD files from OpenPrinting.org which use the hpijs driver"
DESCRIPTION = "PPD files for non-PostScript printers \
which use the Ghostscript IJS driver \
/usr/bin/hpijs from HPLIP."
LICENSE = "GPL-2.0-or-later & MIT"

PV = "4.0.0.2"

RPM_NAME = "OpenPrintingPPDs-hpijs-4.0.0.2-6.9.noarch.rpm"
RPM_HASH = "92c813e1c90db5d5185f957b295bd46419113c02d0c1c6247b27c7a4c14037020cdbc672045f1b8b6c134bb05fe6f21a77d1fca082448fdb86dbbd7b426eb8b5"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "OpenPrintingPPDs-hpijs \
postscriptdriver-apollo;apollo-p-2200; \
postscriptdriver-brother;brother-hl-1450-series; \
postscriptdriver-brother;brother-hl-1470n-series; \
postscriptdriver-brother;brother-hl-2600cn-series; \
postscriptdriver-brother;brother-hl-3450cn-series; \
postscriptdriver-brother;brother-hl-5050-series; \
postscriptdriver-brother;brother-hl-5070n-series; \
postscriptdriver-brother;brother-hl-5150d-series; \
postscriptdriver-brother;brother-hl-5170dn-series; \
postscriptdriver-brother;hl-1050-series; \
postscriptdriver-brother;hl-1070-series; \
postscriptdriver-brother;hl-1250-series; \
postscriptdriver-brother;hl-1430-series; \
postscriptdriver-brother;hl-1440-series; \
postscriptdriver-brother;hl-2030-series; \
postscriptdriver-brother;hl-2040-series; \
postscriptdriver-brother;hl-2140-series; \
postscriptdriver-brother;hl-5040-series; \
postscriptdriver-brother;hl-5140-series; \
postscriptdriver-canon;lbp-1000; \
postscriptdriver-epson;al-c1900-ps3; \
postscriptdriver-epson;al-c2000-ps3; \
postscriptdriver-epson;al-c4000-ps3; \
postscriptdriver-epson;al-c8600-ps3; \
postscriptdriver-epson;epl-5700; \
postscriptdriver-epson;epl-5900-ps3; \
postscriptdriver-epson;epl-6100-ps3; \
postscriptdriver-epson;epl-n1600; \
postscriptdriver-ibm;infoprint; \
postscriptdriver-kyocera-mita;km-1510; \
postscriptdriver-kyocera-mita;km-1530; \
postscriptdriver-kyocera-mita;km-1810; \
postscriptdriver-kyocera-mita;km-2030; \
postscriptdriver-kyocera-mita;km-2530; \
postscriptdriver-kyocera-mita;km-3530; \
postscriptdriver-kyocera-mita;km-4230/5230; \
postscriptdriver-kyocera-mita;km-4230; \
postscriptdriver-kyocera-mita;km-4530; \
postscriptdriver-kyocera-mita;km-5230; \
postscriptdriver-kyocera-mita;km-5530; \
postscriptdriver-kyocera-mita;km-6230; \
postscriptdriver-kyocera-mita;km-c2630; \
postscriptdriver-kyocera-mita;km-c830; \
postscriptdriver-kyocera-mita;km-c850; \
postscriptdriver-kyocera-mita;kyocera-mita-ci-1100; \
postscriptdriver-kyocera-mita;kyocera-mita-cs-1815; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-1000+; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-1010; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-1018mfp; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-1050; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-1800+; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-1800; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-1900; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-1920; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-3800; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-3820n; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-3830n; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-6020; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-6026; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-6750; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-8000c; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-9100dn; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-9500dn; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-c5016n; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-c8008n; \
postscriptdriver-kyocera-mita;kyocera-mita-km-1815; \
postscriptdriver-kyocera;fs-1020d; \
postscriptdriver-kyocera;fs-1600+; \
postscriptdriver-kyocera;fs-1600; \
postscriptdriver-kyocera;fs-3600+; \
postscriptdriver-kyocera;fs-3600; \
postscriptdriver-kyocera;fs-600; \
postscriptdriver-kyocera;fs-6500; \
postscriptdriver-kyocera;kyocera-cs-250ci; \
postscriptdriver-kyocera;kyocera-cs-300ci; \
postscriptdriver-kyocera;kyocera-cs-3050ci; \
postscriptdriver-kyocera;kyocera-cs-3550ci; \
postscriptdriver-kyocera;kyocera-cs-400ci; \
postscriptdriver-kyocera;kyocera-cs-500ci; \
postscriptdriver-kyocera;kyocera-cs-c2525e; \
postscriptdriver-kyocera;kyocera-cs-c3225e; \
postscriptdriver-kyocera;kyocera-cs-c3232e; \
postscriptdriver-kyocera;kyocera-cs-c4035e; \
postscriptdriver-kyocera;kyocera-fs-1000; \
postscriptdriver-kyocera;kyocera-fs-1030d; \
postscriptdriver-kyocera;kyocera-fs-1118mfp; \
postscriptdriver-kyocera;kyocera-fs-1200; \
postscriptdriver-kyocera;kyocera-fs-1700+; \
postscriptdriver-kyocera;kyocera-fs-1700; \
postscriptdriver-kyocera;kyocera-fs-1714m; \
postscriptdriver-kyocera;kyocera-fs-1750; \
postscriptdriver-kyocera;kyocera-fs-2000d; \
postscriptdriver-kyocera;kyocera-fs-2100d; \
postscriptdriver-kyocera;kyocera-fs-2100dn; \
postscriptdriver-kyocera;kyocera-fs-3700+; \
postscriptdriver-kyocera;kyocera-fs-3700; \
postscriptdriver-kyocera;kyocera-fs-3718m; \
postscriptdriver-kyocera;kyocera-fs-3750; \
postscriptdriver-kyocera;kyocera-fs-3900dn; \
postscriptdriver-kyocera;kyocera-fs-4000dn; \
postscriptdriver-kyocera;kyocera-fs-4100dn; \
postscriptdriver-kyocera;kyocera-fs-4200dn; \
postscriptdriver-kyocera;kyocera-fs-4300dn; \
postscriptdriver-kyocera;kyocera-fs-5800c; \
postscriptdriver-kyocera;kyocera-fs-5900c; \
postscriptdriver-kyocera;kyocera-fs-600; \
postscriptdriver-kyocera;kyocera-fs-6300; \
postscriptdriver-kyocera;kyocera-fs-6500+; \
postscriptdriver-kyocera;kyocera-fs-6700; \
postscriptdriver-kyocera;kyocera-fs-680; \
postscriptdriver-kyocera;kyocera-fs-6900; \
postscriptdriver-kyocera;kyocera-fs-6950dn; \
postscriptdriver-kyocera;kyocera-fs-7000+; \
postscriptdriver-kyocera;kyocera-fs-7000; \
postscriptdriver-kyocera;kyocera-fs-7028m; \
postscriptdriver-kyocera;kyocera-fs-800; \
postscriptdriver-kyocera;kyocera-fs-9000; \
postscriptdriver-kyocera;kyocera-fs-9130dn; \
postscriptdriver-kyocera;kyocera-fs-920; \
postscriptdriver-kyocera;kyocera-fs-9530dn; \
postscriptdriver-kyocera;kyocera-fs-c5015n; \
postscriptdriver-kyocera;kyocera-fs-c5020n; \
postscriptdriver-kyocera;kyocera-fs-c5025n; \
postscriptdriver-kyocera;kyocera-fs-c5030n; \
postscriptdriver-kyocera;kyocera-fs-c5100dn; \
postscriptdriver-kyocera;kyocera-fs-c5200dn; \
postscriptdriver-kyocera;kyocera-fs-c5300dn; \
postscriptdriver-kyocera;kyocera-fs-c5350dn; \
postscriptdriver-kyocera;kyocera-fs-c5400dn; \
postscriptdriver-kyocera;kyocera-fs-c8100dn+; \
postscriptdriver-kyocera;kyocera-fs-c8100dn; \
postscriptdriver-kyocera;kyocera-km-1820; \
postscriptdriver-kyocera;kyocera-km-3050; \
postscriptdriver-kyocera;kyocera-km-4050; \
postscriptdriver-kyocera;kyocera-km-5050; \
postscriptdriver-kyocera;kyocera-km-6030; \
postscriptdriver-kyocera;kyocera-km-8030; \
postscriptdriver-kyocera;kyocera-km-c2520; \
postscriptdriver-kyocera;kyocera-km-c2525e; \
postscriptdriver-kyocera;kyocera-km-c3225; \
postscriptdriver-kyocera;kyocera-km-c3225e; \
postscriptdriver-kyocera;kyocera-km-c3232; \
postscriptdriver-kyocera;kyocera-km-c3232e; \
postscriptdriver-kyocera;kyocera-km-c4035e; \
postscriptdriver-kyocera;kyocera-taskalfa-250ci; \
postscriptdriver-kyocera;kyocera-taskalfa-300ci; \
postscriptdriver-kyocera;kyocera-taskalfa-400ci; \
postscriptdriver-kyocera;kyocera-taskalfa-500ci; \
postscriptdriver-lexmark-international;ibm-3112-page-printer; \
postscriptdriver-lexmark-international;lexmark-e120; \
postscriptdriver-lexmark-international;lexmark-e120n; \
postscriptdriver-lexmark-international;lexmark-e230; \
postscriptdriver-lexmark-international;lexmark-e321; \
postscriptdriver-lexmark-international;lexmark-optra-e+-laserprinter; \
postscriptdriver-minolta;pagepro---6e; \
postscriptdriver-minolta;pagepro-1100; \
postscriptdriver-minolta;pagepro-6; \
postscriptdriver-minolta;pagepro-8; \
postscriptdriver-nec;superscript-1800; \
postscriptdriver-oki-data-corp;b410; \
postscriptdriver-oki-data-corp;okidata-okipage-6e; \
postscriptdriver-oki-data-corp;okidata-okipage-6ex; \
postscriptdriver-oki-data-corp;okipage-10e; \
postscriptdriver-oki-data-corp;okipage-10ex; \
postscriptdriver-oki-data-corp;okipage-14ex; \
postscriptdriver-oki-data-corp;okipage-8p; \
postscriptdriver-oki;c5300; \
postscriptdriver-oki;c5400; \
postscriptdriver-oki;c7300; \
postscriptdriver-oki;c9200; \
postscriptdriver-oki;c9400; \
postscriptdriver-samsung;6050; \
postscriptdriver-samsung;ml-1450; \
postscriptdriver-samsung;ml-1650; \
postscriptdriver-samsung;ml-2150-series; \
postscriptdriver-samsung;ml-2550-series; \
postscriptdriver-samsung;ml-2570-series; \
postscriptdriver-samsung;ml-6060; \
postscriptdriver-sharp;ar-160/200-series; \
postscriptdriver-sharp;sharp-ar-nb2; \
postscriptdriver-sharp;sharp-ar-p19; \
postscriptdriver-sharp;sharp-ar-p20; \
postscriptdriver-sharp;sharp-ar-pk4; \
postscriptdriver-sony;all-in-one-ijp-v100; \
postscriptdriver-tektronix;phaser-750dp; \
postscriptdriver-tektronix;phaser-750dx; \
postscriptdriver-tektronix;phaser-750n; \
postscriptdriver-tektronix;phaser-750p; \
postscriptdriver-xerox;docuprint-p8e; \
postscriptdriver-xerox;docuprint; \
postscriptdriver-xerox;phaser-4400b; \
postscriptdriver-xerox;phaser-4400dt; \
postscriptdriver-xerox;phaser-4400dx; \
postscriptdriver-xerox;phaser-4400n; \
postscriptdriver-xerox;phaser-4500b; \
postscriptdriver-xerox;phaser-4500dt; \
postscriptdriver-xerox;phaser-4500dx; \
postscriptdriver-xerox;phaser-4500n; \
postscriptdriver-xerox;phaser-4510b; \
postscriptdriver-xerox;phaser-4510dt; \
postscriptdriver-xerox;phaser-4510dx; \
postscriptdriver-xerox;phaser-4510n; \
postscriptdriver-xerox;phaser-5500b; \
postscriptdriver-xerox;phaser-5500dn; \
postscriptdriver-xerox;phaser-5500dt; \
postscriptdriver-xerox;phaser-5500dx; \
postscriptdriver-xerox;phaser-5500n; \
postscriptdriver-xerox;phaser-6130n; \
postscriptdriver-xerox;phaser-6180dn; \
postscriptdriver-xerox;phaser-6180mfp-d; \
postscriptdriver-xerox;phaser-6200b; \
postscriptdriver-xerox;phaser-6200dp; \
postscriptdriver-xerox;phaser-6200dx; \
postscriptdriver-xerox;phaser-6200n; \
postscriptdriver-xerox;phaser-6250b; \
postscriptdriver-xerox;phaser-6250dp; \
postscriptdriver-xerox;phaser-6250dt; \
postscriptdriver-xerox;phaser-6250dx; \
postscriptdriver-xerox;phaser-6250n; \
postscriptdriver-xerox;phaser-6300dn; \
postscriptdriver-xerox;phaser-6300n; \
postscriptdriver-xerox;phaser-6350dp; \
postscriptdriver-xerox;phaser-6350dt; \
postscriptdriver-xerox;phaser-6350dx; \
postscriptdriver-xerox;phaser-6360dn; \
postscriptdriver-xerox;phaser-6360dx; \
postscriptdriver-xerox;phaser-7300b; \
postscriptdriver-xerox;phaser-7300dn; \
postscriptdriver-xerox;phaser-7300dt; \
postscriptdriver-xerox;phaser-7300dx; \
postscriptdriver-xerox;phaser-7300n; \
postscriptdriver-xerox;phaser-7400dn; \
postscriptdriver-xerox;phaser-7400dt; \
postscriptdriver-xerox;phaser-7400dx; \
postscriptdriver-xerox;phaser-7400dxf; \
postscriptdriver-xerox;phaser-7400n; \
postscriptdriver-xerox;phaser-7700dn; \
postscriptdriver-xerox;phaser-7700dx; \
postscriptdriver-xerox;phaser-7700gx; \
postscriptdriver-xerox;phaser-7750b; \
postscriptdriver-xerox;phaser-7750dn; \
postscriptdriver-xerox;phaser-7750dxf; \
postscriptdriver-xerox;phaser-7750gx; \
postscriptdriver-xerox;phaser-7760dn; \
postscriptdriver-xerox;phaser-7760dx; \
postscriptdriver-xerox;phaser-7760gx; \
postscriptdriver-xerox;phaser-8400b; \
postscriptdriver-xerox;phaser-8400bd; \
postscriptdriver-xerox;phaser-8400dp; \
postscriptdriver-xerox;phaser-8400dx; \
postscriptdriver-xerox;phaser-8400n; \
postscriptdriver-xerox;phaser-8500dn; \
postscriptdriver-xerox;phaser-8500n; \
postscriptdriver-xerox;phaser-8550dp; \
postscriptdriver-xerox;phaser-8550dt; \
postscriptdriver-xerox;phaser-8550dx; \
postscriptdriver-xerox;phaser-8560dn; \
postscriptdriver-xerox;phaser-8860; \
postscriptdriver-xerox;workcentre-c2424; \
postscriptdriver-xerox;xerox-phaser-2135;"

RDEPENDS:${PN} += "foomatic-filters \
ghostscript-library \
hplip-hpijs"

inherit rpm
