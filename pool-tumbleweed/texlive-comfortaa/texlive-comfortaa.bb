SUMMARY = "Sans serif font, with LaTeX support"
DESCRIPTION = "Comfortaa is a sans-serif font, comfortable in every aspect, \
designed by Johan Aakerlund. The font, which includes three \
weights (thin, regular and bold), is available on Johan's \
deviantArt web page as TrueType files under the Open Font \
License version 1.1. This package provides support for this \
font in LaTeX, and includes both the TrueType fonts, and \
conversions to Adobe Type 1 format."
LICENSE = "OFL-1.1"

PV = "2023.209.3.2svn54512"

RPM_NAME = "texlive-comfortaa-2023.209.3.2svn54512-54.1.noarch.rpm"
RPM_HASH = "45aa501f7d02d82c64b238f4a8cbd1268bff30800930c0660664847fa011908b27a638c80c54f853802870437184d4b1b0c2e821301c58a7b7ead73bb62a537b"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-Comfortaa-Bold-LGR--base.tfm \
tex-Comfortaa-Bold-LGR-Slanted--base.tfm \
tex-Comfortaa-Bold-LGR-Slanted.tfm \
tex-Comfortaa-Bold-LGR-Slanted.vf \
tex-Comfortaa-Bold-LGR.tfm \
tex-Comfortaa-Bold-LGR.vf \
tex-Comfortaa-Bold-OT1--base.tfm \
tex-Comfortaa-Bold-OT1-Slanted--base.tfm \
tex-Comfortaa-Bold-OT1-Slanted.tfm \
tex-Comfortaa-Bold-OT1-Slanted.vf \
tex-Comfortaa-Bold-OT1.tfm \
tex-Comfortaa-Bold-OT1.vf \
tex-Comfortaa-Bold-T1--base.tfm \
tex-Comfortaa-Bold-T1-Slanted--base.tfm \
tex-Comfortaa-Bold-T1-Slanted.tfm \
tex-Comfortaa-Bold-T1-Slanted.vf \
tex-Comfortaa-Bold-T1.tfm \
tex-Comfortaa-Bold-T1.vf \
tex-Comfortaa-Bold-T2A--base.tfm \
tex-Comfortaa-Bold-T2A-Slanted--base.tfm \
tex-Comfortaa-Bold-T2A-Slanted.tfm \
tex-Comfortaa-Bold-T2A-Slanted.vf \
tex-Comfortaa-Bold-T2A.tfm \
tex-Comfortaa-Bold-T2A.vf \
tex-Comfortaa-Bold-T2B--base.tfm \
tex-Comfortaa-Bold-T2B-Slanted--base.tfm \
tex-Comfortaa-Bold-T2B-Slanted.tfm \
tex-Comfortaa-Bold-T2B-Slanted.vf \
tex-Comfortaa-Bold-T2B.tfm \
tex-Comfortaa-Bold-T2B.vf \
tex-Comfortaa-Bold-T2C--base.tfm \
tex-Comfortaa-Bold-T2C-Slanted--base.tfm \
tex-Comfortaa-Bold-T2C-Slanted.tfm \
tex-Comfortaa-Bold-T2C-Slanted.vf \
tex-Comfortaa-Bold-T2C.tfm \
tex-Comfortaa-Bold-T2C.vf \
tex-Comfortaa-Bold-TS1--base.tfm \
tex-Comfortaa-Bold-TS1-Slanted--base.tfm \
tex-Comfortaa-Bold-TS1-Slanted.tfm \
tex-Comfortaa-Bold-TS1-Slanted.vf \
tex-Comfortaa-Bold-TS1.tfm \
tex-Comfortaa-Bold-TS1.vf \
tex-Comfortaa-Bold-X2--base.tfm \
tex-Comfortaa-Bold-X2-Slanted--base.tfm \
tex-Comfortaa-Bold-X2-Slanted.tfm \
tex-Comfortaa-Bold-X2-Slanted.vf \
tex-Comfortaa-Bold-X2.tfm \
tex-Comfortaa-Bold-X2.vf \
tex-Comfortaa-Light-LGR--base.tfm \
tex-Comfortaa-Light-LGR-Slanted--base.tfm \
tex-Comfortaa-Light-LGR-Slanted.tfm \
tex-Comfortaa-Light-LGR-Slanted.vf \
tex-Comfortaa-Light-LGR.tfm \
tex-Comfortaa-Light-LGR.vf \
tex-Comfortaa-Light-OT1--base.tfm \
tex-Comfortaa-Light-OT1-Slanted--base.tfm \
tex-Comfortaa-Light-OT1-Slanted.tfm \
tex-Comfortaa-Light-OT1-Slanted.vf \
tex-Comfortaa-Light-OT1.tfm \
tex-Comfortaa-Light-OT1.vf \
tex-Comfortaa-Light-T1--base.tfm \
tex-Comfortaa-Light-T1-Slanted--base.tfm \
tex-Comfortaa-Light-T1-Slanted.tfm \
tex-Comfortaa-Light-T1-Slanted.vf \
tex-Comfortaa-Light-T1.tfm \
tex-Comfortaa-Light-T1.vf \
tex-Comfortaa-Light-T2A--base.tfm \
tex-Comfortaa-Light-T2A-Slanted--base.tfm \
tex-Comfortaa-Light-T2A-Slanted.tfm \
tex-Comfortaa-Light-T2A-Slanted.vf \
tex-Comfortaa-Light-T2A.tfm \
tex-Comfortaa-Light-T2A.vf \
tex-Comfortaa-Light-T2B--base.tfm \
tex-Comfortaa-Light-T2B-Slanted--base.tfm \
tex-Comfortaa-Light-T2B-Slanted.tfm \
tex-Comfortaa-Light-T2B-Slanted.vf \
tex-Comfortaa-Light-T2B.tfm \
tex-Comfortaa-Light-T2B.vf \
tex-Comfortaa-Light-T2C--base.tfm \
tex-Comfortaa-Light-T2C-Slanted--base.tfm \
tex-Comfortaa-Light-T2C-Slanted.tfm \
tex-Comfortaa-Light-T2C-Slanted.vf \
tex-Comfortaa-Light-T2C.tfm \
tex-Comfortaa-Light-T2C.vf \
tex-Comfortaa-Light-TS1--base.tfm \
tex-Comfortaa-Light-TS1-Slanted--base.tfm \
tex-Comfortaa-Light-TS1-Slanted.tfm \
tex-Comfortaa-Light-TS1-Slanted.vf \
tex-Comfortaa-Light-TS1.tfm \
tex-Comfortaa-Light-TS1.vf \
tex-Comfortaa-Light-X2--base.tfm \
tex-Comfortaa-Light-X2-Slanted--base.tfm \
tex-Comfortaa-Light-X2-Slanted.tfm \
tex-Comfortaa-Light-X2-Slanted.vf \
tex-Comfortaa-Light-X2.tfm \
tex-Comfortaa-Light-X2.vf \
tex-Comfortaa-Regular-LGR--base.tfm \
tex-Comfortaa-Regular-LGR-Slanted--base.tfm \
tex-Comfortaa-Regular-LGR-Slanted.tfm \
tex-Comfortaa-Regular-LGR-Slanted.vf \
tex-Comfortaa-Regular-LGR.tfm \
tex-Comfortaa-Regular-LGR.vf \
tex-Comfortaa-Regular-OT1--base.tfm \
tex-Comfortaa-Regular-OT1-Slanted--base.tfm \
tex-Comfortaa-Regular-OT1-Slanted.tfm \
tex-Comfortaa-Regular-OT1-Slanted.vf \
tex-Comfortaa-Regular-OT1.tfm \
tex-Comfortaa-Regular-OT1.vf \
tex-Comfortaa-Regular-T1--base.tfm \
tex-Comfortaa-Regular-T1-Slanted--base.tfm \
tex-Comfortaa-Regular-T1-Slanted.tfm \
tex-Comfortaa-Regular-T1-Slanted.vf \
tex-Comfortaa-Regular-T1.tfm \
tex-Comfortaa-Regular-T1.vf \
tex-Comfortaa-Regular-T2A--base.tfm \
tex-Comfortaa-Regular-T2A-Slanted--base.tfm \
tex-Comfortaa-Regular-T2A-Slanted.tfm \
tex-Comfortaa-Regular-T2A-Slanted.vf \
tex-Comfortaa-Regular-T2A.tfm \
tex-Comfortaa-Regular-T2A.vf \
tex-Comfortaa-Regular-T2B--base.tfm \
tex-Comfortaa-Regular-T2B-Slanted--base.tfm \
tex-Comfortaa-Regular-T2B-Slanted.tfm \
tex-Comfortaa-Regular-T2B-Slanted.vf \
tex-Comfortaa-Regular-T2B.tfm \
tex-Comfortaa-Regular-T2B.vf \
tex-Comfortaa-Regular-T2C--base.tfm \
tex-Comfortaa-Regular-T2C-Slanted--base.tfm \
tex-Comfortaa-Regular-T2C-Slanted.tfm \
tex-Comfortaa-Regular-T2C-Slanted.vf \
tex-Comfortaa-Regular-T2C.tfm \
tex-Comfortaa-Regular-T2C.vf \
tex-Comfortaa-Regular-TS1--base.tfm \
tex-Comfortaa-Regular-TS1-Slanted--base.tfm \
tex-Comfortaa-Regular-TS1-Slanted.tfm \
tex-Comfortaa-Regular-TS1-Slanted.vf \
tex-Comfortaa-Regular-TS1.tfm \
tex-Comfortaa-Regular-TS1.vf \
tex-Comfortaa-Regular-X2--base.tfm \
tex-Comfortaa-Regular-X2-Slanted--base.tfm \
tex-Comfortaa-Regular-X2-Slanted.tfm \
tex-Comfortaa-Regular-X2-Slanted.vf \
tex-Comfortaa-Regular-X2.tfm \
tex-Comfortaa-Regular-X2.vf \
tex-LGRcomfortaa.fd \
tex-OT1comfortaa.fd \
tex-T1comfortaa.fd \
tex-T2Acomfortaa.fd \
tex-T2Bcomfortaa.fd \
tex-T2Ccomfortaa.fd \
tex-TS1comfortaa.fd \
tex-X2comfortaa.fd \
tex-a-64c3ob.enc \
tex-a-bh4242.enc \
tex-a-e4iqkg.enc \
tex-a-m2qr2b.enc \
tex-a-n5moke.enc \
tex-a-ovobyi.enc \
tex-a-q4mh67.enc \
tex-a-qfuw5x.enc \
tex-a-xu66hj.enc \
tex-comfortaa.map \
tex-comfortaa.sty \
texlive-comfortaa"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontspec.sty \
tex-ifluatex.sty \
tex-ifxetex.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-comfortaa-fonts \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
