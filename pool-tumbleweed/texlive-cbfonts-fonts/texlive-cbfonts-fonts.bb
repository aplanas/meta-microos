SUMMARY = "Severed fonts for texlive-cbfonts"
DESCRIPTION = "The  separated fonts package for texlive-cbfonts"
LICENSE = "LPPL-1.0"

PV = "2023.201.svn54080"

RPM_NAME = "texlive-cbfonts-fonts-2023.201.svn54080-52.1.noarch.rpm"
RPM_HASH = "8fa25f86be083cd20fac796e2639d3dd6c4a83563603d140a42b95accf3e2cbf110e7053eb70ebd3af33a45c9d545490f5c5c7877fef6a42019cf8aded5590d7"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "font(glic0700) \
font(glic0800) \
font(glic1000) \
font(glic1200) \
font(glic1382) \
font(glic1659) \
font(glic1991) \
font(glic2389) \
font(glic2866) \
font(glic3440) \
font(glic4128) \
font(glii0700) \
font(glii0800) \
font(glii1000) \
font(glii1200) \
font(glii1382) \
font(glii1659) \
font(glii1991) \
font(glii2389) \
font(glii2866) \
font(glii3440) \
font(glii4128) \
font(glin0700) \
font(glin0800) \
font(glin1000) \
font(glin1200) \
font(glin1382) \
font(glin1659) \
font(glin1991) \
font(glin2389) \
font(glin2866) \
font(glin3440) \
font(glin4128) \
font(glio0700) \
font(glio0800) \
font(glio1000) \
font(glio1200) \
font(glio1382) \
font(glio1659) \
font(glio1991) \
font(glio2389) \
font(glio2866) \
font(glio3440) \
font(glio4128) \
font(gliu0700) \
font(gliu0800) \
font(gliu1000) \
font(gliu1200) \
font(gliu1382) \
font(gliu1659) \
font(gliu1991) \
font(gliu2389) \
font(gliu2866) \
font(gliu3440) \
font(gliu4128) \
font(gljc0700) \
font(gljc0800) \
font(gljc1000) \
font(gljc1200) \
font(gljc1382) \
font(gljc1659) \
font(gljc1991) \
font(gljc2389) \
font(gljc2866) \
font(gljc3440) \
font(gljc4128) \
font(gljn0700) \
font(gljn0800) \
font(gljn1000) \
font(gljn1200) \
font(gljn1382) \
font(gljn1659) \
font(gljn1991) \
font(gljn2389) \
font(gljn2866) \
font(gljn3440) \
font(gljn4128) \
font(gljo0700) \
font(gljo0800) \
font(gljo1000) \
font(gljo1200) \
font(gljo1382) \
font(gljo1659) \
font(gljo1991) \
font(gljo2389) \
font(gljo2866) \
font(gljo3440) \
font(gljo4128) \
font(glmc0700) \
font(glmc0800) \
font(glmc1000) \
font(glmc1200) \
font(glmc1382) \
font(glmc1659) \
font(glmc1991) \
font(glmc2389) \
font(glmc2866) \
font(glmc3440) \
font(glmc4128) \
font(glmi0700) \
font(glmi0800) \
font(glmi1000) \
font(glmi1200) \
font(glmi1382) \
font(glmi1659) \
font(glmi1991) \
font(glmi2389) \
font(glmi2866) \
font(glmi3440) \
font(glmi4128) \
font(glmn0700) \
font(glmn0800) \
font(glmn1000) \
font(glmn1200) \
font(glmn1382) \
font(glmn1659) \
font(glmn1991) \
font(glmn2389) \
font(glmn2866) \
font(glmn3440) \
font(glmn4128) \
font(glmo0700) \
font(glmo0800) \
font(glmo1000) \
font(glmo1200) \
font(glmo1382) \
font(glmo1659) \
font(glmo1991) \
font(glmo2389) \
font(glmo2866) \
font(glmo3440) \
font(glmo4128) \
font(glmu0700) \
font(glmu0800) \
font(glmu1000) \
font(glmu1200) \
font(glmu1382) \
font(glmu1659) \
font(glmu1991) \
font(glmu2389) \
font(glmu2866) \
font(glmu3440) \
font(glmu4128) \
font(gltc0700) \
font(gltc0800) \
font(gltc1000) \
font(gltc1200) \
font(gltc1382) \
font(gltc1659) \
font(gltc1991) \
font(gltc2389) \
font(gltc2866) \
font(gltc3440) \
font(gltc4128) \
font(gltn0700) \
font(gltn0800) \
font(gltn1000) \
font(gltn1200) \
font(gltn1382) \
font(gltn1659) \
font(gltn1991) \
font(gltn2389) \
font(gltn2866) \
font(gltn3440) \
font(gltn4128) \
font(glto0700) \
font(glto0800) \
font(glto1000) \
font(glto1200) \
font(glto1382) \
font(glto1659) \
font(glto1991) \
font(glto2389) \
font(glto2866) \
font(glto3440) \
font(glto4128) \
font(glwc0700) \
font(glwc0800) \
font(glwc1000) \
font(glwc1200) \
font(glwc1382) \
font(glwc1659) \
font(glwc1991) \
font(glwc2389) \
font(glwc2866) \
font(glwc3440) \
font(glwc4128) \
font(glwi0700) \
font(glwi0800) \
font(glwi1000) \
font(glwi1200) \
font(glwi1382) \
font(glwi1659) \
font(glwi1991) \
font(glwi2389) \
font(glwi2866) \
font(glwi3440) \
font(glwi4128) \
font(glwn0700) \
font(glwn0800) \
font(glwn1000) \
font(glwn1200) \
font(glwn1382) \
font(glwn1659) \
font(glwn1991) \
font(glwn2389) \
font(glwn2866) \
font(glwn3440) \
font(glwn4128) \
font(glwo0700) \
font(glwo0800) \
font(glwo1000) \
font(glwo1200) \
font(glwo1382) \
font(glwo1659) \
font(glwo1991) \
font(glwo2389) \
font(glwo2866) \
font(glwo3440) \
font(glwo4128) \
font(glwu0700) \
font(glwu0800) \
font(glwu1000) \
font(glwu1200) \
font(glwu1382) \
font(glwu1659) \
font(glwu1991) \
font(glwu2389) \
font(glwu2866) \
font(glwu3440) \
font(glwu4128) \
font(glxc0700) \
font(glxc0800) \
font(glxc1000) \
font(glxc1200) \
font(glxc1382) \
font(glxc1659) \
font(glxc1991) \
font(glxc2389) \
font(glxc2866) \
font(glxc3440) \
font(glxc4128) \
font(glxi0700) \
font(glxi0800) \
font(glxi1000) \
font(glxi1200) \
font(glxi1382) \
font(glxi1659) \
font(glxi1991) \
font(glxi2389) \
font(glxi2866) \
font(glxi3440) \
font(glxi4128) \
font(glxn0700) \
font(glxn0800) \
font(glxn1000) \
font(glxn1200) \
font(glxn1382) \
font(glxn1659) \
font(glxn1991) \
font(glxn2389) \
font(glxn2866) \
font(glxn3440) \
font(glxn4128) \
font(glxo0700) \
font(glxo0800) \
font(glxo1000) \
font(glxo1200) \
font(glxo1382) \
font(glxo1659) \
font(glxo1991) \
font(glxo2389) \
font(glxo2866) \
font(glxo3440) \
font(glxo4128) \
font(glxu0700) \
font(glxu0800) \
font(glxu1000) \
font(glxu1200) \
font(glxu1382) \
font(glxu1659) \
font(glxu1991) \
font(glxu2389) \
font(glxu2866) \
font(glxu3440) \
font(glxu4128) \
font(gmmn0500) \
font(gmmn0600) \
font(gmmn0700) \
font(gmmn0800) \
font(gmmn0900) \
font(gmmn1000) \
font(gmmn1095) \
font(gmmn1200) \
font(gmmn1440) \
font(gmmn1728) \
font(gmmn2074) \
font(gmmn2488) \
font(gmmn2986) \
font(gmmn3583) \
font(gmmo0500) \
font(gmmo0600) \
font(gmmo0700) \
font(gmmo0800) \
font(gmmo0900) \
font(gmmo1000) \
font(gmmo1095) \
font(gmmo1200) \
font(gmmo1440) \
font(gmmo1728) \
font(gmmo2074) \
font(gmmo2488) \
font(gmmo2986) \
font(gmmo3583) \
font(gmtr0500) \
font(gmtr0600) \
font(gmtr0700) \
font(gmtr0800) \
font(gmtr0900) \
font(gmtr1000) \
font(gmtr1095) \
font(gmtr1200) \
font(gmtr1440) \
font(gmtr1728) \
font(gmtr2074) \
font(gmtr2488) \
font(gmtr2986) \
font(gmtr3583) \
font(gmxn0500) \
font(gmxn0600) \
font(gmxn0700) \
font(gmxn0800) \
font(gmxn0900) \
font(gmxn1000) \
font(gmxn1095) \
font(gmxn1200) \
font(gmxn1440) \
font(gmxn1728) \
font(gmxn2074) \
font(gmxn2488) \
font(gmxn2986) \
font(gmxn3583) \
font(gmxo0500) \
font(gmxo0600) \
font(gmxo0700) \
font(gmxo0800) \
font(gmxo0900) \
font(gmxo1000) \
font(gmxo1095) \
font(gmxo1200) \
font(gmxo1440) \
font(gmxo1728) \
font(gmxo2074) \
font(gmxo2488) \
font(gmxo2986) \
font(gmxo3583) \
font(gomc0500) \
font(gomc0600) \
font(gomc0700) \
font(gomc0800) \
font(gomc0900) \
font(gomc1000) \
font(gomc1095) \
font(gomc1200) \
font(gomc1440) \
font(gomc1728) \
font(gomc2074) \
font(gomc2488) \
font(gomc2986) \
font(gomc3583) \
font(gomi0500) \
font(gomi0600) \
font(gomi0700) \
font(gomi0800) \
font(gomi0900) \
font(gomi1000) \
font(gomi1095) \
font(gomi1200) \
font(gomi1440) \
font(gomi1728) \
font(gomi2074) \
font(gomi2488) \
font(gomi2986) \
font(gomi3583) \
font(gomn0500) \
font(gomn0600) \
font(gomn0700) \
font(gomn0800) \
font(gomn0900) \
font(gomn1000) \
font(gomn1095) \
font(gomn1200) \
font(gomn1440) \
font(gomn1728) \
font(gomn2074) \
font(gomn2488) \
font(gomn2986) \
font(gomn3583) \
font(gomo0500) \
font(gomo0600) \
font(gomo0700) \
font(gomo0800) \
font(gomo0900) \
font(gomo1000) \
font(gomo1095) \
font(gomo1200) \
font(gomo1440) \
font(gomo1728) \
font(gomo2074) \
font(gomo2488) \
font(gomo2986) \
font(gomo3583) \
font(gomu0500) \
font(gomu0600) \
font(gomu0700) \
font(gomu0800) \
font(gomu0900) \
font(gomu1000) \
font(gomu1095) \
font(gomu1200) \
font(gomu1440) \
font(gomu1728) \
font(gomu2074) \
font(gomu2488) \
font(gomu2986) \
font(gomu3583) \
font(goxc0500) \
font(goxc0600) \
font(goxc0700) \
font(goxc0800) \
font(goxc0900) \
font(goxc1000) \
font(goxc1095) \
font(goxc1200) \
font(goxc1440) \
font(goxc1728) \
font(goxc2074) \
font(goxc2488) \
font(goxc2986) \
font(goxc3583) \
font(goxi0500) \
font(goxi0600) \
font(goxi0700) \
font(goxi0800) \
font(goxi0900) \
font(goxi1000) \
font(goxi1095) \
font(goxi1200) \
font(goxi1440) \
font(goxi1728) \
font(goxi2074) \
font(goxi2488) \
font(goxi2986) \
font(goxi3583) \
font(goxn0500) \
font(goxn0600) \
font(goxn0700) \
font(goxn0800) \
font(goxn0900) \
font(goxn1000) \
font(goxn1095) \
font(goxn1200) \
font(goxn1440) \
font(goxn1728) \
font(goxn2074) \
font(goxn2488) \
font(goxn2986) \
font(goxn3583) \
font(goxo0500) \
font(goxo0600) \
font(goxo0700) \
font(goxo0800) \
font(goxo0900) \
font(goxo1000) \
font(goxo1095) \
font(goxo1200) \
font(goxo1440) \
font(goxo1728) \
font(goxo2074) \
font(goxo2488) \
font(goxo2986) \
font(goxo3583) \
font(goxu0500) \
font(goxu0600) \
font(goxu0700) \
font(goxu0800) \
font(goxu0900) \
font(goxu1000) \
font(goxu1095) \
font(goxu1200) \
font(goxu1440) \
font(goxu1728) \
font(goxu2074) \
font(goxu2488) \
font(goxu2986) \
font(goxu3583) \
font(grbl0500) \
font(grbl0600) \
font(grbl0700) \
font(grbl0800) \
font(grbl0900) \
font(grbl1000) \
font(grbl1095) \
font(grbl1200) \
font(grbl1440) \
font(grbl1728) \
font(grbl2074) \
font(grbl2488) \
font(grbl2986) \
font(grbl3583) \
font(grmc0500) \
font(grmc0600) \
font(grmc0700) \
font(grmc0800) \
font(grmc0900) \
font(grmc1000) \
font(grmc1095) \
font(grmc1200) \
font(grmc1440) \
font(grmc1728) \
font(grmc2074) \
font(grmc2488) \
font(grmc2986) \
font(grmc3583) \
font(grmi0500) \
font(grmi0600) \
font(grmi0700) \
font(grmi0800) \
font(grmi0900) \
font(grmi1000) \
font(grmi1095) \
font(grmi1200) \
font(grmi1440) \
font(grmi1728) \
font(grmi2074) \
font(grmi2488) \
font(grmi2986) \
font(grmi3583) \
font(grml0500) \
font(grml0600) \
font(grml0700) \
font(grml0800) \
font(grml0900) \
font(grml1000) \
font(grml1095) \
font(grml1200) \
font(grml1440) \
font(grml1728) \
font(grml2074) \
font(grml2488) \
font(grml2986) \
font(grml3583) \
font(grmn0500) \
font(grmn0600) \
font(grmn0700) \
font(grmn0800) \
font(grmn0900) \
font(grmn1000) \
font(grmn1095) \
font(grmn1200) \
font(grmn1440) \
font(grmn1728) \
font(grmn2074) \
font(grmn2488) \
font(grmn2986) \
font(grmn3583) \
font(grmo0500) \
font(grmo0600) \
font(grmo0700) \
font(grmo0800) \
font(grmo0900) \
font(grmo1000) \
font(grmo1095) \
font(grmo1200) \
font(grmo1440) \
font(grmo1728) \
font(grmo2074) \
font(grmo2488) \
font(grmo2986) \
font(grmo3583) \
font(grmu0500) \
font(grmu0600) \
font(grmu0700) \
font(grmu0800) \
font(grmu0900) \
font(grmu1000) \
font(grmu1095) \
font(grmu1200) \
font(grmu1440) \
font(grmu1728) \
font(grmu2074) \
font(grmu2488) \
font(grmu2986) \
font(grmu3583) \
font(grxc0500) \
font(grxc0600) \
font(grxc0700) \
font(grxc0800) \
font(grxc0900) \
font(grxc1000) \
font(grxc1095) \
font(grxc1200) \
font(grxc1440) \
font(grxc1728) \
font(grxc2074) \
font(grxc2488) \
font(grxc2986) \
font(grxc3583) \
font(grxi0500) \
font(grxi0600) \
font(grxi0700) \
font(grxi0800) \
font(grxi0900) \
font(grxi1000) \
font(grxi1095) \
font(grxi1200) \
font(grxi1440) \
font(grxi1728) \
font(grxi2074) \
font(grxi2488) \
font(grxi2986) \
font(grxi3583) \
font(grxl0500) \
font(grxl0600) \
font(grxl0700) \
font(grxl0800) \
font(grxl0900) \
font(grxl1000) \
font(grxl1095) \
font(grxl1200) \
font(grxl1440) \
font(grxl1728) \
font(grxl2074) \
font(grxl2488) \
font(grxl2986) \
font(grxl3583) \
font(grxn0500) \
font(grxn0600) \
font(grxn0700) \
font(grxn0800) \
font(grxn0900) \
font(grxn1000) \
font(grxn1095) \
font(grxn1200) \
font(grxn1440) \
font(grxn1728) \
font(grxn2074) \
font(grxn2488) \
font(grxn2986) \
font(grxn3583) \
font(grxo0500) \
font(grxo0600) \
font(grxo0700) \
font(grxo0800) \
font(grxo0900) \
font(grxo1000) \
font(grxo1095) \
font(grxo1200) \
font(grxo1440) \
font(grxo1728) \
font(grxo2074) \
font(grxo2488) \
font(grxo2986) \
font(grxo3583) \
font(grxu0500) \
font(grxu0600) \
font(grxu0700) \
font(grxu0800) \
font(grxu0900) \
font(grxu1000) \
font(grxu1095) \
font(grxu1200) \
font(grxu1440) \
font(grxu1728) \
font(grxu2074) \
font(grxu2488) \
font(grxu2986) \
font(grxu3583) \
font(gsma0500) \
font(gsma0600) \
font(gsma0700) \
font(gsma0800) \
font(gsma0900) \
font(gsma1000) \
font(gsma1095) \
font(gsma1200) \
font(gsma1440) \
font(gsma1728) \
font(gsma2074) \
font(gsma2488) \
font(gsma2986) \
font(gsma3583) \
font(gsmc0500) \
font(gsmc0600) \
font(gsmc0700) \
font(gsmc0800) \
font(gsmc0900) \
font(gsmc1000) \
font(gsmc1095) \
font(gsmc1200) \
font(gsmc1440) \
font(gsmc1728) \
font(gsmc2074) \
font(gsmc2488) \
font(gsmc2986) \
font(gsmc3583) \
font(gsme0500) \
font(gsme0600) \
font(gsme0700) \
font(gsme0800) \
font(gsme0900) \
font(gsme1000) \
font(gsme1095) \
font(gsme1200) \
font(gsme1440) \
font(gsme1728) \
font(gsme2074) \
font(gsme2488) \
font(gsme2986) \
font(gsme3583) \
font(gsmi0500) \
font(gsmi0600) \
font(gsmi0700) \
font(gsmi0800) \
font(gsmi0900) \
font(gsmi1000) \
font(gsmi1095) \
font(gsmi1200) \
font(gsmi1440) \
font(gsmi1728) \
font(gsmi2074) \
font(gsmi2488) \
font(gsmi2986) \
font(gsmi3583) \
font(gsmn0500) \
font(gsmn0600) \
font(gsmn0700) \
font(gsmn0800) \
font(gsmn0900) \
font(gsmn1000) \
font(gsmn1095) \
font(gsmn1200) \
font(gsmn1440) \
font(gsmn1728) \
font(gsmn2074) \
font(gsmn2488) \
font(gsmn2986) \
font(gsmn3583) \
font(gsmo0500) \
font(gsmo0600) \
font(gsmo0700) \
font(gsmo0800) \
font(gsmo0900) \
font(gsmo1000) \
font(gsmo1095) \
font(gsmo1200) \
font(gsmo1440) \
font(gsmo1728) \
font(gsmo2074) \
font(gsmo2488) \
font(gsmo2986) \
font(gsmo3583) \
font(gsmu0500) \
font(gsmu0600) \
font(gsmu0700) \
font(gsmu0800) \
font(gsmu0900) \
font(gsmu1000) \
font(gsmu1095) \
font(gsmu1200) \
font(gsmu1440) \
font(gsmu1728) \
font(gsmu2074) \
font(gsmu2488) \
font(gsmu2986) \
font(gsmu3583) \
font(gsxa0500) \
font(gsxa0600) \
font(gsxa0700) \
font(gsxa0800) \
font(gsxa0900) \
font(gsxa1000) \
font(gsxa1095) \
font(gsxa1200) \
font(gsxa1440) \
font(gsxa1728) \
font(gsxa2074) \
font(gsxa2488) \
font(gsxa2986) \
font(gsxa3583) \
font(gsxc0500) \
font(gsxc0600) \
font(gsxc0700) \
font(gsxc0800) \
font(gsxc0900) \
font(gsxc1000) \
font(gsxc1095) \
font(gsxc1200) \
font(gsxc1440) \
font(gsxc1728) \
font(gsxc2074) \
font(gsxc2488) \
font(gsxc2986) \
font(gsxc3583) \
font(gsxe0500) \
font(gsxe0600) \
font(gsxe0700) \
font(gsxe0800) \
font(gsxe0900) \
font(gsxe1000) \
font(gsxe1095) \
font(gsxe1200) \
font(gsxe1440) \
font(gsxe1728) \
font(gsxe2074) \
font(gsxe2488) \
font(gsxe2986) \
font(gsxe3583) \
font(gsxi0500) \
font(gsxi0600) \
font(gsxi0700) \
font(gsxi0800) \
font(gsxi0900) \
font(gsxi1000) \
font(gsxi1095) \
font(gsxi1200) \
font(gsxi1440) \
font(gsxi1728) \
font(gsxi2074) \
font(gsxi2488) \
font(gsxi2986) \
font(gsxi3583) \
font(gsxn0500) \
font(gsxn0600) \
font(gsxn0700) \
font(gsxn0800) \
font(gsxn0900) \
font(gsxn1000) \
font(gsxn1095) \
font(gsxn1200) \
font(gsxn1440) \
font(gsxn1728) \
font(gsxn2074) \
font(gsxn2488) \
font(gsxn2986) \
font(gsxn3583) \
font(gsxo0500) \
font(gsxo0600) \
font(gsxo0700) \
font(gsxo0800) \
font(gsxo0900) \
font(gsxo1000) \
font(gsxo1095) \
font(gsxo1200) \
font(gsxo1440) \
font(gsxo1728) \
font(gsxo2074) \
font(gsxo2488) \
font(gsxo2986) \
font(gsxo3583) \
font(gsxu0500) \
font(gsxu0600) \
font(gsxu0700) \
font(gsxu0800) \
font(gsxu0900) \
font(gsxu1000) \
font(gsxu1095) \
font(gsxu1200) \
font(gsxu1440) \
font(gsxu1728) \
font(gsxu2074) \
font(gsxu2488) \
font(gsxu2986) \
font(gsxu3583) \
font(gttc0500) \
font(gttc0600) \
font(gttc0700) \
font(gttc0800) \
font(gttc0900) \
font(gttc1000) \
font(gttc1095) \
font(gttc1200) \
font(gttc1440) \
font(gttc1728) \
font(gttc2074) \
font(gttc2488) \
font(gttc2986) \
font(gttc3583) \
font(gtti0500) \
font(gtti0600) \
font(gtti0700) \
font(gtti0800) \
font(gtti0900) \
font(gtti1000) \
font(gtti1095) \
font(gtti1200) \
font(gtti1440) \
font(gtti1728) \
font(gtti2074) \
font(gtti2488) \
font(gtti2986) \
font(gtti3583) \
font(gttn0500) \
font(gttn0600) \
font(gttn0700) \
font(gttn0800) \
font(gttn0900) \
font(gttn1000) \
font(gttn1095) \
font(gttn1200) \
font(gttn1440) \
font(gttn1728) \
font(gttn2074) \
font(gttn2488) \
font(gttn2986) \
font(gttn3583) \
font(gtto0500) \
font(gtto0600) \
font(gtto0700) \
font(gtto0800) \
font(gtto0900) \
font(gtto1000) \
font(gtto1095) \
font(gtto1200) \
font(gtto1440) \
font(gtto1728) \
font(gtto2074) \
font(gtto2488) \
font(gtto2986) \
font(gtto3583) \
font(gttu0500) \
font(gttu0600) \
font(gttu0700) \
font(gttu0800) \
font(gttu0900) \
font(gttu1000) \
font(gttu1095) \
font(gttu1200) \
font(gttu1440) \
font(gttu1728) \
font(gttu2074) \
font(gttu2488) \
font(gttu2986) \
font(gttu3583) \
texlive-cbfonts-fonts"

RDEPENDS:${PN} += "/bin/sh \
aaa_base \
coreutils \
fontconfig \
ghostscript-fonts-std \
perl"

inherit rpm
