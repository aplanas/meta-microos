SUMMARY = "Translations for package mate-applet-indicator"
DESCRIPTION = "Provides translations for the 'mate-applet-indicator' package."
LICENSE = "GPL-3.0-only & LGPL-3.0-only"

PV = "1.26.0"

RPM_NAME = "mate-applet-indicator-lang-1.26.0-1.9.noarch.rpm"
RPM_HASH = "2d6978531c694c0bc1e82cc297bf6ff55acd00346979dcf55bb4585d843eaea79c861153c96fefdbf04f304b821e23a0706d716c93aeceadafa48c7d22c90824"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "locale(mate-applet-indicator:af) \
locale(mate-applet-indicator:ar) \
locale(mate-applet-indicator:as) \
locale(mate-applet-indicator:ast) \
locale(mate-applet-indicator:az) \
locale(mate-applet-indicator:be) \
locale(mate-applet-indicator:bg) \
locale(mate-applet-indicator:bn) \
locale(mate-applet-indicator:bn_IN) \
locale(mate-applet-indicator:br) \
locale(mate-applet-indicator:bs) \
locale(mate-applet-indicator:ca) \
locale(mate-applet-indicator:ca@valencia) \
locale(mate-applet-indicator:cs) \
locale(mate-applet-indicator:cy) \
locale(mate-applet-indicator:da) \
locale(mate-applet-indicator:de) \
locale(mate-applet-indicator:dz) \
locale(mate-applet-indicator:el) \
locale(mate-applet-indicator:en_AU) \
locale(mate-applet-indicator:en_CA) \
locale(mate-applet-indicator:en_GB) \
locale(mate-applet-indicator:eo) \
locale(mate-applet-indicator:es) \
locale(mate-applet-indicator:es_AR) \
locale(mate-applet-indicator:es_CL) \
locale(mate-applet-indicator:es_CO) \
locale(mate-applet-indicator:es_CR) \
locale(mate-applet-indicator:es_DO) \
locale(mate-applet-indicator:es_EC) \
locale(mate-applet-indicator:es_ES) \
locale(mate-applet-indicator:es_MX) \
locale(mate-applet-indicator:es_NI) \
locale(mate-applet-indicator:es_PA) \
locale(mate-applet-indicator:es_PE) \
locale(mate-applet-indicator:es_PR) \
locale(mate-applet-indicator:es_SV) \
locale(mate-applet-indicator:es_UY) \
locale(mate-applet-indicator:es_VE) \
locale(mate-applet-indicator:et) \
locale(mate-applet-indicator:eu) \
locale(mate-applet-indicator:fa) \
locale(mate-applet-indicator:fi) \
locale(mate-applet-indicator:fr) \
locale(mate-applet-indicator:fur) \
locale(mate-applet-indicator:ga) \
locale(mate-applet-indicator:gl) \
locale(mate-applet-indicator:gu) \
locale(mate-applet-indicator:he) \
locale(mate-applet-indicator:hi) \
locale(mate-applet-indicator:hr) \
locale(mate-applet-indicator:hu) \
locale(mate-applet-indicator:ia) \
locale(mate-applet-indicator:id) \
locale(mate-applet-indicator:is) \
locale(mate-applet-indicator:it) \
locale(mate-applet-indicator:ja) \
locale(mate-applet-indicator:ka) \
locale(mate-applet-indicator:kk) \
locale(mate-applet-indicator:km) \
locale(mate-applet-indicator:kn) \
locale(mate-applet-indicator:ko) \
locale(mate-applet-indicator:lt) \
locale(mate-applet-indicator:lv) \
locale(mate-applet-indicator:mai) \
locale(mate-applet-indicator:mk) \
locale(mate-applet-indicator:ml) \
locale(mate-applet-indicator:mr) \
locale(mate-applet-indicator:ms) \
locale(mate-applet-indicator:nb) \
locale(mate-applet-indicator:nds) \
locale(mate-applet-indicator:ne) \
locale(mate-applet-indicator:nl) \
locale(mate-applet-indicator:nn) \
locale(mate-applet-indicator:oc) \
locale(mate-applet-indicator:or) \
locale(mate-applet-indicator:pa) \
locale(mate-applet-indicator:pl) \
locale(mate-applet-indicator:pt) \
locale(mate-applet-indicator:pt_BR) \
locale(mate-applet-indicator:ro) \
locale(mate-applet-indicator:ru) \
locale(mate-applet-indicator:si) \
locale(mate-applet-indicator:sk) \
locale(mate-applet-indicator:sl) \
locale(mate-applet-indicator:sq) \
locale(mate-applet-indicator:sr) \
locale(mate-applet-indicator:sr@latin) \
locale(mate-applet-indicator:sv) \
locale(mate-applet-indicator:ta) \
locale(mate-applet-indicator:te) \
locale(mate-applet-indicator:th) \
locale(mate-applet-indicator:tr) \
locale(mate-applet-indicator:ug) \
locale(mate-applet-indicator:uk) \
locale(mate-applet-indicator:vi) \
locale(mate-applet-indicator:wa) \
locale(mate-applet-indicator:zh_CN) \
locale(mate-applet-indicator:zh_HK) \
locale(mate-applet-indicator:zh_TW) \
mate-applet-indicator-lang \
mate-applet-indicator-lang-all"
RDEPENDS:${PN} += "mate-applet-indicator"

inherit rpm
