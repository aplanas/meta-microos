SUMMARY = "Multi-weight Japanese font support for the jlreq class"
DESCRIPTION = "This package provides multi-weight Japanese font support for \
the jlreq class."
LICENSE = "LPPL-1.0"

PV = "2023.201.0.0.4.1svn66115"

RPM_NAME = "texlive-jlreq-deluxe-2023.201.0.0.4.1svn66115-55.1.noarch.rpm"
RPM_HASH = "971bdcbf0efd9a8e6ebacb4c790b9e22967a81ee5d6c5e147b5695bbee8d0324fee694c8ab8a2819e10610b2e3f7f8222555a10f97adab8c347857e8b9f3a022"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-bjlreq--expgothb-h.tfm \
tex-bjlreq--expgothb-h.vf \
tex-bjlreq--expgothb-v.tfm \
tex-bjlreq--expgothb-v.vf \
tex-bjlreq--expgothbn-h.tfm \
tex-bjlreq--expgothbn-h.vf \
tex-bjlreq--expgothbn-v.tfm \
tex-bjlreq--expgothbn-v.vf \
tex-bjlreq--expgotheb-h.tfm \
tex-bjlreq--expgotheb-h.vf \
tex-bjlreq--expgotheb-v.tfm \
tex-bjlreq--expgotheb-v.vf \
tex-bjlreq--expgothebn-h.tfm \
tex-bjlreq--expgothebn-h.vf \
tex-bjlreq--expgothebn-v.tfm \
tex-bjlreq--expgothebn-v.vf \
tex-bjlreq--expgothr-h.tfm \
tex-bjlreq--expgothr-h.vf \
tex-bjlreq--expgothr-v.tfm \
tex-bjlreq--expgothr-v.vf \
tex-bjlreq--expgothrn-h.tfm \
tex-bjlreq--expgothrn-h.vf \
tex-bjlreq--expgothrn-v.tfm \
tex-bjlreq--expgothrn-v.vf \
tex-bjlreq--expmgothr-h.tfm \
tex-bjlreq--expmgothr-h.vf \
tex-bjlreq--expmgothr-v.tfm \
tex-bjlreq--expmgothr-v.vf \
tex-bjlreq--expmgothrn-h.tfm \
tex-bjlreq--expmgothrn-h.vf \
tex-bjlreq--expmgothrn-v.tfm \
tex-bjlreq--expmgothrn-v.vf \
tex-bjlreq--expminb-h.tfm \
tex-bjlreq--expminb-h.vf \
tex-bjlreq--expminb-v.tfm \
tex-bjlreq--expminb-v.vf \
tex-bjlreq--expminbn-h.tfm \
tex-bjlreq--expminbn-h.vf \
tex-bjlreq--expminbn-v.tfm \
tex-bjlreq--expminbn-v.vf \
tex-bjlreq--expminl-h.tfm \
tex-bjlreq--expminl-h.vf \
tex-bjlreq--expminl-v.tfm \
tex-bjlreq--expminl-v.vf \
tex-bjlreq--expminln-h.tfm \
tex-bjlreq--expminln-h.vf \
tex-bjlreq--expminln-v.tfm \
tex-bjlreq--expminln-v.vf \
tex-bjlreq--expminr-h.tfm \
tex-bjlreq--expminr-h.vf \
tex-bjlreq--expminr-v.tfm \
tex-bjlreq--expminr-v.vf \
tex-bjlreq--expminrn-h.tfm \
tex-bjlreq--expminrn-h.vf \
tex-bjlreq--expminrn-v.tfm \
tex-bjlreq--expminrn-v.vf \
tex-bjlreq--nmlgothb-h.tfm \
tex-bjlreq--nmlgothb-h.vf \
tex-bjlreq--nmlgothb-v.tfm \
tex-bjlreq--nmlgothb-v.vf \
tex-bjlreq--nmlgothbn-h.tfm \
tex-bjlreq--nmlgothbn-h.vf \
tex-bjlreq--nmlgothbn-v.tfm \
tex-bjlreq--nmlgothbn-v.vf \
tex-bjlreq--nmlgotheb-h.tfm \
tex-bjlreq--nmlgotheb-h.vf \
tex-bjlreq--nmlgotheb-v.tfm \
tex-bjlreq--nmlgotheb-v.vf \
tex-bjlreq--nmlgothebn-h.tfm \
tex-bjlreq--nmlgothebn-h.vf \
tex-bjlreq--nmlgothebn-v.tfm \
tex-bjlreq--nmlgothebn-v.vf \
tex-bjlreq--nmlgothr-h.tfm \
tex-bjlreq--nmlgothr-h.vf \
tex-bjlreq--nmlgothr-v.tfm \
tex-bjlreq--nmlgothr-v.vf \
tex-bjlreq--nmlgothrn-h.tfm \
tex-bjlreq--nmlgothrn-h.vf \
tex-bjlreq--nmlgothrn-v.tfm \
tex-bjlreq--nmlgothrn-v.vf \
tex-bjlreq--nmlmgothr-h.tfm \
tex-bjlreq--nmlmgothr-h.vf \
tex-bjlreq--nmlmgothr-v.tfm \
tex-bjlreq--nmlmgothr-v.vf \
tex-bjlreq--nmlmgothrn-h.tfm \
tex-bjlreq--nmlmgothrn-h.vf \
tex-bjlreq--nmlmgothrn-v.tfm \
tex-bjlreq--nmlmgothrn-v.vf \
tex-bjlreq--nmlminb-h.tfm \
tex-bjlreq--nmlminb-h.vf \
tex-bjlreq--nmlminb-v.tfm \
tex-bjlreq--nmlminb-v.vf \
tex-bjlreq--nmlminbn-h.tfm \
tex-bjlreq--nmlminbn-h.vf \
tex-bjlreq--nmlminbn-v.tfm \
tex-bjlreq--nmlminbn-v.vf \
tex-bjlreq--nmlminl-h.tfm \
tex-bjlreq--nmlminl-h.vf \
tex-bjlreq--nmlminl-v.tfm \
tex-bjlreq--nmlminl-v.vf \
tex-bjlreq--nmlminln-h.tfm \
tex-bjlreq--nmlminln-h.vf \
tex-bjlreq--nmlminln-v.tfm \
tex-bjlreq--nmlminln-v.vf \
tex-bjlreq--nmlminr-h.tfm \
tex-bjlreq--nmlminr-h.vf \
tex-bjlreq--nmlminr-v.tfm \
tex-bjlreq--nmlminr-v.vf \
tex-bjlreq--nmlminrn-h.tfm \
tex-bjlreq--nmlminrn-h.vf \
tex-bjlreq--nmlminrn-v.tfm \
tex-bjlreq--nmlminrn-v.vf \
tex-bjlreq--rubygothb-h.tfm \
tex-bjlreq--rubygothb-h.vf \
tex-bjlreq--rubygothb-v.tfm \
tex-bjlreq--rubygothb-v.vf \
tex-bjlreq--rubygotheb-h.tfm \
tex-bjlreq--rubygotheb-h.vf \
tex-bjlreq--rubygotheb-v.tfm \
tex-bjlreq--rubygotheb-v.vf \
tex-bjlreq--rubygothr-h.tfm \
tex-bjlreq--rubygothr-h.vf \
tex-bjlreq--rubygothr-v.tfm \
tex-bjlreq--rubygothr-v.vf \
tex-bjlreq--rubymgothr-h.tfm \
tex-bjlreq--rubymgothr-h.vf \
tex-bjlreq--rubymgothr-v.tfm \
tex-bjlreq--rubymgothr-v.vf \
tex-bjlreq--rubyminb-h.tfm \
tex-bjlreq--rubyminb-h.vf \
tex-bjlreq--rubyminb-v.tfm \
tex-bjlreq--rubyminb-v.vf \
tex-bjlreq--rubyminl-h.tfm \
tex-bjlreq--rubyminl-h.vf \
tex-bjlreq--rubyminl-v.tfm \
tex-bjlreq--rubyminl-v.vf \
tex-bjlreq--rubyminr-h.tfm \
tex-bjlreq--rubyminr-h.vf \
tex-bjlreq--rubyminr-v.tfm \
tex-bjlreq--rubyminr-v.vf \
tex-bjlreq--upexpgothb-h.tfm \
tex-bjlreq--upexpgothb-h.vf \
tex-bjlreq--upexpgothb-v.tfm \
tex-bjlreq--upexpgothb-v.vf \
tex-bjlreq--upexpgothbn-h.tfm \
tex-bjlreq--upexpgothbn-h.vf \
tex-bjlreq--upexpgothbn-v.tfm \
tex-bjlreq--upexpgothbn-v.vf \
tex-bjlreq--upexpgotheb-h.tfm \
tex-bjlreq--upexpgotheb-h.vf \
tex-bjlreq--upexpgotheb-v.tfm \
tex-bjlreq--upexpgotheb-v.vf \
tex-bjlreq--upexpgothebn-h.tfm \
tex-bjlreq--upexpgothebn-h.vf \
tex-bjlreq--upexpgothebn-v.tfm \
tex-bjlreq--upexpgothebn-v.vf \
tex-bjlreq--upexpgothr-h.tfm \
tex-bjlreq--upexpgothr-h.vf \
tex-bjlreq--upexpgothr-v.tfm \
tex-bjlreq--upexpgothr-v.vf \
tex-bjlreq--upexpgothrn-h.tfm \
tex-bjlreq--upexpgothrn-h.vf \
tex-bjlreq--upexpgothrn-v.tfm \
tex-bjlreq--upexpgothrn-v.vf \
tex-bjlreq--upexpmgothr-h.tfm \
tex-bjlreq--upexpmgothr-h.vf \
tex-bjlreq--upexpmgothr-v.tfm \
tex-bjlreq--upexpmgothr-v.vf \
tex-bjlreq--upexpmgothrn-h.tfm \
tex-bjlreq--upexpmgothrn-h.vf \
tex-bjlreq--upexpmgothrn-v.tfm \
tex-bjlreq--upexpmgothrn-v.vf \
tex-bjlreq--upexpminb-h.tfm \
tex-bjlreq--upexpminb-h.vf \
tex-bjlreq--upexpminb-v.tfm \
tex-bjlreq--upexpminb-v.vf \
tex-bjlreq--upexpminbn-h.tfm \
tex-bjlreq--upexpminbn-h.vf \
tex-bjlreq--upexpminbn-v.tfm \
tex-bjlreq--upexpminbn-v.vf \
tex-bjlreq--upexpminl-h.tfm \
tex-bjlreq--upexpminl-h.vf \
tex-bjlreq--upexpminl-v.tfm \
tex-bjlreq--upexpminl-v.vf \
tex-bjlreq--upexpminln-h.tfm \
tex-bjlreq--upexpminln-h.vf \
tex-bjlreq--upexpminln-v.tfm \
tex-bjlreq--upexpminln-v.vf \
tex-bjlreq--upexpminr-h.tfm \
tex-bjlreq--upexpminr-h.vf \
tex-bjlreq--upexpminr-v.tfm \
tex-bjlreq--upexpminr-v.vf \
tex-bjlreq--upexpminrn-h.tfm \
tex-bjlreq--upexpminrn-h.vf \
tex-bjlreq--upexpminrn-v.tfm \
tex-bjlreq--upexpminrn-v.vf \
tex-bjlreq--upnmlgothb-h.tfm \
tex-bjlreq--upnmlgothb-h.vf \
tex-bjlreq--upnmlgothb-v.tfm \
tex-bjlreq--upnmlgothb-v.vf \
tex-bjlreq--upnmlgothbn-h.tfm \
tex-bjlreq--upnmlgothbn-h.vf \
tex-bjlreq--upnmlgothbn-v.tfm \
tex-bjlreq--upnmlgothbn-v.vf \
tex-bjlreq--upnmlgotheb-h.tfm \
tex-bjlreq--upnmlgotheb-h.vf \
tex-bjlreq--upnmlgotheb-v.tfm \
tex-bjlreq--upnmlgotheb-v.vf \
tex-bjlreq--upnmlgothebn-h.tfm \
tex-bjlreq--upnmlgothebn-h.vf \
tex-bjlreq--upnmlgothebn-v.tfm \
tex-bjlreq--upnmlgothebn-v.vf \
tex-bjlreq--upnmlgothr-h.tfm \
tex-bjlreq--upnmlgothr-h.vf \
tex-bjlreq--upnmlgothr-v.tfm \
tex-bjlreq--upnmlgothr-v.vf \
tex-bjlreq--upnmlgothrn-h.tfm \
tex-bjlreq--upnmlgothrn-h.vf \
tex-bjlreq--upnmlgothrn-v.tfm \
tex-bjlreq--upnmlgothrn-v.vf \
tex-bjlreq--upnmlmgothr-h.tfm \
tex-bjlreq--upnmlmgothr-h.vf \
tex-bjlreq--upnmlmgothr-v.tfm \
tex-bjlreq--upnmlmgothr-v.vf \
tex-bjlreq--upnmlmgothrn-h.tfm \
tex-bjlreq--upnmlmgothrn-h.vf \
tex-bjlreq--upnmlmgothrn-v.tfm \
tex-bjlreq--upnmlmgothrn-v.vf \
tex-bjlreq--upnmlminb-h.tfm \
tex-bjlreq--upnmlminb-h.vf \
tex-bjlreq--upnmlminb-v.tfm \
tex-bjlreq--upnmlminb-v.vf \
tex-bjlreq--upnmlminbn-h.tfm \
tex-bjlreq--upnmlminbn-h.vf \
tex-bjlreq--upnmlminbn-v.tfm \
tex-bjlreq--upnmlminbn-v.vf \
tex-bjlreq--upnmlminl-h.tfm \
tex-bjlreq--upnmlminl-h.vf \
tex-bjlreq--upnmlminl-v.tfm \
tex-bjlreq--upnmlminl-v.vf \
tex-bjlreq--upnmlminln-h.tfm \
tex-bjlreq--upnmlminln-h.vf \
tex-bjlreq--upnmlminln-v.tfm \
tex-bjlreq--upnmlminln-v.vf \
tex-bjlreq--upnmlminr-h.tfm \
tex-bjlreq--upnmlminr-h.vf \
tex-bjlreq--upnmlminr-v.tfm \
tex-bjlreq--upnmlminr-v.vf \
tex-bjlreq--upnmlminrn-h.tfm \
tex-bjlreq--upnmlminrn-h.vf \
tex-bjlreq--upnmlminrn-v.tfm \
tex-bjlreq--upnmlminrn-v.vf \
tex-bjlreq--uprubygothb-h.tfm \
tex-bjlreq--uprubygothb-h.vf \
tex-bjlreq--uprubygothb-v.tfm \
tex-bjlreq--uprubygothb-v.vf \
tex-bjlreq--uprubygotheb-h.tfm \
tex-bjlreq--uprubygotheb-h.vf \
tex-bjlreq--uprubygotheb-v.tfm \
tex-bjlreq--uprubygotheb-v.vf \
tex-bjlreq--uprubygothr-h.tfm \
tex-bjlreq--uprubygothr-h.vf \
tex-bjlreq--uprubygothr-v.tfm \
tex-bjlreq--uprubygothr-v.vf \
tex-bjlreq--uprubymgothr-h.tfm \
tex-bjlreq--uprubymgothr-h.vf \
tex-bjlreq--uprubymgothr-v.tfm \
tex-bjlreq--uprubymgothr-v.vf \
tex-bjlreq--uprubyminb-h.tfm \
tex-bjlreq--uprubyminb-h.vf \
tex-bjlreq--uprubyminb-v.tfm \
tex-bjlreq--uprubyminb-v.vf \
tex-bjlreq--uprubyminl-h.tfm \
tex-bjlreq--uprubyminl-h.vf \
tex-bjlreq--uprubyminl-v.tfm \
tex-bjlreq--uprubyminl-v.vf \
tex-bjlreq--uprubyminr-h.tfm \
tex-bjlreq--uprubyminr-h.vf \
tex-bjlreq--uprubyminr-v.tfm \
tex-bjlreq--uprubyminr-v.vf \
tex-bzjlreq--expgothb-h.tfm \
tex-bzjlreq--expgothb-h.vf \
tex-bzjlreq--expgothb-v.tfm \
tex-bzjlreq--expgothb-v.vf \
tex-bzjlreq--expgothbn-h.tfm \
tex-bzjlreq--expgothbn-h.vf \
tex-bzjlreq--expgothbn-v.tfm \
tex-bzjlreq--expgothbn-v.vf \
tex-bzjlreq--expgotheb-h.tfm \
tex-bzjlreq--expgotheb-h.vf \
tex-bzjlreq--expgotheb-v.tfm \
tex-bzjlreq--expgotheb-v.vf \
tex-bzjlreq--expgothebn-h.tfm \
tex-bzjlreq--expgothebn-h.vf \
tex-bzjlreq--expgothebn-v.tfm \
tex-bzjlreq--expgothebn-v.vf \
tex-bzjlreq--expgothr-h.tfm \
tex-bzjlreq--expgothr-h.vf \
tex-bzjlreq--expgothr-v.tfm \
tex-bzjlreq--expgothr-v.vf \
tex-bzjlreq--expgothrn-h.tfm \
tex-bzjlreq--expgothrn-h.vf \
tex-bzjlreq--expgothrn-v.tfm \
tex-bzjlreq--expgothrn-v.vf \
tex-bzjlreq--expmgothr-h.tfm \
tex-bzjlreq--expmgothr-h.vf \
tex-bzjlreq--expmgothr-v.tfm \
tex-bzjlreq--expmgothr-v.vf \
tex-bzjlreq--expmgothrn-h.tfm \
tex-bzjlreq--expmgothrn-h.vf \
tex-bzjlreq--expmgothrn-v.tfm \
tex-bzjlreq--expmgothrn-v.vf \
tex-bzjlreq--expminb-h.tfm \
tex-bzjlreq--expminb-h.vf \
tex-bzjlreq--expminb-v.tfm \
tex-bzjlreq--expminb-v.vf \
tex-bzjlreq--expminbn-h.tfm \
tex-bzjlreq--expminbn-h.vf \
tex-bzjlreq--expminbn-v.tfm \
tex-bzjlreq--expminbn-v.vf \
tex-bzjlreq--expminl-h.tfm \
tex-bzjlreq--expminl-h.vf \
tex-bzjlreq--expminl-v.tfm \
tex-bzjlreq--expminl-v.vf \
tex-bzjlreq--expminln-h.tfm \
tex-bzjlreq--expminln-h.vf \
tex-bzjlreq--expminln-v.tfm \
tex-bzjlreq--expminln-v.vf \
tex-bzjlreq--expminr-h.tfm \
tex-bzjlreq--expminr-h.vf \
tex-bzjlreq--expminr-v.tfm \
tex-bzjlreq--expminr-v.vf \
tex-bzjlreq--expminrn-h.tfm \
tex-bzjlreq--expminrn-h.vf \
tex-bzjlreq--expminrn-v.tfm \
tex-bzjlreq--expminrn-v.vf \
tex-bzjlreq--nmlgothb-h.tfm \
tex-bzjlreq--nmlgothb-h.vf \
tex-bzjlreq--nmlgothb-v.tfm \
tex-bzjlreq--nmlgothb-v.vf \
tex-bzjlreq--nmlgothbn-h.tfm \
tex-bzjlreq--nmlgothbn-h.vf \
tex-bzjlreq--nmlgothbn-v.tfm \
tex-bzjlreq--nmlgothbn-v.vf \
tex-bzjlreq--nmlgotheb-h.tfm \
tex-bzjlreq--nmlgotheb-h.vf \
tex-bzjlreq--nmlgotheb-v.tfm \
tex-bzjlreq--nmlgotheb-v.vf \
tex-bzjlreq--nmlgothebn-h.tfm \
tex-bzjlreq--nmlgothebn-h.vf \
tex-bzjlreq--nmlgothebn-v.tfm \
tex-bzjlreq--nmlgothebn-v.vf \
tex-bzjlreq--nmlgothr-h.tfm \
tex-bzjlreq--nmlgothr-h.vf \
tex-bzjlreq--nmlgothr-v.tfm \
tex-bzjlreq--nmlgothr-v.vf \
tex-bzjlreq--nmlgothrn-h.tfm \
tex-bzjlreq--nmlgothrn-h.vf \
tex-bzjlreq--nmlgothrn-v.tfm \
tex-bzjlreq--nmlgothrn-v.vf \
tex-bzjlreq--nmlmgothr-h.tfm \
tex-bzjlreq--nmlmgothr-h.vf \
tex-bzjlreq--nmlmgothr-v.tfm \
tex-bzjlreq--nmlmgothr-v.vf \
tex-bzjlreq--nmlmgothrn-h.tfm \
tex-bzjlreq--nmlmgothrn-h.vf \
tex-bzjlreq--nmlmgothrn-v.tfm \
tex-bzjlreq--nmlmgothrn-v.vf \
tex-bzjlreq--nmlminb-h.tfm \
tex-bzjlreq--nmlminb-h.vf \
tex-bzjlreq--nmlminb-v.tfm \
tex-bzjlreq--nmlminb-v.vf \
tex-bzjlreq--nmlminbn-h.tfm \
tex-bzjlreq--nmlminbn-h.vf \
tex-bzjlreq--nmlminbn-v.tfm \
tex-bzjlreq--nmlminbn-v.vf \
tex-bzjlreq--nmlminl-h.tfm \
tex-bzjlreq--nmlminl-h.vf \
tex-bzjlreq--nmlminl-v.tfm \
tex-bzjlreq--nmlminl-v.vf \
tex-bzjlreq--nmlminln-h.tfm \
tex-bzjlreq--nmlminln-h.vf \
tex-bzjlreq--nmlminln-v.tfm \
tex-bzjlreq--nmlminln-v.vf \
tex-bzjlreq--nmlminr-h.tfm \
tex-bzjlreq--nmlminr-h.vf \
tex-bzjlreq--nmlminr-v.tfm \
tex-bzjlreq--nmlminr-v.vf \
tex-bzjlreq--nmlminrn-h.tfm \
tex-bzjlreq--nmlminrn-h.vf \
tex-bzjlreq--nmlminrn-v.tfm \
tex-bzjlreq--nmlminrn-v.vf \
tex-bzjlreq--rubygothb-h.tfm \
tex-bzjlreq--rubygothb-h.vf \
tex-bzjlreq--rubygothb-v.tfm \
tex-bzjlreq--rubygothb-v.vf \
tex-bzjlreq--rubygotheb-h.tfm \
tex-bzjlreq--rubygotheb-h.vf \
tex-bzjlreq--rubygotheb-v.tfm \
tex-bzjlreq--rubygotheb-v.vf \
tex-bzjlreq--rubygothr-h.tfm \
tex-bzjlreq--rubygothr-h.vf \
tex-bzjlreq--rubygothr-v.tfm \
tex-bzjlreq--rubygothr-v.vf \
tex-bzjlreq--rubymgothr-h.tfm \
tex-bzjlreq--rubymgothr-h.vf \
tex-bzjlreq--rubymgothr-v.tfm \
tex-bzjlreq--rubymgothr-v.vf \
tex-bzjlreq--rubyminb-h.tfm \
tex-bzjlreq--rubyminb-h.vf \
tex-bzjlreq--rubyminb-v.tfm \
tex-bzjlreq--rubyminb-v.vf \
tex-bzjlreq--rubyminl-h.tfm \
tex-bzjlreq--rubyminl-h.vf \
tex-bzjlreq--rubyminl-v.tfm \
tex-bzjlreq--rubyminl-v.vf \
tex-bzjlreq--rubyminr-h.tfm \
tex-bzjlreq--rubyminr-h.vf \
tex-bzjlreq--rubyminr-v.tfm \
tex-bzjlreq--rubyminr-v.vf \
tex-bzjlreq--upexpgothb-h.tfm \
tex-bzjlreq--upexpgothb-h.vf \
tex-bzjlreq--upexpgothb-v.tfm \
tex-bzjlreq--upexpgothb-v.vf \
tex-bzjlreq--upexpgothbn-h.tfm \
tex-bzjlreq--upexpgothbn-h.vf \
tex-bzjlreq--upexpgothbn-v.tfm \
tex-bzjlreq--upexpgothbn-v.vf \
tex-bzjlreq--upexpgotheb-h.tfm \
tex-bzjlreq--upexpgotheb-h.vf \
tex-bzjlreq--upexpgotheb-v.tfm \
tex-bzjlreq--upexpgotheb-v.vf \
tex-bzjlreq--upexpgothebn-h.tfm \
tex-bzjlreq--upexpgothebn-h.vf \
tex-bzjlreq--upexpgothebn-v.tfm \
tex-bzjlreq--upexpgothebn-v.vf \
tex-bzjlreq--upexpgothr-h.tfm \
tex-bzjlreq--upexpgothr-h.vf \
tex-bzjlreq--upexpgothr-v.tfm \
tex-bzjlreq--upexpgothr-v.vf \
tex-bzjlreq--upexpgothrn-h.tfm \
tex-bzjlreq--upexpgothrn-h.vf \
tex-bzjlreq--upexpgothrn-v.tfm \
tex-bzjlreq--upexpgothrn-v.vf \
tex-bzjlreq--upexpmgothr-h.tfm \
tex-bzjlreq--upexpmgothr-h.vf \
tex-bzjlreq--upexpmgothr-v.tfm \
tex-bzjlreq--upexpmgothr-v.vf \
tex-bzjlreq--upexpmgothrn-h.tfm \
tex-bzjlreq--upexpmgothrn-h.vf \
tex-bzjlreq--upexpmgothrn-v.tfm \
tex-bzjlreq--upexpmgothrn-v.vf \
tex-bzjlreq--upexpminb-h.tfm \
tex-bzjlreq--upexpminb-h.vf \
tex-bzjlreq--upexpminb-v.tfm \
tex-bzjlreq--upexpminb-v.vf \
tex-bzjlreq--upexpminbn-h.tfm \
tex-bzjlreq--upexpminbn-h.vf \
tex-bzjlreq--upexpminbn-v.tfm \
tex-bzjlreq--upexpminbn-v.vf \
tex-bzjlreq--upexpminl-h.tfm \
tex-bzjlreq--upexpminl-h.vf \
tex-bzjlreq--upexpminl-v.tfm \
tex-bzjlreq--upexpminl-v.vf \
tex-bzjlreq--upexpminln-h.tfm \
tex-bzjlreq--upexpminln-h.vf \
tex-bzjlreq--upexpminln-v.tfm \
tex-bzjlreq--upexpminln-v.vf \
tex-bzjlreq--upexpminr-h.tfm \
tex-bzjlreq--upexpminr-h.vf \
tex-bzjlreq--upexpminr-v.tfm \
tex-bzjlreq--upexpminr-v.vf \
tex-bzjlreq--upexpminrn-h.tfm \
tex-bzjlreq--upexpminrn-h.vf \
tex-bzjlreq--upexpminrn-v.tfm \
tex-bzjlreq--upexpminrn-v.vf \
tex-bzjlreq--upnmlgothb-h.tfm \
tex-bzjlreq--upnmlgothb-h.vf \
tex-bzjlreq--upnmlgothb-v.tfm \
tex-bzjlreq--upnmlgothb-v.vf \
tex-bzjlreq--upnmlgothbn-h.tfm \
tex-bzjlreq--upnmlgothbn-h.vf \
tex-bzjlreq--upnmlgothbn-v.tfm \
tex-bzjlreq--upnmlgothbn-v.vf \
tex-bzjlreq--upnmlgotheb-h.tfm \
tex-bzjlreq--upnmlgotheb-h.vf \
tex-bzjlreq--upnmlgotheb-v.tfm \
tex-bzjlreq--upnmlgotheb-v.vf \
tex-bzjlreq--upnmlgothebn-h.tfm \
tex-bzjlreq--upnmlgothebn-h.vf \
tex-bzjlreq--upnmlgothebn-v.tfm \
tex-bzjlreq--upnmlgothebn-v.vf \
tex-bzjlreq--upnmlgothr-h.tfm \
tex-bzjlreq--upnmlgothr-h.vf \
tex-bzjlreq--upnmlgothr-v.tfm \
tex-bzjlreq--upnmlgothr-v.vf \
tex-bzjlreq--upnmlgothrn-h.tfm \
tex-bzjlreq--upnmlgothrn-h.vf \
tex-bzjlreq--upnmlgothrn-v.tfm \
tex-bzjlreq--upnmlgothrn-v.vf \
tex-bzjlreq--upnmlmgothr-h.tfm \
tex-bzjlreq--upnmlmgothr-h.vf \
tex-bzjlreq--upnmlmgothr-v.tfm \
tex-bzjlreq--upnmlmgothr-v.vf \
tex-bzjlreq--upnmlmgothrn-h.tfm \
tex-bzjlreq--upnmlmgothrn-h.vf \
tex-bzjlreq--upnmlmgothrn-v.tfm \
tex-bzjlreq--upnmlmgothrn-v.vf \
tex-bzjlreq--upnmlminb-h.tfm \
tex-bzjlreq--upnmlminb-h.vf \
tex-bzjlreq--upnmlminb-v.tfm \
tex-bzjlreq--upnmlminb-v.vf \
tex-bzjlreq--upnmlminbn-h.tfm \
tex-bzjlreq--upnmlminbn-h.vf \
tex-bzjlreq--upnmlminbn-v.tfm \
tex-bzjlreq--upnmlminbn-v.vf \
tex-bzjlreq--upnmlminl-h.tfm \
tex-bzjlreq--upnmlminl-h.vf \
tex-bzjlreq--upnmlminl-v.tfm \
tex-bzjlreq--upnmlminl-v.vf \
tex-bzjlreq--upnmlminln-h.tfm \
tex-bzjlreq--upnmlminln-h.vf \
tex-bzjlreq--upnmlminln-v.tfm \
tex-bzjlreq--upnmlminln-v.vf \
tex-bzjlreq--upnmlminr-h.tfm \
tex-bzjlreq--upnmlminr-h.vf \
tex-bzjlreq--upnmlminr-v.tfm \
tex-bzjlreq--upnmlminr-v.vf \
tex-bzjlreq--upnmlminrn-h.tfm \
tex-bzjlreq--upnmlminrn-h.vf \
tex-bzjlreq--upnmlminrn-v.tfm \
tex-bzjlreq--upnmlminrn-v.vf \
tex-bzjlreq--uprubygothb-h.tfm \
tex-bzjlreq--uprubygothb-h.vf \
tex-bzjlreq--uprubygothb-v.tfm \
tex-bzjlreq--uprubygothb-v.vf \
tex-bzjlreq--uprubygotheb-h.tfm \
tex-bzjlreq--uprubygotheb-h.vf \
tex-bzjlreq--uprubygotheb-v.tfm \
tex-bzjlreq--uprubygotheb-v.vf \
tex-bzjlreq--uprubygothr-h.tfm \
tex-bzjlreq--uprubygothr-h.vf \
tex-bzjlreq--uprubygothr-v.tfm \
tex-bzjlreq--uprubygothr-v.vf \
tex-bzjlreq--uprubymgothr-h.tfm \
tex-bzjlreq--uprubymgothr-h.vf \
tex-bzjlreq--uprubymgothr-v.tfm \
tex-bzjlreq--uprubymgothr-v.vf \
tex-bzjlreq--uprubyminb-h.tfm \
tex-bzjlreq--uprubyminb-h.vf \
tex-bzjlreq--uprubyminb-v.tfm \
tex-bzjlreq--uprubyminb-v.vf \
tex-bzjlreq--uprubyminl-h.tfm \
tex-bzjlreq--uprubyminl-h.vf \
tex-bzjlreq--uprubyminl-v.tfm \
tex-bzjlreq--uprubyminl-v.vf \
tex-bzjlreq--uprubyminr-h.tfm \
tex-bzjlreq--uprubyminr-h.vf \
tex-bzjlreq--uprubyminr-v.tfm \
tex-bzjlreq--uprubyminr-v.vf \
tex-jlreq--expgothb-h.tfm \
tex-jlreq--expgothb-h.vf \
tex-jlreq--expgothb-v.tfm \
tex-jlreq--expgothb-v.vf \
tex-jlreq--expgothbn-h.tfm \
tex-jlreq--expgothbn-h.vf \
tex-jlreq--expgothbn-v.tfm \
tex-jlreq--expgothbn-v.vf \
tex-jlreq--expgotheb-h.tfm \
tex-jlreq--expgotheb-h.vf \
tex-jlreq--expgotheb-v.tfm \
tex-jlreq--expgotheb-v.vf \
tex-jlreq--expgothebn-h.tfm \
tex-jlreq--expgothebn-h.vf \
tex-jlreq--expgothebn-v.tfm \
tex-jlreq--expgothebn-v.vf \
tex-jlreq--expgothr-h.tfm \
tex-jlreq--expgothr-h.vf \
tex-jlreq--expgothr-v.tfm \
tex-jlreq--expgothr-v.vf \
tex-jlreq--expgothrn-h.tfm \
tex-jlreq--expgothrn-h.vf \
tex-jlreq--expgothrn-v.tfm \
tex-jlreq--expgothrn-v.vf \
tex-jlreq--expmgothr-h.tfm \
tex-jlreq--expmgothr-h.vf \
tex-jlreq--expmgothr-v.tfm \
tex-jlreq--expmgothr-v.vf \
tex-jlreq--expmgothrn-h.tfm \
tex-jlreq--expmgothrn-h.vf \
tex-jlreq--expmgothrn-v.tfm \
tex-jlreq--expmgothrn-v.vf \
tex-jlreq--expminb-h.tfm \
tex-jlreq--expminb-h.vf \
tex-jlreq--expminb-v.tfm \
tex-jlreq--expminb-v.vf \
tex-jlreq--expminbn-h.tfm \
tex-jlreq--expminbn-h.vf \
tex-jlreq--expminbn-v.tfm \
tex-jlreq--expminbn-v.vf \
tex-jlreq--expminl-h.tfm \
tex-jlreq--expminl-h.vf \
tex-jlreq--expminl-v.tfm \
tex-jlreq--expminl-v.vf \
tex-jlreq--expminln-h.tfm \
tex-jlreq--expminln-h.vf \
tex-jlreq--expminln-v.tfm \
tex-jlreq--expminln-v.vf \
tex-jlreq--expminr-h.tfm \
tex-jlreq--expminr-h.vf \
tex-jlreq--expminr-v.tfm \
tex-jlreq--expminr-v.vf \
tex-jlreq--expminrn-h.tfm \
tex-jlreq--expminrn-h.vf \
tex-jlreq--expminrn-v.tfm \
tex-jlreq--expminrn-v.vf \
tex-jlreq--nmlgothb-h.tfm \
tex-jlreq--nmlgothb-h.vf \
tex-jlreq--nmlgothb-v.tfm \
tex-jlreq--nmlgothb-v.vf \
tex-jlreq--nmlgothbn-h.tfm \
tex-jlreq--nmlgothbn-h.vf \
tex-jlreq--nmlgothbn-v.tfm \
tex-jlreq--nmlgothbn-v.vf \
tex-jlreq--nmlgotheb-h.tfm \
tex-jlreq--nmlgotheb-h.vf \
tex-jlreq--nmlgotheb-v.tfm \
tex-jlreq--nmlgotheb-v.vf \
tex-jlreq--nmlgothebn-h.tfm \
tex-jlreq--nmlgothebn-h.vf \
tex-jlreq--nmlgothebn-v.tfm \
tex-jlreq--nmlgothebn-v.vf \
tex-jlreq--nmlgothr-h.tfm \
tex-jlreq--nmlgothr-h.vf \
tex-jlreq--nmlgothr-v.tfm \
tex-jlreq--nmlgothr-v.vf \
tex-jlreq--nmlgothrn-h.tfm \
tex-jlreq--nmlgothrn-h.vf \
tex-jlreq--nmlgothrn-v.tfm \
tex-jlreq--nmlgothrn-v.vf \
tex-jlreq--nmlmgothr-h.tfm \
tex-jlreq--nmlmgothr-h.vf \
tex-jlreq--nmlmgothr-v.tfm \
tex-jlreq--nmlmgothr-v.vf \
tex-jlreq--nmlmgothrn-h.tfm \
tex-jlreq--nmlmgothrn-h.vf \
tex-jlreq--nmlmgothrn-v.tfm \
tex-jlreq--nmlmgothrn-v.vf \
tex-jlreq--nmlminb-h.tfm \
tex-jlreq--nmlminb-h.vf \
tex-jlreq--nmlminb-v.tfm \
tex-jlreq--nmlminb-v.vf \
tex-jlreq--nmlminbn-h.tfm \
tex-jlreq--nmlminbn-h.vf \
tex-jlreq--nmlminbn-v.tfm \
tex-jlreq--nmlminbn-v.vf \
tex-jlreq--nmlminl-h.tfm \
tex-jlreq--nmlminl-h.vf \
tex-jlreq--nmlminl-v.tfm \
tex-jlreq--nmlminl-v.vf \
tex-jlreq--nmlminln-h.tfm \
tex-jlreq--nmlminln-h.vf \
tex-jlreq--nmlminln-v.tfm \
tex-jlreq--nmlminln-v.vf \
tex-jlreq--nmlminr-h.tfm \
tex-jlreq--nmlminr-h.vf \
tex-jlreq--nmlminr-v.tfm \
tex-jlreq--nmlminr-v.vf \
tex-jlreq--nmlminrn-h.tfm \
tex-jlreq--nmlminrn-h.vf \
tex-jlreq--nmlminrn-v.tfm \
tex-jlreq--nmlminrn-v.vf \
tex-jlreq--rubygothb-h.tfm \
tex-jlreq--rubygothb-h.vf \
tex-jlreq--rubygothb-v.tfm \
tex-jlreq--rubygothb-v.vf \
tex-jlreq--rubygotheb-h.tfm \
tex-jlreq--rubygotheb-h.vf \
tex-jlreq--rubygotheb-v.tfm \
tex-jlreq--rubygotheb-v.vf \
tex-jlreq--rubygothr-h.tfm \
tex-jlreq--rubygothr-h.vf \
tex-jlreq--rubygothr-v.tfm \
tex-jlreq--rubygothr-v.vf \
tex-jlreq--rubymgothr-h.tfm \
tex-jlreq--rubymgothr-h.vf \
tex-jlreq--rubymgothr-v.tfm \
tex-jlreq--rubymgothr-v.vf \
tex-jlreq--rubyminb-h.tfm \
tex-jlreq--rubyminb-h.vf \
tex-jlreq--rubyminb-v.tfm \
tex-jlreq--rubyminb-v.vf \
tex-jlreq--rubyminl-h.tfm \
tex-jlreq--rubyminl-h.vf \
tex-jlreq--rubyminl-v.tfm \
tex-jlreq--rubyminl-v.vf \
tex-jlreq--rubyminr-h.tfm \
tex-jlreq--rubyminr-h.vf \
tex-jlreq--rubyminr-v.tfm \
tex-jlreq--rubyminr-v.vf \
tex-jlreq--upexpgothb-h.tfm \
tex-jlreq--upexpgothb-h.vf \
tex-jlreq--upexpgothb-v.tfm \
tex-jlreq--upexpgothb-v.vf \
tex-jlreq--upexpgothbn-h.tfm \
tex-jlreq--upexpgothbn-h.vf \
tex-jlreq--upexpgothbn-v.tfm \
tex-jlreq--upexpgothbn-v.vf \
tex-jlreq--upexpgotheb-h.tfm \
tex-jlreq--upexpgotheb-h.vf \
tex-jlreq--upexpgotheb-v.tfm \
tex-jlreq--upexpgotheb-v.vf \
tex-jlreq--upexpgothebn-h.tfm \
tex-jlreq--upexpgothebn-h.vf \
tex-jlreq--upexpgothebn-v.tfm \
tex-jlreq--upexpgothebn-v.vf \
tex-jlreq--upexpgothr-h.tfm \
tex-jlreq--upexpgothr-h.vf \
tex-jlreq--upexpgothr-v.tfm \
tex-jlreq--upexpgothr-v.vf \
tex-jlreq--upexpgothrn-h.tfm \
tex-jlreq--upexpgothrn-h.vf \
tex-jlreq--upexpgothrn-v.tfm \
tex-jlreq--upexpgothrn-v.vf \
tex-jlreq--upexpmgothr-h.tfm \
tex-jlreq--upexpmgothr-h.vf \
tex-jlreq--upexpmgothr-v.tfm \
tex-jlreq--upexpmgothr-v.vf \
tex-jlreq--upexpmgothrn-h.tfm \
tex-jlreq--upexpmgothrn-h.vf \
tex-jlreq--upexpmgothrn-v.tfm \
tex-jlreq--upexpmgothrn-v.vf \
tex-jlreq--upexpminb-h.tfm \
tex-jlreq--upexpminb-h.vf \
tex-jlreq--upexpminb-v.tfm \
tex-jlreq--upexpminb-v.vf \
tex-jlreq--upexpminbn-h.tfm \
tex-jlreq--upexpminbn-h.vf \
tex-jlreq--upexpminbn-v.tfm \
tex-jlreq--upexpminbn-v.vf \
tex-jlreq--upexpminl-h.tfm \
tex-jlreq--upexpminl-h.vf \
tex-jlreq--upexpminl-v.tfm \
tex-jlreq--upexpminl-v.vf \
tex-jlreq--upexpminln-h.tfm \
tex-jlreq--upexpminln-h.vf \
tex-jlreq--upexpminln-v.tfm \
tex-jlreq--upexpminln-v.vf \
tex-jlreq--upexpminr-h.tfm \
tex-jlreq--upexpminr-h.vf \
tex-jlreq--upexpminr-v.tfm \
tex-jlreq--upexpminr-v.vf \
tex-jlreq--upexpminrn-h.tfm \
tex-jlreq--upexpminrn-h.vf \
tex-jlreq--upexpminrn-v.tfm \
tex-jlreq--upexpminrn-v.vf \
tex-jlreq--upnmlgothb-h.tfm \
tex-jlreq--upnmlgothb-h.vf \
tex-jlreq--upnmlgothb-v.tfm \
tex-jlreq--upnmlgothb-v.vf \
tex-jlreq--upnmlgothbn-h.tfm \
tex-jlreq--upnmlgothbn-h.vf \
tex-jlreq--upnmlgothbn-v.tfm \
tex-jlreq--upnmlgothbn-v.vf \
tex-jlreq--upnmlgotheb-h.tfm \
tex-jlreq--upnmlgotheb-h.vf \
tex-jlreq--upnmlgotheb-v.tfm \
tex-jlreq--upnmlgotheb-v.vf \
tex-jlreq--upnmlgothebn-h.tfm \
tex-jlreq--upnmlgothebn-h.vf \
tex-jlreq--upnmlgothebn-v.tfm \
tex-jlreq--upnmlgothebn-v.vf \
tex-jlreq--upnmlgothr-h.tfm \
tex-jlreq--upnmlgothr-h.vf \
tex-jlreq--upnmlgothr-v.tfm \
tex-jlreq--upnmlgothr-v.vf \
tex-jlreq--upnmlgothrn-h.tfm \
tex-jlreq--upnmlgothrn-h.vf \
tex-jlreq--upnmlgothrn-v.tfm \
tex-jlreq--upnmlgothrn-v.vf \
tex-jlreq--upnmlmgothr-h.tfm \
tex-jlreq--upnmlmgothr-h.vf \
tex-jlreq--upnmlmgothr-v.tfm \
tex-jlreq--upnmlmgothr-v.vf \
tex-jlreq--upnmlmgothrn-h.tfm \
tex-jlreq--upnmlmgothrn-h.vf \
tex-jlreq--upnmlmgothrn-v.tfm \
tex-jlreq--upnmlmgothrn-v.vf \
tex-jlreq--upnmlminb-h.tfm \
tex-jlreq--upnmlminb-h.vf \
tex-jlreq--upnmlminb-v.tfm \
tex-jlreq--upnmlminb-v.vf \
tex-jlreq--upnmlminbn-h.tfm \
tex-jlreq--upnmlminbn-h.vf \
tex-jlreq--upnmlminbn-v.tfm \
tex-jlreq--upnmlminbn-v.vf \
tex-jlreq--upnmlminl-h.tfm \
tex-jlreq--upnmlminl-h.vf \
tex-jlreq--upnmlminl-v.tfm \
tex-jlreq--upnmlminl-v.vf \
tex-jlreq--upnmlminln-h.tfm \
tex-jlreq--upnmlminln-h.vf \
tex-jlreq--upnmlminln-v.tfm \
tex-jlreq--upnmlminln-v.vf \
tex-jlreq--upnmlminr-h.tfm \
tex-jlreq--upnmlminr-h.vf \
tex-jlreq--upnmlminr-v.tfm \
tex-jlreq--upnmlminr-v.vf \
tex-jlreq--upnmlminrn-h.tfm \
tex-jlreq--upnmlminrn-h.vf \
tex-jlreq--upnmlminrn-v.tfm \
tex-jlreq--upnmlminrn-v.vf \
tex-jlreq--uprubygothb-h.tfm \
tex-jlreq--uprubygothb-h.vf \
tex-jlreq--uprubygothb-v.tfm \
tex-jlreq--uprubygothb-v.vf \
tex-jlreq--uprubygotheb-h.tfm \
tex-jlreq--uprubygotheb-h.vf \
tex-jlreq--uprubygotheb-v.tfm \
tex-jlreq--uprubygotheb-v.vf \
tex-jlreq--uprubygothr-h.tfm \
tex-jlreq--uprubygothr-h.vf \
tex-jlreq--uprubygothr-v.tfm \
tex-jlreq--uprubygothr-v.vf \
tex-jlreq--uprubymgothr-h.tfm \
tex-jlreq--uprubymgothr-h.vf \
tex-jlreq--uprubymgothr-v.tfm \
tex-jlreq--uprubymgothr-v.vf \
tex-jlreq--uprubyminb-h.tfm \
tex-jlreq--uprubyminb-h.vf \
tex-jlreq--uprubyminb-v.tfm \
tex-jlreq--uprubyminb-v.vf \
tex-jlreq--uprubyminl-h.tfm \
tex-jlreq--uprubyminl-h.vf \
tex-jlreq--uprubyminl-v.tfm \
tex-jlreq--uprubyminl-v.vf \
tex-jlreq--uprubyminr-h.tfm \
tex-jlreq--uprubyminr-h.vf \
tex-jlreq--uprubyminr-v.tfm \
tex-jlreq--uprubyminr-v.vf \
tex-jlreq-deluxe.sty \
tex-zjlreq--expgothb-h.tfm \
tex-zjlreq--expgothb-h.vf \
tex-zjlreq--expgothb-v.tfm \
tex-zjlreq--expgothb-v.vf \
tex-zjlreq--expgothbn-h.tfm \
tex-zjlreq--expgothbn-h.vf \
tex-zjlreq--expgothbn-v.tfm \
tex-zjlreq--expgothbn-v.vf \
tex-zjlreq--expgotheb-h.tfm \
tex-zjlreq--expgotheb-h.vf \
tex-zjlreq--expgotheb-v.tfm \
tex-zjlreq--expgotheb-v.vf \
tex-zjlreq--expgothebn-h.tfm \
tex-zjlreq--expgothebn-h.vf \
tex-zjlreq--expgothebn-v.tfm \
tex-zjlreq--expgothebn-v.vf \
tex-zjlreq--expgothr-h.tfm \
tex-zjlreq--expgothr-h.vf \
tex-zjlreq--expgothr-v.tfm \
tex-zjlreq--expgothr-v.vf \
tex-zjlreq--expgothrn-h.tfm \
tex-zjlreq--expgothrn-h.vf \
tex-zjlreq--expgothrn-v.tfm \
tex-zjlreq--expgothrn-v.vf \
tex-zjlreq--expmgothr-h.tfm \
tex-zjlreq--expmgothr-h.vf \
tex-zjlreq--expmgothr-v.tfm \
tex-zjlreq--expmgothr-v.vf \
tex-zjlreq--expmgothrn-h.tfm \
tex-zjlreq--expmgothrn-h.vf \
tex-zjlreq--expmgothrn-v.tfm \
tex-zjlreq--expmgothrn-v.vf \
tex-zjlreq--expminb-h.tfm \
tex-zjlreq--expminb-h.vf \
tex-zjlreq--expminb-v.tfm \
tex-zjlreq--expminb-v.vf \
tex-zjlreq--expminbn-h.tfm \
tex-zjlreq--expminbn-h.vf \
tex-zjlreq--expminbn-v.tfm \
tex-zjlreq--expminbn-v.vf \
tex-zjlreq--expminl-h.tfm \
tex-zjlreq--expminl-h.vf \
tex-zjlreq--expminl-v.tfm \
tex-zjlreq--expminl-v.vf \
tex-zjlreq--expminln-h.tfm \
tex-zjlreq--expminln-h.vf \
tex-zjlreq--expminln-v.tfm \
tex-zjlreq--expminln-v.vf \
tex-zjlreq--expminr-h.tfm \
tex-zjlreq--expminr-h.vf \
tex-zjlreq--expminr-v.tfm \
tex-zjlreq--expminr-v.vf \
tex-zjlreq--expminrn-h.tfm \
tex-zjlreq--expminrn-h.vf \
tex-zjlreq--expminrn-v.tfm \
tex-zjlreq--expminrn-v.vf \
tex-zjlreq--nmlgothb-h.tfm \
tex-zjlreq--nmlgothb-h.vf \
tex-zjlreq--nmlgothb-v.tfm \
tex-zjlreq--nmlgothb-v.vf \
tex-zjlreq--nmlgothbn-h.tfm \
tex-zjlreq--nmlgothbn-h.vf \
tex-zjlreq--nmlgothbn-v.tfm \
tex-zjlreq--nmlgothbn-v.vf \
tex-zjlreq--nmlgotheb-h.tfm \
tex-zjlreq--nmlgotheb-h.vf \
tex-zjlreq--nmlgotheb-v.tfm \
tex-zjlreq--nmlgotheb-v.vf \
tex-zjlreq--nmlgothebn-h.tfm \
tex-zjlreq--nmlgothebn-h.vf \
tex-zjlreq--nmlgothebn-v.tfm \
tex-zjlreq--nmlgothebn-v.vf \
tex-zjlreq--nmlgothr-h.tfm \
tex-zjlreq--nmlgothr-h.vf \
tex-zjlreq--nmlgothr-v.tfm \
tex-zjlreq--nmlgothr-v.vf \
tex-zjlreq--nmlgothrn-h.tfm \
tex-zjlreq--nmlgothrn-h.vf \
tex-zjlreq--nmlgothrn-v.tfm \
tex-zjlreq--nmlgothrn-v.vf \
tex-zjlreq--nmlmgothr-h.tfm \
tex-zjlreq--nmlmgothr-h.vf \
tex-zjlreq--nmlmgothr-v.tfm \
tex-zjlreq--nmlmgothr-v.vf \
tex-zjlreq--nmlmgothrn-h.tfm \
tex-zjlreq--nmlmgothrn-h.vf \
tex-zjlreq--nmlmgothrn-v.tfm \
tex-zjlreq--nmlmgothrn-v.vf \
tex-zjlreq--nmlminb-h.tfm \
tex-zjlreq--nmlminb-h.vf \
tex-zjlreq--nmlminb-v.tfm \
tex-zjlreq--nmlminb-v.vf \
tex-zjlreq--nmlminbn-h.tfm \
tex-zjlreq--nmlminbn-h.vf \
tex-zjlreq--nmlminbn-v.tfm \
tex-zjlreq--nmlminbn-v.vf \
tex-zjlreq--nmlminl-h.tfm \
tex-zjlreq--nmlminl-h.vf \
tex-zjlreq--nmlminl-v.tfm \
tex-zjlreq--nmlminl-v.vf \
tex-zjlreq--nmlminln-h.tfm \
tex-zjlreq--nmlminln-h.vf \
tex-zjlreq--nmlminln-v.tfm \
tex-zjlreq--nmlminln-v.vf \
tex-zjlreq--nmlminr-h.tfm \
tex-zjlreq--nmlminr-h.vf \
tex-zjlreq--nmlminr-v.tfm \
tex-zjlreq--nmlminr-v.vf \
tex-zjlreq--nmlminrn-h.tfm \
tex-zjlreq--nmlminrn-h.vf \
tex-zjlreq--nmlminrn-v.tfm \
tex-zjlreq--nmlminrn-v.vf \
tex-zjlreq--rubygothb-h.tfm \
tex-zjlreq--rubygothb-h.vf \
tex-zjlreq--rubygothb-v.tfm \
tex-zjlreq--rubygothb-v.vf \
tex-zjlreq--rubygotheb-h.tfm \
tex-zjlreq--rubygotheb-h.vf \
tex-zjlreq--rubygotheb-v.tfm \
tex-zjlreq--rubygotheb-v.vf \
tex-zjlreq--rubygothr-h.tfm \
tex-zjlreq--rubygothr-h.vf \
tex-zjlreq--rubygothr-v.tfm \
tex-zjlreq--rubygothr-v.vf \
tex-zjlreq--rubymgothr-h.tfm \
tex-zjlreq--rubymgothr-h.vf \
tex-zjlreq--rubymgothr-v.tfm \
tex-zjlreq--rubymgothr-v.vf \
tex-zjlreq--rubyminb-h.tfm \
tex-zjlreq--rubyminb-h.vf \
tex-zjlreq--rubyminb-v.tfm \
tex-zjlreq--rubyminb-v.vf \
tex-zjlreq--rubyminl-h.tfm \
tex-zjlreq--rubyminl-h.vf \
tex-zjlreq--rubyminl-v.tfm \
tex-zjlreq--rubyminl-v.vf \
tex-zjlreq--rubyminr-h.tfm \
tex-zjlreq--rubyminr-h.vf \
tex-zjlreq--rubyminr-v.tfm \
tex-zjlreq--rubyminr-v.vf \
tex-zjlreq--upexpgothb-h.tfm \
tex-zjlreq--upexpgothb-h.vf \
tex-zjlreq--upexpgothb-v.tfm \
tex-zjlreq--upexpgothb-v.vf \
tex-zjlreq--upexpgothbn-h.tfm \
tex-zjlreq--upexpgothbn-h.vf \
tex-zjlreq--upexpgothbn-v.tfm \
tex-zjlreq--upexpgothbn-v.vf \
tex-zjlreq--upexpgotheb-h.tfm \
tex-zjlreq--upexpgotheb-h.vf \
tex-zjlreq--upexpgotheb-v.tfm \
tex-zjlreq--upexpgotheb-v.vf \
tex-zjlreq--upexpgothebn-h.tfm \
tex-zjlreq--upexpgothebn-h.vf \
tex-zjlreq--upexpgothebn-v.tfm \
tex-zjlreq--upexpgothebn-v.vf \
tex-zjlreq--upexpgothr-h.tfm \
tex-zjlreq--upexpgothr-h.vf \
tex-zjlreq--upexpgothr-v.tfm \
tex-zjlreq--upexpgothr-v.vf \
tex-zjlreq--upexpgothrn-h.tfm \
tex-zjlreq--upexpgothrn-h.vf \
tex-zjlreq--upexpgothrn-v.tfm \
tex-zjlreq--upexpgothrn-v.vf \
tex-zjlreq--upexpmgothr-h.tfm \
tex-zjlreq--upexpmgothr-h.vf \
tex-zjlreq--upexpmgothr-v.tfm \
tex-zjlreq--upexpmgothr-v.vf \
tex-zjlreq--upexpmgothrn-h.tfm \
tex-zjlreq--upexpmgothrn-h.vf \
tex-zjlreq--upexpmgothrn-v.tfm \
tex-zjlreq--upexpmgothrn-v.vf \
tex-zjlreq--upexpminb-h.tfm \
tex-zjlreq--upexpminb-h.vf \
tex-zjlreq--upexpminb-v.tfm \
tex-zjlreq--upexpminb-v.vf \
tex-zjlreq--upexpminbn-h.tfm \
tex-zjlreq--upexpminbn-h.vf \
tex-zjlreq--upexpminbn-v.tfm \
tex-zjlreq--upexpminbn-v.vf \
tex-zjlreq--upexpminl-h.tfm \
tex-zjlreq--upexpminl-h.vf \
tex-zjlreq--upexpminl-v.tfm \
tex-zjlreq--upexpminl-v.vf \
tex-zjlreq--upexpminln-h.tfm \
tex-zjlreq--upexpminln-h.vf \
tex-zjlreq--upexpminln-v.tfm \
tex-zjlreq--upexpminln-v.vf \
tex-zjlreq--upexpminr-h.tfm \
tex-zjlreq--upexpminr-h.vf \
tex-zjlreq--upexpminr-v.tfm \
tex-zjlreq--upexpminr-v.vf \
tex-zjlreq--upexpminrn-h.tfm \
tex-zjlreq--upexpminrn-h.vf \
tex-zjlreq--upexpminrn-v.tfm \
tex-zjlreq--upexpminrn-v.vf \
tex-zjlreq--upnmlgothb-h.tfm \
tex-zjlreq--upnmlgothb-h.vf \
tex-zjlreq--upnmlgothb-v.tfm \
tex-zjlreq--upnmlgothb-v.vf \
tex-zjlreq--upnmlgothbn-h.tfm \
tex-zjlreq--upnmlgothbn-h.vf \
tex-zjlreq--upnmlgothbn-v.tfm \
tex-zjlreq--upnmlgothbn-v.vf \
tex-zjlreq--upnmlgotheb-h.tfm \
tex-zjlreq--upnmlgotheb-h.vf \
tex-zjlreq--upnmlgotheb-v.tfm \
tex-zjlreq--upnmlgotheb-v.vf \
tex-zjlreq--upnmlgothebn-h.tfm \
tex-zjlreq--upnmlgothebn-h.vf \
tex-zjlreq--upnmlgothebn-v.tfm \
tex-zjlreq--upnmlgothebn-v.vf \
tex-zjlreq--upnmlgothr-h.tfm \
tex-zjlreq--upnmlgothr-h.vf \
tex-zjlreq--upnmlgothr-v.tfm \
tex-zjlreq--upnmlgothr-v.vf \
tex-zjlreq--upnmlgothrn-h.tfm \
tex-zjlreq--upnmlgothrn-h.vf \
tex-zjlreq--upnmlgothrn-v.tfm \
tex-zjlreq--upnmlgothrn-v.vf \
tex-zjlreq--upnmlmgothr-h.tfm \
tex-zjlreq--upnmlmgothr-h.vf \
tex-zjlreq--upnmlmgothr-v.tfm \
tex-zjlreq--upnmlmgothr-v.vf \
tex-zjlreq--upnmlmgothrn-h.tfm \
tex-zjlreq--upnmlmgothrn-h.vf \
tex-zjlreq--upnmlmgothrn-v.tfm \
tex-zjlreq--upnmlmgothrn-v.vf \
tex-zjlreq--upnmlminb-h.tfm \
tex-zjlreq--upnmlminb-h.vf \
tex-zjlreq--upnmlminb-v.tfm \
tex-zjlreq--upnmlminb-v.vf \
tex-zjlreq--upnmlminbn-h.tfm \
tex-zjlreq--upnmlminbn-h.vf \
tex-zjlreq--upnmlminbn-v.tfm \
tex-zjlreq--upnmlminbn-v.vf \
tex-zjlreq--upnmlminl-h.tfm \
tex-zjlreq--upnmlminl-h.vf \
tex-zjlreq--upnmlminl-v.tfm \
tex-zjlreq--upnmlminl-v.vf \
tex-zjlreq--upnmlminln-h.tfm \
tex-zjlreq--upnmlminln-h.vf \
tex-zjlreq--upnmlminln-v.tfm \
tex-zjlreq--upnmlminln-v.vf \
tex-zjlreq--upnmlminr-h.tfm \
tex-zjlreq--upnmlminr-h.vf \
tex-zjlreq--upnmlminr-v.tfm \
tex-zjlreq--upnmlminr-v.vf \
tex-zjlreq--upnmlminrn-h.tfm \
tex-zjlreq--upnmlminrn-h.vf \
tex-zjlreq--upnmlminrn-v.tfm \
tex-zjlreq--upnmlminrn-v.vf \
tex-zjlreq--uprubygothb-h.tfm \
tex-zjlreq--uprubygothb-h.vf \
tex-zjlreq--uprubygothb-v.tfm \
tex-zjlreq--uprubygothb-v.vf \
tex-zjlreq--uprubygotheb-h.tfm \
tex-zjlreq--uprubygotheb-h.vf \
tex-zjlreq--uprubygotheb-v.tfm \
tex-zjlreq--uprubygotheb-v.vf \
tex-zjlreq--uprubygothr-h.tfm \
tex-zjlreq--uprubygothr-h.vf \
tex-zjlreq--uprubygothr-v.tfm \
tex-zjlreq--uprubygothr-v.vf \
tex-zjlreq--uprubymgothr-h.tfm \
tex-zjlreq--uprubymgothr-h.vf \
tex-zjlreq--uprubymgothr-v.tfm \
tex-zjlreq--uprubymgothr-v.vf \
tex-zjlreq--uprubyminb-h.tfm \
tex-zjlreq--uprubyminb-h.vf \
tex-zjlreq--uprubyminb-v.tfm \
tex-zjlreq--uprubyminb-v.vf \
tex-zjlreq--uprubyminl-h.tfm \
tex-zjlreq--uprubyminl-h.vf \
tex-zjlreq--uprubyminl-v.tfm \
tex-zjlreq--uprubyminl-v.vf \
tex-zjlreq--uprubyminr-h.tfm \
tex-zjlreq--uprubyminr-h.vf \
tex-zjlreq--uprubyminr-v.tfm \
tex-zjlreq--uprubyminr-v.vf \
texlive-jlreq-deluxe"

RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-expl3.sty \
tex-hgothb-h.tfm \
tex-hgothb-v.tfm \
tex-hgothbn-h.tfm \
tex-hgothbn-v.tfm \
tex-hgotheb-h.tfm \
tex-hgotheb-v.tfm \
tex-hgothebn-h.tfm \
tex-hgothebn-v.tfm \
tex-hgothr-h.tfm \
tex-hgothr-v.tfm \
tex-hgothrn-h.tfm \
tex-hgothrn-v.tfm \
tex-hmgothr-h.tfm \
tex-hmgothr-v.tfm \
tex-hmgothrn-h.tfm \
tex-hmgothrn-v.tfm \
tex-hminb-h.tfm \
tex-hminb-v.tfm \
tex-hminbn-h.tfm \
tex-hminbn-v.tfm \
tex-hminl-h.tfm \
tex-hminl-v.tfm \
tex-hminln-h.tfm \
tex-hminln-v.tfm \
tex-hminr-h.tfm \
tex-hminr-v.tfm \
tex-hminrn-h.tfm \
tex-hminrn-v.tfm \
tex-l3keys2e.sty \
tex-otf-cjgb-h.tfm \
tex-otf-cjgb-v.tfm \
tex-otf-cjge-h.tfm \
tex-otf-cjge-v.tfm \
tex-otf-cjgr-h.tfm \
tex-otf-cjgr-v.tfm \
tex-otf-cjmb-h.tfm \
tex-otf-cjmb-v.tfm \
tex-otf-cjmgr-h.tfm \
tex-otf-cjmgr-v.tfm \
tex-otf-cjml-h.tfm \
tex-otf-cjml-v.tfm \
tex-otf-cjmr-h.tfm \
tex-otf-cjmr-v.tfm \
tex-pxjodel.sty \
tex-uphgothb-h.tfm \
tex-uphgothb-v.tfm \
tex-uphgothbn-h.tfm \
tex-uphgothbn-v.tfm \
tex-uphgotheb-h.tfm \
tex-uphgotheb-v.tfm \
tex-uphgothebn-h.tfm \
tex-uphgothebn-v.tfm \
tex-uphgothr-h.tfm \
tex-uphgothr-v.tfm \
tex-uphgothrn-h.tfm \
tex-uphgothrn-v.tfm \
tex-uphmgothr-h.tfm \
tex-uphmgothr-v.tfm \
tex-uphmgothrn-h.tfm \
tex-uphmgothrn-v.tfm \
tex-uphminb-h.tfm \
tex-uphminb-v.tfm \
tex-uphminbn-h.tfm \
tex-uphminbn-v.tfm \
tex-uphminl-h.tfm \
tex-uphminl-v.tfm \
tex-uphminln-h.tfm \
tex-uphminln-v.tfm \
tex-uphminr-h.tfm \
tex-uphminr-v.tfm \
tex-uphminrn-h.tfm \
tex-uphminrn-v.tfm \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
