SUMMARY = "Python bindings for upm"
DESCRIPTION = "The UPM repository provides software drivers for a wide variety of commonly \
used sensors and actuators. These software drivers interact with the \
underlying hardware platform (or microcontroller), as well as with the \
attached sensors, through calls to MRAA APIs. \
 \
This package contains python3 bindings for upm."
LICENSE = "MIT"

PV = "2.0.0"

RPM_NAME = "python3-upm-2.0.0-4.2.aarch64.rpm"
RPM_HASH = "958a14c00db808601473b006e780beb48fdea9e0b9f437d23a32432d013e0bc8908ad8bebc9f51e91f326d85fa96770330d215a8a8a87f3e36ae95659379d75c"

RPROVIDES:${PN} += "python3-upm"

RDEPENDS:${PN} += "ld-linux-aarch64.so.1 \
libc.so.6 \
libgcc-s.so.1 \
libmraa.so.2 \
libpython3.11.so.1.0 \
libstdc++.so.6 \
libupm-2jciebu01-usb.so.1 \
libupm-a110x.so.1 \
libupm-abp.so.1 \
libupm-ad8232.so.1 \
libupm-adafruitms1438.so.1 \
libupm-adafruitss.so.1 \
libupm-adc121c021.so.1 \
libupm-adis16448.so.1 \
libupm-ads1x15.so.1 \
libupm-adxl335.so.1 \
libupm-adxl345.so.1 \
libupm-adxrs610.so.1 \
libupm-am2315.so.1 \
libupm-apa102.so.1 \
libupm-apds9002.so.1 \
libupm-apds9930.so.1 \
libupm-at42qt1070.so.1 \
libupm-bh1749.so.1 \
libupm-bh1750.so.1 \
libupm-bh1792.so.1 \
libupm-biss0001.so.1 \
libupm-bma220.so.1 \
libupm-bma250e.so.1 \
libupm-bmg160.so.1 \
libupm-bmi160.so.1 \
libupm-bmm150.so.1 \
libupm-bmp280.so.1 \
libupm-bmpx8x.so.1 \
libupm-bmx055.so.1 \
libupm-bno055.so.1 \
libupm-button.so.1 \
libupm-buzzer.so.1 \
libupm-cjq4435.so.1 \
libupm-collision.so.1 \
libupm-cwlsxxa.so.1 \
libupm-dfrec.so.1 \
libupm-dfrorp.so.1 \
libupm-dfrph.so.1 \
libupm-ds1307.so.1 \
libupm-ds1808lc.so.1 \
libupm-ds18b20.so.1 \
libupm-ds2413.so.1 \
libupm-ecezo.so.1 \
libupm-ecs1030.so.1 \
libupm-ehr.so.1 \
libupm-eldriver.so.1 \
libupm-electromagnet.so.1 \
libupm-emg.so.1 \
libupm-enc03r.so.1 \
libupm-flex.so.1 \
libupm-gas.so.1 \
libupm-gp2y0a.so.1 \
libupm-gprs.so.1 \
libupm-gsr.so.1 \
libupm-guvas12d.so.1 \
libupm-h3lis331dl.so.1 \
libupm-hcsr04.so.1 \
libupm-hdc1000.so.1 \
libupm-hdxxvxta.so.1 \
libupm-hka5.so.1 \
libupm-hlg150h.so.1 \
libupm-hm11.so.1 \
libupm-hmc5883l.so.1 \
libupm-hmtrp.so.1 \
libupm-hp20x.so.1 \
libupm-ht9170.so.1 \
libupm-htu21d.so.1 \
libupm-hx711.so.1 \
libupm-ili9341.so.1 \
libupm-ims.so.1 \
libupm-ina132.so.1 \
libupm-isd1820.so.1 \
libupm-itg3200.so.1 \
libupm-jhd1313m1.so.1 \
libupm-joystick12.so.1 \
libupm-kx122.so.1 \
libupm-kxcjk1013.so.1 \
libupm-kxtj3.so.1 \
libupm-l298.so.1 \
libupm-l3gd20.so.1 \
libupm-lcd.so.1 \
libupm-lcdks.so.1 \
libupm-lcm1602.so.1 \
libupm-ldt0028.so.1 \
libupm-led.so.1 \
libupm-lidarlitev3.so.1 \
libupm-light.so.1 \
libupm-linefinder.so.1 \
libupm-lis2ds12.so.1 \
libupm-lis3dh.so.1 \
libupm-lm35.so.1 \
libupm-lol.so.1 \
libupm-loudness.so.1 \
libupm-lp8860.so.1 \
libupm-lpd8806.so.1 \
libupm-lsm303agr.so.1 \
libupm-lsm303d.so.1 \
libupm-lsm303dlh.so.1 \
libupm-lsm6ds3h.so.1 \
libupm-lsm6dsl.so.1 \
libupm-lsm9ds0.so.1 \
libupm-m24lr64e.so.1 \
libupm-mag3110.so.1 \
libupm-max30100.so.1 \
libupm-max31723.so.1 \
libupm-max31855.so.1 \
libupm-max44000.so.1 \
libupm-max44009.so.1 \
libupm-max5487.so.1 \
libupm-maxds3231m.so.1 \
libupm-maxsonarez.so.1 \
libupm-mb704x.so.1 \
libupm-mcp2515.so.1 \
libupm-mcp9808.so.1 \
libupm-md.so.1 \
libupm-mg811.so.1 \
libupm-mhz16.so.1 \
libupm-mic.so.1 \
libupm-micsv89.so.1 \
libupm-mlx90614.so.1 \
libupm-mma7361.so.1 \
libupm-mma7455.so.1 \
libupm-mma7660.so.1 \
libupm-mma8x5x.so.1 \
libupm-mmc35240.so.1 \
libupm-moisture.so.1 \
libupm-mpl3115a2.so.1 \
libupm-mpr121.so.1 \
libupm-mpu9150.so.1 \
libupm-mq303a.so.1 \
libupm-ms5611.so.1 \
libupm-ms5803.so.1 \
libupm-my9221.so.1 \
libupm-nlgpio16.so.1 \
libupm-nmea-gps.so.1 \
libupm-nrf24l01.so.1 \
libupm-nrf8001.so.1 \
libupm-nunchuck.so.1 \
libupm-o2.so.1 \
libupm-otp538u.so.1 \
libupm-p9813.so.1 \
libupm-pca9685.so.1 \
libupm-pn532.so.1 \
libupm-ppd42ns.so.1 \
libupm-pulsensor.so.1 \
libupm-relay.so.1 \
libupm-rf22.so.1 \
libupm-rfr359f.so.1 \
libupm-rgbringcoder.so.1 \
libupm-rhusb.so.1 \
libupm-rn2903.so.1 \
libupm-rotary.so.1 \
libupm-rotaryencoder.so.1 \
libupm-rpr220.so.1 \
libupm-rsc.so.1 \
libupm-scam.so.1 \
libupm-sensortemplate.so.1 \
libupm-servo.so.1 \
libupm-sht1x.so.1 \
libupm-si1132.so.1 \
libupm-si114x.so.1 \
libupm-si7005.so.1 \
libupm-slide.so.1 \
libupm-sm130.so.1 \
libupm-smartdrive.so.1 \
libupm-speaker.so.1 \
libupm-ssd1351.so.1 \
libupm-st7735.so.1 \
libupm-stepmotor.so.1 \
libupm-sx1276.so.1 \
libupm-sx6119.so.1 \
libupm-t6713.so.1 \
libupm-ta12200.so.1 \
libupm-tca9548a.so.1 \
libupm-tcs3414cs.so.1 \
libupm-tcs37727.so.1 \
libupm-teams.so.1 \
libupm-temperature.so.1 \
libupm-tex00.so.1 \
libupm-th02.so.1 \
libupm-tm1637.so.1 \
libupm-tmp006.so.1 \
libupm-tsl2561.so.1 \
libupm-ttp223.so.1 \
libupm-uartat.so.1 \
libupm-uln200xa.so.1 \
libupm-ultrasonic.so.1 \
libupm-urm37.so.1 \
libupm-vcap.so.1 \
libupm-vdiv.so.1 \
libupm-veml6070.so.1 \
libupm-water.so.1 \
libupm-waterlevel.so.1 \
libupm-wfs.so.1 \
libupm-wheelencoder.so.1 \
libupm-wt5001.so.1 \
libupm-xbee.so.1 \
libupm-yg1006.so.1 \
libupm-zfm20.so.1 \
libupm1 \
libupmc-bh1749.so.1 \
libupmc-bh1792.so.1 \
libupmc-ds18b20.so.1 \
libupmc-enc03r.so.1 \
libupmc-hcsr04.so.1 \
libupmc-kx122.so.1 \
libupmc-kxtj3.so.1 \
libupmc-my9221.so.1 \
libupmc-otp538u.so.1 \
libupmc-wfs.so.1 \
python-abi"

inherit rpm
