SUMMARY = "Drawing flags with TikZ"
DESCRIPTION = "This is a package for drawing flags using TikZ. Currently the \
national flags of all independent nations are included, \
additionally some other flags of various organizations. A flag \
can be drawn ... as a single TikZ-picture within ordinary text, \
as a picture element within a TikZ-picture. The appearance of a \
flag (size, frame etc.) can be adapted using optional \
parameters."
LICENSE = "LPPL-1.0"

PV = "2023.201.svn59171"

RPM_NAME = "texlive-worldflags-2023.201.svn59171-53.1.noarch.rpm"
RPM_HASH = "9437501c85dd18d97211cfa36567a305fd74bd4c9abe7fe937f90b8a2c2f37c478d33fbbd616b35d069bab40e6bf19decf0768e5e13a086cdbea58d018731eab"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-worldflag-0.tex \
tex-worldflag-1.tex \
tex-worldflag-2.tex \
tex-worldflag-3.tex \
tex-worldflag-4.tex \
tex-worldflag-5.tex \
tex-worldflag-6.tex \
tex-worldflag-7.tex \
tex-worldflag-8.tex \
tex-worldflag-9.tex \
tex-worldflag-A.tex \
tex-worldflag-AD.tex \
tex-worldflag-AE.tex \
tex-worldflag-AF.tex \
tex-worldflag-AG.tex \
tex-worldflag-AL.tex \
tex-worldflag-AM.tex \
tex-worldflag-AO.tex \
tex-worldflag-AQ.tex \
tex-worldflag-AR.tex \
tex-worldflag-AT-B.tex \
tex-worldflag-AT-K.tex \
tex-worldflag-AT-N.tex \
tex-worldflag-AT-O.tex \
tex-worldflag-AT-S.tex \
tex-worldflag-AT-St.tex \
tex-worldflag-AT-T.tex \
tex-worldflag-AT-V.tex \
tex-worldflag-AT-W.tex \
tex-worldflag-AT.tex \
tex-worldflag-AU.tex \
tex-worldflag-AX.tex \
tex-worldflag-AZ.tex \
tex-worldflag-Abkhazia.tex \
tex-worldflag-Artsakh.tex \
tex-worldflag-B.tex \
tex-worldflag-BA.tex \
tex-worldflag-BB.tex \
tex-worldflag-BD.tex \
tex-worldflag-BE.tex \
tex-worldflag-BF.tex \
tex-worldflag-BG.tex \
tex-worldflag-BH.tex \
tex-worldflag-BI.tex \
tex-worldflag-BJ.tex \
tex-worldflag-BN.tex \
tex-worldflag-BO.tex \
tex-worldflag-BR.tex \
tex-worldflag-BS.tex \
tex-worldflag-BT.tex \
tex-worldflag-BW.tex \
tex-worldflag-BY.tex \
tex-worldflag-BZ.tex \
tex-worldflag-Bonaire.tex \
tex-worldflag-Buddhism.tex \
tex-worldflag-C.tex \
tex-worldflag-CA.tex \
tex-worldflag-CD.tex \
tex-worldflag-CF.tex \
tex-worldflag-CG.tex \
tex-worldflag-CH.tex \
tex-worldflag-CI.tex \
tex-worldflag-CK.tex \
tex-worldflag-CL.tex \
tex-worldflag-CM.tex \
tex-worldflag-CN.tex \
tex-worldflag-CO.tex \
tex-worldflag-CR.tex \
tex-worldflag-CU.tex \
tex-worldflag-CV.tex \
tex-worldflag-CY.tex \
tex-worldflag-CZ.tex \
tex-worldflag-Christian.tex \
tex-worldflag-D.tex \
tex-worldflag-DE.tex \
tex-worldflag-DJ.tex \
tex-worldflag-DK.tex \
tex-worldflag-DM.tex \
tex-worldflag-DO.tex \
tex-worldflag-DZ.tex \
tex-worldflag-E.tex \
tex-worldflag-EC.tex \
tex-worldflag-EE.tex \
tex-worldflag-EG.tex \
tex-worldflag-EH.tex \
tex-worldflag-ER.tex \
tex-worldflag-ES.tex \
tex-worldflag-ET.tex \
tex-worldflag-EU.tex \
tex-worldflag-Esperanto.tex \
tex-worldflag-F.tex \
tex-worldflag-FI.tex \
tex-worldflag-FJ.tex \
tex-worldflag-FM.tex \
tex-worldflag-FO.tex \
tex-worldflag-FR.tex \
tex-worldflag-G.tex \
tex-worldflag-GA.tex \
tex-worldflag-GB.tex \
tex-worldflag-GD.tex \
tex-worldflag-GE.tex \
tex-worldflag-GF.tex \
tex-worldflag-GG.tex \
tex-worldflag-GH.tex \
tex-worldflag-GI.tex \
tex-worldflag-GL.tex \
tex-worldflag-GM.tex \
tex-worldflag-GN.tex \
tex-worldflag-GQ.tex \
tex-worldflag-GR.tex \
tex-worldflag-GT.tex \
tex-worldflag-GW.tex \
tex-worldflag-GY.tex \
tex-worldflag-H.tex \
tex-worldflag-HN.tex \
tex-worldflag-HR.tex \
tex-worldflag-HT.tex \
tex-worldflag-HU.tex \
tex-worldflag-I.tex \
tex-worldflag-ID.tex \
tex-worldflag-IE.tex \
tex-worldflag-IL.tex \
tex-worldflag-IM.tex \
tex-worldflag-IN.tex \
tex-worldflag-IQ.tex \
tex-worldflag-IR.tex \
tex-worldflag-IS.tex \
tex-worldflag-IT.tex \
tex-worldflag-J.tex \
tex-worldflag-JE.tex \
tex-worldflag-JM.tex \
tex-worldflag-JO.tex \
tex-worldflag-JP.tex \
tex-worldflag-JollyRoger.tex \
tex-worldflag-K.tex \
tex-worldflag-KE.tex \
tex-worldflag-KG.tex \
tex-worldflag-KH.tex \
tex-worldflag-KI.tex \
tex-worldflag-KM.tex \
tex-worldflag-KN.tex \
tex-worldflag-KO.tex \
tex-worldflag-KP.tex \
tex-worldflag-KR.tex \
tex-worldflag-KW.tex \
tex-worldflag-KZ.tex \
tex-worldflag-L.tex \
tex-worldflag-LA.tex \
tex-worldflag-LB.tex \
tex-worldflag-LC.tex \
tex-worldflag-LI.tex \
tex-worldflag-LK.tex \
tex-worldflag-LR.tex \
tex-worldflag-LS.tex \
tex-worldflag-LT.tex \
tex-worldflag-LU.tex \
tex-worldflag-LV.tex \
tex-worldflag-LY.tex \
tex-worldflag-M.tex \
tex-worldflag-MA.tex \
tex-worldflag-MD.tex \
tex-worldflag-ME.tex \
tex-worldflag-MG.tex \
tex-worldflag-MH.tex \
tex-worldflag-MK.tex \
tex-worldflag-ML.tex \
tex-worldflag-MM.tex \
tex-worldflag-MN.tex \
tex-worldflag-MR.tex \
tex-worldflag-MT.tex \
tex-worldflag-MU.tex \
tex-worldflag-MV.tex \
tex-worldflag-MW.tex \
tex-worldflag-MX.tex \
tex-worldflag-MY.tex \
tex-worldflag-MZ.tex \
tex-worldflag-N.tex \
tex-worldflag-NA.tex \
tex-worldflag-NATO.tex \
tex-worldflag-NE.tex \
tex-worldflag-NG.tex \
tex-worldflag-NI.tex \
tex-worldflag-NL.tex \
tex-worldflag-NO.tex \
tex-worldflag-NP.tex \
tex-worldflag-NR.tex \
tex-worldflag-NU.tex \
tex-worldflag-NZ.tex \
tex-worldflag-O.tex \
tex-worldflag-OM.tex \
tex-worldflag-Olympics.tex \
tex-worldflag-P.tex \
tex-worldflag-PA.tex \
tex-worldflag-PE.tex \
tex-worldflag-PG.tex \
tex-worldflag-PH.tex \
tex-worldflag-PK.tex \
tex-worldflag-PL.tex \
tex-worldflag-PR.tex \
tex-worldflag-PS.tex \
tex-worldflag-PT.tex \
tex-worldflag-PW.tex \
tex-worldflag-PY.tex \
tex-worldflag-Q.tex \
tex-worldflag-QA.tex \
tex-worldflag-R.tex \
tex-worldflag-RE.tex \
tex-worldflag-RO.tex \
tex-worldflag-RS.tex \
tex-worldflag-RU.tex \
tex-worldflag-RW.tex \
tex-worldflag-Rainbow.tex \
tex-worldflag-RedCrescent.tex \
tex-worldflag-RedCross.tex \
tex-worldflag-RedCrystal.tex \
tex-worldflag-S.tex \
tex-worldflag-SA.tex \
tex-worldflag-SB.tex \
tex-worldflag-SC.tex \
tex-worldflag-SD.tex \
tex-worldflag-SE.tex \
tex-worldflag-SG.tex \
tex-worldflag-SI.tex \
tex-worldflag-SK.tex \
tex-worldflag-SL.tex \
tex-worldflag-SM.tex \
tex-worldflag-SN.tex \
tex-worldflag-SO.tex \
tex-worldflag-SR.tex \
tex-worldflag-SS.tex \
tex-worldflag-ST.tex \
tex-worldflag-SV.tex \
tex-worldflag-SY.tex \
tex-worldflag-SZ.tex \
tex-worldflag-Saba.tex \
tex-worldflag-Somaliland.tex \
tex-worldflag-StEustasius.tex \
tex-worldflag-T.tex \
tex-worldflag-TD.tex \
tex-worldflag-TG.tex \
tex-worldflag-TH.tex \
tex-worldflag-TJ.tex \
tex-worldflag-TL.tex \
tex-worldflag-TM.tex \
tex-worldflag-TN.tex \
tex-worldflag-TO.tex \
tex-worldflag-TR.tex \
tex-worldflag-TT.tex \
tex-worldflag-TV.tex \
tex-worldflag-TW.tex \
tex-worldflag-TZ.tex \
tex-worldflag-Tibet.tex \
tex-worldflag-Transnistria.tex \
tex-worldflag-U.tex \
tex-worldflag-UA.tex \
tex-worldflag-UG.tex \
tex-worldflag-UNESCO.tex \
tex-worldflag-UNO.tex \
tex-worldflag-US.tex \
tex-worldflag-UY.tex \
tex-worldflag-UZ.tex \
tex-worldflag-V.tex \
tex-worldflag-VA.tex \
tex-worldflag-VC.tex \
tex-worldflag-VE.tex \
tex-worldflag-VN.tex \
tex-worldflag-VU.tex \
tex-worldflag-W.tex \
tex-worldflag-WB.tex \
tex-worldflag-WHO.tex \
tex-worldflag-WS.tex \
tex-worldflag-X.tex \
tex-worldflag-Y.tex \
tex-worldflag-YE.tex \
tex-worldflag-Z.tex \
tex-worldflag-ZA.tex \
tex-worldflag-ZM.tex \
tex-worldflag-ZW.tex \
tex-worldflags.sty \
texlive-worldflags"

RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-etex.sty \
tex-ifthen.sty \
tex-tikz.sty \
tex-xcolor.sty \
tex-xkeyval.sty \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
