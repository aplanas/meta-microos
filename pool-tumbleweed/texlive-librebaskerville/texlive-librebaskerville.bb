SUMMARY = "The Libre Baskerville family of fonts with LaTeX support"
DESCRIPTION = "This package provides the Libre Baskerville family of fonts, \
designed by Pablo Impallari, for use with LaTeX, pdfLaTeX, \
XeLaTeX or LuaLaTeX. It is primarily intended to be a web font \
but is also attractive as a text font. A BoldItalic variant has \
been artificially generated."
LICENSE = "OFL-1.1"

PV = "2023.209.svn64421"

RPM_NAME = "texlive-librebaskerville-2023.209.svn64421-55.1.noarch.rpm"
RPM_HASH = "391e3941f4124e9566f1cb0b7b0bfa15b854a324c2e35ff0c4f319c235d7b0eb68eb4d296fd16d648486a109eb741fb141f24aba3bc62fbe64e522a287df80e0"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-LY1LibreBskvl-LF.fd \
tex-LY1LibreBskvl-Sup.fd \
tex-LibreBaskerville.map \
tex-LibreBskvl-Bold-lf-ly1--base.tfm \
tex-LibreBskvl-Bold-lf-ly1.tfm \
tex-LibreBskvl-Bold-lf-ly1.vf \
tex-LibreBskvl-Bold-lf-ot1.tfm \
tex-LibreBskvl-Bold-lf-t1--base.tfm \
tex-LibreBskvl-Bold-lf-t1.tfm \
tex-LibreBskvl-Bold-lf-t1.vf \
tex-LibreBskvl-Bold-lf-ts1--base.tfm \
tex-LibreBskvl-Bold-lf-ts1.tfm \
tex-LibreBskvl-Bold-lf-ts1.vf \
tex-LibreBskvl-Bold-sup-ly1--base.tfm \
tex-LibreBskvl-Bold-sup-ly1.tfm \
tex-LibreBskvl-Bold-sup-ly1.vf \
tex-LibreBskvl-Bold-sup-ot1.tfm \
tex-LibreBskvl-Bold-sup-t1--base.tfm \
tex-LibreBskvl-Bold-sup-t1.tfm \
tex-LibreBskvl-Bold-sup-t1.vf \
tex-LibreBskvl-BoldItalic-lf-ly1--base.tfm \
tex-LibreBskvl-BoldItalic-lf-ly1.tfm \
tex-LibreBskvl-BoldItalic-lf-ly1.vf \
tex-LibreBskvl-BoldItalic-lf-ot1.tfm \
tex-LibreBskvl-BoldItalic-lf-t1--base.tfm \
tex-LibreBskvl-BoldItalic-lf-t1.tfm \
tex-LibreBskvl-BoldItalic-lf-t1.vf \
tex-LibreBskvl-BoldItalic-lf-ts1--base.tfm \
tex-LibreBskvl-BoldItalic-lf-ts1.tfm \
tex-LibreBskvl-BoldItalic-lf-ts1.vf \
tex-LibreBskvl-BoldItalic-sup-ly1--base.tfm \
tex-LibreBskvl-BoldItalic-sup-ly1.tfm \
tex-LibreBskvl-BoldItalic-sup-ly1.vf \
tex-LibreBskvl-BoldItalic-sup-ot1.tfm \
tex-LibreBskvl-BoldItalic-sup-t1--base.tfm \
tex-LibreBskvl-BoldItalic-sup-t1.tfm \
tex-LibreBskvl-BoldItalic-sup-t1.vf \
tex-LibreBskvl-Italic-lf-ly1--base.tfm \
tex-LibreBskvl-Italic-lf-ly1.tfm \
tex-LibreBskvl-Italic-lf-ly1.vf \
tex-LibreBskvl-Italic-lf-ot1.tfm \
tex-LibreBskvl-Italic-lf-t1--base.tfm \
tex-LibreBskvl-Italic-lf-t1.tfm \
tex-LibreBskvl-Italic-lf-t1.vf \
tex-LibreBskvl-Italic-lf-ts1--base.tfm \
tex-LibreBskvl-Italic-lf-ts1.tfm \
tex-LibreBskvl-Italic-lf-ts1.vf \
tex-LibreBskvl-Italic-sup-ly1--base.tfm \
tex-LibreBskvl-Italic-sup-ly1.tfm \
tex-LibreBskvl-Italic-sup-ly1.vf \
tex-LibreBskvl-Italic-sup-ot1.tfm \
tex-LibreBskvl-Italic-sup-t1--base.tfm \
tex-LibreBskvl-Italic-sup-t1.tfm \
tex-LibreBskvl-Italic-sup-t1.vf \
tex-LibreBskvl-Regular-lf-ly1--base.tfm \
tex-LibreBskvl-Regular-lf-ly1.tfm \
tex-LibreBskvl-Regular-lf-ly1.vf \
tex-LibreBskvl-Regular-lf-ot1.tfm \
tex-LibreBskvl-Regular-lf-t1--base.tfm \
tex-LibreBskvl-Regular-lf-t1.tfm \
tex-LibreBskvl-Regular-lf-t1.vf \
tex-LibreBskvl-Regular-lf-ts1--base.tfm \
tex-LibreBskvl-Regular-lf-ts1.tfm \
tex-LibreBskvl-Regular-lf-ts1.vf \
tex-LibreBskvl-Regular-sup-ly1--base.tfm \
tex-LibreBskvl-Regular-sup-ly1.tfm \
tex-LibreBskvl-Regular-sup-ly1.vf \
tex-LibreBskvl-Regular-sup-ot1.tfm \
tex-LibreBskvl-Regular-sup-t1--base.tfm \
tex-LibreBskvl-Regular-sup-t1.tfm \
tex-LibreBskvl-Regular-sup-t1.vf \
tex-OT1LibreBskvl-LF.fd \
tex-OT1LibreBskvl-Sup.fd \
tex-T1LibreBskvl-LF.fd \
tex-T1LibreBskvl-Sup.fd \
tex-TS1LibreBskvl-LF.fd \
tex-lbskvl-4uz6a2.enc \
tex-lbskvl-4yc6wb.enc \
tex-lbskvl-6hj2ra.enc \
tex-lbskvl-p6yehx.enc \
tex-lbskvl-uf5aa7.enc \
tex-lbskvl-ufnake.enc \
tex-lbskvl-vepvv3.enc \
tex-lbskvl-wpcz7d.enc \
tex-lbskvl-yeotsr.enc \
tex-librebaskerville.sty \
texlive-librebaskerville"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontaxes.sty \
tex-fontenc.sty \
tex-fontspec.sty \
tex-ifluatex.sty \
tex-ifxetex.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-librebaskerville-fonts \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
