SUMMARY = "Best Mega Pack 1+3"
DESCRIPTION = "Bestplugins Mega Pack 1+3 contains dozens of guitar sounds from famous bands."
LICENSE = "GPL-2.0-or-later"

PV = "0.44.1"

RPM_NAME = "bestplugins-0.44.1-2.3.aarch64.rpm"
RPM_HASH = "8e43aa1b23df2862a778fc45ef2261a139d06e9562b4c5192fe12276b27905264cd5890779212d9b1f3791d6a8b8b7a5f41ff8c8bde9ce96fc5b52a0227bb698"

RPROVIDES:${PN} += "bestplugins"

RDEPENDS:${PN} += ""

inherit rpm
