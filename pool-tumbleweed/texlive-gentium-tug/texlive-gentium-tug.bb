SUMMARY = "Gentium fonts (in two formats) and support files"
DESCRIPTION = "Gentium is a typeface family designed to enable the diverse \
ethnic groups around the world who use the Latin, Cyrillic and \
Greek scripts to produce readable, high-quality publications. \
It supports a wide range of Latin- and Cyrillic-based \
alphabets. The package consists of: The original (unaltered) \
GentiumPlus, GentiumBook, and other Gentium-family fonts in \
TrueType format, as developed by SIL and released under the OFL \
(see OFL.txt and OFL-FAQ.txt); Converted fonts in PostScript \
Type 1 format, released under the same terms. These incorporate \
the name 'Gentium' by permission of SIL given to the TeX Users \
Group; LaTeX and other supporting files; TeX-related \
documentation, and the SIL documentation and other files."
LICENSE = "OFL-1.1"

PV = "2023.201.1.102svn63470"

RPM_NAME = "texlive-gentium-tug-2023.201.1.102svn63470-52.1.noarch.rpm"
RPM_HASH = "22cd33cf90b952c1b2ef25655b66f8d6390fbfbbfabd0ae256ba55a248d9d339a958e6d1406550c3cd19e0256ee18a01e11253ede4e8aaa6ca9eb06a22725133"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-agr-gentiumbook-bold.tfm \
tex-agr-gentiumbook-bolditalic.tfm \
tex-agr-gentiumbook-italic.tfm \
tex-agr-gentiumbook-regular.tfm \
tex-agr-gentiumplus-bold.tfm \
tex-agr-gentiumplus-bolditalic.tfm \
tex-agr-gentiumplus-italic.tfm \
tex-agr-gentiumplus-regular.tfm \
tex-ec-gentiumbook-bold-sc.tfm \
tex-ec-gentiumbook-bold.tfm \
tex-ec-gentiumbook-bolditalic-sc.tfm \
tex-ec-gentiumbook-bolditalic.tfm \
tex-ec-gentiumbook-italic-sc.tfm \
tex-ec-gentiumbook-italic.tfm \
tex-ec-gentiumbook-regular-sc.tfm \
tex-ec-gentiumbook-regular.tfm \
tex-ec-gentiumplus-bold-sc.tfm \
tex-ec-gentiumplus-bold.tfm \
tex-ec-gentiumplus-bolditalic-sc.tfm \
tex-ec-gentiumplus-bolditalic.tfm \
tex-ec-gentiumplus-italic-sc.tfm \
tex-ec-gentiumplus-italic.tfm \
tex-ec-gentiumplus-regular-sc.tfm \
tex-ec-gentiumplus-regular.tfm \
tex-gentium-agr.enc \
tex-gentium-ec-sc.enc \
tex-gentium-ec-ttf-sc.enc \
tex-gentium-ec-ttf.enc \
tex-gentium-ec.enc \
tex-gentium-l7x-sc.enc \
tex-gentium-l7x.enc \
tex-gentium-lgr.enc \
tex-gentium-ot1-sc.enc \
tex-gentium-ot1.enc \
tex-gentium-qx-sc.enc \
tex-gentium-qx.enc \
tex-gentium-t2a-sc.enc \
tex-gentium-t2a.enc \
tex-gentium-t2b-sc.enc \
tex-gentium-t2b.enc \
tex-gentium-t2c-sc.enc \
tex-gentium-t2c.enc \
tex-gentium-t5-sc.enc \
tex-gentium-t5-ttf.enc \
tex-gentium-t5.enc \
tex-gentium-texnansi-sc.enc \
tex-gentium-texnansi.enc \
tex-gentium-truetype.map \
tex-gentium-ts1.enc \
tex-gentium-type1.map \
tex-gentium-x2-sc.enc \
tex-gentium-x2.enc \
tex-gentium.sty \
tex-gentiumbook-agr.map \
tex-gentiumbook-ec.map \
tex-gentiumbook-l7x.map \
tex-gentiumbook-lgr.map \
tex-gentiumbook-ot1.map \
tex-gentiumbook-qx.map \
tex-gentiumbook-t2a.map \
tex-gentiumbook-t2b.map \
tex-gentiumbook-t2c.map \
tex-gentiumbook-t5.map \
tex-gentiumbook-texnansi.map \
tex-gentiumbook-truetype.map \
tex-gentiumbook-ts1.map \
tex-gentiumbook-type1.map \
tex-gentiumbook-x2.map \
tex-gentiumbook.sty \
tex-gentiumplus-agr.map \
tex-gentiumplus-ec.map \
tex-gentiumplus-l7x.map \
tex-gentiumplus-lgr.map \
tex-gentiumplus-ot1.map \
tex-gentiumplus-qx.map \
tex-gentiumplus-t2a.map \
tex-gentiumplus-t2b.map \
tex-gentiumplus-t2c.map \
tex-gentiumplus-t5.map \
tex-gentiumplus-texnansi.map \
tex-gentiumplus-truetype.map \
tex-gentiumplus-ts1.map \
tex-gentiumplus-type1.map \
tex-gentiumplus-x2.map \
tex-l7x-gentiumbook-bold-sc.tfm \
tex-l7x-gentiumbook-bold.tfm \
tex-l7x-gentiumbook-bolditalic-sc.tfm \
tex-l7x-gentiumbook-bolditalic.tfm \
tex-l7x-gentiumbook-italic-sc.tfm \
tex-l7x-gentiumbook-italic.tfm \
tex-l7x-gentiumbook-regular-sc.tfm \
tex-l7x-gentiumbook-regular.tfm \
tex-l7x-gentiumplus-bold-sc.tfm \
tex-l7x-gentiumplus-bold.tfm \
tex-l7x-gentiumplus-bolditalic-sc.tfm \
tex-l7x-gentiumplus-bolditalic.tfm \
tex-l7x-gentiumplus-italic-sc.tfm \
tex-l7x-gentiumplus-italic.tfm \
tex-l7x-gentiumplus-regular-sc.tfm \
tex-l7x-gentiumplus-regular.tfm \
tex-l7xgentium.fd \
tex-l7xgentiumbook.fd \
tex-lgr-gentiumbook-bold.tfm \
tex-lgr-gentiumbook-bolditalic.tfm \
tex-lgr-gentiumbook-italic.tfm \
tex-lgr-gentiumbook-regular.tfm \
tex-lgr-gentiumplus-bold.tfm \
tex-lgr-gentiumplus-bolditalic.tfm \
tex-lgr-gentiumplus-italic.tfm \
tex-lgr-gentiumplus-regular.tfm \
tex-lgrgentium.fd \
tex-lgrgentiumbook.fd \
tex-ly1gentium.fd \
tex-ly1gentiumbook.fd \
tex-ot1-gentiumbook-bold-sc.tfm \
tex-ot1-gentiumbook-bold.tfm \
tex-ot1-gentiumbook-bolditalic-sc.tfm \
tex-ot1-gentiumbook-bolditalic.tfm \
tex-ot1-gentiumbook-italic-sc.tfm \
tex-ot1-gentiumbook-italic.tfm \
tex-ot1-gentiumbook-regular-sc.tfm \
tex-ot1-gentiumbook-regular.tfm \
tex-ot1-gentiumplus-bold-sc.tfm \
tex-ot1-gentiumplus-bold.tfm \
tex-ot1-gentiumplus-bolditalic-sc.tfm \
tex-ot1-gentiumplus-bolditalic.tfm \
tex-ot1-gentiumplus-italic-sc.tfm \
tex-ot1-gentiumplus-italic.tfm \
tex-ot1-gentiumplus-regular-sc.tfm \
tex-ot1-gentiumplus-regular.tfm \
tex-ot1gentium.fd \
tex-ot1gentiumbook.fd \
tex-qx-gentiumbook-bold-sc.tfm \
tex-qx-gentiumbook-bold.tfm \
tex-qx-gentiumbook-bolditalic-sc.tfm \
tex-qx-gentiumbook-bolditalic.tfm \
tex-qx-gentiumbook-italic-sc.tfm \
tex-qx-gentiumbook-italic.tfm \
tex-qx-gentiumbook-regular-sc.tfm \
tex-qx-gentiumbook-regular.tfm \
tex-qx-gentiumplus-bold-sc.tfm \
tex-qx-gentiumplus-bold.tfm \
tex-qx-gentiumplus-bolditalic-sc.tfm \
tex-qx-gentiumplus-bolditalic.tfm \
tex-qx-gentiumplus-italic-sc.tfm \
tex-qx-gentiumplus-italic.tfm \
tex-qx-gentiumplus-regular-sc.tfm \
tex-qx-gentiumplus-regular.tfm \
tex-qxgentium.fd \
tex-qxgentiumbook.fd \
tex-t1gentium.fd \
tex-t1gentiumbook.fd \
tex-t2a-gentiumbook-bold-sc.tfm \
tex-t2a-gentiumbook-bold.tfm \
tex-t2a-gentiumbook-bolditalic-sc.tfm \
tex-t2a-gentiumbook-bolditalic.tfm \
tex-t2a-gentiumbook-italic-sc.tfm \
tex-t2a-gentiumbook-italic.tfm \
tex-t2a-gentiumbook-regular-sc.tfm \
tex-t2a-gentiumbook-regular.tfm \
tex-t2a-gentiumplus-bold-sc.tfm \
tex-t2a-gentiumplus-bold.tfm \
tex-t2a-gentiumplus-bolditalic-sc.tfm \
tex-t2a-gentiumplus-bolditalic.tfm \
tex-t2a-gentiumplus-italic-sc.tfm \
tex-t2a-gentiumplus-italic.tfm \
tex-t2a-gentiumplus-regular-sc.tfm \
tex-t2a-gentiumplus-regular.tfm \
tex-t2agentium.fd \
tex-t2agentiumbook.fd \
tex-t2b-gentiumbook-bold-sc.tfm \
tex-t2b-gentiumbook-bold.tfm \
tex-t2b-gentiumbook-bolditalic-sc.tfm \
tex-t2b-gentiumbook-bolditalic.tfm \
tex-t2b-gentiumbook-italic-sc.tfm \
tex-t2b-gentiumbook-italic.tfm \
tex-t2b-gentiumbook-regular-sc.tfm \
tex-t2b-gentiumbook-regular.tfm \
tex-t2b-gentiumplus-bold-sc.tfm \
tex-t2b-gentiumplus-bold.tfm \
tex-t2b-gentiumplus-bolditalic-sc.tfm \
tex-t2b-gentiumplus-bolditalic.tfm \
tex-t2b-gentiumplus-italic-sc.tfm \
tex-t2b-gentiumplus-italic.tfm \
tex-t2b-gentiumplus-regular-sc.tfm \
tex-t2b-gentiumplus-regular.tfm \
tex-t2bgentium.fd \
tex-t2bgentiumbook.fd \
tex-t2c-gentiumbook-bold-sc.tfm \
tex-t2c-gentiumbook-bold.tfm \
tex-t2c-gentiumbook-bolditalic-sc.tfm \
tex-t2c-gentiumbook-bolditalic.tfm \
tex-t2c-gentiumbook-italic-sc.tfm \
tex-t2c-gentiumbook-italic.tfm \
tex-t2c-gentiumbook-regular-sc.tfm \
tex-t2c-gentiumbook-regular.tfm \
tex-t2c-gentiumplus-bold-sc.tfm \
tex-t2c-gentiumplus-bold.tfm \
tex-t2c-gentiumplus-bolditalic-sc.tfm \
tex-t2c-gentiumplus-bolditalic.tfm \
tex-t2c-gentiumplus-italic-sc.tfm \
tex-t2c-gentiumplus-italic.tfm \
tex-t2c-gentiumplus-regular-sc.tfm \
tex-t2c-gentiumplus-regular.tfm \
tex-t2cgentium.fd \
tex-t2cgentiumbook.fd \
tex-t5-gentiumbook-bold-sc.tfm \
tex-t5-gentiumbook-bold.tfm \
tex-t5-gentiumbook-bolditalic-sc.tfm \
tex-t5-gentiumbook-bolditalic.tfm \
tex-t5-gentiumbook-italic-sc.tfm \
tex-t5-gentiumbook-italic.tfm \
tex-t5-gentiumbook-regular-sc.tfm \
tex-t5-gentiumbook-regular.tfm \
tex-t5-gentiumplus-bold-sc.tfm \
tex-t5-gentiumplus-bold.tfm \
tex-t5-gentiumplus-bolditalic-sc.tfm \
tex-t5-gentiumplus-bolditalic.tfm \
tex-t5-gentiumplus-italic-sc.tfm \
tex-t5-gentiumplus-italic.tfm \
tex-t5-gentiumplus-regular-sc.tfm \
tex-t5-gentiumplus-regular.tfm \
tex-t5gentium.fd \
tex-t5gentiumbook.fd \
tex-texnansi-gentiumbook-bold-sc.tfm \
tex-texnansi-gentiumbook-bold.tfm \
tex-texnansi-gentiumbook-bolditalic-sc.tfm \
tex-texnansi-gentiumbook-bolditalic.tfm \
tex-texnansi-gentiumbook-italic-sc.tfm \
tex-texnansi-gentiumbook-italic.tfm \
tex-texnansi-gentiumbook-regular-sc.tfm \
tex-texnansi-gentiumbook-regular.tfm \
tex-texnansi-gentiumplus-bold-sc.tfm \
tex-texnansi-gentiumplus-bold.tfm \
tex-texnansi-gentiumplus-bolditalic-sc.tfm \
tex-texnansi-gentiumplus-bolditalic.tfm \
tex-texnansi-gentiumplus-italic-sc.tfm \
tex-texnansi-gentiumplus-italic.tfm \
tex-texnansi-gentiumplus-regular-sc.tfm \
tex-texnansi-gentiumplus-regular.tfm \
tex-ts1-gentiumbook-bold.tfm \
tex-ts1-gentiumbook-bolditalic.tfm \
tex-ts1-gentiumbook-italic.tfm \
tex-ts1-gentiumbook-regular.tfm \
tex-ts1-gentiumplus-bold.tfm \
tex-ts1-gentiumplus-bolditalic.tfm \
tex-ts1-gentiumplus-italic.tfm \
tex-ts1-gentiumplus-regular.tfm \
tex-ts1gentium.fd \
tex-ts1gentiumbook.fd \
tex-x2-gentiumbook-bold-sc.tfm \
tex-x2-gentiumbook-bold.tfm \
tex-x2-gentiumbook-bolditalic-sc.tfm \
tex-x2-gentiumbook-bolditalic.tfm \
tex-x2-gentiumbook-italic-sc.tfm \
tex-x2-gentiumbook-italic.tfm \
tex-x2-gentiumbook-regular-sc.tfm \
tex-x2-gentiumbook-regular.tfm \
tex-x2-gentiumplus-bold-sc.tfm \
tex-x2-gentiumplus-bold.tfm \
tex-x2-gentiumplus-bolditalic-sc.tfm \
tex-x2-gentiumplus-bolditalic.tfm \
tex-x2-gentiumplus-italic-sc.tfm \
tex-x2-gentiumplus-italic.tfm \
tex-x2-gentiumplus-regular-sc.tfm \
tex-x2-gentiumplus-regular.tfm \
tex-x2gentium.fd \
tex-x2gentiumbook.fd \
texlive-gentium-tug"

RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-filesystem \
texlive-gentium-tug-fonts \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
