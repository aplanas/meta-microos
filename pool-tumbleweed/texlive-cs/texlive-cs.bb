SUMMARY = "Czech/Slovak-tuned Computer Modern fonts"
DESCRIPTION = "The fonts are provided as Metafont source; Type 1 format \
versions (csfonts-t1) are also available."
LICENSE = "GPL-2.0-or-later"

PV = "2023.204.svn41553"

RPM_NAME = "texlive-cs-2023.204.svn41553-54.1.noarch.rpm"
RPM_HASH = "70c42751c58ec98b2bae1eb623cd225a2c8af2cf9bc10c1436409c61810b43df9173befc67161d2cb08477a275efe81619f20b88b5e3a7fde83833990c11b152"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-bchb8z.tfm \
tex-bchb8z.vf \
tex-bchbi8z.tfm \
tex-bchbi8z.vf \
tex-bchr8z.tfm \
tex-bchr8z.vf \
tex-bchri8z.tfm \
tex-bchri8z.vf \
tex-cs-a35-nodownload.map \
tex-cs-a35-urwdownload.map \
tex-cs-charter.map \
tex-csb10.tfm \
tex-csb12.tfm \
tex-csb17.tfm \
tex-csb5.tfm \
tex-csb6.tfm \
tex-csb7.tfm \
tex-csb8.tfm \
tex-csb9.tfm \
tex-csbx10.tfm \
tex-csbx12.tfm \
tex-csbx5.tfm \
tex-csbx6.tfm \
tex-csbx7.tfm \
tex-csbx8.tfm \
tex-csbx9.tfm \
tex-csbxsl10.tfm \
tex-csbxsl12.tfm \
tex-csbxsl5.tfm \
tex-csbxsl6.tfm \
tex-csbxsl7.tfm \
tex-csbxsl8.tfm \
tex-csbxsl9.tfm \
tex-csbxti10.tfm \
tex-csbxti12.tfm \
tex-csbxti17.tfm \
tex-cscsc10.tfm \
tex-cscsc12.tfm \
tex-cscsc17.tfm \
tex-cscsc8.tfm \
tex-cscsc9.tfm \
tex-csdunh10.tfm \
tex-csdunh12.tfm \
tex-csdunh17.tfm \
tex-csdunh5.tfm \
tex-csdunh6.tfm \
tex-csdunh7.tfm \
tex-csdunh8.tfm \
tex-csdunh9.tfm \
tex-csff10.tfm \
tex-csfi10.tfm \
tex-csfib10.tfm \
tex-csfib12.tfm \
tex-csfib8.tfm \
tex-csfib9.tfm \
tex-csfonts.map \
tex-csinch.tfm \
tex-csitt10.tfm \
tex-csitt12.tfm \
tex-csitt17.tfm \
tex-csitt8.tfm \
tex-csitt9.tfm \
tex-csr10.tfm \
tex-csr12.tfm \
tex-csr17.tfm \
tex-csr5.tfm \
tex-csr6.tfm \
tex-csr7.tfm \
tex-csr8.tfm \
tex-csr9.tfm \
tex-cssl10.tfm \
tex-cssl12.tfm \
tex-cssl17.tfm \
tex-cssl5.tfm \
tex-cssl6.tfm \
tex-cssl7.tfm \
tex-cssl8.tfm \
tex-cssl9.tfm \
tex-cssltt10.tfm \
tex-cssltt12.tfm \
tex-cssltt8.tfm \
tex-cssltt9.tfm \
tex-csss10.tfm \
tex-csss12.tfm \
tex-csss17.tfm \
tex-csss8.tfm \
tex-csss9.tfm \
tex-csssbx10.tfm \
tex-csssbx12.tfm \
tex-csssbx17.tfm \
tex-csssbx9.tfm \
tex-csssdc10.tfm \
tex-csssi10.tfm \
tex-csssi12.tfm \
tex-csssi17.tfm \
tex-csssi8.tfm \
tex-csssi9.tfm \
tex-csssq8.tfm \
tex-csssqi8.tfm \
tex-cstcsc10.tfm \
tex-cstcsc12.tfm \
tex-cstcsc17.tfm \
tex-csti10.tfm \
tex-csti12.tfm \
tex-csti17.tfm \
tex-csti7.tfm \
tex-csti8.tfm \
tex-csti9.tfm \
tex-cstt10.tfm \
tex-cstt12.tfm \
tex-cstt8.tfm \
tex-cstt9.tfm \
tex-csu10.tfm \
tex-csu12.tfm \
tex-csu17.tfm \
tex-csu7.tfm \
tex-csu8.tfm \
tex-csu9.tfm \
tex-csvtt10.tfm \
tex-csvtt12.tfm \
tex-csvtt8.tfm \
tex-csvtt9.tfm \
tex-icscsc10.tfm \
tex-icstt8.tfm \
tex-ilcsss8.tfm \
tex-ilcsssb8.tfm \
tex-ilcsssi8.tfm \
tex-lcsss8.tfm \
tex-lcsssb8.tfm \
tex-lcsssi8.tfm \
tex-pagd8z.tfm \
tex-pagdc8z.tfm \
tex-pagdc8z.vf \
tex-pagdo8z.tfm \
tex-pagk8z.tfm \
tex-pagkc8z.tfm \
tex-pagkc8z.vf \
tex-pagko8z.tfm \
tex-pbkd8z.tfm \
tex-pbkdc8z.tfm \
tex-pbkdc8z.vf \
tex-pbkdi8z.tfm \
tex-pbkl8z.tfm \
tex-pbklc8z.tfm \
tex-pbklc8z.vf \
tex-pbkli8z.tfm \
tex-pcrb8u.tfm \
tex-pcrbc8u.tfm \
tex-pcrbc8u.vf \
tex-pcrbo8u.tfm \
tex-pcrr8u.tfm \
tex-pcrrc8u.tfm \
tex-pcrrc8u.vf \
tex-pcrro8u.tfm \
tex-phvb8z.tfm \
tex-phvbc8z.tfm \
tex-phvbc8z.vf \
tex-phvbn8z.tfm \
tex-phvbnc8z.tfm \
tex-phvbnc8z.vf \
tex-phvbo8z.tfm \
tex-phvbon8z.tfm \
tex-phvr8z.tfm \
tex-phvrc8z.tfm \
tex-phvrc8z.vf \
tex-phvrn8z.tfm \
tex-phvrnc8z.tfm \
tex-phvrnc8z.vf \
tex-phvro8z.tfm \
tex-phvron8z.tfm \
tex-pncb8z.tfm \
tex-pncbc8z.tfm \
tex-pncbc8z.vf \
tex-pncbi8z.tfm \
tex-pncr8z.tfm \
tex-pncrc8z.tfm \
tex-pncrc8z.vf \
tex-pncri8z.tfm \
tex-pplb8z.tfm \
tex-pplbc8z.tfm \
tex-pplbc8z.vf \
tex-pplbi8z.tfm \
tex-pplr8z.tfm \
tex-pplrc8z.tfm \
tex-pplrc8z.vf \
tex-pplri8z.tfm \
tex-ptmb8z.tfm \
tex-ptmbc8z.tfm \
tex-ptmbc8z.vf \
tex-ptmbi8z.tfm \
tex-ptmr8z.tfm \
tex-ptmrc8z.tfm \
tex-ptmrc8z.vf \
tex-ptmri8z.tfm \
tex-pzcmi8z.tfm \
tex-rbchb.tfm \
tex-rbchbi.tfm \
tex-rbchr.tfm \
tex-rbchri.tfm \
tex-xl2.enc \
tex-xl2f.enc \
tex-xt2.enc \
texlive-cs"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-updmap.cfg \
texlive \
texlive-cmexb \
texlive-cs-fonts \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
