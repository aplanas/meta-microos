SUMMARY = "Core Fonts for X.Org"
DESCRIPTION = "This package contains the 'fixed' and 'cursor' font required for any X \
Server."
LICENSE = "MIT"

PV = "7.6"

RPM_NAME = "xorg-x11-fonts-core-7.6-45.1.noarch.rpm"
RPM_HASH = "3aa09413db20f5bacf9f623ae47b5879f3d7c3d86fe00cce93eb001a315ac67c941b47ff444d35ac74fde59245d711dee61e7fd5f17140173cee3a0c5fc2439e"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "font(:lang=aa) \
font(:lang=ab) \
font(:lang=af) \
font(:lang=ak) \
font(:lang=am) \
font(:lang=an) \
font(:lang=ar) \
font(:lang=ast) \
font(:lang=av) \
font(:lang=ay) \
font(:lang=az-az) \
font(:lang=az-ir) \
font(:lang=ba) \
font(:lang=be) \
font(:lang=ber-dz) \
font(:lang=bg) \
font(:lang=bi) \
font(:lang=bin) \
font(:lang=bm) \
font(:lang=br) \
font(:lang=bs) \
font(:lang=bua) \
font(:lang=byn) \
font(:lang=ca) \
font(:lang=ce) \
font(:lang=ch) \
font(:lang=chm) \
font(:lang=chr) \
font(:lang=co) \
font(:lang=crh) \
font(:lang=cs) \
font(:lang=csb) \
font(:lang=cu) \
font(:lang=cv) \
font(:lang=cy) \
font(:lang=da) \
font(:lang=de) \
font(:lang=ee) \
font(:lang=el) \
font(:lang=en) \
font(:lang=eo) \
font(:lang=es) \
font(:lang=et) \
font(:lang=eu) \
font(:lang=fa) \
font(:lang=fat) \
font(:lang=ff) \
font(:lang=fi) \
font(:lang=fil) \
font(:lang=fj) \
font(:lang=fo) \
font(:lang=fr) \
font(:lang=fur) \
font(:lang=fy) \
font(:lang=ga) \
font(:lang=gd) \
font(:lang=gez) \
font(:lang=gl) \
font(:lang=gn) \
font(:lang=gv) \
font(:lang=ha) \
font(:lang=haw) \
font(:lang=he) \
font(:lang=ho) \
font(:lang=hr) \
font(:lang=hsb) \
font(:lang=ht) \
font(:lang=hu) \
font(:lang=hy) \
font(:lang=hz) \
font(:lang=ia) \
font(:lang=id) \
font(:lang=ie) \
font(:lang=ig) \
font(:lang=ik) \
font(:lang=io) \
font(:lang=is) \
font(:lang=it) \
font(:lang=ja) \
font(:lang=jv) \
font(:lang=ka) \
font(:lang=kaa) \
font(:lang=kab) \
font(:lang=ki) \
font(:lang=kj) \
font(:lang=kk) \
font(:lang=kl) \
font(:lang=ko) \
font(:lang=kr) \
font(:lang=ku-am) \
font(:lang=ku-iq) \
font(:lang=ku-ir) \
font(:lang=ku-tr) \
font(:lang=kum) \
font(:lang=kv) \
font(:lang=kw) \
font(:lang=kwm) \
font(:lang=ky) \
font(:lang=la) \
font(:lang=lah) \
font(:lang=lb) \
font(:lang=lez) \
font(:lang=lg) \
font(:lang=li) \
font(:lang=ln) \
font(:lang=lo) \
font(:lang=lt) \
font(:lang=lv) \
font(:lang=mg) \
font(:lang=mh) \
font(:lang=mi) \
font(:lang=mk) \
font(:lang=mn-mn) \
font(:lang=mo) \
font(:lang=ms) \
font(:lang=mt) \
font(:lang=na) \
font(:lang=nb) \
font(:lang=nds) \
font(:lang=ng) \
font(:lang=nl) \
font(:lang=nn) \
font(:lang=no) \
font(:lang=nr) \
font(:lang=nso) \
font(:lang=nv) \
font(:lang=ny) \
font(:lang=oc) \
font(:lang=om) \
font(:lang=os) \
font(:lang=ota) \
font(:lang=pa-pk) \
font(:lang=pap-an) \
font(:lang=pap-aw) \
font(:lang=pl) \
font(:lang=ps-af) \
font(:lang=ps-pk) \
font(:lang=pt) \
font(:lang=qu) \
font(:lang=quz) \
font(:lang=rm) \
font(:lang=rn) \
font(:lang=ro) \
font(:lang=ru) \
font(:lang=rw) \
font(:lang=sah) \
font(:lang=sc) \
font(:lang=sco) \
font(:lang=sd) \
font(:lang=se) \
font(:lang=sel) \
font(:lang=sg) \
font(:lang=sh) \
font(:lang=shs) \
font(:lang=sid) \
font(:lang=sk) \
font(:lang=sl) \
font(:lang=sm) \
font(:lang=sma) \
font(:lang=smj) \
font(:lang=smn) \
font(:lang=sms) \
font(:lang=sn) \
font(:lang=so) \
font(:lang=sq) \
font(:lang=sr) \
font(:lang=ss) \
font(:lang=st) \
font(:lang=su) \
font(:lang=sv) \
font(:lang=sw) \
font(:lang=tg) \
font(:lang=th) \
font(:lang=ti-er) \
font(:lang=ti-et) \
font(:lang=tig) \
font(:lang=tk) \
font(:lang=tl) \
font(:lang=tn) \
font(:lang=to) \
font(:lang=tr) \
font(:lang=ts) \
font(:lang=tt) \
font(:lang=tw) \
font(:lang=ty) \
font(:lang=tyv) \
font(:lang=ug) \
font(:lang=uk) \
font(:lang=ur) \
font(:lang=uz) \
font(:lang=ve) \
font(:lang=vi) \
font(:lang=vo) \
font(:lang=vot) \
font(:lang=wa) \
font(:lang=wal) \
font(:lang=wen) \
font(:lang=wo) \
font(:lang=xh) \
font(:lang=yap) \
font(:lang=yi) \
font(:lang=yo) \
font(:lang=za) \
font(:lang=zh-cn) \
font(:lang=zh-sg) \
font(:lang=zu) \
font(cursor.pcf) \
font(micro.pcf) \
font(miscfixed) \
font(miscfixedwide) \
font(sonyfixed) \
xorg-x11-fonts-core \
xorg-x11:/usr/X11R6/lib/X11/fonts/misc/cursor.pcf.gz"

RDEPENDS:${PN} += "/bin/sh \
fonts-config"

inherit rpm
