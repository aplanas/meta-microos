SUMMARY = "Translations for package libKPim5KontactInterface5"
DESCRIPTION = "Provides translations for the 'libKPim5KontactInterface5' package."
LICENSE = "LGPL-2.1-or-later"

PV = "23.04.3"

RPM_NAME = "libKPim5KontactInterface5-lang-23.04.3-1.1.noarch.rpm"
RPM_HASH = "06e69aae770c9f87f7578cea677088cdab2b8a1483642806ed294b36940cfe06ff135d69f337de5adeed4157cd1a30ffe8e59112a6b1799fb70759e1cb1c04c8"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKPim5KontactInterface5-lang \
libKPim5KontactInterface5-lang-all \
locale-libKPim5KontactInterface5-ar \
locale-libKPim5KontactInterface5-az \
locale-libKPim5KontactInterface5-bg \
locale-libKPim5KontactInterface5-bs \
locale-libKPim5KontactInterface5-ca \
locale-libKPim5KontactInterface5-ca@valencia \
locale-libKPim5KontactInterface5-cs \
locale-libKPim5KontactInterface5-da \
locale-libKPim5KontactInterface5-de \
locale-libKPim5KontactInterface5-el \
locale-libKPim5KontactInterface5-en-GB \
locale-libKPim5KontactInterface5-eo \
locale-libKPim5KontactInterface5-es \
locale-libKPim5KontactInterface5-et \
locale-libKPim5KontactInterface5-eu \
locale-libKPim5KontactInterface5-fi \
locale-libKPim5KontactInterface5-fr \
locale-libKPim5KontactInterface5-ga \
locale-libKPim5KontactInterface5-gl \
locale-libKPim5KontactInterface5-he \
locale-libKPim5KontactInterface5-hi \
locale-libKPim5KontactInterface5-hu \
locale-libKPim5KontactInterface5-ia \
locale-libKPim5KontactInterface5-is \
locale-libKPim5KontactInterface5-it \
locale-libKPim5KontactInterface5-ja \
locale-libKPim5KontactInterface5-ka \
locale-libKPim5KontactInterface5-kk \
locale-libKPim5KontactInterface5-km \
locale-libKPim5KontactInterface5-ko \
locale-libKPim5KontactInterface5-lt \
locale-libKPim5KontactInterface5-lv \
locale-libKPim5KontactInterface5-mr \
locale-libKPim5KontactInterface5-nb \
locale-libKPim5KontactInterface5-nds \
locale-libKPim5KontactInterface5-nl \
locale-libKPim5KontactInterface5-nn \
locale-libKPim5KontactInterface5-pa \
locale-libKPim5KontactInterface5-pl \
locale-libKPim5KontactInterface5-pt \
locale-libKPim5KontactInterface5-pt-BR \
locale-libKPim5KontactInterface5-ro \
locale-libKPim5KontactInterface5-ru \
locale-libKPim5KontactInterface5-sk \
locale-libKPim5KontactInterface5-sl \
locale-libKPim5KontactInterface5-sq \
locale-libKPim5KontactInterface5-sr \
locale-libKPim5KontactInterface5-sr@ijekavian \
locale-libKPim5KontactInterface5-sr@ijekavianlatin \
locale-libKPim5KontactInterface5-sr@latin \
locale-libKPim5KontactInterface5-sv \
locale-libKPim5KontactInterface5-tr \
locale-libKPim5KontactInterface5-ug \
locale-libKPim5KontactInterface5-uk \
locale-libKPim5KontactInterface5-vi \
locale-libKPim5KontactInterface5-wa \
locale-libKPim5KontactInterface5-zh-CN \
locale-libKPim5KontactInterface5-zh-TW"

RDEPENDS:${PN} += "libKPim5KontactInterface5"

inherit rpm
