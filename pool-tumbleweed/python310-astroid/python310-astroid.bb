SUMMARY = "Representation of Python source as an AST for pylint"
DESCRIPTION = "This module provides a common base representation of Python source code for \
projects such as pychecker, pyreverse, pylint. The development of this library \
is governed by pylint's needs. \
 \
It provides a compatible representation which comes from the _ast \
module. It rebuilds the tree generated by the builtin _ast module by \
recursively walking down the AST and building an extended ast. The new \
node classes have additional methods and attributes for different \
usages. They include some support for static inference and local name \
scopes. Furthermore, astroid builds partial trees by inspecting living \
objects."
LICENSE = "LGPL-2.1-or-later"

PV = "2.15.6"

RPM_NAME = "python310-astroid-2.15.6-1.1.noarch.rpm"
RPM_HASH = "71dac6871fdda0430ad6840111bfed26179c0fa07ea724868a0d33552ff15651d315df99448cbfec768e8891f63d5c9c333865281e92214b675ccfad5e8ae8a0"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "python3.10dist-astroid \
python310-astroid \
python3dist-astroid"

RDEPENDS:${PN} += "python-abi \
python310-lazy-object-proxy \
python310-typing-extensions \
python310-wrapt"

inherit rpm
