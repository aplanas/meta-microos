SUMMARY = "Various libraries"
DESCRIPTION = "This package provides various libraries: \
chrome-trace \
dune-action-plugin \
dune-build-info \
dune-configurator \
dune-glob \
dune-private-libs \
dune-rpc \
dune-site \
dyn \
ocamlc-loc \
ordering \
stdune \
xdg"
LICENSE = "MIT"

PV = "3.8.3"

RPM_NAME = "ocaml-dune-devel-3.8.3-1.1.aarch64.rpm"
RPM_HASH = "1edbf35aa6985b0ef81bf63e62865662d4046ade2afeaab453c1bec9d9f88c4e0d75ac414bb46b2f6a17640144394de1974c33b6d23bf1e2db3116b51cfde41b"

RPROVIDES:${PN} += "ocaml-Build-info \
ocaml-Build-info-- \
ocaml-Build-info--Build-info-data \
ocaml-Chrome-trace \
ocaml-Configurator \
ocaml-Configurator-- \
ocaml-Configurator--Dune-lang \
ocaml-Configurator--Extract-obj \
ocaml-Configurator--Import \
ocaml-Configurator--Ocaml-config \
ocaml-Configurator--V1 \
ocaml-Csexp \
ocaml-Dune-action-plugin \
ocaml-Dune-action-plugin-- \
ocaml-Dune-action-plugin--Import \
ocaml-Dune-action-plugin--Path \
ocaml-Dune-action-plugin--Protocol \
ocaml-Dune-action-plugin--Sexpable-intf \
ocaml-Dune-filesystem-stubs \
ocaml-Dune-glob \
ocaml-Dune-glob-- \
ocaml-Dune-glob--Glob \
ocaml-Dune-glob--Lexer \
ocaml-Dune-meta-parser \
ocaml-Dune-meta-parser--Meta-lexer \
ocaml-Dune-meta-parser--Meta-parser \
ocaml-Dune-re \
ocaml-Dune-re-- \
ocaml-Dune-re--Automata \
ocaml-Dune-re--Category \
ocaml-Dune-re--Color-map \
ocaml-Dune-re--Core \
ocaml-Dune-re--Cset \
ocaml-Dune-re--Emacs \
ocaml-Dune-re--Fmt \
ocaml-Dune-re--Glob \
ocaml-Dune-re--Group \
ocaml-Dune-re--Pcre \
ocaml-Dune-re--Perl \
ocaml-Dune-re--Pmark \
ocaml-Dune-re--Posix \
ocaml-Dune-re--Re \
ocaml-Dune-re--Str \
ocaml-Dune-rpc \
ocaml-Dune-rpc-private \
ocaml-Dune-rpc-private-- \
ocaml-Dune-rpc-private--Conv \
ocaml-Dune-rpc-private--Dbus-address \
ocaml-Dune-rpc-private--Exported-types \
ocaml-Dune-rpc-private--Fiber-intf \
ocaml-Dune-rpc-private--Import \
ocaml-Dune-rpc-private--Menu \
ocaml-Dune-rpc-private--Procedures \
ocaml-Dune-rpc-private--Registry \
ocaml-Dune-rpc-private--Sub \
ocaml-Dune-rpc-private--Types \
ocaml-Dune-rpc-private--Versioned \
ocaml-Dune-rpc-private--Where \
ocaml-Dune-section \
ocaml-Dune-site \
ocaml-Dune-site-- \
ocaml-Dune-site--Dune-site-data \
ocaml-Dune-site--Helpers \
ocaml-Dune-site-backend \
ocaml-Dune-site-backend--Linker \
ocaml-Dune-site-backend--dune-site-dynlink-linker-- \
ocaml-Dune-site-backend--dune-site-toplevel-linker-- \
ocaml-Dune-site-plugins \
ocaml-Dune-site-plugins-- \
ocaml-Dune-site-plugins--Dune-site-plugins-data \
ocaml-Dune-site-plugins--Meta-parser \
ocaml-Dune-site-plugins--Plugins \
ocaml-Dune-site-private \
ocaml-Dyn \
ocaml-Ocaml-config \
ocaml-Ocamlc-loc \
ocaml-Ocamlc-loc-- \
ocaml-Ocamlc-loc--Lexer \
ocaml-Ordering \
ocaml-Pp \
ocaml-Stdune \
ocaml-Stdune-- \
ocaml-Stdune--Ansi-color \
ocaml-Stdune--Appendable-list \
ocaml-Stdune--Applicative \
ocaml-Stdune--Applicative-intf \
ocaml-Stdune--Array \
ocaml-Stdune--Bin \
ocaml-Stdune--Bool \
ocaml-Stdune--Bytes \
ocaml-Stdune--Bytes-unit \
ocaml-Stdune--Caller-id \
ocaml-Stdune--Char \
ocaml-Stdune--Code-error \
ocaml-Stdune--Comparable \
ocaml-Stdune--Comparable-intf \
ocaml-Stdune--Comparator \
ocaml-Stdune--Dev-null \
ocaml-Stdune--Dune-either \
ocaml-Stdune--Either \
ocaml-Stdune--Env \
ocaml-Stdune--Env-path \
ocaml-Stdune--Escape \
ocaml-Stdune--Exn \
ocaml-Stdune--Exn-with-backtrace \
ocaml-Stdune--Fdecl \
ocaml-Stdune--Filename \
ocaml-Stdune--Float \
ocaml-Stdune--Fpath \
ocaml-Stdune--Hashable \
ocaml-Stdune--Hashtbl \
ocaml-Stdune--Hashtbl-intf \
ocaml-Stdune--Id \
ocaml-Stdune--Int \
ocaml-Stdune--Io \
ocaml-Stdune--Io-intf \
ocaml-Stdune--Lexbuf \
ocaml-Stdune--List \
ocaml-Stdune--Loc \
ocaml-Stdune--Loc0 \
ocaml-Stdune--Map \
ocaml-Stdune--Map-intf \
ocaml-Stdune--Monad \
ocaml-Stdune--Monad-intf \
ocaml-Stdune--Monoid \
ocaml-Stdune--Monoid-intf \
ocaml-Stdune--Nonempty-list \
ocaml-Stdune--Nothing \
ocaml-Stdune--Option \
ocaml-Stdune--Or-exn \
ocaml-Stdune--Path \
ocaml-Stdune--Path-intf \
ocaml-Stdune--Pid \
ocaml-Stdune--Platform \
ocaml-Stdune--Poly \
ocaml-Stdune--Predicate \
ocaml-Stdune--Proc \
ocaml-Stdune--Queue \
ocaml-Stdune--Result \
ocaml-Stdune--Scanf \
ocaml-Stdune--Seq \
ocaml-Stdune--Set \
ocaml-Stdune--Set-intf \
ocaml-Stdune--Sexp \
ocaml-Stdune--Signal \
ocaml-Stdune--Staged \
ocaml-Stdune--State \
ocaml-Stdune--String \
ocaml-Stdune--String-split \
ocaml-Stdune--Sys \
ocaml-Stdune--Table \
ocaml-Stdune--Temp \
ocaml-Stdune--Top-closure \
ocaml-Stdune--Top-closure-intf \
ocaml-Stdune--Tuple \
ocaml-Stdune--Type-eq \
ocaml-Stdune--Unit \
ocaml-Stdune--Univ-map \
ocaml-Stdune--Univ-map-intf \
ocaml-Stdune--User-error \
ocaml-Stdune--User-message \
ocaml-Stdune--User-warning \
ocaml-Xdg \
ocaml-dune-configurator \
ocaml-dune-configurator-devel \
ocaml-dune-devel \
ocamlfind-chrome-trace \
ocamlfind-dune \
ocamlfind-dune-action-plugin \
ocamlfind-dune-build-info \
ocamlfind-dune-configurator \
ocamlfind-dune-glob \
ocamlfind-dune-private-libs \
ocamlfind-dune-private-libs.dune-re \
ocamlfind-dune-private-libs.dune-section \
ocamlfind-dune-private-libs.meta-parser \
ocamlfind-dune-private-libs.ocaml-config \
ocamlfind-dune-rpc \
ocamlfind-dune-rpc.private \
ocamlfind-dune-site \
ocamlfind-dune-site.dynlink \
ocamlfind-dune-site.linker \
ocamlfind-dune-site.plugins \
ocamlfind-dune-site.private \
ocamlfind-dune-site.toplevel \
ocamlfind-dune.configurator \
ocamlfind-dyn \
ocamlfind-dyn.pp \
ocamlfind-ocamlc-loc \
ocamlfind-ordering \
ocamlfind-stdune \
ocamlfind-stdune.csexp \
ocamlfind-stdune.filesystem-stubs \
ocamlfind-xdg \
ocamlx-Build-info \
ocamlx-Build-info-- \
ocamlx-Chrome-trace \
ocamlx-Configurator \
ocamlx-Configurator-- \
ocamlx-Configurator--Dune-lang \
ocamlx-Configurator--Extract-obj \
ocamlx-Configurator--Import \
ocamlx-Configurator--Ocaml-config \
ocamlx-Configurator--V1 \
ocamlx-Csexp \
ocamlx-Dune-action-plugin \
ocamlx-Dune-action-plugin-- \
ocamlx-Dune-action-plugin--Import \
ocamlx-Dune-action-plugin--Path \
ocamlx-Dune-action-plugin--Protocol \
ocamlx-Dune-action-plugin--Sexpable-intf \
ocamlx-Dune-filesystem-stubs \
ocamlx-Dune-glob \
ocamlx-Dune-glob-- \
ocamlx-Dune-glob--Glob \
ocamlx-Dune-glob--Lexer \
ocamlx-Dune-meta-parser \
ocamlx-Dune-meta-parser--Meta-lexer \
ocamlx-Dune-meta-parser--Meta-parser \
ocamlx-Dune-re \
ocamlx-Dune-re-- \
ocamlx-Dune-re--Automata \
ocamlx-Dune-re--Category \
ocamlx-Dune-re--Color-map \
ocamlx-Dune-re--Core \
ocamlx-Dune-re--Cset \
ocamlx-Dune-re--Emacs \
ocamlx-Dune-re--Fmt \
ocamlx-Dune-re--Glob \
ocamlx-Dune-re--Group \
ocamlx-Dune-re--Pcre \
ocamlx-Dune-re--Perl \
ocamlx-Dune-re--Pmark \
ocamlx-Dune-re--Posix \
ocamlx-Dune-re--Re \
ocamlx-Dune-re--Str \
ocamlx-Dune-rpc \
ocamlx-Dune-rpc-private \
ocamlx-Dune-rpc-private-- \
ocamlx-Dune-rpc-private--Conv \
ocamlx-Dune-rpc-private--Dbus-address \
ocamlx-Dune-rpc-private--Exported-types \
ocamlx-Dune-rpc-private--Fiber-intf \
ocamlx-Dune-rpc-private--Import \
ocamlx-Dune-rpc-private--Menu \
ocamlx-Dune-rpc-private--Procedures \
ocamlx-Dune-rpc-private--Registry \
ocamlx-Dune-rpc-private--Sub \
ocamlx-Dune-rpc-private--Types \
ocamlx-Dune-rpc-private--Versioned \
ocamlx-Dune-rpc-private--Where \
ocamlx-Dune-section \
ocamlx-Dune-site \
ocamlx-Dune-site-- \
ocamlx-Dune-site--Helpers \
ocamlx-Dune-site-backend \
ocamlx-Dune-site-backend--Linker \
ocamlx-Dune-site-backend--dune-site-dynlink-linker-- \
ocamlx-Dune-site-plugins \
ocamlx-Dune-site-plugins-- \
ocamlx-Dune-site-plugins--Meta-parser \
ocamlx-Dune-site-plugins--Plugins \
ocamlx-Dune-site-private \
ocamlx-Dyn \
ocamlx-Ocaml-config \
ocamlx-Ocamlc-loc \
ocamlx-Ocamlc-loc-- \
ocamlx-Ocamlc-loc--Lexer \
ocamlx-Ordering \
ocamlx-Pp \
ocamlx-Stdune \
ocamlx-Stdune-- \
ocamlx-Stdune--Ansi-color \
ocamlx-Stdune--Appendable-list \
ocamlx-Stdune--Applicative \
ocamlx-Stdune--Applicative-intf \
ocamlx-Stdune--Array \
ocamlx-Stdune--Bin \
ocamlx-Stdune--Bool \
ocamlx-Stdune--Bytes \
ocamlx-Stdune--Bytes-unit \
ocamlx-Stdune--Caller-id \
ocamlx-Stdune--Char \
ocamlx-Stdune--Code-error \
ocamlx-Stdune--Comparable \
ocamlx-Stdune--Comparable-intf \
ocamlx-Stdune--Comparator \
ocamlx-Stdune--Dev-null \
ocamlx-Stdune--Dune-either \
ocamlx-Stdune--Either \
ocamlx-Stdune--Env \
ocamlx-Stdune--Env-path \
ocamlx-Stdune--Escape \
ocamlx-Stdune--Exn \
ocamlx-Stdune--Exn-with-backtrace \
ocamlx-Stdune--Fdecl \
ocamlx-Stdune--Filename \
ocamlx-Stdune--Float \
ocamlx-Stdune--Fpath \
ocamlx-Stdune--Hashable \
ocamlx-Stdune--Hashtbl \
ocamlx-Stdune--Hashtbl-intf \
ocamlx-Stdune--Id \
ocamlx-Stdune--Int \
ocamlx-Stdune--Io \
ocamlx-Stdune--Io-intf \
ocamlx-Stdune--Lexbuf \
ocamlx-Stdune--List \
ocamlx-Stdune--Loc \
ocamlx-Stdune--Loc0 \
ocamlx-Stdune--Map \
ocamlx-Stdune--Map-intf \
ocamlx-Stdune--Monad \
ocamlx-Stdune--Monad-intf \
ocamlx-Stdune--Monoid \
ocamlx-Stdune--Monoid-intf \
ocamlx-Stdune--Nonempty-list \
ocamlx-Stdune--Nothing \
ocamlx-Stdune--Option \
ocamlx-Stdune--Or-exn \
ocamlx-Stdune--Path \
ocamlx-Stdune--Path-intf \
ocamlx-Stdune--Pid \
ocamlx-Stdune--Platform \
ocamlx-Stdune--Poly \
ocamlx-Stdune--Predicate \
ocamlx-Stdune--Proc \
ocamlx-Stdune--Queue \
ocamlx-Stdune--Result \
ocamlx-Stdune--Scanf \
ocamlx-Stdune--Seq \
ocamlx-Stdune--Set \
ocamlx-Stdune--Set-intf \
ocamlx-Stdune--Sexp \
ocamlx-Stdune--Signal \
ocamlx-Stdune--Staged \
ocamlx-Stdune--State \
ocamlx-Stdune--String \
ocamlx-Stdune--String-split \
ocamlx-Stdune--Sys \
ocamlx-Stdune--Table \
ocamlx-Stdune--Temp \
ocamlx-Stdune--Top-closure \
ocamlx-Stdune--Top-closure-intf \
ocamlx-Stdune--Tuple \
ocamlx-Stdune--Type-eq \
ocamlx-Stdune--Unit \
ocamlx-Stdune--Univ-map \
ocamlx-Stdune--Univ-map-intf \
ocamlx-Stdune--User-error \
ocamlx-Stdune--User-message \
ocamlx-Stdune--User-warning \
ocamlx-Xdg"

RDEPENDS:${PN} += "libc.so.6 \
ocaml-Asttypes \
ocaml-Build-path-prefix-map \
ocaml-CamlinternalFormatBasics \
ocaml-CamlinternalLazy \
ocaml-Cmi-format \
ocaml-Dynlink \
ocaml-Env \
ocaml-Ident \
ocaml-Identifiable \
ocaml-Load-path \
ocaml-Location \
ocaml-Longident \
ocaml-Misc \
ocaml-Outcometree \
ocaml-Parsetree \
ocaml-Path \
ocaml-Primitive \
ocaml-Shape \
ocaml-Stdlib \
ocaml-Stdlib--Arg \
ocaml-Stdlib--Array \
ocaml-Stdlib--ArrayLabels \
ocaml-Stdlib--Bigarray \
ocaml-Stdlib--Buffer \
ocaml-Stdlib--Bytes \
ocaml-Stdlib--BytesLabels \
ocaml-Stdlib--Char \
ocaml-Stdlib--Complex \
ocaml-Stdlib--Digest \
ocaml-Stdlib--Either \
ocaml-Stdlib--Filename \
ocaml-Stdlib--Format \
ocaml-Stdlib--Fun \
ocaml-Stdlib--Hashtbl \
ocaml-Stdlib--Int \
ocaml-Stdlib--Int32 \
ocaml-Stdlib--Int64 \
ocaml-Stdlib--Lazy \
ocaml-Stdlib--Lexing \
ocaml-Stdlib--List \
ocaml-Stdlib--ListLabels \
ocaml-Stdlib--Map \
ocaml-Stdlib--MoreLabels \
ocaml-Stdlib--Nativeint \
ocaml-Stdlib--Obj \
ocaml-Stdlib--Option \
ocaml-Stdlib--Printexc \
ocaml-Stdlib--Printf \
ocaml-Stdlib--Queue \
ocaml-Stdlib--Random \
ocaml-Stdlib--Result \
ocaml-Stdlib--Scanf \
ocaml-Stdlib--Seq \
ocaml-Stdlib--Set \
ocaml-Stdlib--StdLabels \
ocaml-Stdlib--String \
ocaml-Stdlib--StringLabels \
ocaml-Stdlib--Sys \
ocaml-Stdlib--Uchar \
ocaml-Subst \
ocaml-Topdirs \
ocaml-Toploop \
ocaml-Type-immediacy \
ocaml-Types \
ocaml-Unix \
ocaml-Warnings \
ocamlfind-compiler-libs \
ocamlfind-compiler-libs.toplevel \
ocamlfind-dynlink \
ocamlfind-unix \
ocamlx-CamlinternalLazy \
ocamlx-Dynlink \
ocamlx-Stdlib \
ocamlx-Stdlib--Arg \
ocamlx-Stdlib--Array \
ocamlx-Stdlib--ArrayLabels \
ocamlx-Stdlib--Buffer \
ocamlx-Stdlib--Bytes \
ocamlx-Stdlib--BytesLabels \
ocamlx-Stdlib--Char \
ocamlx-Stdlib--Filename \
ocamlx-Stdlib--Format \
ocamlx-Stdlib--Fun \
ocamlx-Stdlib--Hashtbl \
ocamlx-Stdlib--Int \
ocamlx-Stdlib--Int32 \
ocamlx-Stdlib--Int64 \
ocamlx-Stdlib--Lexing \
ocamlx-Stdlib--List \
ocamlx-Stdlib--ListLabels \
ocamlx-Stdlib--Map \
ocamlx-Stdlib--MoreLabels \
ocamlx-Stdlib--Nativeint \
ocamlx-Stdlib--Option \
ocamlx-Stdlib--Printexc \
ocamlx-Stdlib--Printf \
ocamlx-Stdlib--Queue \
ocamlx-Stdlib--Random \
ocamlx-Stdlib--Scanf \
ocamlx-Stdlib--Seq \
ocamlx-Stdlib--Set \
ocamlx-Stdlib--String \
ocamlx-Stdlib--StringLabels \
ocamlx-Stdlib--Sys \
ocamlx-Unix"

inherit rpm
