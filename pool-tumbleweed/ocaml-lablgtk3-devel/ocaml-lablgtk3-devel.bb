SUMMARY = "Development files for ocaml-lablgtk3"
DESCRIPTION = "The ocaml-lablgtk3-devel package contains libraries and signature files for \
developing applications that use ocaml-lablgtk3."
LICENSE = "LGPL-3.0-or-later"

PV = "3.1.3"

RPM_NAME = "ocaml-lablgtk3-devel-3.1.3-2.3.aarch64.rpm"
RPM_HASH = "2dfa303910a130d888a39fbd8e1097e6fc7abaab3212830ae930290c1bf77bdfe9f1220dbba8b4de7f54d6b5a1902006d18985721b0b93a7dd4ae17d8bad54f8"

RPROVIDES:${PN} += "ocaml-Cairo-pango \
ocaml-GAction \
ocaml-GAssistant \
ocaml-GBin \
ocaml-GBuilder \
ocaml-GButton \
ocaml-GContainer \
ocaml-GData \
ocaml-GDraw \
ocaml-GEdit \
ocaml-GFile \
ocaml-GMain \
ocaml-GMenu \
ocaml-GMisc \
ocaml-GObj \
ocaml-GPack \
ocaml-GPango \
ocaml-GRange \
ocaml-GSourceView3 \
ocaml-GText \
ocaml-GToolbox \
ocaml-GTree \
ocaml-GUtil \
ocaml-GWindow \
ocaml-Gaux \
ocaml-Gdk \
ocaml-GdkEnums \
ocaml-GdkEvent \
ocaml-GdkKeysyms \
ocaml-GdkPixbuf \
ocaml-Glib \
ocaml-Gobject \
ocaml-Gpointer \
ocaml-Gtk \
ocaml-GtkActionProps \
ocaml-GtkAssistant \
ocaml-GtkAssistantProps \
ocaml-GtkBase \
ocaml-GtkBaseProps \
ocaml-GtkBin \
ocaml-GtkBinProps \
ocaml-GtkBuilder \
ocaml-GtkBuilderProps \
ocaml-GtkButton \
ocaml-GtkButtonProps \
ocaml-GtkContainers \
ocaml-GtkContainersProps \
ocaml-GtkData \
ocaml-GtkEdit \
ocaml-GtkEditProps \
ocaml-GtkEnums \
ocaml-GtkFile \
ocaml-GtkFileProps \
ocaml-GtkMain \
ocaml-GtkMenu \
ocaml-GtkMenuProps \
ocaml-GtkMisc \
ocaml-GtkMiscProps \
ocaml-GtkObject \
ocaml-GtkPack \
ocaml-GtkPackProps \
ocaml-GtkRange \
ocaml-GtkRangeProps \
ocaml-GtkSignal \
ocaml-GtkSourceView3 \
ocaml-GtkSourceView3-types \
ocaml-GtkSourceView3Props \
ocaml-GtkSpell \
ocaml-GtkStock \
ocaml-GtkText \
ocaml-GtkTextProps \
ocaml-GtkThread \
ocaml-GtkTree \
ocaml-GtkTreeProps \
ocaml-GtkWindow \
ocaml-Gutf8 \
ocaml-OgtkActionProps \
ocaml-OgtkAssistantProps \
ocaml-OgtkBaseProps \
ocaml-OgtkBinProps \
ocaml-OgtkBuilderProps \
ocaml-OgtkButtonProps \
ocaml-OgtkContainersProps \
ocaml-OgtkEditProps \
ocaml-OgtkFileProps \
ocaml-OgtkMenuProps \
ocaml-OgtkMiscProps \
ocaml-OgtkPackProps \
ocaml-OgtkRangeProps \
ocaml-OgtkSourceView3Props \
ocaml-OgtkTextProps \
ocaml-OgtkTreeProps \
ocaml-Pango \
ocaml-PangoEnums \
ocaml-SourceView3Enums \
ocaml-lablgtk3-devel \
ocamlfind-lablgtk3 \
ocamlfind-lablgtk3-gtkspell3 \
ocamlfind-lablgtk3-sourceview3 \
ocamlx-Cairo-pango \
ocamlx-GAction \
ocamlx-GAssistant \
ocamlx-GBin \
ocamlx-GBuilder \
ocamlx-GButton \
ocamlx-GContainer \
ocamlx-GData \
ocamlx-GDraw \
ocamlx-GEdit \
ocamlx-GFile \
ocamlx-GMain \
ocamlx-GMenu \
ocamlx-GMisc \
ocamlx-GObj \
ocamlx-GPack \
ocamlx-GPango \
ocamlx-GRange \
ocamlx-GSourceView3 \
ocamlx-GText \
ocamlx-GToolbox \
ocamlx-GTree \
ocamlx-GUtil \
ocamlx-GWindow \
ocamlx-Gaux \
ocamlx-Gdk \
ocamlx-GdkEnums \
ocamlx-GdkEvent \
ocamlx-GdkKeysyms \
ocamlx-GdkPixbuf \
ocamlx-Glib \
ocamlx-Gobject \
ocamlx-Gpointer \
ocamlx-Gtk \
ocamlx-GtkActionProps \
ocamlx-GtkAssistant \
ocamlx-GtkAssistantProps \
ocamlx-GtkBase \
ocamlx-GtkBaseProps \
ocamlx-GtkBin \
ocamlx-GtkBinProps \
ocamlx-GtkBuilder \
ocamlx-GtkBuilderProps \
ocamlx-GtkButton \
ocamlx-GtkButtonProps \
ocamlx-GtkContainers \
ocamlx-GtkContainersProps \
ocamlx-GtkData \
ocamlx-GtkEdit \
ocamlx-GtkEditProps \
ocamlx-GtkEnums \
ocamlx-GtkFile \
ocamlx-GtkFileProps \
ocamlx-GtkMain \
ocamlx-GtkMenu \
ocamlx-GtkMenuProps \
ocamlx-GtkMisc \
ocamlx-GtkMiscProps \
ocamlx-GtkObject \
ocamlx-GtkPack \
ocamlx-GtkPackProps \
ocamlx-GtkRange \
ocamlx-GtkRangeProps \
ocamlx-GtkSignal \
ocamlx-GtkSourceView3 \
ocamlx-GtkSourceView3Props \
ocamlx-GtkSpell \
ocamlx-GtkStock \
ocamlx-GtkText \
ocamlx-GtkTextProps \
ocamlx-GtkThread \
ocamlx-GtkTree \
ocamlx-GtkTreeProps \
ocamlx-GtkWindow \
ocamlx-Gutf8 \
ocamlx-OgtkActionProps \
ocamlx-OgtkAssistantProps \
ocamlx-OgtkBaseProps \
ocamlx-OgtkBinProps \
ocamlx-OgtkBuilderProps \
ocamlx-OgtkButtonProps \
ocamlx-OgtkContainersProps \
ocamlx-OgtkEditProps \
ocamlx-OgtkFileProps \
ocamlx-OgtkMenuProps \
ocamlx-OgtkMiscProps \
ocamlx-OgtkPackProps \
ocamlx-OgtkRangeProps \
ocamlx-OgtkSourceView3Props \
ocamlx-OgtkTextProps \
ocamlx-OgtkTreeProps \
ocamlx-Pango \
ocamlx-PangoEnums \
ocamlx-SourceView3Enums"

RDEPENDS:${PN} += "libc.so.6 \
libcairo.so.2 \
libgdk-3.so.0 \
libgdk-pixbuf-2.0.so.0 \
libglib-2.0.so.0 \
libgobject-2.0.so.0 \
libgtk-3.so.0 \
libgtksourceview-3.0.so.1 \
libgtkspell3-3.so.0 \
libpango-1.0.so.0 \
libpangocairo-1.0.so.0 \
ocaml-Cairo \
ocaml-CamlinternalFormatBasics \
ocaml-CamlinternalLazy \
ocaml-CamlinternalOO \
ocaml-Condition \
ocaml-Mutex \
ocaml-Stdlib \
ocaml-Stdlib--ArrayLabels \
ocaml-Stdlib--Bigarray \
ocaml-Stdlib--Buffer \
ocaml-Stdlib--BytesLabels \
ocaml-Stdlib--Callback \
ocaml-Stdlib--Char \
ocaml-Stdlib--Complex \
ocaml-Stdlib--Either \
ocaml-Stdlib--Format \
ocaml-Stdlib--Gc \
ocaml-Stdlib--Hashtbl \
ocaml-Stdlib--Int32 \
ocaml-Stdlib--Lazy \
ocaml-Stdlib--List \
ocaml-Stdlib--ListLabels \
ocaml-Stdlib--Nativeint \
ocaml-Stdlib--Obj \
ocaml-Stdlib--Oo \
ocaml-Stdlib--Printexc \
ocaml-Stdlib--Printf \
ocaml-Stdlib--Queue \
ocaml-Stdlib--Seq \
ocaml-Stdlib--StdLabels \
ocaml-Stdlib--StringLabels \
ocaml-Stdlib--Sys \
ocaml-Stdlib--Uchar \
ocaml-Thread \
ocaml-Unix \
ocaml-lablgtk3 \
ocamlfind-cairo2 \
ocamlfind-threads \
ocamlx-CamlinternalLazy \
ocamlx-CamlinternalOO \
ocamlx-Condition \
ocamlx-Mutex \
ocamlx-Stdlib \
ocamlx-Stdlib--ArrayLabels \
ocamlx-Stdlib--Buffer \
ocamlx-Stdlib--BytesLabels \
ocamlx-Stdlib--Callback \
ocamlx-Stdlib--Char \
ocamlx-Stdlib--Format \
ocamlx-Stdlib--Gc \
ocamlx-Stdlib--Hashtbl \
ocamlx-Stdlib--Int32 \
ocamlx-Stdlib--List \
ocamlx-Stdlib--ListLabels \
ocamlx-Stdlib--Nativeint \
ocamlx-Stdlib--Printexc \
ocamlx-Stdlib--Printf \
ocamlx-Stdlib--Queue \
ocamlx-Stdlib--StringLabels \
ocamlx-Stdlib--Sys \
ocamlx-Thread \
pkgconfig-gtk+-3.0 \
pkgconfig-gtksourceview-3.0 \
pkgconfig-gtkspell3-3.0"

inherit rpm
