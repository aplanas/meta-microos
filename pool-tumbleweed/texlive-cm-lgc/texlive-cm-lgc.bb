SUMMARY = "Type 1 CM-based fonts for Latin, Greek and Cyrillic"
DESCRIPTION = "The fonts are converted from Metafont sources of the Computer \
Modern font families, using textrace. Supported encodings are: \
T1 (Latin), T2A (Cyrillic), LGR (Greek) and TS1. The package \
also includes Unicode virtual fonts for use with Omega. The \
font set is not a replacement for any of the other Computer \
Modern-based font sets (for example, cm-super for Latin and \
Cyrillic, or cbgreek for Greek), since it is available at a \
single size only; it offers a compact set for 'general' \
working. The fonts themselves are encoded to external \
standards, and virtual fonts are provided for use with TeX."
LICENSE = "GPL-2.0-or-later"

PV = "2023.201.0.0.5svn28250"

RPM_NAME = "texlive-cm-lgc-2023.201.0.0.5svn28250-53.1.noarch.rpm"
RPM_HASH = "e50056e2038e63d28056d2e65e69a8553ac0c7ac3e4c21966af862d98d92ddb3a2b37c0736cef13d2fea2b07dbcf67d37e9dd25819f52100fed780b812ec44d3"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-8r-mod.enc \
tex-antcmlgc.sty \
tex-cm-lgc.map \
tex-cmlgc.sty \
tex-fcmb6a.tfm \
tex-fcmb6a.vf \
tex-fcmb6y.tfm \
tex-fcmb6z.tfm \
tex-fcmb7k.tfm \
tex-fcmb7k.vf \
tex-fcmb7t.tfm \
tex-fcmb7t.vf \
tex-fcmb8a.tfm \
tex-fcmb8c.tfm \
tex-fcmb8c.vf \
tex-fcmb8r.tfm \
tex-fcmb8t.tfm \
tex-fcmb8t.vf \
tex-fcmbc6a.tfm \
tex-fcmbc6a.vf \
tex-fcmbc6y.tfm \
tex-fcmbc6z.tfm \
tex-fcmbc7k.tfm \
tex-fcmbc7k.vf \
tex-fcmbc7t.tfm \
tex-fcmbc7t.vf \
tex-fcmbc8a.tfm \
tex-fcmbc8r.tfm \
tex-fcmbc8t.tfm \
tex-fcmbc8t.vf \
tex-fcmbcce.tfm \
tex-fcmbce.tfm \
tex-fcmbcgr.tfm \
tex-fcmbcgr.vf \
tex-fcmbcpg.tfm \
tex-fcmbgr.tfm \
tex-fcmbgr.vf \
tex-fcmbi6a.tfm \
tex-fcmbi6a.vf \
tex-fcmbi6y.tfm \
tex-fcmbi6z.tfm \
tex-fcmbi7k.tfm \
tex-fcmbi7k.vf \
tex-fcmbi7t.tfm \
tex-fcmbi7t.vf \
tex-fcmbi8a.tfm \
tex-fcmbi8c.tfm \
tex-fcmbi8c.vf \
tex-fcmbi8r.tfm \
tex-fcmbi8t.tfm \
tex-fcmbi8t.vf \
tex-fcmbice.tfm \
tex-fcmbigr.tfm \
tex-fcmbigr.vf \
tex-fcmbij8a.tfm \
tex-fcmbij8r.tfm \
tex-fcmbipg.tfm \
tex-fcmbo6a.tfm \
tex-fcmbo6a.vf \
tex-fcmbo6y.tfm \
tex-fcmbo6z.tfm \
tex-fcmbo7k.tfm \
tex-fcmbo7k.vf \
tex-fcmbo7t.tfm \
tex-fcmbo7t.vf \
tex-fcmbo8c.tfm \
tex-fcmbo8c.vf \
tex-fcmbo8r.tfm \
tex-fcmbo8t.tfm \
tex-fcmbo8t.vf \
tex-fcmboc8r.tfm \
tex-fcmboce.tfm \
tex-fcmbogr.tfm \
tex-fcmbogr.vf \
tex-fcmbopg.tfm \
tex-fcmbpg.tfm \
tex-fcmbu6a.tfm \
tex-fcmbu6a.vf \
tex-fcmbu6y.tfm \
tex-fcmbu6z.tfm \
tex-fcmbu7k.tfm \
tex-fcmbu7k.vf \
tex-fcmbu7t.tfm \
tex-fcmbu7t.vf \
tex-fcmbu8c.tfm \
tex-fcmbu8c.vf \
tex-fcmbu8r.tfm \
tex-fcmbu8t.tfm \
tex-fcmbu8t.vf \
tex-fcmbuce.tfm \
tex-fcmbugr.tfm \
tex-fcmbugr.vf \
tex-fcmbuj8r.tfm \
tex-fcmbupg.tfm \
tex-fcmr6a.tfm \
tex-fcmr6a.vf \
tex-fcmr6y.tfm \
tex-fcmr6z.tfm \
tex-fcmr7k.tfm \
tex-fcmr7k.vf \
tex-fcmr7t.tfm \
tex-fcmr7t.vf \
tex-fcmr8a.tfm \
tex-fcmr8c.tfm \
tex-fcmr8c.vf \
tex-fcmr8r.tfm \
tex-fcmr8t.tfm \
tex-fcmr8t.vf \
tex-fcmrc6a.tfm \
tex-fcmrc6a.vf \
tex-fcmrc6y.tfm \
tex-fcmrc6z.tfm \
tex-fcmrc7k.tfm \
tex-fcmrc7k.vf \
tex-fcmrc7t.tfm \
tex-fcmrc7t.vf \
tex-fcmrc8a.tfm \
tex-fcmrc8r.tfm \
tex-fcmrc8t.tfm \
tex-fcmrc8t.vf \
tex-fcmrcce.tfm \
tex-fcmrce.tfm \
tex-fcmrcgr.tfm \
tex-fcmrcgr.vf \
tex-fcmrcpg.tfm \
tex-fcmrgr.tfm \
tex-fcmrgr.vf \
tex-fcmri6a.tfm \
tex-fcmri6a.vf \
tex-fcmri6y.tfm \
tex-fcmri6z.tfm \
tex-fcmri7k.tfm \
tex-fcmri7k.vf \
tex-fcmri7t.tfm \
tex-fcmri7t.vf \
tex-fcmri8a.tfm \
tex-fcmri8c.tfm \
tex-fcmri8c.vf \
tex-fcmri8r.tfm \
tex-fcmri8t.tfm \
tex-fcmri8t.vf \
tex-fcmrice.tfm \
tex-fcmrigr.tfm \
tex-fcmrigr.vf \
tex-fcmrij8a.tfm \
tex-fcmrij8r.tfm \
tex-fcmripg.tfm \
tex-fcmro6a.tfm \
tex-fcmro6a.vf \
tex-fcmro6y.tfm \
tex-fcmro6z.tfm \
tex-fcmro7k.tfm \
tex-fcmro7k.vf \
tex-fcmro7t.tfm \
tex-fcmro7t.vf \
tex-fcmro8c.tfm \
tex-fcmro8c.vf \
tex-fcmro8r.tfm \
tex-fcmro8t.tfm \
tex-fcmro8t.vf \
tex-fcmroc8r.tfm \
tex-fcmroce.tfm \
tex-fcmrogr.tfm \
tex-fcmrogr.vf \
tex-fcmropg.tfm \
tex-fcmrpg.tfm \
tex-fcmru6a.tfm \
tex-fcmru6a.vf \
tex-fcmru6y.tfm \
tex-fcmru6z.tfm \
tex-fcmru7k.tfm \
tex-fcmru7k.vf \
tex-fcmru7t.tfm \
tex-fcmru7t.vf \
tex-fcmru8c.tfm \
tex-fcmru8c.vf \
tex-fcmru8r.tfm \
tex-fcmru8t.tfm \
tex-fcmru8t.vf \
tex-fcmruce.tfm \
tex-fcmrugr.tfm \
tex-fcmrugr.vf \
tex-fcmruj8r.tfm \
tex-fcmrupg.tfm \
tex-fcsb6a.tfm \
tex-fcsb6a.vf \
tex-fcsb6y.tfm \
tex-fcsb6z.tfm \
tex-fcsb7k.tfm \
tex-fcsb7k.vf \
tex-fcsb7t.tfm \
tex-fcsb7t.vf \
tex-fcsb8a.tfm \
tex-fcsb8c.tfm \
tex-fcsb8c.vf \
tex-fcsb8r.tfm \
tex-fcsb8t.tfm \
tex-fcsb8t.vf \
tex-fcsbce.tfm \
tex-fcsbgr.tfm \
tex-fcsbgr.vf \
tex-fcsbo6a.tfm \
tex-fcsbo6a.vf \
tex-fcsbo6y.tfm \
tex-fcsbo6z.tfm \
tex-fcsbo7k.tfm \
tex-fcsbo7k.vf \
tex-fcsbo7t.tfm \
tex-fcsbo7t.vf \
tex-fcsbo8a.tfm \
tex-fcsbo8c.tfm \
tex-fcsbo8c.vf \
tex-fcsbo8r.tfm \
tex-fcsbo8t.tfm \
tex-fcsbo8t.vf \
tex-fcsboce.tfm \
tex-fcsbogr.tfm \
tex-fcsbogr.vf \
tex-fcsbopg.tfm \
tex-fcsbpg.tfm \
tex-fcsr6a.tfm \
tex-fcsr6a.vf \
tex-fcsr6y.tfm \
tex-fcsr6z.tfm \
tex-fcsr7k.tfm \
tex-fcsr7k.vf \
tex-fcsr7t.tfm \
tex-fcsr7t.vf \
tex-fcsr8a.tfm \
tex-fcsr8c.tfm \
tex-fcsr8c.vf \
tex-fcsr8r.tfm \
tex-fcsr8t.tfm \
tex-fcsr8t.vf \
tex-fcsrce.tfm \
tex-fcsrgr.tfm \
tex-fcsrgr.vf \
tex-fcsro6a.tfm \
tex-fcsro6a.vf \
tex-fcsro6y.tfm \
tex-fcsro6z.tfm \
tex-fcsro7k.tfm \
tex-fcsro7k.vf \
tex-fcsro7t.tfm \
tex-fcsro7t.vf \
tex-fcsro8a.tfm \
tex-fcsro8c.tfm \
tex-fcsro8c.vf \
tex-fcsro8r.tfm \
tex-fcsro8t.tfm \
tex-fcsro8t.vf \
tex-fcsroce.tfm \
tex-fcsrogr.tfm \
tex-fcsrogr.vf \
tex-fcsropg.tfm \
tex-fcsrpg.tfm \
tex-fctr6a.tfm \
tex-fctr6a.vf \
tex-fctr6y.tfm \
tex-fctr6z.tfm \
tex-fctr7k.tfm \
tex-fctr7k.vf \
tex-fctr7t.tfm \
tex-fctr7t.vf \
tex-fctr8a.tfm \
tex-fctr8c.tfm \
tex-fctr8c.vf \
tex-fctr8r.tfm \
tex-fctr8t.tfm \
tex-fctr8t.vf \
tex-fctrc6a.tfm \
tex-fctrc6a.vf \
tex-fctrc6y.tfm \
tex-fctrc6z.tfm \
tex-fctrc7k.tfm \
tex-fctrc7k.vf \
tex-fctrc7t.tfm \
tex-fctrc7t.vf \
tex-fctrc8a.tfm \
tex-fctrc8r.tfm \
tex-fctrc8t.tfm \
tex-fctrc8t.vf \
tex-fctrcce.tfm \
tex-fctrce.tfm \
tex-fctrcgr.tfm \
tex-fctrcgr.vf \
tex-fctrcpg.tfm \
tex-fctrgr.tfm \
tex-fctrgr.vf \
tex-fctri6a.tfm \
tex-fctri6a.vf \
tex-fctri6y.tfm \
tex-fctri6z.tfm \
tex-fctri7k.tfm \
tex-fctri7k.vf \
tex-fctri7t.tfm \
tex-fctri7t.vf \
tex-fctri8a.tfm \
tex-fctri8c.tfm \
tex-fctri8c.vf \
tex-fctri8r.tfm \
tex-fctri8t.tfm \
tex-fctri8t.vf \
tex-fctrice.tfm \
tex-fctrigr.tfm \
tex-fctrigr.vf \
tex-fctrij8a.tfm \
tex-fctrij8r.tfm \
tex-fctripg.tfm \
tex-fctro6a.tfm \
tex-fctro6a.vf \
tex-fctro6y.tfm \
tex-fctro6z.tfm \
tex-fctro7k.tfm \
tex-fctro7k.vf \
tex-fctro7t.tfm \
tex-fctro7t.vf \
tex-fctro8c.tfm \
tex-fctro8c.vf \
tex-fctro8r.tfm \
tex-fctro8t.tfm \
tex-fctro8t.vf \
tex-fctroc8r.tfm \
tex-fctroce.tfm \
tex-fctrogr.tfm \
tex-fctrogr.vf \
tex-fctropg.tfm \
tex-fctrpg.tfm \
tex-fctru6a.tfm \
tex-fctru6a.vf \
tex-fctru6y.tfm \
tex-fctru6z.tfm \
tex-fctru7k.tfm \
tex-fctru7k.vf \
tex-fctru7t.tfm \
tex-fctru7t.vf \
tex-fctru8c.tfm \
tex-fctru8c.vf \
tex-fctru8r.tfm \
tex-fctru8t.tfm \
tex-fctru8t.vf \
tex-fctruce.tfm \
tex-fctrugr.tfm \
tex-fctrugr.vf \
tex-fctruj8r.tfm \
tex-fctrupg.tfm \
tex-lgrfcm.fd \
tex-lgrfcs.fd \
tex-lgrfct.fd \
tex-ot1fcm.fd \
tex-ot1fcs.fd \
tex-ot1fct.fd \
tex-ot2fcm.fd \
tex-ot2fcs.fd \
tex-ot2fct.fd \
tex-t1fcm.fd \
tex-t1fcs.fd \
tex-t1fct.fd \
tex-t2afcm.fd \
tex-t2afcs.fd \
tex-t2afct.fd \
tex-ts1fcm.fd \
tex-ts1fcs.fd \
tex-ts1fct.fd \
tex-ut1fcm.fd \
tex-ut1fcs.fd \
tex-ut1fct.fd \
texlive-cm-lgc"

RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-updmap.cfg \
texlive \
texlive-cm-lgc-fonts \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
