SUMMARY = "Use SourceSerifPro with TeX(-alike) systems"
DESCRIPTION = "This package provides Source Serif Pro for LaTeX. It includes \
both Type1 and OpenType fonts and selects the latter when using \
XeLaTeX or LuaLaTeX."
LICENSE = "OFL-1.1"

PV = "2023.201.1.4svn54512"

RPM_NAME = "texlive-sourceserifpro-2023.201.1.4svn54512-57.1.noarch.rpm"
RPM_HASH = "4c33b9db69b82b227c9dd1d28f1d9a4fe96d5856a59f67e35a09778b08cfb85a343e355436f3ae1180d8a058a94523aaef9276dcc5fb0d412337f3d3916c7aba"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex(LY1SourceSerifPro-Dnom.fd) \
tex(LY1SourceSerifPro-LF.fd) \
tex(LY1SourceSerifPro-Numr.fd) \
tex(LY1SourceSerifPro-OsF.fd) \
tex(LY1SourceSerifPro-Sup.fd) \
tex(LY1SourceSerifPro-TLF.fd) \
tex(LY1SourceSerifPro-TOsF.fd) \
tex(OT1SourceSerifPro-Dnom.fd) \
tex(OT1SourceSerifPro-LF.fd) \
tex(OT1SourceSerifPro-Numr.fd) \
tex(OT1SourceSerifPro-OsF.fd) \
tex(OT1SourceSerifPro-Sup.fd) \
tex(OT1SourceSerifPro-TLF.fd) \
tex(OT1SourceSerifPro-TOsF.fd) \
tex(SourceSerifPro-Black-dnom-ly1--base.tfm) \
tex(SourceSerifPro-Black-dnom-ly1.tfm) \
tex(SourceSerifPro-Black-dnom-ly1.vf) \
tex(SourceSerifPro-Black-dnom-ot1.tfm) \
tex(SourceSerifPro-Black-dnom-t1--base.tfm) \
tex(SourceSerifPro-Black-dnom-t1.tfm) \
tex(SourceSerifPro-Black-dnom-t1.vf) \
tex(SourceSerifPro-Black-lf-ly1--base.tfm) \
tex(SourceSerifPro-Black-lf-ly1.tfm) \
tex(SourceSerifPro-Black-lf-ly1.vf) \
tex(SourceSerifPro-Black-lf-ot1.tfm) \
tex(SourceSerifPro-Black-lf-sc-ly1--base.tfm) \
tex(SourceSerifPro-Black-lf-sc-ly1.tfm) \
tex(SourceSerifPro-Black-lf-sc-ly1.vf) \
tex(SourceSerifPro-Black-lf-sc-ot1--base.tfm) \
tex(SourceSerifPro-Black-lf-sc-ot1.tfm) \
tex(SourceSerifPro-Black-lf-sc-ot1.vf) \
tex(SourceSerifPro-Black-lf-sc-t1--base.tfm) \
tex(SourceSerifPro-Black-lf-sc-t1.tfm) \
tex(SourceSerifPro-Black-lf-sc-t1.vf) \
tex(SourceSerifPro-Black-lf-t1--base.tfm) \
tex(SourceSerifPro-Black-lf-t1.tfm) \
tex(SourceSerifPro-Black-lf-t1.vf) \
tex(SourceSerifPro-Black-lf-ts1--base.tfm) \
tex(SourceSerifPro-Black-lf-ts1.tfm) \
tex(SourceSerifPro-Black-lf-ts1.vf) \
tex(SourceSerifPro-Black-numr-ly1--base.tfm) \
tex(SourceSerifPro-Black-numr-ly1.tfm) \
tex(SourceSerifPro-Black-numr-ly1.vf) \
tex(SourceSerifPro-Black-numr-ot1.tfm) \
tex(SourceSerifPro-Black-numr-t1--base.tfm) \
tex(SourceSerifPro-Black-numr-t1.tfm) \
tex(SourceSerifPro-Black-numr-t1.vf) \
tex(SourceSerifPro-Black-osf-ly1--base.tfm) \
tex(SourceSerifPro-Black-osf-ly1.tfm) \
tex(SourceSerifPro-Black-osf-ly1.vf) \
tex(SourceSerifPro-Black-osf-ot1.tfm) \
tex(SourceSerifPro-Black-osf-sc-ly1--base.tfm) \
tex(SourceSerifPro-Black-osf-sc-ly1.tfm) \
tex(SourceSerifPro-Black-osf-sc-ly1.vf) \
tex(SourceSerifPro-Black-osf-sc-ot1--base.tfm) \
tex(SourceSerifPro-Black-osf-sc-ot1.tfm) \
tex(SourceSerifPro-Black-osf-sc-ot1.vf) \
tex(SourceSerifPro-Black-osf-sc-t1--base.tfm) \
tex(SourceSerifPro-Black-osf-sc-t1.tfm) \
tex(SourceSerifPro-Black-osf-sc-t1.vf) \
tex(SourceSerifPro-Black-osf-t1--base.tfm) \
tex(SourceSerifPro-Black-osf-t1.tfm) \
tex(SourceSerifPro-Black-osf-t1.vf) \
tex(SourceSerifPro-Black-osf-ts1--base.tfm) \
tex(SourceSerifPro-Black-osf-ts1.tfm) \
tex(SourceSerifPro-Black-osf-ts1.vf) \
tex(SourceSerifPro-Black-sup-ly1--base.tfm) \
tex(SourceSerifPro-Black-sup-ly1.tfm) \
tex(SourceSerifPro-Black-sup-ly1.vf) \
tex(SourceSerifPro-Black-sup-ot1.tfm) \
tex(SourceSerifPro-Black-sup-t1--base.tfm) \
tex(SourceSerifPro-Black-sup-t1.tfm) \
tex(SourceSerifPro-Black-sup-t1.vf) \
tex(SourceSerifPro-Black-tlf-ly1--base.tfm) \
tex(SourceSerifPro-Black-tlf-ly1.tfm) \
tex(SourceSerifPro-Black-tlf-ly1.vf) \
tex(SourceSerifPro-Black-tlf-ot1.tfm) \
tex(SourceSerifPro-Black-tlf-sc-ly1--base.tfm) \
tex(SourceSerifPro-Black-tlf-sc-ly1.tfm) \
tex(SourceSerifPro-Black-tlf-sc-ly1.vf) \
tex(SourceSerifPro-Black-tlf-sc-ot1--base.tfm) \
tex(SourceSerifPro-Black-tlf-sc-ot1.tfm) \
tex(SourceSerifPro-Black-tlf-sc-ot1.vf) \
tex(SourceSerifPro-Black-tlf-sc-t1--base.tfm) \
tex(SourceSerifPro-Black-tlf-sc-t1.tfm) \
tex(SourceSerifPro-Black-tlf-sc-t1.vf) \
tex(SourceSerifPro-Black-tlf-t1--base.tfm) \
tex(SourceSerifPro-Black-tlf-t1.tfm) \
tex(SourceSerifPro-Black-tlf-t1.vf) \
tex(SourceSerifPro-Black-tlf-ts1--base.tfm) \
tex(SourceSerifPro-Black-tlf-ts1.tfm) \
tex(SourceSerifPro-Black-tlf-ts1.vf) \
tex(SourceSerifPro-Black-tosf-ly1--base.tfm) \
tex(SourceSerifPro-Black-tosf-ly1.tfm) \
tex(SourceSerifPro-Black-tosf-ly1.vf) \
tex(SourceSerifPro-Black-tosf-ot1.tfm) \
tex(SourceSerifPro-Black-tosf-sc-ly1--base.tfm) \
tex(SourceSerifPro-Black-tosf-sc-ly1.tfm) \
tex(SourceSerifPro-Black-tosf-sc-ly1.vf) \
tex(SourceSerifPro-Black-tosf-sc-ot1--base.tfm) \
tex(SourceSerifPro-Black-tosf-sc-ot1.tfm) \
tex(SourceSerifPro-Black-tosf-sc-ot1.vf) \
tex(SourceSerifPro-Black-tosf-sc-t1--base.tfm) \
tex(SourceSerifPro-Black-tosf-sc-t1.tfm) \
tex(SourceSerifPro-Black-tosf-sc-t1.vf) \
tex(SourceSerifPro-Black-tosf-t1--base.tfm) \
tex(SourceSerifPro-Black-tosf-t1.tfm) \
tex(SourceSerifPro-Black-tosf-t1.vf) \
tex(SourceSerifPro-Black-tosf-ts1--base.tfm) \
tex(SourceSerifPro-Black-tosf-ts1.tfm) \
tex(SourceSerifPro-Black-tosf-ts1.vf) \
tex(SourceSerifPro-BlackIt-dnom-ly1--base.tfm) \
tex(SourceSerifPro-BlackIt-dnom-ly1.tfm) \
tex(SourceSerifPro-BlackIt-dnom-ly1.vf) \
tex(SourceSerifPro-BlackIt-dnom-ot1.tfm) \
tex(SourceSerifPro-BlackIt-dnom-t1--base.tfm) \
tex(SourceSerifPro-BlackIt-dnom-t1.tfm) \
tex(SourceSerifPro-BlackIt-dnom-t1.vf) \
tex(SourceSerifPro-BlackIt-lf-ly1--base.tfm) \
tex(SourceSerifPro-BlackIt-lf-ly1.tfm) \
tex(SourceSerifPro-BlackIt-lf-ly1.vf) \
tex(SourceSerifPro-BlackIt-lf-ot1.tfm) \
tex(SourceSerifPro-BlackIt-lf-t1--base.tfm) \
tex(SourceSerifPro-BlackIt-lf-t1.tfm) \
tex(SourceSerifPro-BlackIt-lf-t1.vf) \
tex(SourceSerifPro-BlackIt-lf-ts1--base.tfm) \
tex(SourceSerifPro-BlackIt-lf-ts1.tfm) \
tex(SourceSerifPro-BlackIt-lf-ts1.vf) \
tex(SourceSerifPro-BlackIt-numr-ly1--base.tfm) \
tex(SourceSerifPro-BlackIt-numr-ly1.tfm) \
tex(SourceSerifPro-BlackIt-numr-ly1.vf) \
tex(SourceSerifPro-BlackIt-numr-ot1.tfm) \
tex(SourceSerifPro-BlackIt-numr-t1--base.tfm) \
tex(SourceSerifPro-BlackIt-numr-t1.tfm) \
tex(SourceSerifPro-BlackIt-numr-t1.vf) \
tex(SourceSerifPro-BlackIt-osf-ly1--base.tfm) \
tex(SourceSerifPro-BlackIt-osf-ly1.tfm) \
tex(SourceSerifPro-BlackIt-osf-ly1.vf) \
tex(SourceSerifPro-BlackIt-osf-ot1.tfm) \
tex(SourceSerifPro-BlackIt-osf-t1--base.tfm) \
tex(SourceSerifPro-BlackIt-osf-t1.tfm) \
tex(SourceSerifPro-BlackIt-osf-t1.vf) \
tex(SourceSerifPro-BlackIt-osf-ts1--base.tfm) \
tex(SourceSerifPro-BlackIt-osf-ts1.tfm) \
tex(SourceSerifPro-BlackIt-osf-ts1.vf) \
tex(SourceSerifPro-BlackIt-sup-ly1--base.tfm) \
tex(SourceSerifPro-BlackIt-sup-ly1.tfm) \
tex(SourceSerifPro-BlackIt-sup-ly1.vf) \
tex(SourceSerifPro-BlackIt-sup-ot1.tfm) \
tex(SourceSerifPro-BlackIt-sup-t1--base.tfm) \
tex(SourceSerifPro-BlackIt-sup-t1.tfm) \
tex(SourceSerifPro-BlackIt-sup-t1.vf) \
tex(SourceSerifPro-BlackIt-tlf-ly1--base.tfm) \
tex(SourceSerifPro-BlackIt-tlf-ly1.tfm) \
tex(SourceSerifPro-BlackIt-tlf-ly1.vf) \
tex(SourceSerifPro-BlackIt-tlf-ot1.tfm) \
tex(SourceSerifPro-BlackIt-tlf-t1--base.tfm) \
tex(SourceSerifPro-BlackIt-tlf-t1.tfm) \
tex(SourceSerifPro-BlackIt-tlf-t1.vf) \
tex(SourceSerifPro-BlackIt-tlf-ts1--base.tfm) \
tex(SourceSerifPro-BlackIt-tlf-ts1.tfm) \
tex(SourceSerifPro-BlackIt-tlf-ts1.vf) \
tex(SourceSerifPro-BlackIt-tosf-ly1--base.tfm) \
tex(SourceSerifPro-BlackIt-tosf-ly1.tfm) \
tex(SourceSerifPro-BlackIt-tosf-ly1.vf) \
tex(SourceSerifPro-BlackIt-tosf-ot1.tfm) \
tex(SourceSerifPro-BlackIt-tosf-t1--base.tfm) \
tex(SourceSerifPro-BlackIt-tosf-t1.tfm) \
tex(SourceSerifPro-BlackIt-tosf-t1.vf) \
tex(SourceSerifPro-BlackIt-tosf-ts1--base.tfm) \
tex(SourceSerifPro-BlackIt-tosf-ts1.tfm) \
tex(SourceSerifPro-BlackIt-tosf-ts1.vf) \
tex(SourceSerifPro-Bold-dnom-ly1--base.tfm) \
tex(SourceSerifPro-Bold-dnom-ly1.tfm) \
tex(SourceSerifPro-Bold-dnom-ly1.vf) \
tex(SourceSerifPro-Bold-dnom-ot1.tfm) \
tex(SourceSerifPro-Bold-dnom-t1--base.tfm) \
tex(SourceSerifPro-Bold-dnom-t1.tfm) \
tex(SourceSerifPro-Bold-dnom-t1.vf) \
tex(SourceSerifPro-Bold-lf-ly1--base.tfm) \
tex(SourceSerifPro-Bold-lf-ly1.tfm) \
tex(SourceSerifPro-Bold-lf-ly1.vf) \
tex(SourceSerifPro-Bold-lf-ot1.tfm) \
tex(SourceSerifPro-Bold-lf-sc-ly1--base.tfm) \
tex(SourceSerifPro-Bold-lf-sc-ly1.tfm) \
tex(SourceSerifPro-Bold-lf-sc-ly1.vf) \
tex(SourceSerifPro-Bold-lf-sc-ot1--base.tfm) \
tex(SourceSerifPro-Bold-lf-sc-ot1.tfm) \
tex(SourceSerifPro-Bold-lf-sc-ot1.vf) \
tex(SourceSerifPro-Bold-lf-sc-t1--base.tfm) \
tex(SourceSerifPro-Bold-lf-sc-t1.tfm) \
tex(SourceSerifPro-Bold-lf-sc-t1.vf) \
tex(SourceSerifPro-Bold-lf-t1--base.tfm) \
tex(SourceSerifPro-Bold-lf-t1.tfm) \
tex(SourceSerifPro-Bold-lf-t1.vf) \
tex(SourceSerifPro-Bold-lf-ts1--base.tfm) \
tex(SourceSerifPro-Bold-lf-ts1.tfm) \
tex(SourceSerifPro-Bold-lf-ts1.vf) \
tex(SourceSerifPro-Bold-numr-ly1--base.tfm) \
tex(SourceSerifPro-Bold-numr-ly1.tfm) \
tex(SourceSerifPro-Bold-numr-ly1.vf) \
tex(SourceSerifPro-Bold-numr-ot1.tfm) \
tex(SourceSerifPro-Bold-numr-t1--base.tfm) \
tex(SourceSerifPro-Bold-numr-t1.tfm) \
tex(SourceSerifPro-Bold-numr-t1.vf) \
tex(SourceSerifPro-Bold-osf-ly1--base.tfm) \
tex(SourceSerifPro-Bold-osf-ly1.tfm) \
tex(SourceSerifPro-Bold-osf-ly1.vf) \
tex(SourceSerifPro-Bold-osf-ot1.tfm) \
tex(SourceSerifPro-Bold-osf-sc-ly1--base.tfm) \
tex(SourceSerifPro-Bold-osf-sc-ly1.tfm) \
tex(SourceSerifPro-Bold-osf-sc-ly1.vf) \
tex(SourceSerifPro-Bold-osf-sc-ot1--base.tfm) \
tex(SourceSerifPro-Bold-osf-sc-ot1.tfm) \
tex(SourceSerifPro-Bold-osf-sc-ot1.vf) \
tex(SourceSerifPro-Bold-osf-sc-t1--base.tfm) \
tex(SourceSerifPro-Bold-osf-sc-t1.tfm) \
tex(SourceSerifPro-Bold-osf-sc-t1.vf) \
tex(SourceSerifPro-Bold-osf-t1--base.tfm) \
tex(SourceSerifPro-Bold-osf-t1.tfm) \
tex(SourceSerifPro-Bold-osf-t1.vf) \
tex(SourceSerifPro-Bold-osf-ts1--base.tfm) \
tex(SourceSerifPro-Bold-osf-ts1.tfm) \
tex(SourceSerifPro-Bold-osf-ts1.vf) \
tex(SourceSerifPro-Bold-sup-ly1--base.tfm) \
tex(SourceSerifPro-Bold-sup-ly1.tfm) \
tex(SourceSerifPro-Bold-sup-ly1.vf) \
tex(SourceSerifPro-Bold-sup-ot1.tfm) \
tex(SourceSerifPro-Bold-sup-t1--base.tfm) \
tex(SourceSerifPro-Bold-sup-t1.tfm) \
tex(SourceSerifPro-Bold-sup-t1.vf) \
tex(SourceSerifPro-Bold-tlf-ly1--base.tfm) \
tex(SourceSerifPro-Bold-tlf-ly1.tfm) \
tex(SourceSerifPro-Bold-tlf-ly1.vf) \
tex(SourceSerifPro-Bold-tlf-ot1.tfm) \
tex(SourceSerifPro-Bold-tlf-sc-ly1--base.tfm) \
tex(SourceSerifPro-Bold-tlf-sc-ly1.tfm) \
tex(SourceSerifPro-Bold-tlf-sc-ly1.vf) \
tex(SourceSerifPro-Bold-tlf-sc-ot1--base.tfm) \
tex(SourceSerifPro-Bold-tlf-sc-ot1.tfm) \
tex(SourceSerifPro-Bold-tlf-sc-ot1.vf) \
tex(SourceSerifPro-Bold-tlf-sc-t1--base.tfm) \
tex(SourceSerifPro-Bold-tlf-sc-t1.tfm) \
tex(SourceSerifPro-Bold-tlf-sc-t1.vf) \
tex(SourceSerifPro-Bold-tlf-t1--base.tfm) \
tex(SourceSerifPro-Bold-tlf-t1.tfm) \
tex(SourceSerifPro-Bold-tlf-t1.vf) \
tex(SourceSerifPro-Bold-tlf-ts1--base.tfm) \
tex(SourceSerifPro-Bold-tlf-ts1.tfm) \
tex(SourceSerifPro-Bold-tlf-ts1.vf) \
tex(SourceSerifPro-Bold-tosf-ly1--base.tfm) \
tex(SourceSerifPro-Bold-tosf-ly1.tfm) \
tex(SourceSerifPro-Bold-tosf-ly1.vf) \
tex(SourceSerifPro-Bold-tosf-ot1.tfm) \
tex(SourceSerifPro-Bold-tosf-sc-ly1--base.tfm) \
tex(SourceSerifPro-Bold-tosf-sc-ly1.tfm) \
tex(SourceSerifPro-Bold-tosf-sc-ly1.vf) \
tex(SourceSerifPro-Bold-tosf-sc-ot1--base.tfm) \
tex(SourceSerifPro-Bold-tosf-sc-ot1.tfm) \
tex(SourceSerifPro-Bold-tosf-sc-ot1.vf) \
tex(SourceSerifPro-Bold-tosf-sc-t1--base.tfm) \
tex(SourceSerifPro-Bold-tosf-sc-t1.tfm) \
tex(SourceSerifPro-Bold-tosf-sc-t1.vf) \
tex(SourceSerifPro-Bold-tosf-t1--base.tfm) \
tex(SourceSerifPro-Bold-tosf-t1.tfm) \
tex(SourceSerifPro-Bold-tosf-t1.vf) \
tex(SourceSerifPro-Bold-tosf-ts1--base.tfm) \
tex(SourceSerifPro-Bold-tosf-ts1.tfm) \
tex(SourceSerifPro-Bold-tosf-ts1.vf) \
tex(SourceSerifPro-BoldIt-dnom-ly1--base.tfm) \
tex(SourceSerifPro-BoldIt-dnom-ly1.tfm) \
tex(SourceSerifPro-BoldIt-dnom-ly1.vf) \
tex(SourceSerifPro-BoldIt-dnom-ot1.tfm) \
tex(SourceSerifPro-BoldIt-dnom-t1--base.tfm) \
tex(SourceSerifPro-BoldIt-dnom-t1.tfm) \
tex(SourceSerifPro-BoldIt-dnom-t1.vf) \
tex(SourceSerifPro-BoldIt-lf-ly1--base.tfm) \
tex(SourceSerifPro-BoldIt-lf-ly1.tfm) \
tex(SourceSerifPro-BoldIt-lf-ly1.vf) \
tex(SourceSerifPro-BoldIt-lf-ot1.tfm) \
tex(SourceSerifPro-BoldIt-lf-t1--base.tfm) \
tex(SourceSerifPro-BoldIt-lf-t1.tfm) \
tex(SourceSerifPro-BoldIt-lf-t1.vf) \
tex(SourceSerifPro-BoldIt-lf-ts1--base.tfm) \
tex(SourceSerifPro-BoldIt-lf-ts1.tfm) \
tex(SourceSerifPro-BoldIt-lf-ts1.vf) \
tex(SourceSerifPro-BoldIt-numr-ly1--base.tfm) \
tex(SourceSerifPro-BoldIt-numr-ly1.tfm) \
tex(SourceSerifPro-BoldIt-numr-ly1.vf) \
tex(SourceSerifPro-BoldIt-numr-ot1.tfm) \
tex(SourceSerifPro-BoldIt-numr-t1--base.tfm) \
tex(SourceSerifPro-BoldIt-numr-t1.tfm) \
tex(SourceSerifPro-BoldIt-numr-t1.vf) \
tex(SourceSerifPro-BoldIt-osf-ly1--base.tfm) \
tex(SourceSerifPro-BoldIt-osf-ly1.tfm) \
tex(SourceSerifPro-BoldIt-osf-ly1.vf) \
tex(SourceSerifPro-BoldIt-osf-ot1.tfm) \
tex(SourceSerifPro-BoldIt-osf-t1--base.tfm) \
tex(SourceSerifPro-BoldIt-osf-t1.tfm) \
tex(SourceSerifPro-BoldIt-osf-t1.vf) \
tex(SourceSerifPro-BoldIt-osf-ts1--base.tfm) \
tex(SourceSerifPro-BoldIt-osf-ts1.tfm) \
tex(SourceSerifPro-BoldIt-osf-ts1.vf) \
tex(SourceSerifPro-BoldIt-sup-ly1--base.tfm) \
tex(SourceSerifPro-BoldIt-sup-ly1.tfm) \
tex(SourceSerifPro-BoldIt-sup-ly1.vf) \
tex(SourceSerifPro-BoldIt-sup-ot1.tfm) \
tex(SourceSerifPro-BoldIt-sup-t1--base.tfm) \
tex(SourceSerifPro-BoldIt-sup-t1.tfm) \
tex(SourceSerifPro-BoldIt-sup-t1.vf) \
tex(SourceSerifPro-BoldIt-tlf-ly1--base.tfm) \
tex(SourceSerifPro-BoldIt-tlf-ly1.tfm) \
tex(SourceSerifPro-BoldIt-tlf-ly1.vf) \
tex(SourceSerifPro-BoldIt-tlf-ot1.tfm) \
tex(SourceSerifPro-BoldIt-tlf-t1--base.tfm) \
tex(SourceSerifPro-BoldIt-tlf-t1.tfm) \
tex(SourceSerifPro-BoldIt-tlf-t1.vf) \
tex(SourceSerifPro-BoldIt-tlf-ts1--base.tfm) \
tex(SourceSerifPro-BoldIt-tlf-ts1.tfm) \
tex(SourceSerifPro-BoldIt-tlf-ts1.vf) \
tex(SourceSerifPro-BoldIt-tosf-ly1--base.tfm) \
tex(SourceSerifPro-BoldIt-tosf-ly1.tfm) \
tex(SourceSerifPro-BoldIt-tosf-ly1.vf) \
tex(SourceSerifPro-BoldIt-tosf-ot1.tfm) \
tex(SourceSerifPro-BoldIt-tosf-t1--base.tfm) \
tex(SourceSerifPro-BoldIt-tosf-t1.tfm) \
tex(SourceSerifPro-BoldIt-tosf-t1.vf) \
tex(SourceSerifPro-BoldIt-tosf-ts1--base.tfm) \
tex(SourceSerifPro-BoldIt-tosf-ts1.tfm) \
tex(SourceSerifPro-BoldIt-tosf-ts1.vf) \
tex(SourceSerifPro-ExtraLight-dnom-ly1--base.tfm) \
tex(SourceSerifPro-ExtraLight-dnom-ly1.tfm) \
tex(SourceSerifPro-ExtraLight-dnom-ly1.vf) \
tex(SourceSerifPro-ExtraLight-dnom-ot1.tfm) \
tex(SourceSerifPro-ExtraLight-dnom-t1--base.tfm) \
tex(SourceSerifPro-ExtraLight-dnom-t1.tfm) \
tex(SourceSerifPro-ExtraLight-dnom-t1.vf) \
tex(SourceSerifPro-ExtraLight-lf-ly1--base.tfm) \
tex(SourceSerifPro-ExtraLight-lf-ly1.tfm) \
tex(SourceSerifPro-ExtraLight-lf-ly1.vf) \
tex(SourceSerifPro-ExtraLight-lf-ot1.tfm) \
tex(SourceSerifPro-ExtraLight-lf-sc-ly1--base.tfm) \
tex(SourceSerifPro-ExtraLight-lf-sc-ly1.tfm) \
tex(SourceSerifPro-ExtraLight-lf-sc-ly1.vf) \
tex(SourceSerifPro-ExtraLight-lf-sc-ot1--base.tfm) \
tex(SourceSerifPro-ExtraLight-lf-sc-ot1.tfm) \
tex(SourceSerifPro-ExtraLight-lf-sc-ot1.vf) \
tex(SourceSerifPro-ExtraLight-lf-sc-t1--base.tfm) \
tex(SourceSerifPro-ExtraLight-lf-sc-t1.tfm) \
tex(SourceSerifPro-ExtraLight-lf-sc-t1.vf) \
tex(SourceSerifPro-ExtraLight-lf-t1--base.tfm) \
tex(SourceSerifPro-ExtraLight-lf-t1.tfm) \
tex(SourceSerifPro-ExtraLight-lf-t1.vf) \
tex(SourceSerifPro-ExtraLight-lf-ts1--base.tfm) \
tex(SourceSerifPro-ExtraLight-lf-ts1.tfm) \
tex(SourceSerifPro-ExtraLight-lf-ts1.vf) \
tex(SourceSerifPro-ExtraLight-numr-ly1--base.tfm) \
tex(SourceSerifPro-ExtraLight-numr-ly1.tfm) \
tex(SourceSerifPro-ExtraLight-numr-ly1.vf) \
tex(SourceSerifPro-ExtraLight-numr-ot1.tfm) \
tex(SourceSerifPro-ExtraLight-numr-t1--base.tfm) \
tex(SourceSerifPro-ExtraLight-numr-t1.tfm) \
tex(SourceSerifPro-ExtraLight-numr-t1.vf) \
tex(SourceSerifPro-ExtraLight-osf-ly1--base.tfm) \
tex(SourceSerifPro-ExtraLight-osf-ly1.tfm) \
tex(SourceSerifPro-ExtraLight-osf-ly1.vf) \
tex(SourceSerifPro-ExtraLight-osf-ot1.tfm) \
tex(SourceSerifPro-ExtraLight-osf-sc-ly1--base.tfm) \
tex(SourceSerifPro-ExtraLight-osf-sc-ly1.tfm) \
tex(SourceSerifPro-ExtraLight-osf-sc-ly1.vf) \
tex(SourceSerifPro-ExtraLight-osf-sc-ot1--base.tfm) \
tex(SourceSerifPro-ExtraLight-osf-sc-ot1.tfm) \
tex(SourceSerifPro-ExtraLight-osf-sc-ot1.vf) \
tex(SourceSerifPro-ExtraLight-osf-sc-t1--base.tfm) \
tex(SourceSerifPro-ExtraLight-osf-sc-t1.tfm) \
tex(SourceSerifPro-ExtraLight-osf-sc-t1.vf) \
tex(SourceSerifPro-ExtraLight-osf-t1--base.tfm) \
tex(SourceSerifPro-ExtraLight-osf-t1.tfm) \
tex(SourceSerifPro-ExtraLight-osf-t1.vf) \
tex(SourceSerifPro-ExtraLight-osf-ts1--base.tfm) \
tex(SourceSerifPro-ExtraLight-osf-ts1.tfm) \
tex(SourceSerifPro-ExtraLight-osf-ts1.vf) \
tex(SourceSerifPro-ExtraLight-sup-ly1--base.tfm) \
tex(SourceSerifPro-ExtraLight-sup-ly1.tfm) \
tex(SourceSerifPro-ExtraLight-sup-ly1.vf) \
tex(SourceSerifPro-ExtraLight-sup-ot1.tfm) \
tex(SourceSerifPro-ExtraLight-sup-t1--base.tfm) \
tex(SourceSerifPro-ExtraLight-sup-t1.tfm) \
tex(SourceSerifPro-ExtraLight-sup-t1.vf) \
tex(SourceSerifPro-ExtraLight-tlf-ly1--base.tfm) \
tex(SourceSerifPro-ExtraLight-tlf-ly1.tfm) \
tex(SourceSerifPro-ExtraLight-tlf-ly1.vf) \
tex(SourceSerifPro-ExtraLight-tlf-ot1.tfm) \
tex(SourceSerifPro-ExtraLight-tlf-sc-ly1--base.tfm) \
tex(SourceSerifPro-ExtraLight-tlf-sc-ly1.tfm) \
tex(SourceSerifPro-ExtraLight-tlf-sc-ly1.vf) \
tex(SourceSerifPro-ExtraLight-tlf-sc-ot1--base.tfm) \
tex(SourceSerifPro-ExtraLight-tlf-sc-ot1.tfm) \
tex(SourceSerifPro-ExtraLight-tlf-sc-ot1.vf) \
tex(SourceSerifPro-ExtraLight-tlf-sc-t1--base.tfm) \
tex(SourceSerifPro-ExtraLight-tlf-sc-t1.tfm) \
tex(SourceSerifPro-ExtraLight-tlf-sc-t1.vf) \
tex(SourceSerifPro-ExtraLight-tlf-t1--base.tfm) \
tex(SourceSerifPro-ExtraLight-tlf-t1.tfm) \
tex(SourceSerifPro-ExtraLight-tlf-t1.vf) \
tex(SourceSerifPro-ExtraLight-tlf-ts1--base.tfm) \
tex(SourceSerifPro-ExtraLight-tlf-ts1.tfm) \
tex(SourceSerifPro-ExtraLight-tlf-ts1.vf) \
tex(SourceSerifPro-ExtraLight-tosf-ly1--base.tfm) \
tex(SourceSerifPro-ExtraLight-tosf-ly1.tfm) \
tex(SourceSerifPro-ExtraLight-tosf-ly1.vf) \
tex(SourceSerifPro-ExtraLight-tosf-ot1.tfm) \
tex(SourceSerifPro-ExtraLight-tosf-sc-ly1--base.tfm) \
tex(SourceSerifPro-ExtraLight-tosf-sc-ly1.tfm) \
tex(SourceSerifPro-ExtraLight-tosf-sc-ly1.vf) \
tex(SourceSerifPro-ExtraLight-tosf-sc-ot1--base.tfm) \
tex(SourceSerifPro-ExtraLight-tosf-sc-ot1.tfm) \
tex(SourceSerifPro-ExtraLight-tosf-sc-ot1.vf) \
tex(SourceSerifPro-ExtraLight-tosf-sc-t1--base.tfm) \
tex(SourceSerifPro-ExtraLight-tosf-sc-t1.tfm) \
tex(SourceSerifPro-ExtraLight-tosf-sc-t1.vf) \
tex(SourceSerifPro-ExtraLight-tosf-t1--base.tfm) \
tex(SourceSerifPro-ExtraLight-tosf-t1.tfm) \
tex(SourceSerifPro-ExtraLight-tosf-t1.vf) \
tex(SourceSerifPro-ExtraLight-tosf-ts1--base.tfm) \
tex(SourceSerifPro-ExtraLight-tosf-ts1.tfm) \
tex(SourceSerifPro-ExtraLight-tosf-ts1.vf) \
tex(SourceSerifPro-ExtraLightIt-dnom-ly1--base.tfm) \
tex(SourceSerifPro-ExtraLightIt-dnom-ly1.tfm) \
tex(SourceSerifPro-ExtraLightIt-dnom-ly1.vf) \
tex(SourceSerifPro-ExtraLightIt-dnom-ot1.tfm) \
tex(SourceSerifPro-ExtraLightIt-dnom-t1--base.tfm) \
tex(SourceSerifPro-ExtraLightIt-dnom-t1.tfm) \
tex(SourceSerifPro-ExtraLightIt-dnom-t1.vf) \
tex(SourceSerifPro-ExtraLightIt-lf-ly1--base.tfm) \
tex(SourceSerifPro-ExtraLightIt-lf-ly1.tfm) \
tex(SourceSerifPro-ExtraLightIt-lf-ly1.vf) \
tex(SourceSerifPro-ExtraLightIt-lf-ot1.tfm) \
tex(SourceSerifPro-ExtraLightIt-lf-t1--base.tfm) \
tex(SourceSerifPro-ExtraLightIt-lf-t1.tfm) \
tex(SourceSerifPro-ExtraLightIt-lf-t1.vf) \
tex(SourceSerifPro-ExtraLightIt-lf-ts1--base.tfm) \
tex(SourceSerifPro-ExtraLightIt-lf-ts1.tfm) \
tex(SourceSerifPro-ExtraLightIt-lf-ts1.vf) \
tex(SourceSerifPro-ExtraLightIt-numr-ly1--base.tfm) \
tex(SourceSerifPro-ExtraLightIt-numr-ly1.tfm) \
tex(SourceSerifPro-ExtraLightIt-numr-ly1.vf) \
tex(SourceSerifPro-ExtraLightIt-numr-ot1.tfm) \
tex(SourceSerifPro-ExtraLightIt-numr-t1--base.tfm) \
tex(SourceSerifPro-ExtraLightIt-numr-t1.tfm) \
tex(SourceSerifPro-ExtraLightIt-numr-t1.vf) \
tex(SourceSerifPro-ExtraLightIt-osf-ly1--base.tfm) \
tex(SourceSerifPro-ExtraLightIt-osf-ly1.tfm) \
tex(SourceSerifPro-ExtraLightIt-osf-ly1.vf) \
tex(SourceSerifPro-ExtraLightIt-osf-ot1.tfm) \
tex(SourceSerifPro-ExtraLightIt-osf-t1--base.tfm) \
tex(SourceSerifPro-ExtraLightIt-osf-t1.tfm) \
tex(SourceSerifPro-ExtraLightIt-osf-t1.vf) \
tex(SourceSerifPro-ExtraLightIt-osf-ts1--base.tfm) \
tex(SourceSerifPro-ExtraLightIt-osf-ts1.tfm) \
tex(SourceSerifPro-ExtraLightIt-osf-ts1.vf) \
tex(SourceSerifPro-ExtraLightIt-sup-ly1--base.tfm) \
tex(SourceSerifPro-ExtraLightIt-sup-ly1.tfm) \
tex(SourceSerifPro-ExtraLightIt-sup-ly1.vf) \
tex(SourceSerifPro-ExtraLightIt-sup-ot1.tfm) \
tex(SourceSerifPro-ExtraLightIt-sup-t1--base.tfm) \
tex(SourceSerifPro-ExtraLightIt-sup-t1.tfm) \
tex(SourceSerifPro-ExtraLightIt-sup-t1.vf) \
tex(SourceSerifPro-ExtraLightIt-tlf-ly1--base.tfm) \
tex(SourceSerifPro-ExtraLightIt-tlf-ly1.tfm) \
tex(SourceSerifPro-ExtraLightIt-tlf-ly1.vf) \
tex(SourceSerifPro-ExtraLightIt-tlf-ot1.tfm) \
tex(SourceSerifPro-ExtraLightIt-tlf-t1--base.tfm) \
tex(SourceSerifPro-ExtraLightIt-tlf-t1.tfm) \
tex(SourceSerifPro-ExtraLightIt-tlf-t1.vf) \
tex(SourceSerifPro-ExtraLightIt-tlf-ts1--base.tfm) \
tex(SourceSerifPro-ExtraLightIt-tlf-ts1.tfm) \
tex(SourceSerifPro-ExtraLightIt-tlf-ts1.vf) \
tex(SourceSerifPro-ExtraLightIt-tosf-ly1--base.tfm) \
tex(SourceSerifPro-ExtraLightIt-tosf-ly1.tfm) \
tex(SourceSerifPro-ExtraLightIt-tosf-ly1.vf) \
tex(SourceSerifPro-ExtraLightIt-tosf-ot1.tfm) \
tex(SourceSerifPro-ExtraLightIt-tosf-t1--base.tfm) \
tex(SourceSerifPro-ExtraLightIt-tosf-t1.tfm) \
tex(SourceSerifPro-ExtraLightIt-tosf-t1.vf) \
tex(SourceSerifPro-ExtraLightIt-tosf-ts1--base.tfm) \
tex(SourceSerifPro-ExtraLightIt-tosf-ts1.tfm) \
tex(SourceSerifPro-ExtraLightIt-tosf-ts1.vf) \
tex(SourceSerifPro-It-dnom-ly1--base.tfm) \
tex(SourceSerifPro-It-dnom-ly1.tfm) \
tex(SourceSerifPro-It-dnom-ly1.vf) \
tex(SourceSerifPro-It-dnom-ot1.tfm) \
tex(SourceSerifPro-It-dnom-t1--base.tfm) \
tex(SourceSerifPro-It-dnom-t1.tfm) \
tex(SourceSerifPro-It-dnom-t1.vf) \
tex(SourceSerifPro-It-lf-ly1--base.tfm) \
tex(SourceSerifPro-It-lf-ly1.tfm) \
tex(SourceSerifPro-It-lf-ly1.vf) \
tex(SourceSerifPro-It-lf-ot1.tfm) \
tex(SourceSerifPro-It-lf-t1--base.tfm) \
tex(SourceSerifPro-It-lf-t1.tfm) \
tex(SourceSerifPro-It-lf-t1.vf) \
tex(SourceSerifPro-It-lf-ts1--base.tfm) \
tex(SourceSerifPro-It-lf-ts1.tfm) \
tex(SourceSerifPro-It-lf-ts1.vf) \
tex(SourceSerifPro-It-numr-ly1--base.tfm) \
tex(SourceSerifPro-It-numr-ly1.tfm) \
tex(SourceSerifPro-It-numr-ly1.vf) \
tex(SourceSerifPro-It-numr-ot1.tfm) \
tex(SourceSerifPro-It-numr-t1--base.tfm) \
tex(SourceSerifPro-It-numr-t1.tfm) \
tex(SourceSerifPro-It-numr-t1.vf) \
tex(SourceSerifPro-It-osf-ly1--base.tfm) \
tex(SourceSerifPro-It-osf-ly1.tfm) \
tex(SourceSerifPro-It-osf-ly1.vf) \
tex(SourceSerifPro-It-osf-ot1.tfm) \
tex(SourceSerifPro-It-osf-t1--base.tfm) \
tex(SourceSerifPro-It-osf-t1.tfm) \
tex(SourceSerifPro-It-osf-t1.vf) \
tex(SourceSerifPro-It-osf-ts1--base.tfm) \
tex(SourceSerifPro-It-osf-ts1.tfm) \
tex(SourceSerifPro-It-osf-ts1.vf) \
tex(SourceSerifPro-It-sup-ly1--base.tfm) \
tex(SourceSerifPro-It-sup-ly1.tfm) \
tex(SourceSerifPro-It-sup-ly1.vf) \
tex(SourceSerifPro-It-sup-ot1.tfm) \
tex(SourceSerifPro-It-sup-t1--base.tfm) \
tex(SourceSerifPro-It-sup-t1.tfm) \
tex(SourceSerifPro-It-sup-t1.vf) \
tex(SourceSerifPro-It-tlf-ly1--base.tfm) \
tex(SourceSerifPro-It-tlf-ly1.tfm) \
tex(SourceSerifPro-It-tlf-ly1.vf) \
tex(SourceSerifPro-It-tlf-ot1.tfm) \
tex(SourceSerifPro-It-tlf-t1--base.tfm) \
tex(SourceSerifPro-It-tlf-t1.tfm) \
tex(SourceSerifPro-It-tlf-t1.vf) \
tex(SourceSerifPro-It-tlf-ts1--base.tfm) \
tex(SourceSerifPro-It-tlf-ts1.tfm) \
tex(SourceSerifPro-It-tlf-ts1.vf) \
tex(SourceSerifPro-It-tosf-ly1--base.tfm) \
tex(SourceSerifPro-It-tosf-ly1.tfm) \
tex(SourceSerifPro-It-tosf-ly1.vf) \
tex(SourceSerifPro-It-tosf-ot1.tfm) \
tex(SourceSerifPro-It-tosf-t1--base.tfm) \
tex(SourceSerifPro-It-tosf-t1.tfm) \
tex(SourceSerifPro-It-tosf-t1.vf) \
tex(SourceSerifPro-It-tosf-ts1--base.tfm) \
tex(SourceSerifPro-It-tosf-ts1.tfm) \
tex(SourceSerifPro-It-tosf-ts1.vf) \
tex(SourceSerifPro-Light-dnom-ly1--base.tfm) \
tex(SourceSerifPro-Light-dnom-ly1.tfm) \
tex(SourceSerifPro-Light-dnom-ly1.vf) \
tex(SourceSerifPro-Light-dnom-ot1.tfm) \
tex(SourceSerifPro-Light-dnom-t1--base.tfm) \
tex(SourceSerifPro-Light-dnom-t1.tfm) \
tex(SourceSerifPro-Light-dnom-t1.vf) \
tex(SourceSerifPro-Light-lf-ly1--base.tfm) \
tex(SourceSerifPro-Light-lf-ly1.tfm) \
tex(SourceSerifPro-Light-lf-ly1.vf) \
tex(SourceSerifPro-Light-lf-ot1.tfm) \
tex(SourceSerifPro-Light-lf-sc-ly1--base.tfm) \
tex(SourceSerifPro-Light-lf-sc-ly1.tfm) \
tex(SourceSerifPro-Light-lf-sc-ly1.vf) \
tex(SourceSerifPro-Light-lf-sc-ot1--base.tfm) \
tex(SourceSerifPro-Light-lf-sc-ot1.tfm) \
tex(SourceSerifPro-Light-lf-sc-ot1.vf) \
tex(SourceSerifPro-Light-lf-sc-t1--base.tfm) \
tex(SourceSerifPro-Light-lf-sc-t1.tfm) \
tex(SourceSerifPro-Light-lf-sc-t1.vf) \
tex(SourceSerifPro-Light-lf-t1--base.tfm) \
tex(SourceSerifPro-Light-lf-t1.tfm) \
tex(SourceSerifPro-Light-lf-t1.vf) \
tex(SourceSerifPro-Light-lf-ts1--base.tfm) \
tex(SourceSerifPro-Light-lf-ts1.tfm) \
tex(SourceSerifPro-Light-lf-ts1.vf) \
tex(SourceSerifPro-Light-numr-ly1--base.tfm) \
tex(SourceSerifPro-Light-numr-ly1.tfm) \
tex(SourceSerifPro-Light-numr-ly1.vf) \
tex(SourceSerifPro-Light-numr-ot1.tfm) \
tex(SourceSerifPro-Light-numr-t1--base.tfm) \
tex(SourceSerifPro-Light-numr-t1.tfm) \
tex(SourceSerifPro-Light-numr-t1.vf) \
tex(SourceSerifPro-Light-osf-ly1--base.tfm) \
tex(SourceSerifPro-Light-osf-ly1.tfm) \
tex(SourceSerifPro-Light-osf-ly1.vf) \
tex(SourceSerifPro-Light-osf-ot1.tfm) \
tex(SourceSerifPro-Light-osf-sc-ly1--base.tfm) \
tex(SourceSerifPro-Light-osf-sc-ly1.tfm) \
tex(SourceSerifPro-Light-osf-sc-ly1.vf) \
tex(SourceSerifPro-Light-osf-sc-ot1--base.tfm) \
tex(SourceSerifPro-Light-osf-sc-ot1.tfm) \
tex(SourceSerifPro-Light-osf-sc-ot1.vf) \
tex(SourceSerifPro-Light-osf-sc-t1--base.tfm) \
tex(SourceSerifPro-Light-osf-sc-t1.tfm) \
tex(SourceSerifPro-Light-osf-sc-t1.vf) \
tex(SourceSerifPro-Light-osf-t1--base.tfm) \
tex(SourceSerifPro-Light-osf-t1.tfm) \
tex(SourceSerifPro-Light-osf-t1.vf) \
tex(SourceSerifPro-Light-osf-ts1--base.tfm) \
tex(SourceSerifPro-Light-osf-ts1.tfm) \
tex(SourceSerifPro-Light-osf-ts1.vf) \
tex(SourceSerifPro-Light-sup-ly1--base.tfm) \
tex(SourceSerifPro-Light-sup-ly1.tfm) \
tex(SourceSerifPro-Light-sup-ly1.vf) \
tex(SourceSerifPro-Light-sup-ot1.tfm) \
tex(SourceSerifPro-Light-sup-t1--base.tfm) \
tex(SourceSerifPro-Light-sup-t1.tfm) \
tex(SourceSerifPro-Light-sup-t1.vf) \
tex(SourceSerifPro-Light-tlf-ly1--base.tfm) \
tex(SourceSerifPro-Light-tlf-ly1.tfm) \
tex(SourceSerifPro-Light-tlf-ly1.vf) \
tex(SourceSerifPro-Light-tlf-ot1.tfm) \
tex(SourceSerifPro-Light-tlf-sc-ly1--base.tfm) \
tex(SourceSerifPro-Light-tlf-sc-ly1.tfm) \
tex(SourceSerifPro-Light-tlf-sc-ly1.vf) \
tex(SourceSerifPro-Light-tlf-sc-ot1--base.tfm) \
tex(SourceSerifPro-Light-tlf-sc-ot1.tfm) \
tex(SourceSerifPro-Light-tlf-sc-ot1.vf) \
tex(SourceSerifPro-Light-tlf-sc-t1--base.tfm) \
tex(SourceSerifPro-Light-tlf-sc-t1.tfm) \
tex(SourceSerifPro-Light-tlf-sc-t1.vf) \
tex(SourceSerifPro-Light-tlf-t1--base.tfm) \
tex(SourceSerifPro-Light-tlf-t1.tfm) \
tex(SourceSerifPro-Light-tlf-t1.vf) \
tex(SourceSerifPro-Light-tlf-ts1--base.tfm) \
tex(SourceSerifPro-Light-tlf-ts1.tfm) \
tex(SourceSerifPro-Light-tlf-ts1.vf) \
tex(SourceSerifPro-Light-tosf-ly1--base.tfm) \
tex(SourceSerifPro-Light-tosf-ly1.tfm) \
tex(SourceSerifPro-Light-tosf-ly1.vf) \
tex(SourceSerifPro-Light-tosf-ot1.tfm) \
tex(SourceSerifPro-Light-tosf-sc-ly1--base.tfm) \
tex(SourceSerifPro-Light-tosf-sc-ly1.tfm) \
tex(SourceSerifPro-Light-tosf-sc-ly1.vf) \
tex(SourceSerifPro-Light-tosf-sc-ot1--base.tfm) \
tex(SourceSerifPro-Light-tosf-sc-ot1.tfm) \
tex(SourceSerifPro-Light-tosf-sc-ot1.vf) \
tex(SourceSerifPro-Light-tosf-sc-t1--base.tfm) \
tex(SourceSerifPro-Light-tosf-sc-t1.tfm) \
tex(SourceSerifPro-Light-tosf-sc-t1.vf) \
tex(SourceSerifPro-Light-tosf-t1--base.tfm) \
tex(SourceSerifPro-Light-tosf-t1.tfm) \
tex(SourceSerifPro-Light-tosf-t1.vf) \
tex(SourceSerifPro-Light-tosf-ts1--base.tfm) \
tex(SourceSerifPro-Light-tosf-ts1.tfm) \
tex(SourceSerifPro-Light-tosf-ts1.vf) \
tex(SourceSerifPro-LightIt-dnom-ly1--base.tfm) \
tex(SourceSerifPro-LightIt-dnom-ly1.tfm) \
tex(SourceSerifPro-LightIt-dnom-ly1.vf) \
tex(SourceSerifPro-LightIt-dnom-ot1.tfm) \
tex(SourceSerifPro-LightIt-dnom-t1--base.tfm) \
tex(SourceSerifPro-LightIt-dnom-t1.tfm) \
tex(SourceSerifPro-LightIt-dnom-t1.vf) \
tex(SourceSerifPro-LightIt-lf-ly1--base.tfm) \
tex(SourceSerifPro-LightIt-lf-ly1.tfm) \
tex(SourceSerifPro-LightIt-lf-ly1.vf) \
tex(SourceSerifPro-LightIt-lf-ot1.tfm) \
tex(SourceSerifPro-LightIt-lf-t1--base.tfm) \
tex(SourceSerifPro-LightIt-lf-t1.tfm) \
tex(SourceSerifPro-LightIt-lf-t1.vf) \
tex(SourceSerifPro-LightIt-lf-ts1--base.tfm) \
tex(SourceSerifPro-LightIt-lf-ts1.tfm) \
tex(SourceSerifPro-LightIt-lf-ts1.vf) \
tex(SourceSerifPro-LightIt-numr-ly1--base.tfm) \
tex(SourceSerifPro-LightIt-numr-ly1.tfm) \
tex(SourceSerifPro-LightIt-numr-ly1.vf) \
tex(SourceSerifPro-LightIt-numr-ot1.tfm) \
tex(SourceSerifPro-LightIt-numr-t1--base.tfm) \
tex(SourceSerifPro-LightIt-numr-t1.tfm) \
tex(SourceSerifPro-LightIt-numr-t1.vf) \
tex(SourceSerifPro-LightIt-osf-ly1--base.tfm) \
tex(SourceSerifPro-LightIt-osf-ly1.tfm) \
tex(SourceSerifPro-LightIt-osf-ly1.vf) \
tex(SourceSerifPro-LightIt-osf-ot1.tfm) \
tex(SourceSerifPro-LightIt-osf-t1--base.tfm) \
tex(SourceSerifPro-LightIt-osf-t1.tfm) \
tex(SourceSerifPro-LightIt-osf-t1.vf) \
tex(SourceSerifPro-LightIt-osf-ts1--base.tfm) \
tex(SourceSerifPro-LightIt-osf-ts1.tfm) \
tex(SourceSerifPro-LightIt-osf-ts1.vf) \
tex(SourceSerifPro-LightIt-sup-ly1--base.tfm) \
tex(SourceSerifPro-LightIt-sup-ly1.tfm) \
tex(SourceSerifPro-LightIt-sup-ly1.vf) \
tex(SourceSerifPro-LightIt-sup-ot1.tfm) \
tex(SourceSerifPro-LightIt-sup-t1--base.tfm) \
tex(SourceSerifPro-LightIt-sup-t1.tfm) \
tex(SourceSerifPro-LightIt-sup-t1.vf) \
tex(SourceSerifPro-LightIt-tlf-ly1--base.tfm) \
tex(SourceSerifPro-LightIt-tlf-ly1.tfm) \
tex(SourceSerifPro-LightIt-tlf-ly1.vf) \
tex(SourceSerifPro-LightIt-tlf-ot1.tfm) \
tex(SourceSerifPro-LightIt-tlf-t1--base.tfm) \
tex(SourceSerifPro-LightIt-tlf-t1.tfm) \
tex(SourceSerifPro-LightIt-tlf-t1.vf) \
tex(SourceSerifPro-LightIt-tlf-ts1--base.tfm) \
tex(SourceSerifPro-LightIt-tlf-ts1.tfm) \
tex(SourceSerifPro-LightIt-tlf-ts1.vf) \
tex(SourceSerifPro-LightIt-tosf-ly1--base.tfm) \
tex(SourceSerifPro-LightIt-tosf-ly1.tfm) \
tex(SourceSerifPro-LightIt-tosf-ly1.vf) \
tex(SourceSerifPro-LightIt-tosf-ot1.tfm) \
tex(SourceSerifPro-LightIt-tosf-t1--base.tfm) \
tex(SourceSerifPro-LightIt-tosf-t1.tfm) \
tex(SourceSerifPro-LightIt-tosf-t1.vf) \
tex(SourceSerifPro-LightIt-tosf-ts1--base.tfm) \
tex(SourceSerifPro-LightIt-tosf-ts1.tfm) \
tex(SourceSerifPro-LightIt-tosf-ts1.vf) \
tex(SourceSerifPro-Regular-dnom-ly1--base.tfm) \
tex(SourceSerifPro-Regular-dnom-ly1.tfm) \
tex(SourceSerifPro-Regular-dnom-ly1.vf) \
tex(SourceSerifPro-Regular-dnom-ot1.tfm) \
tex(SourceSerifPro-Regular-dnom-t1--base.tfm) \
tex(SourceSerifPro-Regular-dnom-t1.tfm) \
tex(SourceSerifPro-Regular-dnom-t1.vf) \
tex(SourceSerifPro-Regular-lf-ly1--base.tfm) \
tex(SourceSerifPro-Regular-lf-ly1.tfm) \
tex(SourceSerifPro-Regular-lf-ly1.vf) \
tex(SourceSerifPro-Regular-lf-ot1.tfm) \
tex(SourceSerifPro-Regular-lf-sc-ly1--base.tfm) \
tex(SourceSerifPro-Regular-lf-sc-ly1.tfm) \
tex(SourceSerifPro-Regular-lf-sc-ly1.vf) \
tex(SourceSerifPro-Regular-lf-sc-ot1--base.tfm) \
tex(SourceSerifPro-Regular-lf-sc-ot1.tfm) \
tex(SourceSerifPro-Regular-lf-sc-ot1.vf) \
tex(SourceSerifPro-Regular-lf-sc-t1--base.tfm) \
tex(SourceSerifPro-Regular-lf-sc-t1.tfm) \
tex(SourceSerifPro-Regular-lf-sc-t1.vf) \
tex(SourceSerifPro-Regular-lf-t1--base.tfm) \
tex(SourceSerifPro-Regular-lf-t1.tfm) \
tex(SourceSerifPro-Regular-lf-t1.vf) \
tex(SourceSerifPro-Regular-lf-ts1--base.tfm) \
tex(SourceSerifPro-Regular-lf-ts1.tfm) \
tex(SourceSerifPro-Regular-lf-ts1.vf) \
tex(SourceSerifPro-Regular-numr-ly1--base.tfm) \
tex(SourceSerifPro-Regular-numr-ly1.tfm) \
tex(SourceSerifPro-Regular-numr-ly1.vf) \
tex(SourceSerifPro-Regular-numr-ot1.tfm) \
tex(SourceSerifPro-Regular-numr-t1--base.tfm) \
tex(SourceSerifPro-Regular-numr-t1.tfm) \
tex(SourceSerifPro-Regular-numr-t1.vf) \
tex(SourceSerifPro-Regular-osf-ly1--base.tfm) \
tex(SourceSerifPro-Regular-osf-ly1.tfm) \
tex(SourceSerifPro-Regular-osf-ly1.vf) \
tex(SourceSerifPro-Regular-osf-ot1.tfm) \
tex(SourceSerifPro-Regular-osf-sc-ly1--base.tfm) \
tex(SourceSerifPro-Regular-osf-sc-ly1.tfm) \
tex(SourceSerifPro-Regular-osf-sc-ly1.vf) \
tex(SourceSerifPro-Regular-osf-sc-ot1--base.tfm) \
tex(SourceSerifPro-Regular-osf-sc-ot1.tfm) \
tex(SourceSerifPro-Regular-osf-sc-ot1.vf) \
tex(SourceSerifPro-Regular-osf-sc-t1--base.tfm) \
tex(SourceSerifPro-Regular-osf-sc-t1.tfm) \
tex(SourceSerifPro-Regular-osf-sc-t1.vf) \
tex(SourceSerifPro-Regular-osf-t1--base.tfm) \
tex(SourceSerifPro-Regular-osf-t1.tfm) \
tex(SourceSerifPro-Regular-osf-t1.vf) \
tex(SourceSerifPro-Regular-osf-ts1--base.tfm) \
tex(SourceSerifPro-Regular-osf-ts1.tfm) \
tex(SourceSerifPro-Regular-osf-ts1.vf) \
tex(SourceSerifPro-Regular-sup-ly1--base.tfm) \
tex(SourceSerifPro-Regular-sup-ly1.tfm) \
tex(SourceSerifPro-Regular-sup-ly1.vf) \
tex(SourceSerifPro-Regular-sup-ot1.tfm) \
tex(SourceSerifPro-Regular-sup-t1--base.tfm) \
tex(SourceSerifPro-Regular-sup-t1.tfm) \
tex(SourceSerifPro-Regular-sup-t1.vf) \
tex(SourceSerifPro-Regular-tlf-ly1--base.tfm) \
tex(SourceSerifPro-Regular-tlf-ly1.tfm) \
tex(SourceSerifPro-Regular-tlf-ly1.vf) \
tex(SourceSerifPro-Regular-tlf-ot1.tfm) \
tex(SourceSerifPro-Regular-tlf-sc-ly1--base.tfm) \
tex(SourceSerifPro-Regular-tlf-sc-ly1.tfm) \
tex(SourceSerifPro-Regular-tlf-sc-ly1.vf) \
tex(SourceSerifPro-Regular-tlf-sc-ot1--base.tfm) \
tex(SourceSerifPro-Regular-tlf-sc-ot1.tfm) \
tex(SourceSerifPro-Regular-tlf-sc-ot1.vf) \
tex(SourceSerifPro-Regular-tlf-sc-t1--base.tfm) \
tex(SourceSerifPro-Regular-tlf-sc-t1.tfm) \
tex(SourceSerifPro-Regular-tlf-sc-t1.vf) \
tex(SourceSerifPro-Regular-tlf-t1--base.tfm) \
tex(SourceSerifPro-Regular-tlf-t1.tfm) \
tex(SourceSerifPro-Regular-tlf-t1.vf) \
tex(SourceSerifPro-Regular-tlf-ts1--base.tfm) \
tex(SourceSerifPro-Regular-tlf-ts1.tfm) \
tex(SourceSerifPro-Regular-tlf-ts1.vf) \
tex(SourceSerifPro-Regular-tosf-ly1--base.tfm) \
tex(SourceSerifPro-Regular-tosf-ly1.tfm) \
tex(SourceSerifPro-Regular-tosf-ly1.vf) \
tex(SourceSerifPro-Regular-tosf-ot1.tfm) \
tex(SourceSerifPro-Regular-tosf-sc-ly1--base.tfm) \
tex(SourceSerifPro-Regular-tosf-sc-ly1.tfm) \
tex(SourceSerifPro-Regular-tosf-sc-ly1.vf) \
tex(SourceSerifPro-Regular-tosf-sc-ot1--base.tfm) \
tex(SourceSerifPro-Regular-tosf-sc-ot1.tfm) \
tex(SourceSerifPro-Regular-tosf-sc-ot1.vf) \
tex(SourceSerifPro-Regular-tosf-sc-t1--base.tfm) \
tex(SourceSerifPro-Regular-tosf-sc-t1.tfm) \
tex(SourceSerifPro-Regular-tosf-sc-t1.vf) \
tex(SourceSerifPro-Regular-tosf-t1--base.tfm) \
tex(SourceSerifPro-Regular-tosf-t1.tfm) \
tex(SourceSerifPro-Regular-tosf-t1.vf) \
tex(SourceSerifPro-Regular-tosf-ts1--base.tfm) \
tex(SourceSerifPro-Regular-tosf-ts1.tfm) \
tex(SourceSerifPro-Regular-tosf-ts1.vf) \
tex(SourceSerifPro-Semibold-dnom-ly1--base.tfm) \
tex(SourceSerifPro-Semibold-dnom-ly1.tfm) \
tex(SourceSerifPro-Semibold-dnom-ly1.vf) \
tex(SourceSerifPro-Semibold-dnom-ot1.tfm) \
tex(SourceSerifPro-Semibold-dnom-t1--base.tfm) \
tex(SourceSerifPro-Semibold-dnom-t1.tfm) \
tex(SourceSerifPro-Semibold-dnom-t1.vf) \
tex(SourceSerifPro-Semibold-lf-ly1--base.tfm) \
tex(SourceSerifPro-Semibold-lf-ly1.tfm) \
tex(SourceSerifPro-Semibold-lf-ly1.vf) \
tex(SourceSerifPro-Semibold-lf-ot1.tfm) \
tex(SourceSerifPro-Semibold-lf-sc-ly1--base.tfm) \
tex(SourceSerifPro-Semibold-lf-sc-ly1.tfm) \
tex(SourceSerifPro-Semibold-lf-sc-ly1.vf) \
tex(SourceSerifPro-Semibold-lf-sc-ot1--base.tfm) \
tex(SourceSerifPro-Semibold-lf-sc-ot1.tfm) \
tex(SourceSerifPro-Semibold-lf-sc-ot1.vf) \
tex(SourceSerifPro-Semibold-lf-sc-t1--base.tfm) \
tex(SourceSerifPro-Semibold-lf-sc-t1.tfm) \
tex(SourceSerifPro-Semibold-lf-sc-t1.vf) \
tex(SourceSerifPro-Semibold-lf-t1--base.tfm) \
tex(SourceSerifPro-Semibold-lf-t1.tfm) \
tex(SourceSerifPro-Semibold-lf-t1.vf) \
tex(SourceSerifPro-Semibold-lf-ts1--base.tfm) \
tex(SourceSerifPro-Semibold-lf-ts1.tfm) \
tex(SourceSerifPro-Semibold-lf-ts1.vf) \
tex(SourceSerifPro-Semibold-numr-ly1--base.tfm) \
tex(SourceSerifPro-Semibold-numr-ly1.tfm) \
tex(SourceSerifPro-Semibold-numr-ly1.vf) \
tex(SourceSerifPro-Semibold-numr-ot1.tfm) \
tex(SourceSerifPro-Semibold-numr-t1--base.tfm) \
tex(SourceSerifPro-Semibold-numr-t1.tfm) \
tex(SourceSerifPro-Semibold-numr-t1.vf) \
tex(SourceSerifPro-Semibold-osf-ly1--base.tfm) \
tex(SourceSerifPro-Semibold-osf-ly1.tfm) \
tex(SourceSerifPro-Semibold-osf-ly1.vf) \
tex(SourceSerifPro-Semibold-osf-ot1.tfm) \
tex(SourceSerifPro-Semibold-osf-sc-ly1--base.tfm) \
tex(SourceSerifPro-Semibold-osf-sc-ly1.tfm) \
tex(SourceSerifPro-Semibold-osf-sc-ly1.vf) \
tex(SourceSerifPro-Semibold-osf-sc-ot1--base.tfm) \
tex(SourceSerifPro-Semibold-osf-sc-ot1.tfm) \
tex(SourceSerifPro-Semibold-osf-sc-ot1.vf) \
tex(SourceSerifPro-Semibold-osf-sc-t1--base.tfm) \
tex(SourceSerifPro-Semibold-osf-sc-t1.tfm) \
tex(SourceSerifPro-Semibold-osf-sc-t1.vf) \
tex(SourceSerifPro-Semibold-osf-t1--base.tfm) \
tex(SourceSerifPro-Semibold-osf-t1.tfm) \
tex(SourceSerifPro-Semibold-osf-t1.vf) \
tex(SourceSerifPro-Semibold-osf-ts1--base.tfm) \
tex(SourceSerifPro-Semibold-osf-ts1.tfm) \
tex(SourceSerifPro-Semibold-osf-ts1.vf) \
tex(SourceSerifPro-Semibold-sup-ly1--base.tfm) \
tex(SourceSerifPro-Semibold-sup-ly1.tfm) \
tex(SourceSerifPro-Semibold-sup-ly1.vf) \
tex(SourceSerifPro-Semibold-sup-ot1.tfm) \
tex(SourceSerifPro-Semibold-sup-t1--base.tfm) \
tex(SourceSerifPro-Semibold-sup-t1.tfm) \
tex(SourceSerifPro-Semibold-sup-t1.vf) \
tex(SourceSerifPro-Semibold-tlf-ly1--base.tfm) \
tex(SourceSerifPro-Semibold-tlf-ly1.tfm) \
tex(SourceSerifPro-Semibold-tlf-ly1.vf) \
tex(SourceSerifPro-Semibold-tlf-ot1.tfm) \
tex(SourceSerifPro-Semibold-tlf-sc-ly1--base.tfm) \
tex(SourceSerifPro-Semibold-tlf-sc-ly1.tfm) \
tex(SourceSerifPro-Semibold-tlf-sc-ly1.vf) \
tex(SourceSerifPro-Semibold-tlf-sc-ot1--base.tfm) \
tex(SourceSerifPro-Semibold-tlf-sc-ot1.tfm) \
tex(SourceSerifPro-Semibold-tlf-sc-ot1.vf) \
tex(SourceSerifPro-Semibold-tlf-sc-t1--base.tfm) \
tex(SourceSerifPro-Semibold-tlf-sc-t1.tfm) \
tex(SourceSerifPro-Semibold-tlf-sc-t1.vf) \
tex(SourceSerifPro-Semibold-tlf-t1--base.tfm) \
tex(SourceSerifPro-Semibold-tlf-t1.tfm) \
tex(SourceSerifPro-Semibold-tlf-t1.vf) \
tex(SourceSerifPro-Semibold-tlf-ts1--base.tfm) \
tex(SourceSerifPro-Semibold-tlf-ts1.tfm) \
tex(SourceSerifPro-Semibold-tlf-ts1.vf) \
tex(SourceSerifPro-Semibold-tosf-ly1--base.tfm) \
tex(SourceSerifPro-Semibold-tosf-ly1.tfm) \
tex(SourceSerifPro-Semibold-tosf-ly1.vf) \
tex(SourceSerifPro-Semibold-tosf-ot1.tfm) \
tex(SourceSerifPro-Semibold-tosf-sc-ly1--base.tfm) \
tex(SourceSerifPro-Semibold-tosf-sc-ly1.tfm) \
tex(SourceSerifPro-Semibold-tosf-sc-ly1.vf) \
tex(SourceSerifPro-Semibold-tosf-sc-ot1--base.tfm) \
tex(SourceSerifPro-Semibold-tosf-sc-ot1.tfm) \
tex(SourceSerifPro-Semibold-tosf-sc-ot1.vf) \
tex(SourceSerifPro-Semibold-tosf-sc-t1--base.tfm) \
tex(SourceSerifPro-Semibold-tosf-sc-t1.tfm) \
tex(SourceSerifPro-Semibold-tosf-sc-t1.vf) \
tex(SourceSerifPro-Semibold-tosf-t1--base.tfm) \
tex(SourceSerifPro-Semibold-tosf-t1.tfm) \
tex(SourceSerifPro-Semibold-tosf-t1.vf) \
tex(SourceSerifPro-Semibold-tosf-ts1--base.tfm) \
tex(SourceSerifPro-Semibold-tosf-ts1.tfm) \
tex(SourceSerifPro-Semibold-tosf-ts1.vf) \
tex(SourceSerifPro-SemiboldIt-dnom-ly1--base.tfm) \
tex(SourceSerifPro-SemiboldIt-dnom-ly1.tfm) \
tex(SourceSerifPro-SemiboldIt-dnom-ly1.vf) \
tex(SourceSerifPro-SemiboldIt-dnom-ot1.tfm) \
tex(SourceSerifPro-SemiboldIt-dnom-t1--base.tfm) \
tex(SourceSerifPro-SemiboldIt-dnom-t1.tfm) \
tex(SourceSerifPro-SemiboldIt-dnom-t1.vf) \
tex(SourceSerifPro-SemiboldIt-lf-ly1--base.tfm) \
tex(SourceSerifPro-SemiboldIt-lf-ly1.tfm) \
tex(SourceSerifPro-SemiboldIt-lf-ly1.vf) \
tex(SourceSerifPro-SemiboldIt-lf-ot1.tfm) \
tex(SourceSerifPro-SemiboldIt-lf-t1--base.tfm) \
tex(SourceSerifPro-SemiboldIt-lf-t1.tfm) \
tex(SourceSerifPro-SemiboldIt-lf-t1.vf) \
tex(SourceSerifPro-SemiboldIt-lf-ts1--base.tfm) \
tex(SourceSerifPro-SemiboldIt-lf-ts1.tfm) \
tex(SourceSerifPro-SemiboldIt-lf-ts1.vf) \
tex(SourceSerifPro-SemiboldIt-numr-ly1--base.tfm) \
tex(SourceSerifPro-SemiboldIt-numr-ly1.tfm) \
tex(SourceSerifPro-SemiboldIt-numr-ly1.vf) \
tex(SourceSerifPro-SemiboldIt-numr-ot1.tfm) \
tex(SourceSerifPro-SemiboldIt-numr-t1--base.tfm) \
tex(SourceSerifPro-SemiboldIt-numr-t1.tfm) \
tex(SourceSerifPro-SemiboldIt-numr-t1.vf) \
tex(SourceSerifPro-SemiboldIt-osf-ly1--base.tfm) \
tex(SourceSerifPro-SemiboldIt-osf-ly1.tfm) \
tex(SourceSerifPro-SemiboldIt-osf-ly1.vf) \
tex(SourceSerifPro-SemiboldIt-osf-ot1.tfm) \
tex(SourceSerifPro-SemiboldIt-osf-t1--base.tfm) \
tex(SourceSerifPro-SemiboldIt-osf-t1.tfm) \
tex(SourceSerifPro-SemiboldIt-osf-t1.vf) \
tex(SourceSerifPro-SemiboldIt-osf-ts1--base.tfm) \
tex(SourceSerifPro-SemiboldIt-osf-ts1.tfm) \
tex(SourceSerifPro-SemiboldIt-osf-ts1.vf) \
tex(SourceSerifPro-SemiboldIt-sup-ly1--base.tfm) \
tex(SourceSerifPro-SemiboldIt-sup-ly1.tfm) \
tex(SourceSerifPro-SemiboldIt-sup-ly1.vf) \
tex(SourceSerifPro-SemiboldIt-sup-ot1.tfm) \
tex(SourceSerifPro-SemiboldIt-sup-t1--base.tfm) \
tex(SourceSerifPro-SemiboldIt-sup-t1.tfm) \
tex(SourceSerifPro-SemiboldIt-sup-t1.vf) \
tex(SourceSerifPro-SemiboldIt-tlf-ly1--base.tfm) \
tex(SourceSerifPro-SemiboldIt-tlf-ly1.tfm) \
tex(SourceSerifPro-SemiboldIt-tlf-ly1.vf) \
tex(SourceSerifPro-SemiboldIt-tlf-ot1.tfm) \
tex(SourceSerifPro-SemiboldIt-tlf-t1--base.tfm) \
tex(SourceSerifPro-SemiboldIt-tlf-t1.tfm) \
tex(SourceSerifPro-SemiboldIt-tlf-t1.vf) \
tex(SourceSerifPro-SemiboldIt-tlf-ts1--base.tfm) \
tex(SourceSerifPro-SemiboldIt-tlf-ts1.tfm) \
tex(SourceSerifPro-SemiboldIt-tlf-ts1.vf) \
tex(SourceSerifPro-SemiboldIt-tosf-ly1--base.tfm) \
tex(SourceSerifPro-SemiboldIt-tosf-ly1.tfm) \
tex(SourceSerifPro-SemiboldIt-tosf-ly1.vf) \
tex(SourceSerifPro-SemiboldIt-tosf-ot1.tfm) \
tex(SourceSerifPro-SemiboldIt-tosf-t1--base.tfm) \
tex(SourceSerifPro-SemiboldIt-tosf-t1.tfm) \
tex(SourceSerifPro-SemiboldIt-tosf-t1.vf) \
tex(SourceSerifPro-SemiboldIt-tosf-ts1--base.tfm) \
tex(SourceSerifPro-SemiboldIt-tosf-ts1.tfm) \
tex(SourceSerifPro-SemiboldIt-tosf-ts1.vf) \
tex(SourceSerifPro.map) \
tex(T1SourceSerifPro-Dnom.fd) \
tex(T1SourceSerifPro-LF.fd) \
tex(T1SourceSerifPro-Numr.fd) \
tex(T1SourceSerifPro-OsF.fd) \
tex(T1SourceSerifPro-Sup.fd) \
tex(T1SourceSerifPro-TLF.fd) \
tex(T1SourceSerifPro-TOsF.fd) \
tex(TS1SourceSerifPro-LF.fd) \
tex(TS1SourceSerifPro-OsF.fd) \
tex(TS1SourceSerifPro-TLF.fd) \
tex(TS1SourceSerifPro-TOsF.fd) \
tex(a_3wqk3b.enc) \
tex(a_5mjl2d.enc) \
tex(a_5ts2b6.enc) \
tex(a_6lyhkv.enc) \
tex(a_a6i6f2.enc) \
tex(a_abavx3.enc) \
tex(a_an4p3v.enc) \
tex(a_bdm2ki.enc) \
tex(a_bizpe5.enc) \
tex(a_brdplf.enc) \
tex(a_dc746j.enc) \
tex(a_etdltz.enc) \
tex(a_flbt57.enc) \
tex(a_g6m65j.enc) \
tex(a_gtvdgc.enc) \
tex(a_jevuw6.enc) \
tex(a_l72wii.enc) \
tex(a_lnjzcs.enc) \
tex(a_lseshj.enc) \
tex(a_meqgh4.enc) \
tex(a_mjlzxh.enc) \
tex(a_n7bg2c.enc) \
tex(a_nan7a4.enc) \
tex(a_nqu667.enc) \
tex(a_nx47sx.enc) \
tex(a_ob4xxw.enc) \
tex(a_oi66c4.enc) \
tex(a_oprvft.enc) \
tex(a_osimgj.enc) \
tex(a_osnaur.enc) \
tex(a_qiz27h.enc) \
tex(a_r74etr.enc) \
tex(a_rlbtkr.enc) \
tex(a_s5phdg.enc) \
tex(a_s6kslv.enc) \
tex(a_sboynu.enc) \
tex(a_sonlso.enc) \
tex(a_sor56s.enc) \
tex(a_tf7hcc.enc) \
tex(a_uima5p.enc) \
tex(a_upudw7.enc) \
tex(a_vbwd4w.enc) \
tex(a_vnu3m6.enc) \
tex(a_z6lp4v.enc) \
tex(a_ztztxn.enc) \
tex(sourceserifpro-type1-autoinst.sty) \
tex(sourceserifpro.sty) \
texlive-sourceserifpro"

RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex(fontaxes.sty) \
tex(fontenc.sty) \
tex(fontspec.sty) \
tex(ifluatex.sty) \
tex(ifxetex.sty) \
tex(mweights.sty) \
tex(textcomp.sty) \
tex(updmap.cfg) \
tex(xkeyval.sty) \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin \
texlive-sourceserifpro-fonts"

inherit rpm
