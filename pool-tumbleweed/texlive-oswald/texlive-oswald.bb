SUMMARY = "The Oswald family of fonts with support for LaTeX and pdfLaTeX"
DESCRIPTION = "This package provides the Oswald family of fonts, designed by \
Vernon Adams, Kalapi Gajjar, Cyreal, with support for LaTeX and \
pdfLaTeX."
LICENSE = "OFL-1.1"

PV = "2023.209.svn60784"

RPM_NAME = "texlive-oswald-2023.209.svn60784-55.1.noarch.rpm"
RPM_HASH = "b4acb124fac93bdeb9126a24f8d6e20076fcc3ffada5f686a4059553fd9907badfc6ce7e2b386d17e4ef9e4688c6f2de8235d9433b8ef7d8b2c6224e872e3a50"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-0swald-Bold-sup-ly1--base.tfm \
tex-0swald-Bold-sup-ly1.tfm \
tex-0swald-Bold-sup-ly1.vf \
tex-0swald-Bold-sup-ot1.tfm \
tex-0swald-Bold-sup-t1--base.tfm \
tex-0swald-Bold-sup-t1.tfm \
tex-0swald-Bold-sup-t1.vf \
tex-0swald-Bold-tlf-ly1--base.tfm \
tex-0swald-Bold-tlf-ly1.tfm \
tex-0swald-Bold-tlf-ly1.vf \
tex-0swald-Bold-tlf-ot1.tfm \
tex-0swald-Bold-tlf-t1--base.tfm \
tex-0swald-Bold-tlf-t1.tfm \
tex-0swald-Bold-tlf-t1.vf \
tex-0swald-Bold-tlf-ts1--base.tfm \
tex-0swald-Bold-tlf-ts1.tfm \
tex-0swald-Bold-tlf-ts1.vf \
tex-0swald-ExtraLight-sup-ly1--base.tfm \
tex-0swald-ExtraLight-sup-ly1.tfm \
tex-0swald-ExtraLight-sup-ly1.vf \
tex-0swald-ExtraLight-sup-ot1.tfm \
tex-0swald-ExtraLight-sup-t1--base.tfm \
tex-0swald-ExtraLight-sup-t1.tfm \
tex-0swald-ExtraLight-sup-t1.vf \
tex-0swald-ExtraLight-tlf-ly1--base.tfm \
tex-0swald-ExtraLight-tlf-ly1.tfm \
tex-0swald-ExtraLight-tlf-ly1.vf \
tex-0swald-ExtraLight-tlf-ot1.tfm \
tex-0swald-ExtraLight-tlf-t1--base.tfm \
tex-0swald-ExtraLight-tlf-t1.tfm \
tex-0swald-ExtraLight-tlf-t1.vf \
tex-0swald-ExtraLight-tlf-ts1--base.tfm \
tex-0swald-ExtraLight-tlf-ts1.tfm \
tex-0swald-ExtraLight-tlf-ts1.vf \
tex-0swald-Light-sup-ly1--base.tfm \
tex-0swald-Light-sup-ly1.tfm \
tex-0swald-Light-sup-ly1.vf \
tex-0swald-Light-sup-ot1.tfm \
tex-0swald-Light-sup-t1--base.tfm \
tex-0swald-Light-sup-t1.tfm \
tex-0swald-Light-sup-t1.vf \
tex-0swald-Light-tlf-ly1--base.tfm \
tex-0swald-Light-tlf-ly1.tfm \
tex-0swald-Light-tlf-ly1.vf \
tex-0swald-Light-tlf-ot1.tfm \
tex-0swald-Light-tlf-t1--base.tfm \
tex-0swald-Light-tlf-t1.tfm \
tex-0swald-Light-tlf-t1.vf \
tex-0swald-Light-tlf-ts1--base.tfm \
tex-0swald-Light-tlf-ts1.tfm \
tex-0swald-Light-tlf-ts1.vf \
tex-0swald-Medium-sup-ly1--base.tfm \
tex-0swald-Medium-sup-ly1.tfm \
tex-0swald-Medium-sup-ly1.vf \
tex-0swald-Medium-sup-ot1.tfm \
tex-0swald-Medium-sup-t1--base.tfm \
tex-0swald-Medium-sup-t1.tfm \
tex-0swald-Medium-sup-t1.vf \
tex-0swald-Medium-tlf-ly1--base.tfm \
tex-0swald-Medium-tlf-ly1.tfm \
tex-0swald-Medium-tlf-ly1.vf \
tex-0swald-Medium-tlf-ot1.tfm \
tex-0swald-Medium-tlf-t1--base.tfm \
tex-0swald-Medium-tlf-t1.tfm \
tex-0swald-Medium-tlf-t1.vf \
tex-0swald-Medium-tlf-ts1--base.tfm \
tex-0swald-Medium-tlf-ts1.tfm \
tex-0swald-Medium-tlf-ts1.vf \
tex-0swald-Regular-sup-ly1--base.tfm \
tex-0swald-Regular-sup-ly1.tfm \
tex-0swald-Regular-sup-ly1.vf \
tex-0swald-Regular-sup-ot1.tfm \
tex-0swald-Regular-sup-t1--base.tfm \
tex-0swald-Regular-sup-t1.tfm \
tex-0swald-Regular-sup-t1.vf \
tex-0swald-Regular-tlf-ly1--base.tfm \
tex-0swald-Regular-tlf-ly1.tfm \
tex-0swald-Regular-tlf-ly1.vf \
tex-0swald-Regular-tlf-ot1.tfm \
tex-0swald-Regular-tlf-t1--base.tfm \
tex-0swald-Regular-tlf-t1.tfm \
tex-0swald-Regular-tlf-t1.vf \
tex-0swald-Regular-tlf-ts1--base.tfm \
tex-0swald-Regular-tlf-ts1.tfm \
tex-0swald-Regular-tlf-ts1.vf \
tex-0swald-SemiBold-sup-ly1--base.tfm \
tex-0swald-SemiBold-sup-ly1.tfm \
tex-0swald-SemiBold-sup-ly1.vf \
tex-0swald-SemiBold-sup-ot1.tfm \
tex-0swald-SemiBold-sup-t1--base.tfm \
tex-0swald-SemiBold-sup-t1.tfm \
tex-0swald-SemiBold-sup-t1.vf \
tex-0swald-SemiBold-tlf-ly1--base.tfm \
tex-0swald-SemiBold-tlf-ly1.tfm \
tex-0swald-SemiBold-tlf-ly1.vf \
tex-0swald-SemiBold-tlf-ot1.tfm \
tex-0swald-SemiBold-tlf-t1--base.tfm \
tex-0swald-SemiBold-tlf-t1.tfm \
tex-0swald-SemiBold-tlf-t1.vf \
tex-0swald-SemiBold-tlf-ts1--base.tfm \
tex-0swald-SemiBold-tlf-ts1.tfm \
tex-0swald-SemiBold-tlf-ts1.vf \
tex-LY1Zeroswald-Sup.fd \
tex-LY1Zeroswald-TLF.fd \
tex-OT1Zeroswald-Sup.fd \
tex-OT1Zeroswald-TLF.fd \
tex-Oswald.sty \
tex-T1Zeroswald-Sup.fd \
tex-T1Zeroswald-TLF.fd \
tex-TS1Zeroswald-TLF.fd \
tex-Zeroswald.map \
tex-a-7goukv.enc \
tex-a-d2anrk.enc \
tex-a-j5f6hs.enc \
tex-a-leqwth.enc \
tex-a-rymxky.enc \
tex-a-ts7dz6.enc \
tex-a-wbqrrh.enc \
texlive-oswald"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontaxes.sty \
tex-fontenc.sty \
tex-ifthen.sty \
tex-mweights.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-oswald-fonts \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
