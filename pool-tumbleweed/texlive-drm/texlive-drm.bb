SUMMARY = "A complete family of fonts written in Metafont"
DESCRIPTION = "The package provides access to the DRM (Don's Revised Modern) \
family of fonts, which includes a variety of optical sizes in \
Roman (in four weights), italic, and small caps, among other \
shapes, along with a set of symbols and ornaments. It is \
intended to be a full-body text font, but its larger sizes can \
also be used for simple display purposes, and its significant \
body of symbols can stand on its own. It comes complete with \
textual ('old-style') and lining figures, and even has \
small-caps figures. It also comes with extensible decorative \
rules to be used with ornaments from itself or other fonts, \
along with an extremely flexible ellipsis package."
LICENSE = "LPPL-1.0"

PV = "2023.201.4.4svn38157"

RPM_NAME = "texlive-drm-2023.201.4.4svn38157-52.1.noarch.rpm"
RPM_HASH = "3ceca8db68ff0d86f50a8ea87c20abb2b8087604377ac62443964599133e940c7a75160dd25185e8a6bd9fc7e22956399a56e8b756ae1252b6c44f61e959d81c"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-drm.map \
tex-drm.sty \
tex-drm10.tfm \
tex-drm100.tfm \
tex-drm11.tfm \
tex-drm12.tfm \
tex-drm14.tfm \
tex-drm17.tfm \
tex-drm24.tfm \
tex-drm6.tfm \
tex-drm7.tfm \
tex-drm8.tfm \
tex-drm9.tfm \
tex-drmb10.tfm \
tex-drmb11.tfm \
tex-drmb12.tfm \
tex-drmb14.tfm \
tex-drmb17.tfm \
tex-drmb24.tfm \
tex-drmb6.tfm \
tex-drmb7.tfm \
tex-drmb8.tfm \
tex-drmb9.tfm \
tex-drmbs10.tfm \
tex-drmbx10.tfm \
tex-drmbx11.tfm \
tex-drmbx12.tfm \
tex-drmbx14.tfm \
tex-drmbx17.tfm \
tex-drmbx24.tfm \
tex-drmbx6.tfm \
tex-drmbx7.tfm \
tex-drmbx8.tfm \
tex-drmbx9.tfm \
tex-drmdoz10.tfm \
tex-drmdoz11.tfm \
tex-drmdoz12.tfm \
tex-drmdoz14.tfm \
tex-drmdoz17.tfm \
tex-drmdoz24.tfm \
tex-drmdoz6.tfm \
tex-drmdoz7.tfm \
tex-drmdoz8.tfm \
tex-drmdoz9.tfm \
tex-drmdozb10.tfm \
tex-drmdozb11.tfm \
tex-drmdozb12.tfm \
tex-drmdozb14.tfm \
tex-drmdozb17.tfm \
tex-drmdozb24.tfm \
tex-drmdozb6.tfm \
tex-drmdozb7.tfm \
tex-drmdozb8.tfm \
tex-drmdozb9.tfm \
tex-drmdozbx10.tfm \
tex-drmdozbx11.tfm \
tex-drmdozbx12.tfm \
tex-drmdozbx14.tfm \
tex-drmdozbx17.tfm \
tex-drmdozbx24.tfm \
tex-drmdozbx6.tfm \
tex-drmdozbx7.tfm \
tex-drmdozbx8.tfm \
tex-drmdozbx9.tfm \
tex-drmdozit10.tfm \
tex-drmdozit11.tfm \
tex-drmdozit12.tfm \
tex-drmdozit14.tfm \
tex-drmdozit17.tfm \
tex-drmdozit24.tfm \
tex-drmdozit6.tfm \
tex-drmdozit7.tfm \
tex-drmdozit8.tfm \
tex-drmdozit9.tfm \
tex-drmdozitbx10.tfm \
tex-drmdozitbx11.tfm \
tex-drmdozitbx12.tfm \
tex-drmdozitbx14.tfm \
tex-drmdozitbx17.tfm \
tex-drmdozitbx24.tfm \
tex-drmdozitbx6.tfm \
tex-drmdozitbx7.tfm \
tex-drmdozitbx8.tfm \
tex-drmdozitbx9.tfm \
tex-drmdozitsc10.tfm \
tex-drmdozitsc11.tfm \
tex-drmdozitsc12.tfm \
tex-drmdozitsc14.tfm \
tex-drmdozitsc17.tfm \
tex-drmdozitsc24.tfm \
tex-drmdozitsc6.tfm \
tex-drmdozitsc7.tfm \
tex-drmdozitsc8.tfm \
tex-drmdozitsc9.tfm \
tex-drmdozittc10.tfm \
tex-drmdozittc11.tfm \
tex-drmdozittc12.tfm \
tex-drmdozittc14.tfm \
tex-drmdozittc17.tfm \
tex-drmdozittc24.tfm \
tex-drmdozittc6.tfm \
tex-drmdozittc7.tfm \
tex-drmdozittc8.tfm \
tex-drmdozittc9.tfm \
tex-drmdozl10.tfm \
tex-drmdozl11.tfm \
tex-drmdozl12.tfm \
tex-drmdozl14.tfm \
tex-drmdozl17.tfm \
tex-drmdozl24.tfm \
tex-drmdozl6.tfm \
tex-drmdozl7.tfm \
tex-drmdozl8.tfm \
tex-drmdozl9.tfm \
tex-drmdozsc10.tfm \
tex-drmdozsc11.tfm \
tex-drmdozsc12.tfm \
tex-drmdozsc14.tfm \
tex-drmdozsc17.tfm \
tex-drmdozsc24.tfm \
tex-drmdozsc6.tfm \
tex-drmdozsc7.tfm \
tex-drmdozsc8.tfm \
tex-drmdozsc9.tfm \
tex-drmdozscbx10.tfm \
tex-drmdozscbx11.tfm \
tex-drmdozscbx12.tfm \
tex-drmdozscbx14.tfm \
tex-drmdozscbx17.tfm \
tex-drmdozscbx24.tfm \
tex-drmdozscbx6.tfm \
tex-drmdozscbx7.tfm \
tex-drmdozscbx8.tfm \
tex-drmdozscbx9.tfm \
tex-drmdozsl10.tfm \
tex-drmdozsl11.tfm \
tex-drmdozsl12.tfm \
tex-drmdozsl14.tfm \
tex-drmdozsl17.tfm \
tex-drmdozsl24.tfm \
tex-drmdozsl6.tfm \
tex-drmdozsl7.tfm \
tex-drmdozsl8.tfm \
tex-drmdozsl9.tfm \
tex-drmdoztc10.tfm \
tex-drmdoztc11.tfm \
tex-drmdoztc12.tfm \
tex-drmdoztc14.tfm \
tex-drmdoztc17.tfm \
tex-drmdoztc24.tfm \
tex-drmdoztc6.tfm \
tex-drmdoztc7.tfm \
tex-drmdoztc8.tfm \
tex-drmdoztc9.tfm \
tex-drmdoztcbx10.tfm \
tex-drmdoztcbx11.tfm \
tex-drmdoztcbx12.tfm \
tex-drmdoztcbx14.tfm \
tex-drmdoztcbx17.tfm \
tex-drmdoztcbx24.tfm \
tex-drmdoztcbx6.tfm \
tex-drmdoztcbx7.tfm \
tex-drmdoztcbx8.tfm \
tex-drmdoztcbx9.tfm \
tex-drmdozui10.tfm \
tex-drmdozui11.tfm \
tex-drmdozui12.tfm \
tex-drmdozui14.tfm \
tex-drmdozui17.tfm \
tex-drmdozui24.tfm \
tex-drmdozui6.tfm \
tex-drmdozui7.tfm \
tex-drmdozui8.tfm \
tex-drmdozui9.tfm \
tex-drmdozuibx10.tfm \
tex-drmdozuibx11.tfm \
tex-drmdozuibx12.tfm \
tex-drmdozuibx14.tfm \
tex-drmdozuibx17.tfm \
tex-drmdozuibx24.tfm \
tex-drmdozuibx6.tfm \
tex-drmdozuibx7.tfm \
tex-drmdozuibx8.tfm \
tex-drmdozuibx9.tfm \
tex-drmfigs10.tfm \
tex-drmfigs11.tfm \
tex-drmfigs12.tfm \
tex-drmfigs14.tfm \
tex-drmfigs17.tfm \
tex-drmfigs24.tfm \
tex-drmfigs6.tfm \
tex-drmfigs7.tfm \
tex-drmfigs8.tfm \
tex-drmfigs9.tfm \
tex-drmgrk10.tfm \
tex-drminf10.tfm \
tex-drminf11.tfm \
tex-drminf12.tfm \
tex-drminf14.tfm \
tex-drminf17.tfm \
tex-drminf24.tfm \
tex-drminf6.tfm \
tex-drminf7.tfm \
tex-drminf8.tfm \
tex-drminf9.tfm \
tex-drmit10.tfm \
tex-drmit11.tfm \
tex-drmit12.tfm \
tex-drmit14.tfm \
tex-drmit17.tfm \
tex-drmit24.tfm \
tex-drmit6.tfm \
tex-drmit7.tfm \
tex-drmit8.tfm \
tex-drmit9.tfm \
tex-drmitbx10.tfm \
tex-drmitbx11.tfm \
tex-drmitbx12.tfm \
tex-drmitbx14.tfm \
tex-drmitbx17.tfm \
tex-drmitbx24.tfm \
tex-drmitbx6.tfm \
tex-drmitbx7.tfm \
tex-drmitbx8.tfm \
tex-drmitbx9.tfm \
tex-drmitsc10.tfm \
tex-drmitsc11.tfm \
tex-drmitsc12.tfm \
tex-drmitsc14.tfm \
tex-drmitsc17.tfm \
tex-drmitsc24.tfm \
tex-drmitsc6.tfm \
tex-drmitsc7.tfm \
tex-drmitsc8.tfm \
tex-drmitsc9.tfm \
tex-drmittc10.tfm \
tex-drmittc11.tfm \
tex-drmittc12.tfm \
tex-drmittc14.tfm \
tex-drmittc17.tfm \
tex-drmittc24.tfm \
tex-drmittc6.tfm \
tex-drmittc7.tfm \
tex-drmittc8.tfm \
tex-drmittc9.tfm \
tex-drml10.tfm \
tex-drml11.tfm \
tex-drml12.tfm \
tex-drml14.tfm \
tex-drml17.tfm \
tex-drml24.tfm \
tex-drml6.tfm \
tex-drml7.tfm \
tex-drml8.tfm \
tex-drml9.tfm \
tex-drmmi10.tfm \
tex-drmomx10.tfm \
tex-drmorns.tfm \
tex-drmsc10.tfm \
tex-drmsc11.tfm \
tex-drmsc12.tfm \
tex-drmsc14.tfm \
tex-drmsc17.tfm \
tex-drmsc24.tfm \
tex-drmsc6.tfm \
tex-drmsc7.tfm \
tex-drmsc8.tfm \
tex-drmsc9.tfm \
tex-drmscbx10.tfm \
tex-drmscbx11.tfm \
tex-drmscbx12.tfm \
tex-drmscbx14.tfm \
tex-drmscbx17.tfm \
tex-drmscbx24.tfm \
tex-drmscbx6.tfm \
tex-drmscbx7.tfm \
tex-drmscbx8.tfm \
tex-drmscbx9.tfm \
tex-drmsl10.tfm \
tex-drmsl11.tfm \
tex-drmsl12.tfm \
tex-drmsl14.tfm \
tex-drmsl17.tfm \
tex-drmsl24.tfm \
tex-drmsl6.tfm \
tex-drmsl7.tfm \
tex-drmsl8.tfm \
tex-drmsl9.tfm \
tex-drmsy10.tfm \
tex-drmsym10.tfm \
tex-drmsym11.tfm \
tex-drmsym12.tfm \
tex-drmsym14.tfm \
tex-drmsym17.tfm \
tex-drmsym24.tfm \
tex-drmsym7.tfm \
tex-drmsym8.tfm \
tex-drmsym9.tfm \
tex-drmtc10.tfm \
tex-drmtc11.tfm \
tex-drmtc12.tfm \
tex-drmtc14.tfm \
tex-drmtc17.tfm \
tex-drmtc24.tfm \
tex-drmtc6.tfm \
tex-drmtc7.tfm \
tex-drmtc8.tfm \
tex-drmtc9.tfm \
tex-drmtcbx10.tfm \
tex-drmtcbx11.tfm \
tex-drmtcbx12.tfm \
tex-drmtcbx14.tfm \
tex-drmtcbx17.tfm \
tex-drmtcbx24.tfm \
tex-drmtcbx6.tfm \
tex-drmtcbx7.tfm \
tex-drmtcbx8.tfm \
tex-drmtcbx9.tfm \
tex-drmui10.tfm \
tex-drmui11.tfm \
tex-drmui12.tfm \
tex-drmui14.tfm \
tex-drmui17.tfm \
tex-drmui24.tfm \
tex-drmui6.tfm \
tex-drmui7.tfm \
tex-drmui8.tfm \
tex-drmui9.tfm \
tex-drmuibx10.tfm \
tex-drmuibx11.tfm \
tex-drmuibx12.tfm \
tex-drmuibx14.tfm \
tex-drmuibx17.tfm \
tex-drmuibx24.tfm \
tex-drmuibx6.tfm \
tex-drmuibx7.tfm \
tex-drmuibx8.tfm \
tex-drmuibx9.tfm \
texlive-drm"

RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-amsmath.sty \
tex-fontenc.sty \
tex-gmp.sty \
tex-ifpdf.sty \
tex-modroman.sty \
texlive \
texlive-drm-fonts \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
