SUMMARY = "The Archivo font face with support for LaTeX and pdfLaTeX"
DESCRIPTION = "This package provides the Archivo family of fonts designed by \
Omnibus-Type, with support for LaTeX and pdfLaTeX."
LICENSE = "OFL-1.1"

PV = "2023.201.0.0.0.2svn57283"

RPM_NAME = "texlive-archivo-2023.201.0.0.0.2svn57283-54.1.noarch.rpm"
RPM_HASH = "ea5eaecfbd58b48dcdfea08de4aaf1fbfd4de074daf188dbb399ce09dd93d4c2aa6a8d152f0eb6bdcdae9771b0a8be086fb6ce0636cb954c353f90b888227d73"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex(Archiv0-Bold-lf-ly1--base.tfm) \
tex(Archiv0-Bold-lf-ly1.tfm) \
tex(Archiv0-Bold-lf-ly1.vf) \
tex(Archiv0-Bold-lf-ot1.tfm) \
tex(Archiv0-Bold-lf-t1--base.tfm) \
tex(Archiv0-Bold-lf-t1.tfm) \
tex(Archiv0-Bold-lf-t1.vf) \
tex(Archiv0-Bold-lf-ts1--base.tfm) \
tex(Archiv0-Bold-lf-ts1.tfm) \
tex(Archiv0-Bold-lf-ts1.vf) \
tex(Archiv0-Bold-osf-ly1--base.tfm) \
tex(Archiv0-Bold-osf-ly1.tfm) \
tex(Archiv0-Bold-osf-ly1.vf) \
tex(Archiv0-Bold-osf-ot1.tfm) \
tex(Archiv0-Bold-osf-t1--base.tfm) \
tex(Archiv0-Bold-osf-t1.tfm) \
tex(Archiv0-Bold-osf-t1.vf) \
tex(Archiv0-Bold-osf-ts1--base.tfm) \
tex(Archiv0-Bold-osf-ts1.tfm) \
tex(Archiv0-Bold-osf-ts1.vf) \
tex(Archiv0-Bold-sup-ly1--base.tfm) \
tex(Archiv0-Bold-sup-ly1.tfm) \
tex(Archiv0-Bold-sup-ly1.vf) \
tex(Archiv0-Bold-sup-ot1.tfm) \
tex(Archiv0-Bold-sup-t1--base.tfm) \
tex(Archiv0-Bold-sup-t1.tfm) \
tex(Archiv0-Bold-sup-t1.vf) \
tex(Archiv0-Bold-tlf-ly1--base.tfm) \
tex(Archiv0-Bold-tlf-ly1.tfm) \
tex(Archiv0-Bold-tlf-ly1.vf) \
tex(Archiv0-Bold-tlf-ot1.tfm) \
tex(Archiv0-Bold-tlf-t1--base.tfm) \
tex(Archiv0-Bold-tlf-t1.tfm) \
tex(Archiv0-Bold-tlf-t1.vf) \
tex(Archiv0-Bold-tlf-ts1--base.tfm) \
tex(Archiv0-Bold-tlf-ts1.tfm) \
tex(Archiv0-Bold-tlf-ts1.vf) \
tex(Archiv0-Bold-tosf-ly1--base.tfm) \
tex(Archiv0-Bold-tosf-ly1.tfm) \
tex(Archiv0-Bold-tosf-ly1.vf) \
tex(Archiv0-Bold-tosf-ot1.tfm) \
tex(Archiv0-Bold-tosf-t1--base.tfm) \
tex(Archiv0-Bold-tosf-t1.tfm) \
tex(Archiv0-Bold-tosf-t1.vf) \
tex(Archiv0-Bold-tosf-ts1--base.tfm) \
tex(Archiv0-Bold-tosf-ts1.tfm) \
tex(Archiv0-Bold-tosf-ts1.vf) \
tex(Archiv0-BoldItalic-lf-ly1--base.tfm) \
tex(Archiv0-BoldItalic-lf-ly1.tfm) \
tex(Archiv0-BoldItalic-lf-ly1.vf) \
tex(Archiv0-BoldItalic-lf-ot1.tfm) \
tex(Archiv0-BoldItalic-lf-t1--base.tfm) \
tex(Archiv0-BoldItalic-lf-t1.tfm) \
tex(Archiv0-BoldItalic-lf-t1.vf) \
tex(Archiv0-BoldItalic-lf-ts1--base.tfm) \
tex(Archiv0-BoldItalic-lf-ts1.tfm) \
tex(Archiv0-BoldItalic-lf-ts1.vf) \
tex(Archiv0-BoldItalic-osf-ly1--base.tfm) \
tex(Archiv0-BoldItalic-osf-ly1.tfm) \
tex(Archiv0-BoldItalic-osf-ly1.vf) \
tex(Archiv0-BoldItalic-osf-ot1.tfm) \
tex(Archiv0-BoldItalic-osf-t1--base.tfm) \
tex(Archiv0-BoldItalic-osf-t1.tfm) \
tex(Archiv0-BoldItalic-osf-t1.vf) \
tex(Archiv0-BoldItalic-osf-ts1--base.tfm) \
tex(Archiv0-BoldItalic-osf-ts1.tfm) \
tex(Archiv0-BoldItalic-osf-ts1.vf) \
tex(Archiv0-BoldItalic-sup-ly1--base.tfm) \
tex(Archiv0-BoldItalic-sup-ly1.tfm) \
tex(Archiv0-BoldItalic-sup-ly1.vf) \
tex(Archiv0-BoldItalic-sup-ot1.tfm) \
tex(Archiv0-BoldItalic-sup-t1--base.tfm) \
tex(Archiv0-BoldItalic-sup-t1.tfm) \
tex(Archiv0-BoldItalic-sup-t1.vf) \
tex(Archiv0-BoldItalic-tlf-ly1--base.tfm) \
tex(Archiv0-BoldItalic-tlf-ly1.tfm) \
tex(Archiv0-BoldItalic-tlf-ly1.vf) \
tex(Archiv0-BoldItalic-tlf-ot1.tfm) \
tex(Archiv0-BoldItalic-tlf-t1--base.tfm) \
tex(Archiv0-BoldItalic-tlf-t1.tfm) \
tex(Archiv0-BoldItalic-tlf-t1.vf) \
tex(Archiv0-BoldItalic-tlf-ts1--base.tfm) \
tex(Archiv0-BoldItalic-tlf-ts1.tfm) \
tex(Archiv0-BoldItalic-tlf-ts1.vf) \
tex(Archiv0-BoldItalic-tosf-ly1--base.tfm) \
tex(Archiv0-BoldItalic-tosf-ly1.tfm) \
tex(Archiv0-BoldItalic-tosf-ly1.vf) \
tex(Archiv0-BoldItalic-tosf-ot1.tfm) \
tex(Archiv0-BoldItalic-tosf-t1--base.tfm) \
tex(Archiv0-BoldItalic-tosf-t1.tfm) \
tex(Archiv0-BoldItalic-tosf-t1.vf) \
tex(Archiv0-BoldItalic-tosf-ts1--base.tfm) \
tex(Archiv0-BoldItalic-tosf-ts1.tfm) \
tex(Archiv0-BoldItalic-tosf-ts1.vf) \
tex(Archiv0-Italic-lf-ly1--base.tfm) \
tex(Archiv0-Italic-lf-ly1.tfm) \
tex(Archiv0-Italic-lf-ly1.vf) \
tex(Archiv0-Italic-lf-ot1.tfm) \
tex(Archiv0-Italic-lf-t1--base.tfm) \
tex(Archiv0-Italic-lf-t1.tfm) \
tex(Archiv0-Italic-lf-t1.vf) \
tex(Archiv0-Italic-lf-ts1--base.tfm) \
tex(Archiv0-Italic-lf-ts1.tfm) \
tex(Archiv0-Italic-lf-ts1.vf) \
tex(Archiv0-Italic-osf-ly1--base.tfm) \
tex(Archiv0-Italic-osf-ly1.tfm) \
tex(Archiv0-Italic-osf-ly1.vf) \
tex(Archiv0-Italic-osf-ot1.tfm) \
tex(Archiv0-Italic-osf-t1--base.tfm) \
tex(Archiv0-Italic-osf-t1.tfm) \
tex(Archiv0-Italic-osf-t1.vf) \
tex(Archiv0-Italic-osf-ts1--base.tfm) \
tex(Archiv0-Italic-osf-ts1.tfm) \
tex(Archiv0-Italic-osf-ts1.vf) \
tex(Archiv0-Italic-sup-ly1--base.tfm) \
tex(Archiv0-Italic-sup-ly1.tfm) \
tex(Archiv0-Italic-sup-ly1.vf) \
tex(Archiv0-Italic-sup-ot1.tfm) \
tex(Archiv0-Italic-sup-t1--base.tfm) \
tex(Archiv0-Italic-sup-t1.tfm) \
tex(Archiv0-Italic-sup-t1.vf) \
tex(Archiv0-Italic-tlf-ly1--base.tfm) \
tex(Archiv0-Italic-tlf-ly1.tfm) \
tex(Archiv0-Italic-tlf-ly1.vf) \
tex(Archiv0-Italic-tlf-ot1.tfm) \
tex(Archiv0-Italic-tlf-t1--base.tfm) \
tex(Archiv0-Italic-tlf-t1.tfm) \
tex(Archiv0-Italic-tlf-t1.vf) \
tex(Archiv0-Italic-tlf-ts1--base.tfm) \
tex(Archiv0-Italic-tlf-ts1.tfm) \
tex(Archiv0-Italic-tlf-ts1.vf) \
tex(Archiv0-Italic-tosf-ly1--base.tfm) \
tex(Archiv0-Italic-tosf-ly1.tfm) \
tex(Archiv0-Italic-tosf-ly1.vf) \
tex(Archiv0-Italic-tosf-ot1.tfm) \
tex(Archiv0-Italic-tosf-t1--base.tfm) \
tex(Archiv0-Italic-tosf-t1.tfm) \
tex(Archiv0-Italic-tosf-t1.vf) \
tex(Archiv0-Italic-tosf-ts1--base.tfm) \
tex(Archiv0-Italic-tosf-ts1.tfm) \
tex(Archiv0-Italic-tosf-ts1.vf) \
tex(Archiv0-Medium-lf-ly1--base.tfm) \
tex(Archiv0-Medium-lf-ly1.tfm) \
tex(Archiv0-Medium-lf-ly1.vf) \
tex(Archiv0-Medium-lf-ot1.tfm) \
tex(Archiv0-Medium-lf-t1--base.tfm) \
tex(Archiv0-Medium-lf-t1.tfm) \
tex(Archiv0-Medium-lf-t1.vf) \
tex(Archiv0-Medium-lf-ts1--base.tfm) \
tex(Archiv0-Medium-lf-ts1.tfm) \
tex(Archiv0-Medium-lf-ts1.vf) \
tex(Archiv0-Medium-osf-ly1--base.tfm) \
tex(Archiv0-Medium-osf-ly1.tfm) \
tex(Archiv0-Medium-osf-ly1.vf) \
tex(Archiv0-Medium-osf-ot1.tfm) \
tex(Archiv0-Medium-osf-t1--base.tfm) \
tex(Archiv0-Medium-osf-t1.tfm) \
tex(Archiv0-Medium-osf-t1.vf) \
tex(Archiv0-Medium-osf-ts1--base.tfm) \
tex(Archiv0-Medium-osf-ts1.tfm) \
tex(Archiv0-Medium-osf-ts1.vf) \
tex(Archiv0-Medium-sup-ly1--base.tfm) \
tex(Archiv0-Medium-sup-ly1.tfm) \
tex(Archiv0-Medium-sup-ly1.vf) \
tex(Archiv0-Medium-sup-ot1.tfm) \
tex(Archiv0-Medium-sup-t1--base.tfm) \
tex(Archiv0-Medium-sup-t1.tfm) \
tex(Archiv0-Medium-sup-t1.vf) \
tex(Archiv0-Medium-tlf-ly1--base.tfm) \
tex(Archiv0-Medium-tlf-ly1.tfm) \
tex(Archiv0-Medium-tlf-ly1.vf) \
tex(Archiv0-Medium-tlf-ot1.tfm) \
tex(Archiv0-Medium-tlf-t1--base.tfm) \
tex(Archiv0-Medium-tlf-t1.tfm) \
tex(Archiv0-Medium-tlf-t1.vf) \
tex(Archiv0-Medium-tlf-ts1--base.tfm) \
tex(Archiv0-Medium-tlf-ts1.tfm) \
tex(Archiv0-Medium-tlf-ts1.vf) \
tex(Archiv0-Medium-tosf-ly1--base.tfm) \
tex(Archiv0-Medium-tosf-ly1.tfm) \
tex(Archiv0-Medium-tosf-ly1.vf) \
tex(Archiv0-Medium-tosf-ot1.tfm) \
tex(Archiv0-Medium-tosf-t1--base.tfm) \
tex(Archiv0-Medium-tosf-t1.tfm) \
tex(Archiv0-Medium-tosf-t1.vf) \
tex(Archiv0-Medium-tosf-ts1--base.tfm) \
tex(Archiv0-Medium-tosf-ts1.tfm) \
tex(Archiv0-Medium-tosf-ts1.vf) \
tex(Archiv0-MediumItalic-lf-ly1--base.tfm) \
tex(Archiv0-MediumItalic-lf-ly1.tfm) \
tex(Archiv0-MediumItalic-lf-ly1.vf) \
tex(Archiv0-MediumItalic-lf-ot1.tfm) \
tex(Archiv0-MediumItalic-lf-t1--base.tfm) \
tex(Archiv0-MediumItalic-lf-t1.tfm) \
tex(Archiv0-MediumItalic-lf-t1.vf) \
tex(Archiv0-MediumItalic-lf-ts1--base.tfm) \
tex(Archiv0-MediumItalic-lf-ts1.tfm) \
tex(Archiv0-MediumItalic-lf-ts1.vf) \
tex(Archiv0-MediumItalic-osf-ly1--base.tfm) \
tex(Archiv0-MediumItalic-osf-ly1.tfm) \
tex(Archiv0-MediumItalic-osf-ly1.vf) \
tex(Archiv0-MediumItalic-osf-ot1.tfm) \
tex(Archiv0-MediumItalic-osf-t1--base.tfm) \
tex(Archiv0-MediumItalic-osf-t1.tfm) \
tex(Archiv0-MediumItalic-osf-t1.vf) \
tex(Archiv0-MediumItalic-osf-ts1--base.tfm) \
tex(Archiv0-MediumItalic-osf-ts1.tfm) \
tex(Archiv0-MediumItalic-osf-ts1.vf) \
tex(Archiv0-MediumItalic-sup-ly1--base.tfm) \
tex(Archiv0-MediumItalic-sup-ly1.tfm) \
tex(Archiv0-MediumItalic-sup-ly1.vf) \
tex(Archiv0-MediumItalic-sup-ot1.tfm) \
tex(Archiv0-MediumItalic-sup-t1--base.tfm) \
tex(Archiv0-MediumItalic-sup-t1.tfm) \
tex(Archiv0-MediumItalic-sup-t1.vf) \
tex(Archiv0-MediumItalic-tlf-ly1--base.tfm) \
tex(Archiv0-MediumItalic-tlf-ly1.tfm) \
tex(Archiv0-MediumItalic-tlf-ly1.vf) \
tex(Archiv0-MediumItalic-tlf-ot1.tfm) \
tex(Archiv0-MediumItalic-tlf-t1--base.tfm) \
tex(Archiv0-MediumItalic-tlf-t1.tfm) \
tex(Archiv0-MediumItalic-tlf-t1.vf) \
tex(Archiv0-MediumItalic-tlf-ts1--base.tfm) \
tex(Archiv0-MediumItalic-tlf-ts1.tfm) \
tex(Archiv0-MediumItalic-tlf-ts1.vf) \
tex(Archiv0-MediumItalic-tosf-ly1--base.tfm) \
tex(Archiv0-MediumItalic-tosf-ly1.tfm) \
tex(Archiv0-MediumItalic-tosf-ly1.vf) \
tex(Archiv0-MediumItalic-tosf-ot1.tfm) \
tex(Archiv0-MediumItalic-tosf-t1--base.tfm) \
tex(Archiv0-MediumItalic-tosf-t1.tfm) \
tex(Archiv0-MediumItalic-tosf-t1.vf) \
tex(Archiv0-MediumItalic-tosf-ts1--base.tfm) \
tex(Archiv0-MediumItalic-tosf-ts1.tfm) \
tex(Archiv0-MediumItalic-tosf-ts1.vf) \
tex(Archiv0-Regular-lf-ly1--base.tfm) \
tex(Archiv0-Regular-lf-ly1.tfm) \
tex(Archiv0-Regular-lf-ly1.vf) \
tex(Archiv0-Regular-lf-ot1.tfm) \
tex(Archiv0-Regular-lf-t1--base.tfm) \
tex(Archiv0-Regular-lf-t1.tfm) \
tex(Archiv0-Regular-lf-t1.vf) \
tex(Archiv0-Regular-lf-ts1--base.tfm) \
tex(Archiv0-Regular-lf-ts1.tfm) \
tex(Archiv0-Regular-lf-ts1.vf) \
tex(Archiv0-Regular-osf-ly1--base.tfm) \
tex(Archiv0-Regular-osf-ly1.tfm) \
tex(Archiv0-Regular-osf-ly1.vf) \
tex(Archiv0-Regular-osf-ot1.tfm) \
tex(Archiv0-Regular-osf-t1--base.tfm) \
tex(Archiv0-Regular-osf-t1.tfm) \
tex(Archiv0-Regular-osf-t1.vf) \
tex(Archiv0-Regular-osf-ts1--base.tfm) \
tex(Archiv0-Regular-osf-ts1.tfm) \
tex(Archiv0-Regular-osf-ts1.vf) \
tex(Archiv0-Regular-sup-ly1--base.tfm) \
tex(Archiv0-Regular-sup-ly1.tfm) \
tex(Archiv0-Regular-sup-ly1.vf) \
tex(Archiv0-Regular-sup-ot1.tfm) \
tex(Archiv0-Regular-sup-t1--base.tfm) \
tex(Archiv0-Regular-sup-t1.tfm) \
tex(Archiv0-Regular-sup-t1.vf) \
tex(Archiv0-Regular-tlf-ly1--base.tfm) \
tex(Archiv0-Regular-tlf-ly1.tfm) \
tex(Archiv0-Regular-tlf-ly1.vf) \
tex(Archiv0-Regular-tlf-ot1.tfm) \
tex(Archiv0-Regular-tlf-t1--base.tfm) \
tex(Archiv0-Regular-tlf-t1.tfm) \
tex(Archiv0-Regular-tlf-t1.vf) \
tex(Archiv0-Regular-tlf-ts1--base.tfm) \
tex(Archiv0-Regular-tlf-ts1.tfm) \
tex(Archiv0-Regular-tlf-ts1.vf) \
tex(Archiv0-Regular-tosf-ly1--base.tfm) \
tex(Archiv0-Regular-tosf-ly1.tfm) \
tex(Archiv0-Regular-tosf-ly1.vf) \
tex(Archiv0-Regular-tosf-ot1.tfm) \
tex(Archiv0-Regular-tosf-t1--base.tfm) \
tex(Archiv0-Regular-tosf-t1.tfm) \
tex(Archiv0-Regular-tosf-t1.vf) \
tex(Archiv0-Regular-tosf-ts1--base.tfm) \
tex(Archiv0-Regular-tosf-ts1.tfm) \
tex(Archiv0-Regular-tosf-ts1.vf) \
tex(Archiv0-SemiBold-lf-ly1--base.tfm) \
tex(Archiv0-SemiBold-lf-ly1.tfm) \
tex(Archiv0-SemiBold-lf-ly1.vf) \
tex(Archiv0-SemiBold-lf-ot1.tfm) \
tex(Archiv0-SemiBold-lf-t1--base.tfm) \
tex(Archiv0-SemiBold-lf-t1.tfm) \
tex(Archiv0-SemiBold-lf-t1.vf) \
tex(Archiv0-SemiBold-lf-ts1--base.tfm) \
tex(Archiv0-SemiBold-lf-ts1.tfm) \
tex(Archiv0-SemiBold-lf-ts1.vf) \
tex(Archiv0-SemiBold-osf-ly1--base.tfm) \
tex(Archiv0-SemiBold-osf-ly1.tfm) \
tex(Archiv0-SemiBold-osf-ly1.vf) \
tex(Archiv0-SemiBold-osf-ot1.tfm) \
tex(Archiv0-SemiBold-osf-t1--base.tfm) \
tex(Archiv0-SemiBold-osf-t1.tfm) \
tex(Archiv0-SemiBold-osf-t1.vf) \
tex(Archiv0-SemiBold-osf-ts1--base.tfm) \
tex(Archiv0-SemiBold-osf-ts1.tfm) \
tex(Archiv0-SemiBold-osf-ts1.vf) \
tex(Archiv0-SemiBold-sup-ly1--base.tfm) \
tex(Archiv0-SemiBold-sup-ly1.tfm) \
tex(Archiv0-SemiBold-sup-ly1.vf) \
tex(Archiv0-SemiBold-sup-ot1.tfm) \
tex(Archiv0-SemiBold-sup-t1--base.tfm) \
tex(Archiv0-SemiBold-sup-t1.tfm) \
tex(Archiv0-SemiBold-sup-t1.vf) \
tex(Archiv0-SemiBold-tlf-ly1--base.tfm) \
tex(Archiv0-SemiBold-tlf-ly1.tfm) \
tex(Archiv0-SemiBold-tlf-ly1.vf) \
tex(Archiv0-SemiBold-tlf-ot1.tfm) \
tex(Archiv0-SemiBold-tlf-t1--base.tfm) \
tex(Archiv0-SemiBold-tlf-t1.tfm) \
tex(Archiv0-SemiBold-tlf-t1.vf) \
tex(Archiv0-SemiBold-tlf-ts1--base.tfm) \
tex(Archiv0-SemiBold-tlf-ts1.tfm) \
tex(Archiv0-SemiBold-tlf-ts1.vf) \
tex(Archiv0-SemiBold-tosf-ly1--base.tfm) \
tex(Archiv0-SemiBold-tosf-ly1.tfm) \
tex(Archiv0-SemiBold-tosf-ly1.vf) \
tex(Archiv0-SemiBold-tosf-ot1.tfm) \
tex(Archiv0-SemiBold-tosf-t1--base.tfm) \
tex(Archiv0-SemiBold-tosf-t1.tfm) \
tex(Archiv0-SemiBold-tosf-t1.vf) \
tex(Archiv0-SemiBold-tosf-ts1--base.tfm) \
tex(Archiv0-SemiBold-tosf-ts1.tfm) \
tex(Archiv0-SemiBold-tosf-ts1.vf) \
tex(Archiv0-SemiBoldItalic-lf-ly1--base.tfm) \
tex(Archiv0-SemiBoldItalic-lf-ly1.tfm) \
tex(Archiv0-SemiBoldItalic-lf-ly1.vf) \
tex(Archiv0-SemiBoldItalic-lf-ot1.tfm) \
tex(Archiv0-SemiBoldItalic-lf-t1--base.tfm) \
tex(Archiv0-SemiBoldItalic-lf-t1.tfm) \
tex(Archiv0-SemiBoldItalic-lf-t1.vf) \
tex(Archiv0-SemiBoldItalic-lf-ts1--base.tfm) \
tex(Archiv0-SemiBoldItalic-lf-ts1.tfm) \
tex(Archiv0-SemiBoldItalic-lf-ts1.vf) \
tex(Archiv0-SemiBoldItalic-osf-ly1--base.tfm) \
tex(Archiv0-SemiBoldItalic-osf-ly1.tfm) \
tex(Archiv0-SemiBoldItalic-osf-ly1.vf) \
tex(Archiv0-SemiBoldItalic-osf-ot1.tfm) \
tex(Archiv0-SemiBoldItalic-osf-t1--base.tfm) \
tex(Archiv0-SemiBoldItalic-osf-t1.tfm) \
tex(Archiv0-SemiBoldItalic-osf-t1.vf) \
tex(Archiv0-SemiBoldItalic-osf-ts1--base.tfm) \
tex(Archiv0-SemiBoldItalic-osf-ts1.tfm) \
tex(Archiv0-SemiBoldItalic-osf-ts1.vf) \
tex(Archiv0-SemiBoldItalic-sup-ly1--base.tfm) \
tex(Archiv0-SemiBoldItalic-sup-ly1.tfm) \
tex(Archiv0-SemiBoldItalic-sup-ly1.vf) \
tex(Archiv0-SemiBoldItalic-sup-ot1.tfm) \
tex(Archiv0-SemiBoldItalic-sup-t1--base.tfm) \
tex(Archiv0-SemiBoldItalic-sup-t1.tfm) \
tex(Archiv0-SemiBoldItalic-sup-t1.vf) \
tex(Archiv0-SemiBoldItalic-tlf-ly1--base.tfm) \
tex(Archiv0-SemiBoldItalic-tlf-ly1.tfm) \
tex(Archiv0-SemiBoldItalic-tlf-ly1.vf) \
tex(Archiv0-SemiBoldItalic-tlf-ot1.tfm) \
tex(Archiv0-SemiBoldItalic-tlf-t1--base.tfm) \
tex(Archiv0-SemiBoldItalic-tlf-t1.tfm) \
tex(Archiv0-SemiBoldItalic-tlf-t1.vf) \
tex(Archiv0-SemiBoldItalic-tlf-ts1--base.tfm) \
tex(Archiv0-SemiBoldItalic-tlf-ts1.tfm) \
tex(Archiv0-SemiBoldItalic-tlf-ts1.vf) \
tex(Archiv0-SemiBoldItalic-tosf-ly1--base.tfm) \
tex(Archiv0-SemiBoldItalic-tosf-ly1.tfm) \
tex(Archiv0-SemiBoldItalic-tosf-ly1.vf) \
tex(Archiv0-SemiBoldItalic-tosf-ot1.tfm) \
tex(Archiv0-SemiBoldItalic-tosf-t1--base.tfm) \
tex(Archiv0-SemiBoldItalic-tosf-t1.tfm) \
tex(Archiv0-SemiBoldItalic-tosf-t1.vf) \
tex(Archiv0-SemiBoldItalic-tosf-ts1--base.tfm) \
tex(Archiv0-SemiBoldItalic-tosf-ts1.tfm) \
tex(Archiv0-SemiBoldItalic-tosf-ts1.vf) \
tex(ArchivZero.map) \
tex(Archivo.sty) \
tex(LY1ArchivZero-LF.fd) \
tex(LY1ArchivZero-OsF.fd) \
tex(LY1ArchivZero-Sup.fd) \
tex(LY1ArchivZero-TLF.fd) \
tex(LY1ArchivZero-TOsF.fd) \
tex(OT1ArchivZero-LF.fd) \
tex(OT1ArchivZero-OsF.fd) \
tex(OT1ArchivZero-Sup.fd) \
tex(OT1ArchivZero-TLF.fd) \
tex(OT1ArchivZero-TOsF.fd) \
tex(T1ArchivZero-LF.fd) \
tex(T1ArchivZero-OsF.fd) \
tex(T1ArchivZero-Sup.fd) \
tex(T1ArchivZero-TLF.fd) \
tex(T1ArchivZero-TOsF.fd) \
tex(TS1ArchivZero-LF.fd) \
tex(TS1ArchivZero-OsF.fd) \
tex(TS1ArchivZero-TLF.fd) \
tex(TS1ArchivZero-TOsF.fd) \
tex(a_24xxsv.enc) \
tex(a_5xld5w.enc) \
tex(a_7npxgm.enc) \
tex(a_fiyauo.enc) \
tex(a_flfbvu.enc) \
tex(a_lwgukc.enc) \
tex(a_lzhlbi.enc) \
tex(a_mq36jn.enc) \
tex(a_owzwzj.enc) \
tex(a_ttjzpe.enc) \
tex(a_utd4ik.enc) \
tex(a_vgwtwr.enc) \
tex(a_vqpkf5.enc) \
texlive-archivo"

RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex(fontaxes.sty) \
tex(fontenc.sty) \
tex(ifthen.sty) \
tex(mweights.sty) \
tex(textcomp.sty) \
tex(updmap.cfg) \
tex(xkeyval.sty) \
texlive \
texlive-archivo-fonts \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
