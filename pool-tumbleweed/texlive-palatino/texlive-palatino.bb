SUMMARY = "URW 'Base 35' font pack for LaTeX"
DESCRIPTION = "A set of fonts for use as 'drop-in' replacements for Adobe's \
basic set, comprising: Century Schoolbook (substituting for \
Adobe's New Century Schoolbook); Dingbats (substituting for \
Adobe's Zapf Dingbats); Nimbus Mono L (substituting for Abobe's \
Courier); Nimbus Roman No9 L (substituting for Adobe's Times); \
Nimbus Sans L (substituting for Adobe's Helvetica); Standard \
Symbols L (substituting for Adobe's Symbol); URW Bookman; URW \
Chancery L Medium Italic (substituting for Adobe's Zapf \
Chancery); URW Gothic L Book (substituting for Adobe's Avant \
Garde); and URW Palladio L (substituting for Adobe's Palatino)."
LICENSE = "GPL-2.0-or-later"

PV = "2023.201.svn61719"

RPM_NAME = "texlive-palatino-2023.201.svn61719-51.1.noarch.rpm"
RPM_HASH = "1acf607bfa98ed52e06b12732a390cc74f992288546654f01d0d3bd4532fea89b5340c1a9e2fd40e0299cf4a0a0885a5c612d6f13fd9409dd4460da4dad852b6"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-8rupl.fd \
tex-eurbo10.tfm \
tex-eurmo10.tfm \
tex-omlupl.fd \
tex-omsupl.fd \
tex-ot1upl.fd \
tex-pplb.tfm \
tex-pplb.vf \
tex-pplb7t.tfm \
tex-pplb7t.vf \
tex-pplb8c.tfm \
tex-pplb8c.vf \
tex-pplb8r.tfm \
tex-pplb8t.tfm \
tex-pplb8t.vf \
tex-pplb9c.tfm \
tex-pplb9c.vf \
tex-pplb9d.tfm \
tex-pplb9d.vf \
tex-pplb9e.tfm \
tex-pplb9e.vf \
tex-pplb9o.tfm \
tex-pplb9o.vf \
tex-pplb9t.tfm \
tex-pplb9t.vf \
tex-pplbc.tfm \
tex-pplbc.vf \
tex-pplbc7t.tfm \
tex-pplbc7t.vf \
tex-pplbc8t.tfm \
tex-pplbc8t.vf \
tex-pplbi.tfm \
tex-pplbi.vf \
tex-pplbi7t.tfm \
tex-pplbi7t.vf \
tex-pplbi8c.tfm \
tex-pplbi8c.vf \
tex-pplbi8r.tfm \
tex-pplbi8t.tfm \
tex-pplbi8t.vf \
tex-pplbi9c.tfm \
tex-pplbi9c.vf \
tex-pplbi9d.tfm \
tex-pplbi9d.vf \
tex-pplbi9e.tfm \
tex-pplbi9e.vf \
tex-pplbi9o.tfm \
tex-pplbi9o.vf \
tex-pplbi9t.tfm \
tex-pplbi9t.vf \
tex-pplbij8r.tfm \
tex-pplbj8r.tfm \
tex-pplbo.tfm \
tex-pplbo.vf \
tex-pplbo7t.tfm \
tex-pplbo7t.vf \
tex-pplbo8c.tfm \
tex-pplbo8c.vf \
tex-pplbo8r.tfm \
tex-pplbo8t.tfm \
tex-pplbo8t.vf \
tex-pplbu.tfm \
tex-pplbu.vf \
tex-pplbu8r.tfm \
tex-pplr.tfm \
tex-pplr.vf \
tex-pplr7t.tfm \
tex-pplr7t.vf \
tex-pplr8c.tfm \
tex-pplr8c.vf \
tex-pplr8r.tfm \
tex-pplr8rn.tfm \
tex-pplr8t.tfm \
tex-pplr8t.vf \
tex-pplr9c.tfm \
tex-pplr9c.vf \
tex-pplr9d.tfm \
tex-pplr9d.vf \
tex-pplr9e.tfm \
tex-pplr9e.vf \
tex-pplr9o.tfm \
tex-pplr9o.vf \
tex-pplr9t.tfm \
tex-pplr9t.vf \
tex-pplrc.tfm \
tex-pplrc.vf \
tex-pplrc7t.tfm \
tex-pplrc7t.vf \
tex-pplrc8r.tfm \
tex-pplrc8t.tfm \
tex-pplrc8t.vf \
tex-pplrc9d.tfm \
tex-pplrc9d.vf \
tex-pplrc9e.tfm \
tex-pplrc9e.vf \
tex-pplrc9o.tfm \
tex-pplrc9o.vf \
tex-pplrc9t.tfm \
tex-pplrc9t.vf \
tex-pplri.tfm \
tex-pplri.vf \
tex-pplri7t.tfm \
tex-pplri7t.vf \
tex-pplri8c.tfm \
tex-pplri8c.vf \
tex-pplri8r.tfm \
tex-pplri8t.tfm \
tex-pplri8t.vf \
tex-pplri9c.tfm \
tex-pplri9c.vf \
tex-pplri9d.tfm \
tex-pplri9d.vf \
tex-pplri9e.tfm \
tex-pplri9e.vf \
tex-pplri9o.tfm \
tex-pplri9o.vf \
tex-pplri9t.tfm \
tex-pplri9t.vf \
tex-pplrij8r.tfm \
tex-pplro.tfm \
tex-pplro.vf \
tex-pplro7t.tfm \
tex-pplro7t.vf \
tex-pplro8c.tfm \
tex-pplro8c.vf \
tex-pplro8r.tfm \
tex-pplro8t.tfm \
tex-pplro8t.vf \
tex-pplrr8re.tfm \
tex-pplrre.tfm \
tex-pplrre.vf \
tex-pplrrn.tfm \
tex-pplrrn.vf \
tex-pplru.tfm \
tex-pplru.vf \
tex-pplru8r.tfm \
tex-t1upl.fd \
tex-ts1upl.fd \
tex-upl.map \
tex-uplb7t.tfm \
tex-uplb7t.vf \
tex-uplb8c.tfm \
tex-uplb8c.vf \
tex-uplb8r.tfm \
tex-uplb8t.tfm \
tex-uplb8t.vf \
tex-uplbc7t.tfm \
tex-uplbc7t.vf \
tex-uplbc8t.tfm \
tex-uplbc8t.vf \
tex-uplbi7t.tfm \
tex-uplbi7t.vf \
tex-uplbi8c.tfm \
tex-uplbi8c.vf \
tex-uplbi8r.tfm \
tex-uplbi8t.tfm \
tex-uplbi8t.vf \
tex-uplbo7t.tfm \
tex-uplbo7t.vf \
tex-uplbo8c.tfm \
tex-uplbo8c.vf \
tex-uplbo8r.tfm \
tex-uplbo8t.tfm \
tex-uplbo8t.vf \
tex-uplr7t.tfm \
tex-uplr7t.vf \
tex-uplr8c.tfm \
tex-uplr8c.vf \
tex-uplr8r.tfm \
tex-uplr8t.tfm \
tex-uplr8t.vf \
tex-uplrc7t.tfm \
tex-uplrc7t.vf \
tex-uplrc8t.tfm \
tex-uplrc8t.vf \
tex-uplri7t.tfm \
tex-uplri7t.vf \
tex-uplri8c.tfm \
tex-uplri8c.vf \
tex-uplri8r.tfm \
tex-uplri8t.tfm \
tex-uplri8t.vf \
tex-uplro7t.tfm \
tex-uplro7t.vf \
tex-uplro8c.tfm \
tex-uplro8c.vf \
tex-uplro8r.tfm \
tex-uplro8t.tfm \
tex-uplro8t.vf \
tex-zppleb7m.tfm \
tex-zppleb7m.vf \
tex-zppleb7t.tfm \
tex-zppleb7t.vf \
tex-zppleb7y.tfm \
tex-zppleb7y.vf \
tex-zppler7m.tfm \
tex-zppler7m.vf \
tex-zppler7t.tfm \
tex-zppler7t.vf \
tex-zppler7v.tfm \
tex-zppler7v.vf \
tex-zppler7y.tfm \
tex-zppler7y.vf \
texlive-palatino"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-cmbsy10.tfm \
tex-cmbx10.tfm \
tex-cmex10.tfm \
tex-cmmi10.tfm \
tex-cmmib10.tfm \
tex-cmr10.tfm \
tex-cmsy10.tfm \
tex-euex10.tfm \
tex-eurb10.tfm \
tex-eurm10.tfm \
tex-eusb10.tfm \
tex-eusm10.tfm \
tex-fplmb.tfm \
tex-fplmbi.tfm \
tex-fplmr.tfm \
tex-fplmri.tfm \
tex-psyr.tfm \
tex-updmap.cfg \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-palatino-fonts \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
