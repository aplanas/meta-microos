SUMMARY = "A kernel module to create V4L2 loopback devices"
DESCRIPTION = "This module allows you to create 'virtual video devices'. Normal (v4l2) \
applications will read these devices as if they were ordinary video \
devices, but the video will not be read from e.g. a capture card but \
instead it is generated by another application."
LICENSE = "GPL-2.0-or-later"

PV = "0.12.7_k6.3.9_1"

RPM_NAME = "v4l2loopback-kmp-64kb-0.12.7_k6.3.9_1-1.45.aarch64.rpm"
RPM_HASH = "2860da3b89efe47b23bd3780055b4f90a44bb814378545ee8ba0214238d4be4d7ffd5ce8c1e0fbd1fac71e65ce6733e60b8eac252021d5ae28bc320ff490a5f9"

RPROVIDES:${PN} += "kmod-v4l2loopback.ko \
multiversion-kernel \
v4l2loopback-kmp \
v4l2loopback-kmp-64kb \
v4l2loopback-kmp-64kb-k6.3.9-1"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
grep \
kernel-64kb \
kernel-uname-r \
suse-kernel-rpm-scriptlets"

inherit rpm
