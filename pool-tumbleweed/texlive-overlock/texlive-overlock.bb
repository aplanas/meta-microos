SUMMARY = "Overlock sans fonts with LaTeX support"
DESCRIPTION = "The package provides the Overlock and OverlockSC families of \
fonts, designed by Dario Manuel Muhafara of the TIPO foundry \
(http://www.tipo.net.ar), 'rounded' sans-serif fonts in three \
weights (Regular, Bold, Black) with italic variants for each of \
them. There are also small-caps and old-style figures in the \
Regular weight."
LICENSE = "OFL-1.1"

PV = "2023.201.svn64495"

RPM_NAME = "texlive-overlock-2023.201.svn64495-51.1.noarch.rpm"
RPM_HASH = "947300338737d36ffaf2d32bd1946e3a19ad7ca7c2feea13bbe05f8db45770c5c035f597c9d42ba858e42588ddb90b3000702f166d7a936680f4ab22b557ab71"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-LY1Ovrlck-LF.fd \
tex-LY1Ovrlck-OsF.fd \
tex-OT1Ovrlck-LF.fd \
tex-OT1Ovrlck-OsF.fd \
tex-Ovrlck-Black-lf-ly1--base.tfm \
tex-Ovrlck-Black-lf-ly1--lcdfj.tfm \
tex-Ovrlck-Black-lf-ly1.tfm \
tex-Ovrlck-Black-lf-ly1.vf \
tex-Ovrlck-Black-lf-ot1--base.tfm \
tex-Ovrlck-Black-lf-ot1--lcdfj.tfm \
tex-Ovrlck-Black-lf-ot1.tfm \
tex-Ovrlck-Black-lf-ot1.vf \
tex-Ovrlck-Black-lf-t1--base.tfm \
tex-Ovrlck-Black-lf-t1--lcdfj.tfm \
tex-Ovrlck-Black-lf-t1.tfm \
tex-Ovrlck-Black-lf-t1.vf \
tex-Ovrlck-Black-lf-ts1--base.tfm \
tex-Ovrlck-Black-lf-ts1.tfm \
tex-Ovrlck-Black-lf-ts1.vf \
tex-Ovrlck-Black-osf-ly1--base.tfm \
tex-Ovrlck-Black-osf-ly1--lcdfj.tfm \
tex-Ovrlck-Black-osf-ly1.tfm \
tex-Ovrlck-Black-osf-ly1.vf \
tex-Ovrlck-Black-osf-ot1--base.tfm \
tex-Ovrlck-Black-osf-ot1--lcdfj.tfm \
tex-Ovrlck-Black-osf-ot1.tfm \
tex-Ovrlck-Black-osf-ot1.vf \
tex-Ovrlck-Black-osf-t1--base.tfm \
tex-Ovrlck-Black-osf-t1--lcdfj.tfm \
tex-Ovrlck-Black-osf-t1.tfm \
tex-Ovrlck-Black-osf-t1.vf \
tex-Ovrlck-Black-osf-ts1--base.tfm \
tex-Ovrlck-Black-osf-ts1.tfm \
tex-Ovrlck-Black-osf-ts1.vf \
tex-Ovrlck-BlackItalic-lf-ly1--base.tfm \
tex-Ovrlck-BlackItalic-lf-ly1--lcdfj.tfm \
tex-Ovrlck-BlackItalic-lf-ly1.tfm \
tex-Ovrlck-BlackItalic-lf-ly1.vf \
tex-Ovrlck-BlackItalic-lf-ot1--base.tfm \
tex-Ovrlck-BlackItalic-lf-ot1--lcdfj.tfm \
tex-Ovrlck-BlackItalic-lf-ot1.tfm \
tex-Ovrlck-BlackItalic-lf-ot1.vf \
tex-Ovrlck-BlackItalic-lf-t1--base.tfm \
tex-Ovrlck-BlackItalic-lf-t1--lcdfj.tfm \
tex-Ovrlck-BlackItalic-lf-t1.tfm \
tex-Ovrlck-BlackItalic-lf-t1.vf \
tex-Ovrlck-BlackItalic-lf-ts1--base.tfm \
tex-Ovrlck-BlackItalic-lf-ts1.tfm \
tex-Ovrlck-BlackItalic-lf-ts1.vf \
tex-Ovrlck-BlackItalic-osf-ly1--base.tfm \
tex-Ovrlck-BlackItalic-osf-ly1--lcdfj.tfm \
tex-Ovrlck-BlackItalic-osf-ly1.tfm \
tex-Ovrlck-BlackItalic-osf-ly1.vf \
tex-Ovrlck-BlackItalic-osf-ot1--base.tfm \
tex-Ovrlck-BlackItalic-osf-ot1--lcdfj.tfm \
tex-Ovrlck-BlackItalic-osf-ot1.tfm \
tex-Ovrlck-BlackItalic-osf-ot1.vf \
tex-Ovrlck-BlackItalic-osf-t1--base.tfm \
tex-Ovrlck-BlackItalic-osf-t1--lcdfj.tfm \
tex-Ovrlck-BlackItalic-osf-t1.tfm \
tex-Ovrlck-BlackItalic-osf-t1.vf \
tex-Ovrlck-BlackItalic-osf-ts1--base.tfm \
tex-Ovrlck-BlackItalic-osf-ts1.tfm \
tex-Ovrlck-BlackItalic-osf-ts1.vf \
tex-Ovrlck-Bold-lf-ly1--base.tfm \
tex-Ovrlck-Bold-lf-ly1--lcdfj.tfm \
tex-Ovrlck-Bold-lf-ly1.tfm \
tex-Ovrlck-Bold-lf-ly1.vf \
tex-Ovrlck-Bold-lf-ot1--base.tfm \
tex-Ovrlck-Bold-lf-ot1--lcdfj.tfm \
tex-Ovrlck-Bold-lf-ot1.tfm \
tex-Ovrlck-Bold-lf-ot1.vf \
tex-Ovrlck-Bold-lf-t1--base.tfm \
tex-Ovrlck-Bold-lf-t1--lcdfj.tfm \
tex-Ovrlck-Bold-lf-t1.tfm \
tex-Ovrlck-Bold-lf-t1.vf \
tex-Ovrlck-Bold-lf-ts1--base.tfm \
tex-Ovrlck-Bold-lf-ts1.tfm \
tex-Ovrlck-Bold-lf-ts1.vf \
tex-Ovrlck-Bold-osf-ly1--base.tfm \
tex-Ovrlck-Bold-osf-ly1--lcdfj.tfm \
tex-Ovrlck-Bold-osf-ly1.tfm \
tex-Ovrlck-Bold-osf-ly1.vf \
tex-Ovrlck-Bold-osf-ot1--base.tfm \
tex-Ovrlck-Bold-osf-ot1--lcdfj.tfm \
tex-Ovrlck-Bold-osf-ot1.tfm \
tex-Ovrlck-Bold-osf-ot1.vf \
tex-Ovrlck-Bold-osf-t1--base.tfm \
tex-Ovrlck-Bold-osf-t1--lcdfj.tfm \
tex-Ovrlck-Bold-osf-t1.tfm \
tex-Ovrlck-Bold-osf-t1.vf \
tex-Ovrlck-Bold-osf-ts1--base.tfm \
tex-Ovrlck-Bold-osf-ts1.tfm \
tex-Ovrlck-Bold-osf-ts1.vf \
tex-Ovrlck-BoldItalic-lf-ly1--base.tfm \
tex-Ovrlck-BoldItalic-lf-ly1--lcdfj.tfm \
tex-Ovrlck-BoldItalic-lf-ly1.tfm \
tex-Ovrlck-BoldItalic-lf-ly1.vf \
tex-Ovrlck-BoldItalic-lf-ot1--base.tfm \
tex-Ovrlck-BoldItalic-lf-ot1--lcdfj.tfm \
tex-Ovrlck-BoldItalic-lf-ot1.tfm \
tex-Ovrlck-BoldItalic-lf-ot1.vf \
tex-Ovrlck-BoldItalic-lf-t1--base.tfm \
tex-Ovrlck-BoldItalic-lf-t1--lcdfj.tfm \
tex-Ovrlck-BoldItalic-lf-t1.tfm \
tex-Ovrlck-BoldItalic-lf-t1.vf \
tex-Ovrlck-BoldItalic-lf-ts1--base.tfm \
tex-Ovrlck-BoldItalic-lf-ts1.tfm \
tex-Ovrlck-BoldItalic-lf-ts1.vf \
tex-Ovrlck-BoldItalic-osf-ly1--base.tfm \
tex-Ovrlck-BoldItalic-osf-ly1--lcdfj.tfm \
tex-Ovrlck-BoldItalic-osf-ly1.tfm \
tex-Ovrlck-BoldItalic-osf-ly1.vf \
tex-Ovrlck-BoldItalic-osf-ot1--base.tfm \
tex-Ovrlck-BoldItalic-osf-ot1--lcdfj.tfm \
tex-Ovrlck-BoldItalic-osf-ot1.tfm \
tex-Ovrlck-BoldItalic-osf-ot1.vf \
tex-Ovrlck-BoldItalic-osf-t1--base.tfm \
tex-Ovrlck-BoldItalic-osf-t1--lcdfj.tfm \
tex-Ovrlck-BoldItalic-osf-t1.tfm \
tex-Ovrlck-BoldItalic-osf-t1.vf \
tex-Ovrlck-BoldItalic-osf-ts1--base.tfm \
tex-Ovrlck-BoldItalic-osf-ts1.tfm \
tex-Ovrlck-BoldItalic-osf-ts1.vf \
tex-Ovrlck-Italic-lf-ly1--base.tfm \
tex-Ovrlck-Italic-lf-ly1--lcdfj.tfm \
tex-Ovrlck-Italic-lf-ly1.tfm \
tex-Ovrlck-Italic-lf-ly1.vf \
tex-Ovrlck-Italic-lf-ot1--base.tfm \
tex-Ovrlck-Italic-lf-ot1--lcdfj.tfm \
tex-Ovrlck-Italic-lf-ot1.tfm \
tex-Ovrlck-Italic-lf-ot1.vf \
tex-Ovrlck-Italic-lf-t1--base.tfm \
tex-Ovrlck-Italic-lf-t1--lcdfj.tfm \
tex-Ovrlck-Italic-lf-t1.tfm \
tex-Ovrlck-Italic-lf-t1.vf \
tex-Ovrlck-Italic-lf-ts1--base.tfm \
tex-Ovrlck-Italic-lf-ts1.tfm \
tex-Ovrlck-Italic-lf-ts1.vf \
tex-Ovrlck-Italic-osf-ly1--base.tfm \
tex-Ovrlck-Italic-osf-ly1--lcdfj.tfm \
tex-Ovrlck-Italic-osf-ly1.tfm \
tex-Ovrlck-Italic-osf-ly1.vf \
tex-Ovrlck-Italic-osf-ot1--base.tfm \
tex-Ovrlck-Italic-osf-ot1--lcdfj.tfm \
tex-Ovrlck-Italic-osf-ot1.tfm \
tex-Ovrlck-Italic-osf-ot1.vf \
tex-Ovrlck-Italic-osf-t1--base.tfm \
tex-Ovrlck-Italic-osf-t1--lcdfj.tfm \
tex-Ovrlck-Italic-osf-t1.tfm \
tex-Ovrlck-Italic-osf-t1.vf \
tex-Ovrlck-Italic-osf-ts1--base.tfm \
tex-Ovrlck-Italic-osf-ts1.tfm \
tex-Ovrlck-Italic-osf-ts1.vf \
tex-Ovrlck-Regular-lf-ly1--base.tfm \
tex-Ovrlck-Regular-lf-ly1--lcdfj.tfm \
tex-Ovrlck-Regular-lf-ly1.tfm \
tex-Ovrlck-Regular-lf-ly1.vf \
tex-Ovrlck-Regular-lf-ot1--base.tfm \
tex-Ovrlck-Regular-lf-ot1--lcdfj.tfm \
tex-Ovrlck-Regular-lf-ot1.tfm \
tex-Ovrlck-Regular-lf-ot1.vf \
tex-Ovrlck-Regular-lf-sc-ly1--base.tfm \
tex-Ovrlck-Regular-lf-sc-ly1--lcdfj.tfm \
tex-Ovrlck-Regular-lf-sc-ly1.tfm \
tex-Ovrlck-Regular-lf-sc-ly1.vf \
tex-Ovrlck-Regular-lf-sc-ot1--base.tfm \
tex-Ovrlck-Regular-lf-sc-ot1--lcdfj.tfm \
tex-Ovrlck-Regular-lf-sc-ot1.tfm \
tex-Ovrlck-Regular-lf-sc-ot1.vf \
tex-Ovrlck-Regular-lf-sc-t1--base.tfm \
tex-Ovrlck-Regular-lf-sc-t1--lcdfj.tfm \
tex-Ovrlck-Regular-lf-sc-t1.tfm \
tex-Ovrlck-Regular-lf-sc-t1.vf \
tex-Ovrlck-Regular-lf-t1--base.tfm \
tex-Ovrlck-Regular-lf-t1--lcdfj.tfm \
tex-Ovrlck-Regular-lf-t1.tfm \
tex-Ovrlck-Regular-lf-t1.vf \
tex-Ovrlck-Regular-lf-ts1--base.tfm \
tex-Ovrlck-Regular-lf-ts1.tfm \
tex-Ovrlck-Regular-lf-ts1.vf \
tex-Ovrlck-Regular-osf-ly1--base.tfm \
tex-Ovrlck-Regular-osf-ly1--lcdfj.tfm \
tex-Ovrlck-Regular-osf-ly1.tfm \
tex-Ovrlck-Regular-osf-ly1.vf \
tex-Ovrlck-Regular-osf-ot1--base.tfm \
tex-Ovrlck-Regular-osf-ot1--lcdfj.tfm \
tex-Ovrlck-Regular-osf-ot1.tfm \
tex-Ovrlck-Regular-osf-ot1.vf \
tex-Ovrlck-Regular-osf-sc-ly1--base.tfm \
tex-Ovrlck-Regular-osf-sc-ly1--lcdfj.tfm \
tex-Ovrlck-Regular-osf-sc-ly1.tfm \
tex-Ovrlck-Regular-osf-sc-ly1.vf \
tex-Ovrlck-Regular-osf-sc-ot1--base.tfm \
tex-Ovrlck-Regular-osf-sc-ot1--lcdfj.tfm \
tex-Ovrlck-Regular-osf-sc-ot1.tfm \
tex-Ovrlck-Regular-osf-sc-ot1.vf \
tex-Ovrlck-Regular-osf-sc-t1--base.tfm \
tex-Ovrlck-Regular-osf-sc-t1--lcdfj.tfm \
tex-Ovrlck-Regular-osf-sc-t1.tfm \
tex-Ovrlck-Regular-osf-sc-t1.vf \
tex-Ovrlck-Regular-osf-t1--base.tfm \
tex-Ovrlck-Regular-osf-t1--lcdfj.tfm \
tex-Ovrlck-Regular-osf-t1.tfm \
tex-Ovrlck-Regular-osf-t1.vf \
tex-Ovrlck-Regular-osf-ts1--base.tfm \
tex-Ovrlck-Regular-osf-ts1.tfm \
tex-Ovrlck-Regular-osf-ts1.vf \
tex-T1Ovrlck-LF.fd \
tex-T1Ovrlck-OsF.fd \
tex-TS1Ovrlck-LF.fd \
tex-TS1Ovrlck-OsF.fd \
tex-overlock.map \
tex-overlock.sty \
tex-ovrlck-2sdgnb.enc \
tex-ovrlck-325tkf.enc \
tex-ovrlck-7l4e47.enc \
tex-ovrlck-a4aghc.enc \
tex-ovrlck-bhbhyo.enc \
tex-ovrlck-cj365g.enc \
tex-ovrlck-cr35rj.enc \
tex-ovrlck-e3j4ia.enc \
tex-ovrlck-fqfhhf.enc \
tex-ovrlck-gmmlzo.enc \
tex-ovrlck-irzqhk.enc \
tex-ovrlck-j3mq5n.enc \
tex-ovrlck-k2npiy.enc \
tex-ovrlck-lhx5go.enc \
tex-ovrlck-lqqrub.enc \
tex-ovrlck-siy5zo.enc \
tex-ovrlck-tmoia5.enc \
tex-ovrlck-vvi6px.enc \
tex-ovrlck-woxjio.enc \
texlive-overlock"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontaxes.sty \
tex-fontenc.sty \
tex-fontspec.sty \
tex-ifluatex.sty \
tex-ifxetex.sty \
tex-mweights.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-overlock-fonts \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
