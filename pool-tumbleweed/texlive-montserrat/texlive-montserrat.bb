SUMMARY = "Montserrat sans serif, otf and pfb, with LaTeX support files"
DESCRIPTION = "Montserrat is a geometric sans-serif typeface designed by \
Julieta Ulanovsky, inspired by posters and signage from her \
historical Buenos Aires neighborhood of the same name. It is \
rather close in spirit to Gotham and Proxima Nova, but has its \
own individual appearance -- more informal, less extended, and \
more idiosyncratic. It is provided in a total of nine different \
weights, each having eight figure styles and small caps in both \
upright and italic shapes. There are two quite different \
versions that don't fit into the usual LaTeX classifications. \
The version having the appellation 'Alternates' has letter \
shapes that are much more rounded than the default version, \
reflecting the signage in the neighborhood of Montserrat."
LICENSE = "OFL-1.1"

PV = "2023.201.1.03svn54512"

RPM_NAME = "texlive-montserrat-2023.201.1.03svn54512-54.1.noarch.rpm"
RPM_HASH = "7e18bce002dd05966985b5d219769bded2139f2fbb8e43fc2bd6d88f56eb346a3a65d7f33ea86d3114142ee1d535db11af4625f3f0009ba98158476910603d40"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-LY1Montserrat-Dnom.fd \
tex-LY1Montserrat-Inf.fd \
tex-LY1Montserrat-LF.fd \
tex-LY1Montserrat-Numr.fd \
tex-LY1Montserrat-OsF.fd \
tex-LY1Montserrat-Sup.fd \
tex-LY1Montserrat-TLF.fd \
tex-LY1Montserrat-TOsF.fd \
tex-LY1MontserratAlternates-Dnom.fd \
tex-LY1MontserratAlternates-Inf.fd \
tex-LY1MontserratAlternates-LF.fd \
tex-LY1MontserratAlternates-Numr.fd \
tex-LY1MontserratAlternates-OsF.fd \
tex-LY1MontserratAlternates-Sup.fd \
tex-LY1MontserratAlternates-TLF.fd \
tex-LY1MontserratAlternates-TOsF.fd \
tex-Montserrat-Black-dnom-ly1--base.tfm \
tex-Montserrat-Black-dnom-ly1.tfm \
tex-Montserrat-Black-dnom-ly1.vf \
tex-Montserrat-Black-dnom-ot1.tfm \
tex-Montserrat-Black-dnom-t1--base.tfm \
tex-Montserrat-Black-dnom-t1.tfm \
tex-Montserrat-Black-dnom-t1.vf \
tex-Montserrat-Black-inf-ly1--base.tfm \
tex-Montserrat-Black-inf-ly1.tfm \
tex-Montserrat-Black-inf-ly1.vf \
tex-Montserrat-Black-inf-ot1.tfm \
tex-Montserrat-Black-inf-t1--base.tfm \
tex-Montserrat-Black-inf-t1.tfm \
tex-Montserrat-Black-inf-t1.vf \
tex-Montserrat-Black-lf-ly1--base.tfm \
tex-Montserrat-Black-lf-ly1.tfm \
tex-Montserrat-Black-lf-ly1.vf \
tex-Montserrat-Black-lf-ot1.tfm \
tex-Montserrat-Black-lf-sc-ly1--base.tfm \
tex-Montserrat-Black-lf-sc-ly1.tfm \
tex-Montserrat-Black-lf-sc-ly1.vf \
tex-Montserrat-Black-lf-sc-ot1--base.tfm \
tex-Montserrat-Black-lf-sc-ot1.tfm \
tex-Montserrat-Black-lf-sc-ot1.vf \
tex-Montserrat-Black-lf-sc-t1--base.tfm \
tex-Montserrat-Black-lf-sc-t1.tfm \
tex-Montserrat-Black-lf-sc-t1.vf \
tex-Montserrat-Black-lf-t1--base.tfm \
tex-Montserrat-Black-lf-t1.tfm \
tex-Montserrat-Black-lf-t1.vf \
tex-Montserrat-Black-lf-ts1--base.tfm \
tex-Montserrat-Black-lf-ts1.tfm \
tex-Montserrat-Black-lf-ts1.vf \
tex-Montserrat-Black-numr-ly1--base.tfm \
tex-Montserrat-Black-numr-ly1.tfm \
tex-Montserrat-Black-numr-ly1.vf \
tex-Montserrat-Black-numr-ot1.tfm \
tex-Montserrat-Black-numr-t1--base.tfm \
tex-Montserrat-Black-numr-t1.tfm \
tex-Montserrat-Black-numr-t1.vf \
tex-Montserrat-Black-osf-ly1--base.tfm \
tex-Montserrat-Black-osf-ly1.tfm \
tex-Montserrat-Black-osf-ly1.vf \
tex-Montserrat-Black-osf-ot1.tfm \
tex-Montserrat-Black-osf-sc-ly1--base.tfm \
tex-Montserrat-Black-osf-sc-ly1.tfm \
tex-Montserrat-Black-osf-sc-ly1.vf \
tex-Montserrat-Black-osf-sc-ot1--base.tfm \
tex-Montserrat-Black-osf-sc-ot1.tfm \
tex-Montserrat-Black-osf-sc-ot1.vf \
tex-Montserrat-Black-osf-sc-t1--base.tfm \
tex-Montserrat-Black-osf-sc-t1.tfm \
tex-Montserrat-Black-osf-sc-t1.vf \
tex-Montserrat-Black-osf-t1--base.tfm \
tex-Montserrat-Black-osf-t1.tfm \
tex-Montserrat-Black-osf-t1.vf \
tex-Montserrat-Black-osf-ts1--base.tfm \
tex-Montserrat-Black-osf-ts1.tfm \
tex-Montserrat-Black-osf-ts1.vf \
tex-Montserrat-Black-sup-ly1--base.tfm \
tex-Montserrat-Black-sup-ly1.tfm \
tex-Montserrat-Black-sup-ly1.vf \
tex-Montserrat-Black-sup-ot1.tfm \
tex-Montserrat-Black-sup-t1--base.tfm \
tex-Montserrat-Black-sup-t1.tfm \
tex-Montserrat-Black-sup-t1.vf \
tex-Montserrat-Black-tlf-ly1--base.tfm \
tex-Montserrat-Black-tlf-ly1.tfm \
tex-Montserrat-Black-tlf-ly1.vf \
tex-Montserrat-Black-tlf-ot1.tfm \
tex-Montserrat-Black-tlf-sc-ly1--base.tfm \
tex-Montserrat-Black-tlf-sc-ly1.tfm \
tex-Montserrat-Black-tlf-sc-ly1.vf \
tex-Montserrat-Black-tlf-sc-ot1--base.tfm \
tex-Montserrat-Black-tlf-sc-ot1.tfm \
tex-Montserrat-Black-tlf-sc-ot1.vf \
tex-Montserrat-Black-tlf-sc-t1--base.tfm \
tex-Montserrat-Black-tlf-sc-t1.tfm \
tex-Montserrat-Black-tlf-sc-t1.vf \
tex-Montserrat-Black-tlf-t1--base.tfm \
tex-Montserrat-Black-tlf-t1.tfm \
tex-Montserrat-Black-tlf-t1.vf \
tex-Montserrat-Black-tlf-ts1--base.tfm \
tex-Montserrat-Black-tlf-ts1.tfm \
tex-Montserrat-Black-tlf-ts1.vf \
tex-Montserrat-Black-tosf-ly1--base.tfm \
tex-Montserrat-Black-tosf-ly1.tfm \
tex-Montserrat-Black-tosf-ly1.vf \
tex-Montserrat-Black-tosf-ot1.tfm \
tex-Montserrat-Black-tosf-sc-ly1--base.tfm \
tex-Montserrat-Black-tosf-sc-ly1.tfm \
tex-Montserrat-Black-tosf-sc-ly1.vf \
tex-Montserrat-Black-tosf-sc-ot1--base.tfm \
tex-Montserrat-Black-tosf-sc-ot1.tfm \
tex-Montserrat-Black-tosf-sc-ot1.vf \
tex-Montserrat-Black-tosf-sc-t1--base.tfm \
tex-Montserrat-Black-tosf-sc-t1.tfm \
tex-Montserrat-Black-tosf-sc-t1.vf \
tex-Montserrat-Black-tosf-t1--base.tfm \
tex-Montserrat-Black-tosf-t1.tfm \
tex-Montserrat-Black-tosf-t1.vf \
tex-Montserrat-Black-tosf-ts1--base.tfm \
tex-Montserrat-Black-tosf-ts1.tfm \
tex-Montserrat-Black-tosf-ts1.vf \
tex-Montserrat-BlackItalic-dnom-ly1--base.tfm \
tex-Montserrat-BlackItalic-dnom-ly1.tfm \
tex-Montserrat-BlackItalic-dnom-ly1.vf \
tex-Montserrat-BlackItalic-dnom-ot1.tfm \
tex-Montserrat-BlackItalic-dnom-t1--base.tfm \
tex-Montserrat-BlackItalic-dnom-t1.tfm \
tex-Montserrat-BlackItalic-dnom-t1.vf \
tex-Montserrat-BlackItalic-inf-ly1--base.tfm \
tex-Montserrat-BlackItalic-inf-ly1.tfm \
tex-Montserrat-BlackItalic-inf-ly1.vf \
tex-Montserrat-BlackItalic-inf-ot1.tfm \
tex-Montserrat-BlackItalic-inf-t1--base.tfm \
tex-Montserrat-BlackItalic-inf-t1.tfm \
tex-Montserrat-BlackItalic-inf-t1.vf \
tex-Montserrat-BlackItalic-lf-ly1--base.tfm \
tex-Montserrat-BlackItalic-lf-ly1.tfm \
tex-Montserrat-BlackItalic-lf-ly1.vf \
tex-Montserrat-BlackItalic-lf-ot1.tfm \
tex-Montserrat-BlackItalic-lf-sc-ly1--base.tfm \
tex-Montserrat-BlackItalic-lf-sc-ly1.tfm \
tex-Montserrat-BlackItalic-lf-sc-ly1.vf \
tex-Montserrat-BlackItalic-lf-sc-ot1--base.tfm \
tex-Montserrat-BlackItalic-lf-sc-ot1.tfm \
tex-Montserrat-BlackItalic-lf-sc-ot1.vf \
tex-Montserrat-BlackItalic-lf-sc-t1--base.tfm \
tex-Montserrat-BlackItalic-lf-sc-t1.tfm \
tex-Montserrat-BlackItalic-lf-sc-t1.vf \
tex-Montserrat-BlackItalic-lf-t1--base.tfm \
tex-Montserrat-BlackItalic-lf-t1.tfm \
tex-Montserrat-BlackItalic-lf-t1.vf \
tex-Montserrat-BlackItalic-lf-ts1--base.tfm \
tex-Montserrat-BlackItalic-lf-ts1.tfm \
tex-Montserrat-BlackItalic-lf-ts1.vf \
tex-Montserrat-BlackItalic-numr-ly1--base.tfm \
tex-Montserrat-BlackItalic-numr-ly1.tfm \
tex-Montserrat-BlackItalic-numr-ly1.vf \
tex-Montserrat-BlackItalic-numr-ot1.tfm \
tex-Montserrat-BlackItalic-numr-t1--base.tfm \
tex-Montserrat-BlackItalic-numr-t1.tfm \
tex-Montserrat-BlackItalic-numr-t1.vf \
tex-Montserrat-BlackItalic-osf-ly1--base.tfm \
tex-Montserrat-BlackItalic-osf-ly1.tfm \
tex-Montserrat-BlackItalic-osf-ly1.vf \
tex-Montserrat-BlackItalic-osf-ot1.tfm \
tex-Montserrat-BlackItalic-osf-sc-ly1--base.tfm \
tex-Montserrat-BlackItalic-osf-sc-ly1.tfm \
tex-Montserrat-BlackItalic-osf-sc-ly1.vf \
tex-Montserrat-BlackItalic-osf-sc-ot1--base.tfm \
tex-Montserrat-BlackItalic-osf-sc-ot1.tfm \
tex-Montserrat-BlackItalic-osf-sc-ot1.vf \
tex-Montserrat-BlackItalic-osf-sc-t1--base.tfm \
tex-Montserrat-BlackItalic-osf-sc-t1.tfm \
tex-Montserrat-BlackItalic-osf-sc-t1.vf \
tex-Montserrat-BlackItalic-osf-t1--base.tfm \
tex-Montserrat-BlackItalic-osf-t1.tfm \
tex-Montserrat-BlackItalic-osf-t1.vf \
tex-Montserrat-BlackItalic-osf-ts1--base.tfm \
tex-Montserrat-BlackItalic-osf-ts1.tfm \
tex-Montserrat-BlackItalic-osf-ts1.vf \
tex-Montserrat-BlackItalic-sup-ly1--base.tfm \
tex-Montserrat-BlackItalic-sup-ly1.tfm \
tex-Montserrat-BlackItalic-sup-ly1.vf \
tex-Montserrat-BlackItalic-sup-ot1.tfm \
tex-Montserrat-BlackItalic-sup-t1--base.tfm \
tex-Montserrat-BlackItalic-sup-t1.tfm \
tex-Montserrat-BlackItalic-sup-t1.vf \
tex-Montserrat-BlackItalic-tlf-ly1--base.tfm \
tex-Montserrat-BlackItalic-tlf-ly1.tfm \
tex-Montserrat-BlackItalic-tlf-ly1.vf \
tex-Montserrat-BlackItalic-tlf-ot1.tfm \
tex-Montserrat-BlackItalic-tlf-sc-ly1--base.tfm \
tex-Montserrat-BlackItalic-tlf-sc-ly1.tfm \
tex-Montserrat-BlackItalic-tlf-sc-ly1.vf \
tex-Montserrat-BlackItalic-tlf-sc-ot1--base.tfm \
tex-Montserrat-BlackItalic-tlf-sc-ot1.tfm \
tex-Montserrat-BlackItalic-tlf-sc-ot1.vf \
tex-Montserrat-BlackItalic-tlf-sc-t1--base.tfm \
tex-Montserrat-BlackItalic-tlf-sc-t1.tfm \
tex-Montserrat-BlackItalic-tlf-sc-t1.vf \
tex-Montserrat-BlackItalic-tlf-t1--base.tfm \
tex-Montserrat-BlackItalic-tlf-t1.tfm \
tex-Montserrat-BlackItalic-tlf-t1.vf \
tex-Montserrat-BlackItalic-tlf-ts1--base.tfm \
tex-Montserrat-BlackItalic-tlf-ts1.tfm \
tex-Montserrat-BlackItalic-tlf-ts1.vf \
tex-Montserrat-BlackItalic-tosf-ly1--base.tfm \
tex-Montserrat-BlackItalic-tosf-ly1.tfm \
tex-Montserrat-BlackItalic-tosf-ly1.vf \
tex-Montserrat-BlackItalic-tosf-ot1.tfm \
tex-Montserrat-BlackItalic-tosf-sc-ly1--base.tfm \
tex-Montserrat-BlackItalic-tosf-sc-ly1.tfm \
tex-Montserrat-BlackItalic-tosf-sc-ly1.vf \
tex-Montserrat-BlackItalic-tosf-sc-ot1--base.tfm \
tex-Montserrat-BlackItalic-tosf-sc-ot1.tfm \
tex-Montserrat-BlackItalic-tosf-sc-ot1.vf \
tex-Montserrat-BlackItalic-tosf-sc-t1--base.tfm \
tex-Montserrat-BlackItalic-tosf-sc-t1.tfm \
tex-Montserrat-BlackItalic-tosf-sc-t1.vf \
tex-Montserrat-BlackItalic-tosf-t1--base.tfm \
tex-Montserrat-BlackItalic-tosf-t1.tfm \
tex-Montserrat-BlackItalic-tosf-t1.vf \
tex-Montserrat-BlackItalic-tosf-ts1--base.tfm \
tex-Montserrat-BlackItalic-tosf-ts1.tfm \
tex-Montserrat-BlackItalic-tosf-ts1.vf \
tex-Montserrat-Bold-dnom-ly1--base.tfm \
tex-Montserrat-Bold-dnom-ly1.tfm \
tex-Montserrat-Bold-dnom-ly1.vf \
tex-Montserrat-Bold-dnom-ot1.tfm \
tex-Montserrat-Bold-dnom-t1--base.tfm \
tex-Montserrat-Bold-dnom-t1.tfm \
tex-Montserrat-Bold-dnom-t1.vf \
tex-Montserrat-Bold-inf-ly1--base.tfm \
tex-Montserrat-Bold-inf-ly1.tfm \
tex-Montserrat-Bold-inf-ly1.vf \
tex-Montserrat-Bold-inf-ot1.tfm \
tex-Montserrat-Bold-inf-t1--base.tfm \
tex-Montserrat-Bold-inf-t1.tfm \
tex-Montserrat-Bold-inf-t1.vf \
tex-Montserrat-Bold-lf-ly1--base.tfm \
tex-Montserrat-Bold-lf-ly1.tfm \
tex-Montserrat-Bold-lf-ly1.vf \
tex-Montserrat-Bold-lf-ot1.tfm \
tex-Montserrat-Bold-lf-sc-ly1--base.tfm \
tex-Montserrat-Bold-lf-sc-ly1.tfm \
tex-Montserrat-Bold-lf-sc-ly1.vf \
tex-Montserrat-Bold-lf-sc-ot1--base.tfm \
tex-Montserrat-Bold-lf-sc-ot1.tfm \
tex-Montserrat-Bold-lf-sc-ot1.vf \
tex-Montserrat-Bold-lf-sc-t1--base.tfm \
tex-Montserrat-Bold-lf-sc-t1.tfm \
tex-Montserrat-Bold-lf-sc-t1.vf \
tex-Montserrat-Bold-lf-t1--base.tfm \
tex-Montserrat-Bold-lf-t1.tfm \
tex-Montserrat-Bold-lf-t1.vf \
tex-Montserrat-Bold-lf-ts1--base.tfm \
tex-Montserrat-Bold-lf-ts1.tfm \
tex-Montserrat-Bold-lf-ts1.vf \
tex-Montserrat-Bold-numr-ly1--base.tfm \
tex-Montserrat-Bold-numr-ly1.tfm \
tex-Montserrat-Bold-numr-ly1.vf \
tex-Montserrat-Bold-numr-ot1.tfm \
tex-Montserrat-Bold-numr-t1--base.tfm \
tex-Montserrat-Bold-numr-t1.tfm \
tex-Montserrat-Bold-numr-t1.vf \
tex-Montserrat-Bold-osf-ly1--base.tfm \
tex-Montserrat-Bold-osf-ly1.tfm \
tex-Montserrat-Bold-osf-ly1.vf \
tex-Montserrat-Bold-osf-ot1.tfm \
tex-Montserrat-Bold-osf-sc-ly1--base.tfm \
tex-Montserrat-Bold-osf-sc-ly1.tfm \
tex-Montserrat-Bold-osf-sc-ly1.vf \
tex-Montserrat-Bold-osf-sc-ot1--base.tfm \
tex-Montserrat-Bold-osf-sc-ot1.tfm \
tex-Montserrat-Bold-osf-sc-ot1.vf \
tex-Montserrat-Bold-osf-sc-t1--base.tfm \
tex-Montserrat-Bold-osf-sc-t1.tfm \
tex-Montserrat-Bold-osf-sc-t1.vf \
tex-Montserrat-Bold-osf-t1--base.tfm \
tex-Montserrat-Bold-osf-t1.tfm \
tex-Montserrat-Bold-osf-t1.vf \
tex-Montserrat-Bold-osf-ts1--base.tfm \
tex-Montserrat-Bold-osf-ts1.tfm \
tex-Montserrat-Bold-osf-ts1.vf \
tex-Montserrat-Bold-sup-ly1--base.tfm \
tex-Montserrat-Bold-sup-ly1.tfm \
tex-Montserrat-Bold-sup-ly1.vf \
tex-Montserrat-Bold-sup-ot1.tfm \
tex-Montserrat-Bold-sup-t1--base.tfm \
tex-Montserrat-Bold-sup-t1.tfm \
tex-Montserrat-Bold-sup-t1.vf \
tex-Montserrat-Bold-tlf-ly1--base.tfm \
tex-Montserrat-Bold-tlf-ly1.tfm \
tex-Montserrat-Bold-tlf-ly1.vf \
tex-Montserrat-Bold-tlf-ot1.tfm \
tex-Montserrat-Bold-tlf-sc-ly1--base.tfm \
tex-Montserrat-Bold-tlf-sc-ly1.tfm \
tex-Montserrat-Bold-tlf-sc-ly1.vf \
tex-Montserrat-Bold-tlf-sc-ot1--base.tfm \
tex-Montserrat-Bold-tlf-sc-ot1.tfm \
tex-Montserrat-Bold-tlf-sc-ot1.vf \
tex-Montserrat-Bold-tlf-sc-t1--base.tfm \
tex-Montserrat-Bold-tlf-sc-t1.tfm \
tex-Montserrat-Bold-tlf-sc-t1.vf \
tex-Montserrat-Bold-tlf-t1--base.tfm \
tex-Montserrat-Bold-tlf-t1.tfm \
tex-Montserrat-Bold-tlf-t1.vf \
tex-Montserrat-Bold-tlf-ts1--base.tfm \
tex-Montserrat-Bold-tlf-ts1.tfm \
tex-Montserrat-Bold-tlf-ts1.vf \
tex-Montserrat-Bold-tosf-ly1--base.tfm \
tex-Montserrat-Bold-tosf-ly1.tfm \
tex-Montserrat-Bold-tosf-ly1.vf \
tex-Montserrat-Bold-tosf-ot1.tfm \
tex-Montserrat-Bold-tosf-sc-ly1--base.tfm \
tex-Montserrat-Bold-tosf-sc-ly1.tfm \
tex-Montserrat-Bold-tosf-sc-ly1.vf \
tex-Montserrat-Bold-tosf-sc-ot1--base.tfm \
tex-Montserrat-Bold-tosf-sc-ot1.tfm \
tex-Montserrat-Bold-tosf-sc-ot1.vf \
tex-Montserrat-Bold-tosf-sc-t1--base.tfm \
tex-Montserrat-Bold-tosf-sc-t1.tfm \
tex-Montserrat-Bold-tosf-sc-t1.vf \
tex-Montserrat-Bold-tosf-t1--base.tfm \
tex-Montserrat-Bold-tosf-t1.tfm \
tex-Montserrat-Bold-tosf-t1.vf \
tex-Montserrat-Bold-tosf-ts1--base.tfm \
tex-Montserrat-Bold-tosf-ts1.tfm \
tex-Montserrat-Bold-tosf-ts1.vf \
tex-Montserrat-BoldItalic-dnom-ly1--base.tfm \
tex-Montserrat-BoldItalic-dnom-ly1.tfm \
tex-Montserrat-BoldItalic-dnom-ly1.vf \
tex-Montserrat-BoldItalic-dnom-ot1.tfm \
tex-Montserrat-BoldItalic-dnom-t1--base.tfm \
tex-Montserrat-BoldItalic-dnom-t1.tfm \
tex-Montserrat-BoldItalic-dnom-t1.vf \
tex-Montserrat-BoldItalic-inf-ly1--base.tfm \
tex-Montserrat-BoldItalic-inf-ly1.tfm \
tex-Montserrat-BoldItalic-inf-ly1.vf \
tex-Montserrat-BoldItalic-inf-ot1.tfm \
tex-Montserrat-BoldItalic-inf-t1--base.tfm \
tex-Montserrat-BoldItalic-inf-t1.tfm \
tex-Montserrat-BoldItalic-inf-t1.vf \
tex-Montserrat-BoldItalic-lf-ly1--base.tfm \
tex-Montserrat-BoldItalic-lf-ly1.tfm \
tex-Montserrat-BoldItalic-lf-ly1.vf \
tex-Montserrat-BoldItalic-lf-ot1.tfm \
tex-Montserrat-BoldItalic-lf-sc-ly1--base.tfm \
tex-Montserrat-BoldItalic-lf-sc-ly1.tfm \
tex-Montserrat-BoldItalic-lf-sc-ly1.vf \
tex-Montserrat-BoldItalic-lf-sc-ot1--base.tfm \
tex-Montserrat-BoldItalic-lf-sc-ot1.tfm \
tex-Montserrat-BoldItalic-lf-sc-ot1.vf \
tex-Montserrat-BoldItalic-lf-sc-t1--base.tfm \
tex-Montserrat-BoldItalic-lf-sc-t1.tfm \
tex-Montserrat-BoldItalic-lf-sc-t1.vf \
tex-Montserrat-BoldItalic-lf-t1--base.tfm \
tex-Montserrat-BoldItalic-lf-t1.tfm \
tex-Montserrat-BoldItalic-lf-t1.vf \
tex-Montserrat-BoldItalic-lf-ts1--base.tfm \
tex-Montserrat-BoldItalic-lf-ts1.tfm \
tex-Montserrat-BoldItalic-lf-ts1.vf \
tex-Montserrat-BoldItalic-numr-ly1--base.tfm \
tex-Montserrat-BoldItalic-numr-ly1.tfm \
tex-Montserrat-BoldItalic-numr-ly1.vf \
tex-Montserrat-BoldItalic-numr-ot1.tfm \
tex-Montserrat-BoldItalic-numr-t1--base.tfm \
tex-Montserrat-BoldItalic-numr-t1.tfm \
tex-Montserrat-BoldItalic-numr-t1.vf \
tex-Montserrat-BoldItalic-osf-ly1--base.tfm \
tex-Montserrat-BoldItalic-osf-ly1.tfm \
tex-Montserrat-BoldItalic-osf-ly1.vf \
tex-Montserrat-BoldItalic-osf-ot1.tfm \
tex-Montserrat-BoldItalic-osf-sc-ly1--base.tfm \
tex-Montserrat-BoldItalic-osf-sc-ly1.tfm \
tex-Montserrat-BoldItalic-osf-sc-ly1.vf \
tex-Montserrat-BoldItalic-osf-sc-ot1--base.tfm \
tex-Montserrat-BoldItalic-osf-sc-ot1.tfm \
tex-Montserrat-BoldItalic-osf-sc-ot1.vf \
tex-Montserrat-BoldItalic-osf-sc-t1--base.tfm \
tex-Montserrat-BoldItalic-osf-sc-t1.tfm \
tex-Montserrat-BoldItalic-osf-sc-t1.vf \
tex-Montserrat-BoldItalic-osf-t1--base.tfm \
tex-Montserrat-BoldItalic-osf-t1.tfm \
tex-Montserrat-BoldItalic-osf-t1.vf \
tex-Montserrat-BoldItalic-osf-ts1--base.tfm \
tex-Montserrat-BoldItalic-osf-ts1.tfm \
tex-Montserrat-BoldItalic-osf-ts1.vf \
tex-Montserrat-BoldItalic-sup-ly1--base.tfm \
tex-Montserrat-BoldItalic-sup-ly1.tfm \
tex-Montserrat-BoldItalic-sup-ly1.vf \
tex-Montserrat-BoldItalic-sup-ot1.tfm \
tex-Montserrat-BoldItalic-sup-t1--base.tfm \
tex-Montserrat-BoldItalic-sup-t1.tfm \
tex-Montserrat-BoldItalic-sup-t1.vf \
tex-Montserrat-BoldItalic-tlf-ly1--base.tfm \
tex-Montserrat-BoldItalic-tlf-ly1.tfm \
tex-Montserrat-BoldItalic-tlf-ly1.vf \
tex-Montserrat-BoldItalic-tlf-ot1.tfm \
tex-Montserrat-BoldItalic-tlf-sc-ly1--base.tfm \
tex-Montserrat-BoldItalic-tlf-sc-ly1.tfm \
tex-Montserrat-BoldItalic-tlf-sc-ly1.vf \
tex-Montserrat-BoldItalic-tlf-sc-ot1--base.tfm \
tex-Montserrat-BoldItalic-tlf-sc-ot1.tfm \
tex-Montserrat-BoldItalic-tlf-sc-ot1.vf \
tex-Montserrat-BoldItalic-tlf-sc-t1--base.tfm \
tex-Montserrat-BoldItalic-tlf-sc-t1.tfm \
tex-Montserrat-BoldItalic-tlf-sc-t1.vf \
tex-Montserrat-BoldItalic-tlf-t1--base.tfm \
tex-Montserrat-BoldItalic-tlf-t1.tfm \
tex-Montserrat-BoldItalic-tlf-t1.vf \
tex-Montserrat-BoldItalic-tlf-ts1--base.tfm \
tex-Montserrat-BoldItalic-tlf-ts1.tfm \
tex-Montserrat-BoldItalic-tlf-ts1.vf \
tex-Montserrat-BoldItalic-tosf-ly1--base.tfm \
tex-Montserrat-BoldItalic-tosf-ly1.tfm \
tex-Montserrat-BoldItalic-tosf-ly1.vf \
tex-Montserrat-BoldItalic-tosf-ot1.tfm \
tex-Montserrat-BoldItalic-tosf-sc-ly1--base.tfm \
tex-Montserrat-BoldItalic-tosf-sc-ly1.tfm \
tex-Montserrat-BoldItalic-tosf-sc-ly1.vf \
tex-Montserrat-BoldItalic-tosf-sc-ot1--base.tfm \
tex-Montserrat-BoldItalic-tosf-sc-ot1.tfm \
tex-Montserrat-BoldItalic-tosf-sc-ot1.vf \
tex-Montserrat-BoldItalic-tosf-sc-t1--base.tfm \
tex-Montserrat-BoldItalic-tosf-sc-t1.tfm \
tex-Montserrat-BoldItalic-tosf-sc-t1.vf \
tex-Montserrat-BoldItalic-tosf-t1--base.tfm \
tex-Montserrat-BoldItalic-tosf-t1.tfm \
tex-Montserrat-BoldItalic-tosf-t1.vf \
tex-Montserrat-BoldItalic-tosf-ts1--base.tfm \
tex-Montserrat-BoldItalic-tosf-ts1.tfm \
tex-Montserrat-BoldItalic-tosf-ts1.vf \
tex-Montserrat-ExtraBold-dnom-ly1--base.tfm \
tex-Montserrat-ExtraBold-dnom-ly1.tfm \
tex-Montserrat-ExtraBold-dnom-ly1.vf \
tex-Montserrat-ExtraBold-dnom-ot1.tfm \
tex-Montserrat-ExtraBold-dnom-t1--base.tfm \
tex-Montserrat-ExtraBold-dnom-t1.tfm \
tex-Montserrat-ExtraBold-dnom-t1.vf \
tex-Montserrat-ExtraBold-inf-ly1--base.tfm \
tex-Montserrat-ExtraBold-inf-ly1.tfm \
tex-Montserrat-ExtraBold-inf-ly1.vf \
tex-Montserrat-ExtraBold-inf-ot1.tfm \
tex-Montserrat-ExtraBold-inf-t1--base.tfm \
tex-Montserrat-ExtraBold-inf-t1.tfm \
tex-Montserrat-ExtraBold-inf-t1.vf \
tex-Montserrat-ExtraBold-lf-ly1--base.tfm \
tex-Montserrat-ExtraBold-lf-ly1.tfm \
tex-Montserrat-ExtraBold-lf-ly1.vf \
tex-Montserrat-ExtraBold-lf-ot1.tfm \
tex-Montserrat-ExtraBold-lf-sc-ly1--base.tfm \
tex-Montserrat-ExtraBold-lf-sc-ly1.tfm \
tex-Montserrat-ExtraBold-lf-sc-ly1.vf \
tex-Montserrat-ExtraBold-lf-sc-ot1--base.tfm \
tex-Montserrat-ExtraBold-lf-sc-ot1.tfm \
tex-Montserrat-ExtraBold-lf-sc-ot1.vf \
tex-Montserrat-ExtraBold-lf-sc-t1--base.tfm \
tex-Montserrat-ExtraBold-lf-sc-t1.tfm \
tex-Montserrat-ExtraBold-lf-sc-t1.vf \
tex-Montserrat-ExtraBold-lf-t1--base.tfm \
tex-Montserrat-ExtraBold-lf-t1.tfm \
tex-Montserrat-ExtraBold-lf-t1.vf \
tex-Montserrat-ExtraBold-lf-ts1--base.tfm \
tex-Montserrat-ExtraBold-lf-ts1.tfm \
tex-Montserrat-ExtraBold-lf-ts1.vf \
tex-Montserrat-ExtraBold-numr-ly1--base.tfm \
tex-Montserrat-ExtraBold-numr-ly1.tfm \
tex-Montserrat-ExtraBold-numr-ly1.vf \
tex-Montserrat-ExtraBold-numr-ot1.tfm \
tex-Montserrat-ExtraBold-numr-t1--base.tfm \
tex-Montserrat-ExtraBold-numr-t1.tfm \
tex-Montserrat-ExtraBold-numr-t1.vf \
tex-Montserrat-ExtraBold-osf-ly1--base.tfm \
tex-Montserrat-ExtraBold-osf-ly1.tfm \
tex-Montserrat-ExtraBold-osf-ly1.vf \
tex-Montserrat-ExtraBold-osf-ot1.tfm \
tex-Montserrat-ExtraBold-osf-sc-ly1--base.tfm \
tex-Montserrat-ExtraBold-osf-sc-ly1.tfm \
tex-Montserrat-ExtraBold-osf-sc-ly1.vf \
tex-Montserrat-ExtraBold-osf-sc-ot1--base.tfm \
tex-Montserrat-ExtraBold-osf-sc-ot1.tfm \
tex-Montserrat-ExtraBold-osf-sc-ot1.vf \
tex-Montserrat-ExtraBold-osf-sc-t1--base.tfm \
tex-Montserrat-ExtraBold-osf-sc-t1.tfm \
tex-Montserrat-ExtraBold-osf-sc-t1.vf \
tex-Montserrat-ExtraBold-osf-t1--base.tfm \
tex-Montserrat-ExtraBold-osf-t1.tfm \
tex-Montserrat-ExtraBold-osf-t1.vf \
tex-Montserrat-ExtraBold-osf-ts1--base.tfm \
tex-Montserrat-ExtraBold-osf-ts1.tfm \
tex-Montserrat-ExtraBold-osf-ts1.vf \
tex-Montserrat-ExtraBold-sup-ly1--base.tfm \
tex-Montserrat-ExtraBold-sup-ly1.tfm \
tex-Montserrat-ExtraBold-sup-ly1.vf \
tex-Montserrat-ExtraBold-sup-ot1.tfm \
tex-Montserrat-ExtraBold-sup-t1--base.tfm \
tex-Montserrat-ExtraBold-sup-t1.tfm \
tex-Montserrat-ExtraBold-sup-t1.vf \
tex-Montserrat-ExtraBold-tlf-ly1--base.tfm \
tex-Montserrat-ExtraBold-tlf-ly1.tfm \
tex-Montserrat-ExtraBold-tlf-ly1.vf \
tex-Montserrat-ExtraBold-tlf-ot1.tfm \
tex-Montserrat-ExtraBold-tlf-sc-ly1--base.tfm \
tex-Montserrat-ExtraBold-tlf-sc-ly1.tfm \
tex-Montserrat-ExtraBold-tlf-sc-ly1.vf \
tex-Montserrat-ExtraBold-tlf-sc-ot1--base.tfm \
tex-Montserrat-ExtraBold-tlf-sc-ot1.tfm \
tex-Montserrat-ExtraBold-tlf-sc-ot1.vf \
tex-Montserrat-ExtraBold-tlf-sc-t1--base.tfm \
tex-Montserrat-ExtraBold-tlf-sc-t1.tfm \
tex-Montserrat-ExtraBold-tlf-sc-t1.vf \
tex-Montserrat-ExtraBold-tlf-t1--base.tfm \
tex-Montserrat-ExtraBold-tlf-t1.tfm \
tex-Montserrat-ExtraBold-tlf-t1.vf \
tex-Montserrat-ExtraBold-tlf-ts1--base.tfm \
tex-Montserrat-ExtraBold-tlf-ts1.tfm \
tex-Montserrat-ExtraBold-tlf-ts1.vf \
tex-Montserrat-ExtraBold-tosf-ly1--base.tfm \
tex-Montserrat-ExtraBold-tosf-ly1.tfm \
tex-Montserrat-ExtraBold-tosf-ly1.vf \
tex-Montserrat-ExtraBold-tosf-ot1.tfm \
tex-Montserrat-ExtraBold-tosf-sc-ly1--base.tfm \
tex-Montserrat-ExtraBold-tosf-sc-ly1.tfm \
tex-Montserrat-ExtraBold-tosf-sc-ly1.vf \
tex-Montserrat-ExtraBold-tosf-sc-ot1--base.tfm \
tex-Montserrat-ExtraBold-tosf-sc-ot1.tfm \
tex-Montserrat-ExtraBold-tosf-sc-ot1.vf \
tex-Montserrat-ExtraBold-tosf-sc-t1--base.tfm \
tex-Montserrat-ExtraBold-tosf-sc-t1.tfm \
tex-Montserrat-ExtraBold-tosf-sc-t1.vf \
tex-Montserrat-ExtraBold-tosf-t1--base.tfm \
tex-Montserrat-ExtraBold-tosf-t1.tfm \
tex-Montserrat-ExtraBold-tosf-t1.vf \
tex-Montserrat-ExtraBold-tosf-ts1--base.tfm \
tex-Montserrat-ExtraBold-tosf-ts1.tfm \
tex-Montserrat-ExtraBold-tosf-ts1.vf \
tex-Montserrat-ExtraBoldItalic-dnom-ly1--base.tfm \
tex-Montserrat-ExtraBoldItalic-dnom-ly1.tfm \
tex-Montserrat-ExtraBoldItalic-dnom-ly1.vf \
tex-Montserrat-ExtraBoldItalic-dnom-ot1.tfm \
tex-Montserrat-ExtraBoldItalic-dnom-t1--base.tfm \
tex-Montserrat-ExtraBoldItalic-dnom-t1.tfm \
tex-Montserrat-ExtraBoldItalic-dnom-t1.vf \
tex-Montserrat-ExtraBoldItalic-inf-ly1--base.tfm \
tex-Montserrat-ExtraBoldItalic-inf-ly1.tfm \
tex-Montserrat-ExtraBoldItalic-inf-ly1.vf \
tex-Montserrat-ExtraBoldItalic-inf-ot1.tfm \
tex-Montserrat-ExtraBoldItalic-inf-t1--base.tfm \
tex-Montserrat-ExtraBoldItalic-inf-t1.tfm \
tex-Montserrat-ExtraBoldItalic-inf-t1.vf \
tex-Montserrat-ExtraBoldItalic-lf-ly1--base.tfm \
tex-Montserrat-ExtraBoldItalic-lf-ly1.tfm \
tex-Montserrat-ExtraBoldItalic-lf-ly1.vf \
tex-Montserrat-ExtraBoldItalic-lf-ot1.tfm \
tex-Montserrat-ExtraBoldItalic-lf-sc-ly1--base.tfm \
tex-Montserrat-ExtraBoldItalic-lf-sc-ly1.tfm \
tex-Montserrat-ExtraBoldItalic-lf-sc-ly1.vf \
tex-Montserrat-ExtraBoldItalic-lf-sc-ot1--base.tfm \
tex-Montserrat-ExtraBoldItalic-lf-sc-ot1.tfm \
tex-Montserrat-ExtraBoldItalic-lf-sc-ot1.vf \
tex-Montserrat-ExtraBoldItalic-lf-sc-t1--base.tfm \
tex-Montserrat-ExtraBoldItalic-lf-sc-t1.tfm \
tex-Montserrat-ExtraBoldItalic-lf-sc-t1.vf \
tex-Montserrat-ExtraBoldItalic-lf-t1--base.tfm \
tex-Montserrat-ExtraBoldItalic-lf-t1.tfm \
tex-Montserrat-ExtraBoldItalic-lf-t1.vf \
tex-Montserrat-ExtraBoldItalic-lf-ts1--base.tfm \
tex-Montserrat-ExtraBoldItalic-lf-ts1.tfm \
tex-Montserrat-ExtraBoldItalic-lf-ts1.vf \
tex-Montserrat-ExtraBoldItalic-numr-ly1--base.tfm \
tex-Montserrat-ExtraBoldItalic-numr-ly1.tfm \
tex-Montserrat-ExtraBoldItalic-numr-ly1.vf \
tex-Montserrat-ExtraBoldItalic-numr-ot1.tfm \
tex-Montserrat-ExtraBoldItalic-numr-t1--base.tfm \
tex-Montserrat-ExtraBoldItalic-numr-t1.tfm \
tex-Montserrat-ExtraBoldItalic-numr-t1.vf \
tex-Montserrat-ExtraBoldItalic-osf-ly1--base.tfm \
tex-Montserrat-ExtraBoldItalic-osf-ly1.tfm \
tex-Montserrat-ExtraBoldItalic-osf-ly1.vf \
tex-Montserrat-ExtraBoldItalic-osf-ot1.tfm \
tex-Montserrat-ExtraBoldItalic-osf-sc-ly1--base.tfm \
tex-Montserrat-ExtraBoldItalic-osf-sc-ly1.tfm \
tex-Montserrat-ExtraBoldItalic-osf-sc-ly1.vf \
tex-Montserrat-ExtraBoldItalic-osf-sc-ot1--base.tfm \
tex-Montserrat-ExtraBoldItalic-osf-sc-ot1.tfm \
tex-Montserrat-ExtraBoldItalic-osf-sc-ot1.vf \
tex-Montserrat-ExtraBoldItalic-osf-sc-t1--base.tfm \
tex-Montserrat-ExtraBoldItalic-osf-sc-t1.tfm \
tex-Montserrat-ExtraBoldItalic-osf-sc-t1.vf \
tex-Montserrat-ExtraBoldItalic-osf-t1--base.tfm \
tex-Montserrat-ExtraBoldItalic-osf-t1.tfm \
tex-Montserrat-ExtraBoldItalic-osf-t1.vf \
tex-Montserrat-ExtraBoldItalic-osf-ts1--base.tfm \
tex-Montserrat-ExtraBoldItalic-osf-ts1.tfm \
tex-Montserrat-ExtraBoldItalic-osf-ts1.vf \
tex-Montserrat-ExtraBoldItalic-sup-ly1--base.tfm \
tex-Montserrat-ExtraBoldItalic-sup-ly1.tfm \
tex-Montserrat-ExtraBoldItalic-sup-ly1.vf \
tex-Montserrat-ExtraBoldItalic-sup-ot1.tfm \
tex-Montserrat-ExtraBoldItalic-sup-t1--base.tfm \
tex-Montserrat-ExtraBoldItalic-sup-t1.tfm \
tex-Montserrat-ExtraBoldItalic-sup-t1.vf \
tex-Montserrat-ExtraBoldItalic-tlf-ly1--base.tfm \
tex-Montserrat-ExtraBoldItalic-tlf-ly1.tfm \
tex-Montserrat-ExtraBoldItalic-tlf-ly1.vf \
tex-Montserrat-ExtraBoldItalic-tlf-ot1.tfm \
tex-Montserrat-ExtraBoldItalic-tlf-sc-ly1--base.tfm \
tex-Montserrat-ExtraBoldItalic-tlf-sc-ly1.tfm \
tex-Montserrat-ExtraBoldItalic-tlf-sc-ly1.vf \
tex-Montserrat-ExtraBoldItalic-tlf-sc-ot1--base.tfm \
tex-Montserrat-ExtraBoldItalic-tlf-sc-ot1.tfm \
tex-Montserrat-ExtraBoldItalic-tlf-sc-ot1.vf \
tex-Montserrat-ExtraBoldItalic-tlf-sc-t1--base.tfm \
tex-Montserrat-ExtraBoldItalic-tlf-sc-t1.tfm \
tex-Montserrat-ExtraBoldItalic-tlf-sc-t1.vf \
tex-Montserrat-ExtraBoldItalic-tlf-t1--base.tfm \
tex-Montserrat-ExtraBoldItalic-tlf-t1.tfm \
tex-Montserrat-ExtraBoldItalic-tlf-t1.vf \
tex-Montserrat-ExtraBoldItalic-tlf-ts1--base.tfm \
tex-Montserrat-ExtraBoldItalic-tlf-ts1.tfm \
tex-Montserrat-ExtraBoldItalic-tlf-ts1.vf \
tex-Montserrat-ExtraBoldItalic-tosf-ly1--base.tfm \
tex-Montserrat-ExtraBoldItalic-tosf-ly1.tfm \
tex-Montserrat-ExtraBoldItalic-tosf-ly1.vf \
tex-Montserrat-ExtraBoldItalic-tosf-ot1.tfm \
tex-Montserrat-ExtraBoldItalic-tosf-sc-ly1--base.tfm \
tex-Montserrat-ExtraBoldItalic-tosf-sc-ly1.tfm \
tex-Montserrat-ExtraBoldItalic-tosf-sc-ly1.vf \
tex-Montserrat-ExtraBoldItalic-tosf-sc-ot1--base.tfm \
tex-Montserrat-ExtraBoldItalic-tosf-sc-ot1.tfm \
tex-Montserrat-ExtraBoldItalic-tosf-sc-ot1.vf \
tex-Montserrat-ExtraBoldItalic-tosf-sc-t1--base.tfm \
tex-Montserrat-ExtraBoldItalic-tosf-sc-t1.tfm \
tex-Montserrat-ExtraBoldItalic-tosf-sc-t1.vf \
tex-Montserrat-ExtraBoldItalic-tosf-t1--base.tfm \
tex-Montserrat-ExtraBoldItalic-tosf-t1.tfm \
tex-Montserrat-ExtraBoldItalic-tosf-t1.vf \
tex-Montserrat-ExtraBoldItalic-tosf-ts1--base.tfm \
tex-Montserrat-ExtraBoldItalic-tosf-ts1.tfm \
tex-Montserrat-ExtraBoldItalic-tosf-ts1.vf \
tex-Montserrat-ExtraLight-dnom-ly1--base.tfm \
tex-Montserrat-ExtraLight-dnom-ly1.tfm \
tex-Montserrat-ExtraLight-dnom-ly1.vf \
tex-Montserrat-ExtraLight-dnom-ot1.tfm \
tex-Montserrat-ExtraLight-dnom-t1--base.tfm \
tex-Montserrat-ExtraLight-dnom-t1.tfm \
tex-Montserrat-ExtraLight-dnom-t1.vf \
tex-Montserrat-ExtraLight-inf-ly1--base.tfm \
tex-Montserrat-ExtraLight-inf-ly1.tfm \
tex-Montserrat-ExtraLight-inf-ly1.vf \
tex-Montserrat-ExtraLight-inf-ot1.tfm \
tex-Montserrat-ExtraLight-inf-t1--base.tfm \
tex-Montserrat-ExtraLight-inf-t1.tfm \
tex-Montserrat-ExtraLight-inf-t1.vf \
tex-Montserrat-ExtraLight-lf-ly1--base.tfm \
tex-Montserrat-ExtraLight-lf-ly1.tfm \
tex-Montserrat-ExtraLight-lf-ly1.vf \
tex-Montserrat-ExtraLight-lf-ot1.tfm \
tex-Montserrat-ExtraLight-lf-sc-ly1--base.tfm \
tex-Montserrat-ExtraLight-lf-sc-ly1.tfm \
tex-Montserrat-ExtraLight-lf-sc-ly1.vf \
tex-Montserrat-ExtraLight-lf-sc-ot1--base.tfm \
tex-Montserrat-ExtraLight-lf-sc-ot1.tfm \
tex-Montserrat-ExtraLight-lf-sc-ot1.vf \
tex-Montserrat-ExtraLight-lf-sc-t1--base.tfm \
tex-Montserrat-ExtraLight-lf-sc-t1.tfm \
tex-Montserrat-ExtraLight-lf-sc-t1.vf \
tex-Montserrat-ExtraLight-lf-t1--base.tfm \
tex-Montserrat-ExtraLight-lf-t1.tfm \
tex-Montserrat-ExtraLight-lf-t1.vf \
tex-Montserrat-ExtraLight-lf-ts1--base.tfm \
tex-Montserrat-ExtraLight-lf-ts1.tfm \
tex-Montserrat-ExtraLight-lf-ts1.vf \
tex-Montserrat-ExtraLight-numr-ly1--base.tfm \
tex-Montserrat-ExtraLight-numr-ly1.tfm \
tex-Montserrat-ExtraLight-numr-ly1.vf \
tex-Montserrat-ExtraLight-numr-ot1.tfm \
tex-Montserrat-ExtraLight-numr-t1--base.tfm \
tex-Montserrat-ExtraLight-numr-t1.tfm \
tex-Montserrat-ExtraLight-numr-t1.vf \
tex-Montserrat-ExtraLight-osf-ly1--base.tfm \
tex-Montserrat-ExtraLight-osf-ly1.tfm \
tex-Montserrat-ExtraLight-osf-ly1.vf \
tex-Montserrat-ExtraLight-osf-ot1.tfm \
tex-Montserrat-ExtraLight-osf-sc-ly1--base.tfm \
tex-Montserrat-ExtraLight-osf-sc-ly1.tfm \
tex-Montserrat-ExtraLight-osf-sc-ly1.vf \
tex-Montserrat-ExtraLight-osf-sc-ot1--base.tfm \
tex-Montserrat-ExtraLight-osf-sc-ot1.tfm \
tex-Montserrat-ExtraLight-osf-sc-ot1.vf \
tex-Montserrat-ExtraLight-osf-sc-t1--base.tfm \
tex-Montserrat-ExtraLight-osf-sc-t1.tfm \
tex-Montserrat-ExtraLight-osf-sc-t1.vf \
tex-Montserrat-ExtraLight-osf-t1--base.tfm \
tex-Montserrat-ExtraLight-osf-t1.tfm \
tex-Montserrat-ExtraLight-osf-t1.vf \
tex-Montserrat-ExtraLight-osf-ts1--base.tfm \
tex-Montserrat-ExtraLight-osf-ts1.tfm \
tex-Montserrat-ExtraLight-osf-ts1.vf \
tex-Montserrat-ExtraLight-sup-ly1--base.tfm \
tex-Montserrat-ExtraLight-sup-ly1.tfm \
tex-Montserrat-ExtraLight-sup-ly1.vf \
tex-Montserrat-ExtraLight-sup-ot1.tfm \
tex-Montserrat-ExtraLight-sup-t1--base.tfm \
tex-Montserrat-ExtraLight-sup-t1.tfm \
tex-Montserrat-ExtraLight-sup-t1.vf \
tex-Montserrat-ExtraLight-tlf-ly1--base.tfm \
tex-Montserrat-ExtraLight-tlf-ly1.tfm \
tex-Montserrat-ExtraLight-tlf-ly1.vf \
tex-Montserrat-ExtraLight-tlf-ot1.tfm \
tex-Montserrat-ExtraLight-tlf-sc-ly1--base.tfm \
tex-Montserrat-ExtraLight-tlf-sc-ly1.tfm \
tex-Montserrat-ExtraLight-tlf-sc-ly1.vf \
tex-Montserrat-ExtraLight-tlf-sc-ot1--base.tfm \
tex-Montserrat-ExtraLight-tlf-sc-ot1.tfm \
tex-Montserrat-ExtraLight-tlf-sc-ot1.vf \
tex-Montserrat-ExtraLight-tlf-sc-t1--base.tfm \
tex-Montserrat-ExtraLight-tlf-sc-t1.tfm \
tex-Montserrat-ExtraLight-tlf-sc-t1.vf \
tex-Montserrat-ExtraLight-tlf-t1--base.tfm \
tex-Montserrat-ExtraLight-tlf-t1.tfm \
tex-Montserrat-ExtraLight-tlf-t1.vf \
tex-Montserrat-ExtraLight-tlf-ts1--base.tfm \
tex-Montserrat-ExtraLight-tlf-ts1.tfm \
tex-Montserrat-ExtraLight-tlf-ts1.vf \
tex-Montserrat-ExtraLight-tosf-ly1--base.tfm \
tex-Montserrat-ExtraLight-tosf-ly1.tfm \
tex-Montserrat-ExtraLight-tosf-ly1.vf \
tex-Montserrat-ExtraLight-tosf-ot1.tfm \
tex-Montserrat-ExtraLight-tosf-sc-ly1--base.tfm \
tex-Montserrat-ExtraLight-tosf-sc-ly1.tfm \
tex-Montserrat-ExtraLight-tosf-sc-ly1.vf \
tex-Montserrat-ExtraLight-tosf-sc-ot1--base.tfm \
tex-Montserrat-ExtraLight-tosf-sc-ot1.tfm \
tex-Montserrat-ExtraLight-tosf-sc-ot1.vf \
tex-Montserrat-ExtraLight-tosf-sc-t1--base.tfm \
tex-Montserrat-ExtraLight-tosf-sc-t1.tfm \
tex-Montserrat-ExtraLight-tosf-sc-t1.vf \
tex-Montserrat-ExtraLight-tosf-t1--base.tfm \
tex-Montserrat-ExtraLight-tosf-t1.tfm \
tex-Montserrat-ExtraLight-tosf-t1.vf \
tex-Montserrat-ExtraLight-tosf-ts1--base.tfm \
tex-Montserrat-ExtraLight-tosf-ts1.tfm \
tex-Montserrat-ExtraLight-tosf-ts1.vf \
tex-Montserrat-ExtraLightItalic-dnom-ly1--base.tfm \
tex-Montserrat-ExtraLightItalic-dnom-ly1.tfm \
tex-Montserrat-ExtraLightItalic-dnom-ly1.vf \
tex-Montserrat-ExtraLightItalic-dnom-ot1.tfm \
tex-Montserrat-ExtraLightItalic-dnom-t1--base.tfm \
tex-Montserrat-ExtraLightItalic-dnom-t1.tfm \
tex-Montserrat-ExtraLightItalic-dnom-t1.vf \
tex-Montserrat-ExtraLightItalic-inf-ly1--base.tfm \
tex-Montserrat-ExtraLightItalic-inf-ly1.tfm \
tex-Montserrat-ExtraLightItalic-inf-ly1.vf \
tex-Montserrat-ExtraLightItalic-inf-ot1.tfm \
tex-Montserrat-ExtraLightItalic-inf-t1--base.tfm \
tex-Montserrat-ExtraLightItalic-inf-t1.tfm \
tex-Montserrat-ExtraLightItalic-inf-t1.vf \
tex-Montserrat-ExtraLightItalic-lf-ly1--base.tfm \
tex-Montserrat-ExtraLightItalic-lf-ly1.tfm \
tex-Montserrat-ExtraLightItalic-lf-ly1.vf \
tex-Montserrat-ExtraLightItalic-lf-ot1.tfm \
tex-Montserrat-ExtraLightItalic-lf-sc-ly1--base.tfm \
tex-Montserrat-ExtraLightItalic-lf-sc-ly1.tfm \
tex-Montserrat-ExtraLightItalic-lf-sc-ly1.vf \
tex-Montserrat-ExtraLightItalic-lf-sc-ot1--base.tfm \
tex-Montserrat-ExtraLightItalic-lf-sc-ot1.tfm \
tex-Montserrat-ExtraLightItalic-lf-sc-ot1.vf \
tex-Montserrat-ExtraLightItalic-lf-sc-t1--base.tfm \
tex-Montserrat-ExtraLightItalic-lf-sc-t1.tfm \
tex-Montserrat-ExtraLightItalic-lf-sc-t1.vf \
tex-Montserrat-ExtraLightItalic-lf-t1--base.tfm \
tex-Montserrat-ExtraLightItalic-lf-t1.tfm \
tex-Montserrat-ExtraLightItalic-lf-t1.vf \
tex-Montserrat-ExtraLightItalic-lf-ts1--base.tfm \
tex-Montserrat-ExtraLightItalic-lf-ts1.tfm \
tex-Montserrat-ExtraLightItalic-lf-ts1.vf \
tex-Montserrat-ExtraLightItalic-numr-ly1--base.tfm \
tex-Montserrat-ExtraLightItalic-numr-ly1.tfm \
tex-Montserrat-ExtraLightItalic-numr-ly1.vf \
tex-Montserrat-ExtraLightItalic-numr-ot1.tfm \
tex-Montserrat-ExtraLightItalic-numr-t1--base.tfm \
tex-Montserrat-ExtraLightItalic-numr-t1.tfm \
tex-Montserrat-ExtraLightItalic-numr-t1.vf \
tex-Montserrat-ExtraLightItalic-osf-ly1--base.tfm \
tex-Montserrat-ExtraLightItalic-osf-ly1.tfm \
tex-Montserrat-ExtraLightItalic-osf-ly1.vf \
tex-Montserrat-ExtraLightItalic-osf-ot1.tfm \
tex-Montserrat-ExtraLightItalic-osf-sc-ly1--base.tfm \
tex-Montserrat-ExtraLightItalic-osf-sc-ly1.tfm \
tex-Montserrat-ExtraLightItalic-osf-sc-ly1.vf \
tex-Montserrat-ExtraLightItalic-osf-sc-ot1--base.tfm \
tex-Montserrat-ExtraLightItalic-osf-sc-ot1.tfm \
tex-Montserrat-ExtraLightItalic-osf-sc-ot1.vf \
tex-Montserrat-ExtraLightItalic-osf-sc-t1--base.tfm \
tex-Montserrat-ExtraLightItalic-osf-sc-t1.tfm \
tex-Montserrat-ExtraLightItalic-osf-sc-t1.vf \
tex-Montserrat-ExtraLightItalic-osf-t1--base.tfm \
tex-Montserrat-ExtraLightItalic-osf-t1.tfm \
tex-Montserrat-ExtraLightItalic-osf-t1.vf \
tex-Montserrat-ExtraLightItalic-osf-ts1--base.tfm \
tex-Montserrat-ExtraLightItalic-osf-ts1.tfm \
tex-Montserrat-ExtraLightItalic-osf-ts1.vf \
tex-Montserrat-ExtraLightItalic-sup-ly1--base.tfm \
tex-Montserrat-ExtraLightItalic-sup-ly1.tfm \
tex-Montserrat-ExtraLightItalic-sup-ly1.vf \
tex-Montserrat-ExtraLightItalic-sup-ot1.tfm \
tex-Montserrat-ExtraLightItalic-sup-t1--base.tfm \
tex-Montserrat-ExtraLightItalic-sup-t1.tfm \
tex-Montserrat-ExtraLightItalic-sup-t1.vf \
tex-Montserrat-ExtraLightItalic-tlf-ly1--base.tfm \
tex-Montserrat-ExtraLightItalic-tlf-ly1.tfm \
tex-Montserrat-ExtraLightItalic-tlf-ly1.vf \
tex-Montserrat-ExtraLightItalic-tlf-ot1.tfm \
tex-Montserrat-ExtraLightItalic-tlf-sc-ly1--base.tfm \
tex-Montserrat-ExtraLightItalic-tlf-sc-ly1.tfm \
tex-Montserrat-ExtraLightItalic-tlf-sc-ly1.vf \
tex-Montserrat-ExtraLightItalic-tlf-sc-ot1--base.tfm \
tex-Montserrat-ExtraLightItalic-tlf-sc-ot1.tfm \
tex-Montserrat-ExtraLightItalic-tlf-sc-ot1.vf \
tex-Montserrat-ExtraLightItalic-tlf-sc-t1--base.tfm \
tex-Montserrat-ExtraLightItalic-tlf-sc-t1.tfm \
tex-Montserrat-ExtraLightItalic-tlf-sc-t1.vf \
tex-Montserrat-ExtraLightItalic-tlf-t1--base.tfm \
tex-Montserrat-ExtraLightItalic-tlf-t1.tfm \
tex-Montserrat-ExtraLightItalic-tlf-t1.vf \
tex-Montserrat-ExtraLightItalic-tlf-ts1--base.tfm \
tex-Montserrat-ExtraLightItalic-tlf-ts1.tfm \
tex-Montserrat-ExtraLightItalic-tlf-ts1.vf \
tex-Montserrat-ExtraLightItalic-tosf-ly1--base.tfm \
tex-Montserrat-ExtraLightItalic-tosf-ly1.tfm \
tex-Montserrat-ExtraLightItalic-tosf-ly1.vf \
tex-Montserrat-ExtraLightItalic-tosf-ot1.tfm \
tex-Montserrat-ExtraLightItalic-tosf-sc-ly1--base.tfm \
tex-Montserrat-ExtraLightItalic-tosf-sc-ly1.tfm \
tex-Montserrat-ExtraLightItalic-tosf-sc-ly1.vf \
tex-Montserrat-ExtraLightItalic-tosf-sc-ot1--base.tfm \
tex-Montserrat-ExtraLightItalic-tosf-sc-ot1.tfm \
tex-Montserrat-ExtraLightItalic-tosf-sc-ot1.vf \
tex-Montserrat-ExtraLightItalic-tosf-sc-t1--base.tfm \
tex-Montserrat-ExtraLightItalic-tosf-sc-t1.tfm \
tex-Montserrat-ExtraLightItalic-tosf-sc-t1.vf \
tex-Montserrat-ExtraLightItalic-tosf-t1--base.tfm \
tex-Montserrat-ExtraLightItalic-tosf-t1.tfm \
tex-Montserrat-ExtraLightItalic-tosf-t1.vf \
tex-Montserrat-ExtraLightItalic-tosf-ts1--base.tfm \
tex-Montserrat-ExtraLightItalic-tosf-ts1.tfm \
tex-Montserrat-ExtraLightItalic-tosf-ts1.vf \
tex-Montserrat-Italic-dnom-ly1--base.tfm \
tex-Montserrat-Italic-dnom-ly1.tfm \
tex-Montserrat-Italic-dnom-ly1.vf \
tex-Montserrat-Italic-dnom-ot1.tfm \
tex-Montserrat-Italic-dnom-t1--base.tfm \
tex-Montserrat-Italic-dnom-t1.tfm \
tex-Montserrat-Italic-dnom-t1.vf \
tex-Montserrat-Italic-inf-ly1--base.tfm \
tex-Montserrat-Italic-inf-ly1.tfm \
tex-Montserrat-Italic-inf-ly1.vf \
tex-Montserrat-Italic-inf-ot1.tfm \
tex-Montserrat-Italic-inf-t1--base.tfm \
tex-Montserrat-Italic-inf-t1.tfm \
tex-Montserrat-Italic-inf-t1.vf \
tex-Montserrat-Italic-lf-ly1--base.tfm \
tex-Montserrat-Italic-lf-ly1.tfm \
tex-Montserrat-Italic-lf-ly1.vf \
tex-Montserrat-Italic-lf-ot1.tfm \
tex-Montserrat-Italic-lf-sc-ly1--base.tfm \
tex-Montserrat-Italic-lf-sc-ly1.tfm \
tex-Montserrat-Italic-lf-sc-ly1.vf \
tex-Montserrat-Italic-lf-sc-ot1--base.tfm \
tex-Montserrat-Italic-lf-sc-ot1.tfm \
tex-Montserrat-Italic-lf-sc-ot1.vf \
tex-Montserrat-Italic-lf-sc-t1--base.tfm \
tex-Montserrat-Italic-lf-sc-t1.tfm \
tex-Montserrat-Italic-lf-sc-t1.vf \
tex-Montserrat-Italic-lf-t1--base.tfm \
tex-Montserrat-Italic-lf-t1.tfm \
tex-Montserrat-Italic-lf-t1.vf \
tex-Montserrat-Italic-lf-ts1--base.tfm \
tex-Montserrat-Italic-lf-ts1.tfm \
tex-Montserrat-Italic-lf-ts1.vf \
tex-Montserrat-Italic-numr-ly1--base.tfm \
tex-Montserrat-Italic-numr-ly1.tfm \
tex-Montserrat-Italic-numr-ly1.vf \
tex-Montserrat-Italic-numr-ot1.tfm \
tex-Montserrat-Italic-numr-t1--base.tfm \
tex-Montserrat-Italic-numr-t1.tfm \
tex-Montserrat-Italic-numr-t1.vf \
tex-Montserrat-Italic-osf-ly1--base.tfm \
tex-Montserrat-Italic-osf-ly1.tfm \
tex-Montserrat-Italic-osf-ly1.vf \
tex-Montserrat-Italic-osf-ot1.tfm \
tex-Montserrat-Italic-osf-sc-ly1--base.tfm \
tex-Montserrat-Italic-osf-sc-ly1.tfm \
tex-Montserrat-Italic-osf-sc-ly1.vf \
tex-Montserrat-Italic-osf-sc-ot1--base.tfm \
tex-Montserrat-Italic-osf-sc-ot1.tfm \
tex-Montserrat-Italic-osf-sc-ot1.vf \
tex-Montserrat-Italic-osf-sc-t1--base.tfm \
tex-Montserrat-Italic-osf-sc-t1.tfm \
tex-Montserrat-Italic-osf-sc-t1.vf \
tex-Montserrat-Italic-osf-t1--base.tfm \
tex-Montserrat-Italic-osf-t1.tfm \
tex-Montserrat-Italic-osf-t1.vf \
tex-Montserrat-Italic-osf-ts1--base.tfm \
tex-Montserrat-Italic-osf-ts1.tfm \
tex-Montserrat-Italic-osf-ts1.vf \
tex-Montserrat-Italic-sup-ly1--base.tfm \
tex-Montserrat-Italic-sup-ly1.tfm \
tex-Montserrat-Italic-sup-ly1.vf \
tex-Montserrat-Italic-sup-ot1.tfm \
tex-Montserrat-Italic-sup-t1--base.tfm \
tex-Montserrat-Italic-sup-t1.tfm \
tex-Montserrat-Italic-sup-t1.vf \
tex-Montserrat-Italic-tlf-ly1--base.tfm \
tex-Montserrat-Italic-tlf-ly1.tfm \
tex-Montserrat-Italic-tlf-ly1.vf \
tex-Montserrat-Italic-tlf-ot1.tfm \
tex-Montserrat-Italic-tlf-sc-ly1--base.tfm \
tex-Montserrat-Italic-tlf-sc-ly1.tfm \
tex-Montserrat-Italic-tlf-sc-ly1.vf \
tex-Montserrat-Italic-tlf-sc-ot1--base.tfm \
tex-Montserrat-Italic-tlf-sc-ot1.tfm \
tex-Montserrat-Italic-tlf-sc-ot1.vf \
tex-Montserrat-Italic-tlf-sc-t1--base.tfm \
tex-Montserrat-Italic-tlf-sc-t1.tfm \
tex-Montserrat-Italic-tlf-sc-t1.vf \
tex-Montserrat-Italic-tlf-t1--base.tfm \
tex-Montserrat-Italic-tlf-t1.tfm \
tex-Montserrat-Italic-tlf-t1.vf \
tex-Montserrat-Italic-tlf-ts1--base.tfm \
tex-Montserrat-Italic-tlf-ts1.tfm \
tex-Montserrat-Italic-tlf-ts1.vf \
tex-Montserrat-Italic-tosf-ly1--base.tfm \
tex-Montserrat-Italic-tosf-ly1.tfm \
tex-Montserrat-Italic-tosf-ly1.vf \
tex-Montserrat-Italic-tosf-ot1.tfm \
tex-Montserrat-Italic-tosf-sc-ly1--base.tfm \
tex-Montserrat-Italic-tosf-sc-ly1.tfm \
tex-Montserrat-Italic-tosf-sc-ly1.vf \
tex-Montserrat-Italic-tosf-sc-ot1--base.tfm \
tex-Montserrat-Italic-tosf-sc-ot1.tfm \
tex-Montserrat-Italic-tosf-sc-ot1.vf \
tex-Montserrat-Italic-tosf-sc-t1--base.tfm \
tex-Montserrat-Italic-tosf-sc-t1.tfm \
tex-Montserrat-Italic-tosf-sc-t1.vf \
tex-Montserrat-Italic-tosf-t1--base.tfm \
tex-Montserrat-Italic-tosf-t1.tfm \
tex-Montserrat-Italic-tosf-t1.vf \
tex-Montserrat-Italic-tosf-ts1--base.tfm \
tex-Montserrat-Italic-tosf-ts1.tfm \
tex-Montserrat-Italic-tosf-ts1.vf \
tex-Montserrat-Light-dnom-ly1--base.tfm \
tex-Montserrat-Light-dnom-ly1.tfm \
tex-Montserrat-Light-dnom-ly1.vf \
tex-Montserrat-Light-dnom-ot1.tfm \
tex-Montserrat-Light-dnom-t1--base.tfm \
tex-Montserrat-Light-dnom-t1.tfm \
tex-Montserrat-Light-dnom-t1.vf \
tex-Montserrat-Light-inf-ly1--base.tfm \
tex-Montserrat-Light-inf-ly1.tfm \
tex-Montserrat-Light-inf-ly1.vf \
tex-Montserrat-Light-inf-ot1.tfm \
tex-Montserrat-Light-inf-t1--base.tfm \
tex-Montserrat-Light-inf-t1.tfm \
tex-Montserrat-Light-inf-t1.vf \
tex-Montserrat-Light-lf-ly1--base.tfm \
tex-Montserrat-Light-lf-ly1.tfm \
tex-Montserrat-Light-lf-ly1.vf \
tex-Montserrat-Light-lf-ot1.tfm \
tex-Montserrat-Light-lf-sc-ly1--base.tfm \
tex-Montserrat-Light-lf-sc-ly1.tfm \
tex-Montserrat-Light-lf-sc-ly1.vf \
tex-Montserrat-Light-lf-sc-ot1--base.tfm \
tex-Montserrat-Light-lf-sc-ot1.tfm \
tex-Montserrat-Light-lf-sc-ot1.vf \
tex-Montserrat-Light-lf-sc-t1--base.tfm \
tex-Montserrat-Light-lf-sc-t1.tfm \
tex-Montserrat-Light-lf-sc-t1.vf \
tex-Montserrat-Light-lf-t1--base.tfm \
tex-Montserrat-Light-lf-t1.tfm \
tex-Montserrat-Light-lf-t1.vf \
tex-Montserrat-Light-lf-ts1--base.tfm \
tex-Montserrat-Light-lf-ts1.tfm \
tex-Montserrat-Light-lf-ts1.vf \
tex-Montserrat-Light-numr-ly1--base.tfm \
tex-Montserrat-Light-numr-ly1.tfm \
tex-Montserrat-Light-numr-ly1.vf \
tex-Montserrat-Light-numr-ot1.tfm \
tex-Montserrat-Light-numr-t1--base.tfm \
tex-Montserrat-Light-numr-t1.tfm \
tex-Montserrat-Light-numr-t1.vf \
tex-Montserrat-Light-osf-ly1--base.tfm \
tex-Montserrat-Light-osf-ly1.tfm \
tex-Montserrat-Light-osf-ly1.vf \
tex-Montserrat-Light-osf-ot1.tfm \
tex-Montserrat-Light-osf-sc-ly1--base.tfm \
tex-Montserrat-Light-osf-sc-ly1.tfm \
tex-Montserrat-Light-osf-sc-ly1.vf \
tex-Montserrat-Light-osf-sc-ot1--base.tfm \
tex-Montserrat-Light-osf-sc-ot1.tfm \
tex-Montserrat-Light-osf-sc-ot1.vf \
tex-Montserrat-Light-osf-sc-t1--base.tfm \
tex-Montserrat-Light-osf-sc-t1.tfm \
tex-Montserrat-Light-osf-sc-t1.vf \
tex-Montserrat-Light-osf-t1--base.tfm \
tex-Montserrat-Light-osf-t1.tfm \
tex-Montserrat-Light-osf-t1.vf \
tex-Montserrat-Light-osf-ts1--base.tfm \
tex-Montserrat-Light-osf-ts1.tfm \
tex-Montserrat-Light-osf-ts1.vf \
tex-Montserrat-Light-sup-ly1--base.tfm \
tex-Montserrat-Light-sup-ly1.tfm \
tex-Montserrat-Light-sup-ly1.vf \
tex-Montserrat-Light-sup-ot1.tfm \
tex-Montserrat-Light-sup-t1--base.tfm \
tex-Montserrat-Light-sup-t1.tfm \
tex-Montserrat-Light-sup-t1.vf \
tex-Montserrat-Light-tlf-ly1--base.tfm \
tex-Montserrat-Light-tlf-ly1.tfm \
tex-Montserrat-Light-tlf-ly1.vf \
tex-Montserrat-Light-tlf-ot1.tfm \
tex-Montserrat-Light-tlf-sc-ly1--base.tfm \
tex-Montserrat-Light-tlf-sc-ly1.tfm \
tex-Montserrat-Light-tlf-sc-ly1.vf \
tex-Montserrat-Light-tlf-sc-ot1--base.tfm \
tex-Montserrat-Light-tlf-sc-ot1.tfm \
tex-Montserrat-Light-tlf-sc-ot1.vf \
tex-Montserrat-Light-tlf-sc-t1--base.tfm \
tex-Montserrat-Light-tlf-sc-t1.tfm \
tex-Montserrat-Light-tlf-sc-t1.vf \
tex-Montserrat-Light-tlf-t1--base.tfm \
tex-Montserrat-Light-tlf-t1.tfm \
tex-Montserrat-Light-tlf-t1.vf \
tex-Montserrat-Light-tlf-ts1--base.tfm \
tex-Montserrat-Light-tlf-ts1.tfm \
tex-Montserrat-Light-tlf-ts1.vf \
tex-Montserrat-Light-tosf-ly1--base.tfm \
tex-Montserrat-Light-tosf-ly1.tfm \
tex-Montserrat-Light-tosf-ly1.vf \
tex-Montserrat-Light-tosf-ot1.tfm \
tex-Montserrat-Light-tosf-sc-ly1--base.tfm \
tex-Montserrat-Light-tosf-sc-ly1.tfm \
tex-Montserrat-Light-tosf-sc-ly1.vf \
tex-Montserrat-Light-tosf-sc-ot1--base.tfm \
tex-Montserrat-Light-tosf-sc-ot1.tfm \
tex-Montserrat-Light-tosf-sc-ot1.vf \
tex-Montserrat-Light-tosf-sc-t1--base.tfm \
tex-Montserrat-Light-tosf-sc-t1.tfm \
tex-Montserrat-Light-tosf-sc-t1.vf \
tex-Montserrat-Light-tosf-t1--base.tfm \
tex-Montserrat-Light-tosf-t1.tfm \
tex-Montserrat-Light-tosf-t1.vf \
tex-Montserrat-Light-tosf-ts1--base.tfm \
tex-Montserrat-Light-tosf-ts1.tfm \
tex-Montserrat-Light-tosf-ts1.vf \
tex-Montserrat-LightItalic-dnom-ly1--base.tfm \
tex-Montserrat-LightItalic-dnom-ly1.tfm \
tex-Montserrat-LightItalic-dnom-ly1.vf \
tex-Montserrat-LightItalic-dnom-ot1.tfm \
tex-Montserrat-LightItalic-dnom-t1--base.tfm \
tex-Montserrat-LightItalic-dnom-t1.tfm \
tex-Montserrat-LightItalic-dnom-t1.vf \
tex-Montserrat-LightItalic-inf-ly1--base.tfm \
tex-Montserrat-LightItalic-inf-ly1.tfm \
tex-Montserrat-LightItalic-inf-ly1.vf \
tex-Montserrat-LightItalic-inf-ot1.tfm \
tex-Montserrat-LightItalic-inf-t1--base.tfm \
tex-Montserrat-LightItalic-inf-t1.tfm \
tex-Montserrat-LightItalic-inf-t1.vf \
tex-Montserrat-LightItalic-lf-ly1--base.tfm \
tex-Montserrat-LightItalic-lf-ly1.tfm \
tex-Montserrat-LightItalic-lf-ly1.vf \
tex-Montserrat-LightItalic-lf-ot1.tfm \
tex-Montserrat-LightItalic-lf-sc-ly1--base.tfm \
tex-Montserrat-LightItalic-lf-sc-ly1.tfm \
tex-Montserrat-LightItalic-lf-sc-ly1.vf \
tex-Montserrat-LightItalic-lf-sc-ot1--base.tfm \
tex-Montserrat-LightItalic-lf-sc-ot1.tfm \
tex-Montserrat-LightItalic-lf-sc-ot1.vf \
tex-Montserrat-LightItalic-lf-sc-t1--base.tfm \
tex-Montserrat-LightItalic-lf-sc-t1.tfm \
tex-Montserrat-LightItalic-lf-sc-t1.vf \
tex-Montserrat-LightItalic-lf-t1--base.tfm \
tex-Montserrat-LightItalic-lf-t1.tfm \
tex-Montserrat-LightItalic-lf-t1.vf \
tex-Montserrat-LightItalic-lf-ts1--base.tfm \
tex-Montserrat-LightItalic-lf-ts1.tfm \
tex-Montserrat-LightItalic-lf-ts1.vf \
tex-Montserrat-LightItalic-numr-ly1--base.tfm \
tex-Montserrat-LightItalic-numr-ly1.tfm \
tex-Montserrat-LightItalic-numr-ly1.vf \
tex-Montserrat-LightItalic-numr-ot1.tfm \
tex-Montserrat-LightItalic-numr-t1--base.tfm \
tex-Montserrat-LightItalic-numr-t1.tfm \
tex-Montserrat-LightItalic-numr-t1.vf \
tex-Montserrat-LightItalic-osf-ly1--base.tfm \
tex-Montserrat-LightItalic-osf-ly1.tfm \
tex-Montserrat-LightItalic-osf-ly1.vf \
tex-Montserrat-LightItalic-osf-ot1.tfm \
tex-Montserrat-LightItalic-osf-sc-ly1--base.tfm \
tex-Montserrat-LightItalic-osf-sc-ly1.tfm \
tex-Montserrat-LightItalic-osf-sc-ly1.vf \
tex-Montserrat-LightItalic-osf-sc-ot1--base.tfm \
tex-Montserrat-LightItalic-osf-sc-ot1.tfm \
tex-Montserrat-LightItalic-osf-sc-ot1.vf \
tex-Montserrat-LightItalic-osf-sc-t1--base.tfm \
tex-Montserrat-LightItalic-osf-sc-t1.tfm \
tex-Montserrat-LightItalic-osf-sc-t1.vf \
tex-Montserrat-LightItalic-osf-t1--base.tfm \
tex-Montserrat-LightItalic-osf-t1.tfm \
tex-Montserrat-LightItalic-osf-t1.vf \
tex-Montserrat-LightItalic-osf-ts1--base.tfm \
tex-Montserrat-LightItalic-osf-ts1.tfm \
tex-Montserrat-LightItalic-osf-ts1.vf \
tex-Montserrat-LightItalic-sup-ly1--base.tfm \
tex-Montserrat-LightItalic-sup-ly1.tfm \
tex-Montserrat-LightItalic-sup-ly1.vf \
tex-Montserrat-LightItalic-sup-ot1.tfm \
tex-Montserrat-LightItalic-sup-t1--base.tfm \
tex-Montserrat-LightItalic-sup-t1.tfm \
tex-Montserrat-LightItalic-sup-t1.vf \
tex-Montserrat-LightItalic-tlf-ly1--base.tfm \
tex-Montserrat-LightItalic-tlf-ly1.tfm \
tex-Montserrat-LightItalic-tlf-ly1.vf \
tex-Montserrat-LightItalic-tlf-ot1.tfm \
tex-Montserrat-LightItalic-tlf-sc-ly1--base.tfm \
tex-Montserrat-LightItalic-tlf-sc-ly1.tfm \
tex-Montserrat-LightItalic-tlf-sc-ly1.vf \
tex-Montserrat-LightItalic-tlf-sc-ot1--base.tfm \
tex-Montserrat-LightItalic-tlf-sc-ot1.tfm \
tex-Montserrat-LightItalic-tlf-sc-ot1.vf \
tex-Montserrat-LightItalic-tlf-sc-t1--base.tfm \
tex-Montserrat-LightItalic-tlf-sc-t1.tfm \
tex-Montserrat-LightItalic-tlf-sc-t1.vf \
tex-Montserrat-LightItalic-tlf-t1--base.tfm \
tex-Montserrat-LightItalic-tlf-t1.tfm \
tex-Montserrat-LightItalic-tlf-t1.vf \
tex-Montserrat-LightItalic-tlf-ts1--base.tfm \
tex-Montserrat-LightItalic-tlf-ts1.tfm \
tex-Montserrat-LightItalic-tlf-ts1.vf \
tex-Montserrat-LightItalic-tosf-ly1--base.tfm \
tex-Montserrat-LightItalic-tosf-ly1.tfm \
tex-Montserrat-LightItalic-tosf-ly1.vf \
tex-Montserrat-LightItalic-tosf-ot1.tfm \
tex-Montserrat-LightItalic-tosf-sc-ly1--base.tfm \
tex-Montserrat-LightItalic-tosf-sc-ly1.tfm \
tex-Montserrat-LightItalic-tosf-sc-ly1.vf \
tex-Montserrat-LightItalic-tosf-sc-ot1--base.tfm \
tex-Montserrat-LightItalic-tosf-sc-ot1.tfm \
tex-Montserrat-LightItalic-tosf-sc-ot1.vf \
tex-Montserrat-LightItalic-tosf-sc-t1--base.tfm \
tex-Montserrat-LightItalic-tosf-sc-t1.tfm \
tex-Montserrat-LightItalic-tosf-sc-t1.vf \
tex-Montserrat-LightItalic-tosf-t1--base.tfm \
tex-Montserrat-LightItalic-tosf-t1.tfm \
tex-Montserrat-LightItalic-tosf-t1.vf \
tex-Montserrat-LightItalic-tosf-ts1--base.tfm \
tex-Montserrat-LightItalic-tosf-ts1.tfm \
tex-Montserrat-LightItalic-tosf-ts1.vf \
tex-Montserrat-Medium-dnom-ly1--base.tfm \
tex-Montserrat-Medium-dnom-ly1.tfm \
tex-Montserrat-Medium-dnom-ly1.vf \
tex-Montserrat-Medium-dnom-ot1.tfm \
tex-Montserrat-Medium-dnom-t1--base.tfm \
tex-Montserrat-Medium-dnom-t1.tfm \
tex-Montserrat-Medium-dnom-t1.vf \
tex-Montserrat-Medium-inf-ly1--base.tfm \
tex-Montserrat-Medium-inf-ly1.tfm \
tex-Montserrat-Medium-inf-ly1.vf \
tex-Montserrat-Medium-inf-ot1.tfm \
tex-Montserrat-Medium-inf-t1--base.tfm \
tex-Montserrat-Medium-inf-t1.tfm \
tex-Montserrat-Medium-inf-t1.vf \
tex-Montserrat-Medium-lf-ly1--base.tfm \
tex-Montserrat-Medium-lf-ly1.tfm \
tex-Montserrat-Medium-lf-ly1.vf \
tex-Montserrat-Medium-lf-ot1.tfm \
tex-Montserrat-Medium-lf-sc-ly1--base.tfm \
tex-Montserrat-Medium-lf-sc-ly1.tfm \
tex-Montserrat-Medium-lf-sc-ly1.vf \
tex-Montserrat-Medium-lf-sc-ot1--base.tfm \
tex-Montserrat-Medium-lf-sc-ot1.tfm \
tex-Montserrat-Medium-lf-sc-ot1.vf \
tex-Montserrat-Medium-lf-sc-t1--base.tfm \
tex-Montserrat-Medium-lf-sc-t1.tfm \
tex-Montserrat-Medium-lf-sc-t1.vf \
tex-Montserrat-Medium-lf-t1--base.tfm \
tex-Montserrat-Medium-lf-t1.tfm \
tex-Montserrat-Medium-lf-t1.vf \
tex-Montserrat-Medium-lf-ts1--base.tfm \
tex-Montserrat-Medium-lf-ts1.tfm \
tex-Montserrat-Medium-lf-ts1.vf \
tex-Montserrat-Medium-numr-ly1--base.tfm \
tex-Montserrat-Medium-numr-ly1.tfm \
tex-Montserrat-Medium-numr-ly1.vf \
tex-Montserrat-Medium-numr-ot1.tfm \
tex-Montserrat-Medium-numr-t1--base.tfm \
tex-Montserrat-Medium-numr-t1.tfm \
tex-Montserrat-Medium-numr-t1.vf \
tex-Montserrat-Medium-osf-ly1--base.tfm \
tex-Montserrat-Medium-osf-ly1.tfm \
tex-Montserrat-Medium-osf-ly1.vf \
tex-Montserrat-Medium-osf-ot1.tfm \
tex-Montserrat-Medium-osf-sc-ly1--base.tfm \
tex-Montserrat-Medium-osf-sc-ly1.tfm \
tex-Montserrat-Medium-osf-sc-ly1.vf \
tex-Montserrat-Medium-osf-sc-ot1--base.tfm \
tex-Montserrat-Medium-osf-sc-ot1.tfm \
tex-Montserrat-Medium-osf-sc-ot1.vf \
tex-Montserrat-Medium-osf-sc-t1--base.tfm \
tex-Montserrat-Medium-osf-sc-t1.tfm \
tex-Montserrat-Medium-osf-sc-t1.vf \
tex-Montserrat-Medium-osf-t1--base.tfm \
tex-Montserrat-Medium-osf-t1.tfm \
tex-Montserrat-Medium-osf-t1.vf \
tex-Montserrat-Medium-osf-ts1--base.tfm \
tex-Montserrat-Medium-osf-ts1.tfm \
tex-Montserrat-Medium-osf-ts1.vf \
tex-Montserrat-Medium-sup-ly1--base.tfm \
tex-Montserrat-Medium-sup-ly1.tfm \
tex-Montserrat-Medium-sup-ly1.vf \
tex-Montserrat-Medium-sup-ot1.tfm \
tex-Montserrat-Medium-sup-t1--base.tfm \
tex-Montserrat-Medium-sup-t1.tfm \
tex-Montserrat-Medium-sup-t1.vf \
tex-Montserrat-Medium-tlf-ly1--base.tfm \
tex-Montserrat-Medium-tlf-ly1.tfm \
tex-Montserrat-Medium-tlf-ly1.vf \
tex-Montserrat-Medium-tlf-ot1.tfm \
tex-Montserrat-Medium-tlf-sc-ly1--base.tfm \
tex-Montserrat-Medium-tlf-sc-ly1.tfm \
tex-Montserrat-Medium-tlf-sc-ly1.vf \
tex-Montserrat-Medium-tlf-sc-ot1--base.tfm \
tex-Montserrat-Medium-tlf-sc-ot1.tfm \
tex-Montserrat-Medium-tlf-sc-ot1.vf \
tex-Montserrat-Medium-tlf-sc-t1--base.tfm \
tex-Montserrat-Medium-tlf-sc-t1.tfm \
tex-Montserrat-Medium-tlf-sc-t1.vf \
tex-Montserrat-Medium-tlf-t1--base.tfm \
tex-Montserrat-Medium-tlf-t1.tfm \
tex-Montserrat-Medium-tlf-t1.vf \
tex-Montserrat-Medium-tlf-ts1--base.tfm \
tex-Montserrat-Medium-tlf-ts1.tfm \
tex-Montserrat-Medium-tlf-ts1.vf \
tex-Montserrat-Medium-tosf-ly1--base.tfm \
tex-Montserrat-Medium-tosf-ly1.tfm \
tex-Montserrat-Medium-tosf-ly1.vf \
tex-Montserrat-Medium-tosf-ot1.tfm \
tex-Montserrat-Medium-tosf-sc-ly1--base.tfm \
tex-Montserrat-Medium-tosf-sc-ly1.tfm \
tex-Montserrat-Medium-tosf-sc-ly1.vf \
tex-Montserrat-Medium-tosf-sc-ot1--base.tfm \
tex-Montserrat-Medium-tosf-sc-ot1.tfm \
tex-Montserrat-Medium-tosf-sc-ot1.vf \
tex-Montserrat-Medium-tosf-sc-t1--base.tfm \
tex-Montserrat-Medium-tosf-sc-t1.tfm \
tex-Montserrat-Medium-tosf-sc-t1.vf \
tex-Montserrat-Medium-tosf-t1--base.tfm \
tex-Montserrat-Medium-tosf-t1.tfm \
tex-Montserrat-Medium-tosf-t1.vf \
tex-Montserrat-Medium-tosf-ts1--base.tfm \
tex-Montserrat-Medium-tosf-ts1.tfm \
tex-Montserrat-Medium-tosf-ts1.vf \
tex-Montserrat-MediumItalic-dnom-ly1--base.tfm \
tex-Montserrat-MediumItalic-dnom-ly1.tfm \
tex-Montserrat-MediumItalic-dnom-ly1.vf \
tex-Montserrat-MediumItalic-dnom-ot1.tfm \
tex-Montserrat-MediumItalic-dnom-t1--base.tfm \
tex-Montserrat-MediumItalic-dnom-t1.tfm \
tex-Montserrat-MediumItalic-dnom-t1.vf \
tex-Montserrat-MediumItalic-inf-ly1--base.tfm \
tex-Montserrat-MediumItalic-inf-ly1.tfm \
tex-Montserrat-MediumItalic-inf-ly1.vf \
tex-Montserrat-MediumItalic-inf-ot1.tfm \
tex-Montserrat-MediumItalic-inf-t1--base.tfm \
tex-Montserrat-MediumItalic-inf-t1.tfm \
tex-Montserrat-MediumItalic-inf-t1.vf \
tex-Montserrat-MediumItalic-lf-ly1--base.tfm \
tex-Montserrat-MediumItalic-lf-ly1.tfm \
tex-Montserrat-MediumItalic-lf-ly1.vf \
tex-Montserrat-MediumItalic-lf-ot1.tfm \
tex-Montserrat-MediumItalic-lf-sc-ly1--base.tfm \
tex-Montserrat-MediumItalic-lf-sc-ly1.tfm \
tex-Montserrat-MediumItalic-lf-sc-ly1.vf \
tex-Montserrat-MediumItalic-lf-sc-ot1--base.tfm \
tex-Montserrat-MediumItalic-lf-sc-ot1.tfm \
tex-Montserrat-MediumItalic-lf-sc-ot1.vf \
tex-Montserrat-MediumItalic-lf-sc-t1--base.tfm \
tex-Montserrat-MediumItalic-lf-sc-t1.tfm \
tex-Montserrat-MediumItalic-lf-sc-t1.vf \
tex-Montserrat-MediumItalic-lf-t1--base.tfm \
tex-Montserrat-MediumItalic-lf-t1.tfm \
tex-Montserrat-MediumItalic-lf-t1.vf \
tex-Montserrat-MediumItalic-lf-ts1--base.tfm \
tex-Montserrat-MediumItalic-lf-ts1.tfm \
tex-Montserrat-MediumItalic-lf-ts1.vf \
tex-Montserrat-MediumItalic-numr-ly1--base.tfm \
tex-Montserrat-MediumItalic-numr-ly1.tfm \
tex-Montserrat-MediumItalic-numr-ly1.vf \
tex-Montserrat-MediumItalic-numr-ot1.tfm \
tex-Montserrat-MediumItalic-numr-t1--base.tfm \
tex-Montserrat-MediumItalic-numr-t1.tfm \
tex-Montserrat-MediumItalic-numr-t1.vf \
tex-Montserrat-MediumItalic-osf-ly1--base.tfm \
tex-Montserrat-MediumItalic-osf-ly1.tfm \
tex-Montserrat-MediumItalic-osf-ly1.vf \
tex-Montserrat-MediumItalic-osf-ot1.tfm \
tex-Montserrat-MediumItalic-osf-sc-ly1--base.tfm \
tex-Montserrat-MediumItalic-osf-sc-ly1.tfm \
tex-Montserrat-MediumItalic-osf-sc-ly1.vf \
tex-Montserrat-MediumItalic-osf-sc-ot1--base.tfm \
tex-Montserrat-MediumItalic-osf-sc-ot1.tfm \
tex-Montserrat-MediumItalic-osf-sc-ot1.vf \
tex-Montserrat-MediumItalic-osf-sc-t1--base.tfm \
tex-Montserrat-MediumItalic-osf-sc-t1.tfm \
tex-Montserrat-MediumItalic-osf-sc-t1.vf \
tex-Montserrat-MediumItalic-osf-t1--base.tfm \
tex-Montserrat-MediumItalic-osf-t1.tfm \
tex-Montserrat-MediumItalic-osf-t1.vf \
tex-Montserrat-MediumItalic-osf-ts1--base.tfm \
tex-Montserrat-MediumItalic-osf-ts1.tfm \
tex-Montserrat-MediumItalic-osf-ts1.vf \
tex-Montserrat-MediumItalic-sup-ly1--base.tfm \
tex-Montserrat-MediumItalic-sup-ly1.tfm \
tex-Montserrat-MediumItalic-sup-ly1.vf \
tex-Montserrat-MediumItalic-sup-ot1.tfm \
tex-Montserrat-MediumItalic-sup-t1--base.tfm \
tex-Montserrat-MediumItalic-sup-t1.tfm \
tex-Montserrat-MediumItalic-sup-t1.vf \
tex-Montserrat-MediumItalic-tlf-ly1--base.tfm \
tex-Montserrat-MediumItalic-tlf-ly1.tfm \
tex-Montserrat-MediumItalic-tlf-ly1.vf \
tex-Montserrat-MediumItalic-tlf-ot1.tfm \
tex-Montserrat-MediumItalic-tlf-sc-ly1--base.tfm \
tex-Montserrat-MediumItalic-tlf-sc-ly1.tfm \
tex-Montserrat-MediumItalic-tlf-sc-ly1.vf \
tex-Montserrat-MediumItalic-tlf-sc-ot1--base.tfm \
tex-Montserrat-MediumItalic-tlf-sc-ot1.tfm \
tex-Montserrat-MediumItalic-tlf-sc-ot1.vf \
tex-Montserrat-MediumItalic-tlf-sc-t1--base.tfm \
tex-Montserrat-MediumItalic-tlf-sc-t1.tfm \
tex-Montserrat-MediumItalic-tlf-sc-t1.vf \
tex-Montserrat-MediumItalic-tlf-t1--base.tfm \
tex-Montserrat-MediumItalic-tlf-t1.tfm \
tex-Montserrat-MediumItalic-tlf-t1.vf \
tex-Montserrat-MediumItalic-tlf-ts1--base.tfm \
tex-Montserrat-MediumItalic-tlf-ts1.tfm \
tex-Montserrat-MediumItalic-tlf-ts1.vf \
tex-Montserrat-MediumItalic-tosf-ly1--base.tfm \
tex-Montserrat-MediumItalic-tosf-ly1.tfm \
tex-Montserrat-MediumItalic-tosf-ly1.vf \
tex-Montserrat-MediumItalic-tosf-ot1.tfm \
tex-Montserrat-MediumItalic-tosf-sc-ly1--base.tfm \
tex-Montserrat-MediumItalic-tosf-sc-ly1.tfm \
tex-Montserrat-MediumItalic-tosf-sc-ly1.vf \
tex-Montserrat-MediumItalic-tosf-sc-ot1--base.tfm \
tex-Montserrat-MediumItalic-tosf-sc-ot1.tfm \
tex-Montserrat-MediumItalic-tosf-sc-ot1.vf \
tex-Montserrat-MediumItalic-tosf-sc-t1--base.tfm \
tex-Montserrat-MediumItalic-tosf-sc-t1.tfm \
tex-Montserrat-MediumItalic-tosf-sc-t1.vf \
tex-Montserrat-MediumItalic-tosf-t1--base.tfm \
tex-Montserrat-MediumItalic-tosf-t1.tfm \
tex-Montserrat-MediumItalic-tosf-t1.vf \
tex-Montserrat-MediumItalic-tosf-ts1--base.tfm \
tex-Montserrat-MediumItalic-tosf-ts1.tfm \
tex-Montserrat-MediumItalic-tosf-ts1.vf \
tex-Montserrat-Regular-dnom-ly1--base.tfm \
tex-Montserrat-Regular-dnom-ly1.tfm \
tex-Montserrat-Regular-dnom-ly1.vf \
tex-Montserrat-Regular-dnom-ot1.tfm \
tex-Montserrat-Regular-dnom-t1--base.tfm \
tex-Montserrat-Regular-dnom-t1.tfm \
tex-Montserrat-Regular-dnom-t1.vf \
tex-Montserrat-Regular-inf-ly1--base.tfm \
tex-Montserrat-Regular-inf-ly1.tfm \
tex-Montserrat-Regular-inf-ly1.vf \
tex-Montserrat-Regular-inf-ot1.tfm \
tex-Montserrat-Regular-inf-t1--base.tfm \
tex-Montserrat-Regular-inf-t1.tfm \
tex-Montserrat-Regular-inf-t1.vf \
tex-Montserrat-Regular-lf-ly1--base.tfm \
tex-Montserrat-Regular-lf-ly1.tfm \
tex-Montserrat-Regular-lf-ly1.vf \
tex-Montserrat-Regular-lf-ot1.tfm \
tex-Montserrat-Regular-lf-sc-ly1--base.tfm \
tex-Montserrat-Regular-lf-sc-ly1.tfm \
tex-Montserrat-Regular-lf-sc-ly1.vf \
tex-Montserrat-Regular-lf-sc-ot1--base.tfm \
tex-Montserrat-Regular-lf-sc-ot1.tfm \
tex-Montserrat-Regular-lf-sc-ot1.vf \
tex-Montserrat-Regular-lf-sc-t1--base.tfm \
tex-Montserrat-Regular-lf-sc-t1.tfm \
tex-Montserrat-Regular-lf-sc-t1.vf \
tex-Montserrat-Regular-lf-t1--base.tfm \
tex-Montserrat-Regular-lf-t1.tfm \
tex-Montserrat-Regular-lf-t1.vf \
tex-Montserrat-Regular-lf-ts1--base.tfm \
tex-Montserrat-Regular-lf-ts1.tfm \
tex-Montserrat-Regular-lf-ts1.vf \
tex-Montserrat-Regular-numr-ly1--base.tfm \
tex-Montserrat-Regular-numr-ly1.tfm \
tex-Montserrat-Regular-numr-ly1.vf \
tex-Montserrat-Regular-numr-ot1.tfm \
tex-Montserrat-Regular-numr-t1--base.tfm \
tex-Montserrat-Regular-numr-t1.tfm \
tex-Montserrat-Regular-numr-t1.vf \
tex-Montserrat-Regular-osf-ly1--base.tfm \
tex-Montserrat-Regular-osf-ly1.tfm \
tex-Montserrat-Regular-osf-ly1.vf \
tex-Montserrat-Regular-osf-ot1.tfm \
tex-Montserrat-Regular-osf-sc-ly1--base.tfm \
tex-Montserrat-Regular-osf-sc-ly1.tfm \
tex-Montserrat-Regular-osf-sc-ly1.vf \
tex-Montserrat-Regular-osf-sc-ot1--base.tfm \
tex-Montserrat-Regular-osf-sc-ot1.tfm \
tex-Montserrat-Regular-osf-sc-ot1.vf \
tex-Montserrat-Regular-osf-sc-t1--base.tfm \
tex-Montserrat-Regular-osf-sc-t1.tfm \
tex-Montserrat-Regular-osf-sc-t1.vf \
tex-Montserrat-Regular-osf-t1--base.tfm \
tex-Montserrat-Regular-osf-t1.tfm \
tex-Montserrat-Regular-osf-t1.vf \
tex-Montserrat-Regular-osf-ts1--base.tfm \
tex-Montserrat-Regular-osf-ts1.tfm \
tex-Montserrat-Regular-osf-ts1.vf \
tex-Montserrat-Regular-sup-ly1--base.tfm \
tex-Montserrat-Regular-sup-ly1.tfm \
tex-Montserrat-Regular-sup-ly1.vf \
tex-Montserrat-Regular-sup-ot1.tfm \
tex-Montserrat-Regular-sup-t1--base.tfm \
tex-Montserrat-Regular-sup-t1.tfm \
tex-Montserrat-Regular-sup-t1.vf \
tex-Montserrat-Regular-tlf-ly1--base.tfm \
tex-Montserrat-Regular-tlf-ly1.tfm \
tex-Montserrat-Regular-tlf-ly1.vf \
tex-Montserrat-Regular-tlf-ot1.tfm \
tex-Montserrat-Regular-tlf-sc-ly1--base.tfm \
tex-Montserrat-Regular-tlf-sc-ly1.tfm \
tex-Montserrat-Regular-tlf-sc-ly1.vf \
tex-Montserrat-Regular-tlf-sc-ot1--base.tfm \
tex-Montserrat-Regular-tlf-sc-ot1.tfm \
tex-Montserrat-Regular-tlf-sc-ot1.vf \
tex-Montserrat-Regular-tlf-sc-t1--base.tfm \
tex-Montserrat-Regular-tlf-sc-t1.tfm \
tex-Montserrat-Regular-tlf-sc-t1.vf \
tex-Montserrat-Regular-tlf-t1--base.tfm \
tex-Montserrat-Regular-tlf-t1.tfm \
tex-Montserrat-Regular-tlf-t1.vf \
tex-Montserrat-Regular-tlf-ts1--base.tfm \
tex-Montserrat-Regular-tlf-ts1.tfm \
tex-Montserrat-Regular-tlf-ts1.vf \
tex-Montserrat-Regular-tosf-ly1--base.tfm \
tex-Montserrat-Regular-tosf-ly1.tfm \
tex-Montserrat-Regular-tosf-ly1.vf \
tex-Montserrat-Regular-tosf-ot1.tfm \
tex-Montserrat-Regular-tosf-sc-ly1--base.tfm \
tex-Montserrat-Regular-tosf-sc-ly1.tfm \
tex-Montserrat-Regular-tosf-sc-ly1.vf \
tex-Montserrat-Regular-tosf-sc-ot1--base.tfm \
tex-Montserrat-Regular-tosf-sc-ot1.tfm \
tex-Montserrat-Regular-tosf-sc-ot1.vf \
tex-Montserrat-Regular-tosf-sc-t1--base.tfm \
tex-Montserrat-Regular-tosf-sc-t1.tfm \
tex-Montserrat-Regular-tosf-sc-t1.vf \
tex-Montserrat-Regular-tosf-t1--base.tfm \
tex-Montserrat-Regular-tosf-t1.tfm \
tex-Montserrat-Regular-tosf-t1.vf \
tex-Montserrat-Regular-tosf-ts1--base.tfm \
tex-Montserrat-Regular-tosf-ts1.tfm \
tex-Montserrat-Regular-tosf-ts1.vf \
tex-Montserrat-SemiBold-dnom-ly1--base.tfm \
tex-Montserrat-SemiBold-dnom-ly1.tfm \
tex-Montserrat-SemiBold-dnom-ly1.vf \
tex-Montserrat-SemiBold-dnom-ot1.tfm \
tex-Montserrat-SemiBold-dnom-t1--base.tfm \
tex-Montserrat-SemiBold-dnom-t1.tfm \
tex-Montserrat-SemiBold-dnom-t1.vf \
tex-Montserrat-SemiBold-inf-ly1--base.tfm \
tex-Montserrat-SemiBold-inf-ly1.tfm \
tex-Montserrat-SemiBold-inf-ly1.vf \
tex-Montserrat-SemiBold-inf-ot1.tfm \
tex-Montserrat-SemiBold-inf-t1--base.tfm \
tex-Montserrat-SemiBold-inf-t1.tfm \
tex-Montserrat-SemiBold-inf-t1.vf \
tex-Montserrat-SemiBold-lf-ly1--base.tfm \
tex-Montserrat-SemiBold-lf-ly1.tfm \
tex-Montserrat-SemiBold-lf-ly1.vf \
tex-Montserrat-SemiBold-lf-ot1.tfm \
tex-Montserrat-SemiBold-lf-sc-ly1--base.tfm \
tex-Montserrat-SemiBold-lf-sc-ly1.tfm \
tex-Montserrat-SemiBold-lf-sc-ly1.vf \
tex-Montserrat-SemiBold-lf-sc-ot1--base.tfm \
tex-Montserrat-SemiBold-lf-sc-ot1.tfm \
tex-Montserrat-SemiBold-lf-sc-ot1.vf \
tex-Montserrat-SemiBold-lf-sc-t1--base.tfm \
tex-Montserrat-SemiBold-lf-sc-t1.tfm \
tex-Montserrat-SemiBold-lf-sc-t1.vf \
tex-Montserrat-SemiBold-lf-t1--base.tfm \
tex-Montserrat-SemiBold-lf-t1.tfm \
tex-Montserrat-SemiBold-lf-t1.vf \
tex-Montserrat-SemiBold-lf-ts1--base.tfm \
tex-Montserrat-SemiBold-lf-ts1.tfm \
tex-Montserrat-SemiBold-lf-ts1.vf \
tex-Montserrat-SemiBold-numr-ly1--base.tfm \
tex-Montserrat-SemiBold-numr-ly1.tfm \
tex-Montserrat-SemiBold-numr-ly1.vf \
tex-Montserrat-SemiBold-numr-ot1.tfm \
tex-Montserrat-SemiBold-numr-t1--base.tfm \
tex-Montserrat-SemiBold-numr-t1.tfm \
tex-Montserrat-SemiBold-numr-t1.vf \
tex-Montserrat-SemiBold-osf-ly1--base.tfm \
tex-Montserrat-SemiBold-osf-ly1.tfm \
tex-Montserrat-SemiBold-osf-ly1.vf \
tex-Montserrat-SemiBold-osf-ot1.tfm \
tex-Montserrat-SemiBold-osf-sc-ly1--base.tfm \
tex-Montserrat-SemiBold-osf-sc-ly1.tfm \
tex-Montserrat-SemiBold-osf-sc-ly1.vf \
tex-Montserrat-SemiBold-osf-sc-ot1--base.tfm \
tex-Montserrat-SemiBold-osf-sc-ot1.tfm \
tex-Montserrat-SemiBold-osf-sc-ot1.vf \
tex-Montserrat-SemiBold-osf-sc-t1--base.tfm \
tex-Montserrat-SemiBold-osf-sc-t1.tfm \
tex-Montserrat-SemiBold-osf-sc-t1.vf \
tex-Montserrat-SemiBold-osf-t1--base.tfm \
tex-Montserrat-SemiBold-osf-t1.tfm \
tex-Montserrat-SemiBold-osf-t1.vf \
tex-Montserrat-SemiBold-osf-ts1--base.tfm \
tex-Montserrat-SemiBold-osf-ts1.tfm \
tex-Montserrat-SemiBold-osf-ts1.vf \
tex-Montserrat-SemiBold-sup-ly1--base.tfm \
tex-Montserrat-SemiBold-sup-ly1.tfm \
tex-Montserrat-SemiBold-sup-ly1.vf \
tex-Montserrat-SemiBold-sup-ot1.tfm \
tex-Montserrat-SemiBold-sup-t1--base.tfm \
tex-Montserrat-SemiBold-sup-t1.tfm \
tex-Montserrat-SemiBold-sup-t1.vf \
tex-Montserrat-SemiBold-tlf-ly1--base.tfm \
tex-Montserrat-SemiBold-tlf-ly1.tfm \
tex-Montserrat-SemiBold-tlf-ly1.vf \
tex-Montserrat-SemiBold-tlf-ot1.tfm \
tex-Montserrat-SemiBold-tlf-sc-ly1--base.tfm \
tex-Montserrat-SemiBold-tlf-sc-ly1.tfm \
tex-Montserrat-SemiBold-tlf-sc-ly1.vf \
tex-Montserrat-SemiBold-tlf-sc-ot1--base.tfm \
tex-Montserrat-SemiBold-tlf-sc-ot1.tfm \
tex-Montserrat-SemiBold-tlf-sc-ot1.vf \
tex-Montserrat-SemiBold-tlf-sc-t1--base.tfm \
tex-Montserrat-SemiBold-tlf-sc-t1.tfm \
tex-Montserrat-SemiBold-tlf-sc-t1.vf \
tex-Montserrat-SemiBold-tlf-t1--base.tfm \
tex-Montserrat-SemiBold-tlf-t1.tfm \
tex-Montserrat-SemiBold-tlf-t1.vf \
tex-Montserrat-SemiBold-tlf-ts1--base.tfm \
tex-Montserrat-SemiBold-tlf-ts1.tfm \
tex-Montserrat-SemiBold-tlf-ts1.vf \
tex-Montserrat-SemiBold-tosf-ly1--base.tfm \
tex-Montserrat-SemiBold-tosf-ly1.tfm \
tex-Montserrat-SemiBold-tosf-ly1.vf \
tex-Montserrat-SemiBold-tosf-ot1.tfm \
tex-Montserrat-SemiBold-tosf-sc-ly1--base.tfm \
tex-Montserrat-SemiBold-tosf-sc-ly1.tfm \
tex-Montserrat-SemiBold-tosf-sc-ly1.vf \
tex-Montserrat-SemiBold-tosf-sc-ot1--base.tfm \
tex-Montserrat-SemiBold-tosf-sc-ot1.tfm \
tex-Montserrat-SemiBold-tosf-sc-ot1.vf \
tex-Montserrat-SemiBold-tosf-sc-t1--base.tfm \
tex-Montserrat-SemiBold-tosf-sc-t1.tfm \
tex-Montserrat-SemiBold-tosf-sc-t1.vf \
tex-Montserrat-SemiBold-tosf-t1--base.tfm \
tex-Montserrat-SemiBold-tosf-t1.tfm \
tex-Montserrat-SemiBold-tosf-t1.vf \
tex-Montserrat-SemiBold-tosf-ts1--base.tfm \
tex-Montserrat-SemiBold-tosf-ts1.tfm \
tex-Montserrat-SemiBold-tosf-ts1.vf \
tex-Montserrat-SemiBoldItalic-dnom-ly1--base.tfm \
tex-Montserrat-SemiBoldItalic-dnom-ly1.tfm \
tex-Montserrat-SemiBoldItalic-dnom-ly1.vf \
tex-Montserrat-SemiBoldItalic-dnom-ot1.tfm \
tex-Montserrat-SemiBoldItalic-dnom-t1--base.tfm \
tex-Montserrat-SemiBoldItalic-dnom-t1.tfm \
tex-Montserrat-SemiBoldItalic-dnom-t1.vf \
tex-Montserrat-SemiBoldItalic-inf-ly1--base.tfm \
tex-Montserrat-SemiBoldItalic-inf-ly1.tfm \
tex-Montserrat-SemiBoldItalic-inf-ly1.vf \
tex-Montserrat-SemiBoldItalic-inf-ot1.tfm \
tex-Montserrat-SemiBoldItalic-inf-t1--base.tfm \
tex-Montserrat-SemiBoldItalic-inf-t1.tfm \
tex-Montserrat-SemiBoldItalic-inf-t1.vf \
tex-Montserrat-SemiBoldItalic-lf-ly1--base.tfm \
tex-Montserrat-SemiBoldItalic-lf-ly1.tfm \
tex-Montserrat-SemiBoldItalic-lf-ly1.vf \
tex-Montserrat-SemiBoldItalic-lf-ot1.tfm \
tex-Montserrat-SemiBoldItalic-lf-sc-ly1--base.tfm \
tex-Montserrat-SemiBoldItalic-lf-sc-ly1.tfm \
tex-Montserrat-SemiBoldItalic-lf-sc-ly1.vf \
tex-Montserrat-SemiBoldItalic-lf-sc-ot1--base.tfm \
tex-Montserrat-SemiBoldItalic-lf-sc-ot1.tfm \
tex-Montserrat-SemiBoldItalic-lf-sc-ot1.vf \
tex-Montserrat-SemiBoldItalic-lf-sc-t1--base.tfm \
tex-Montserrat-SemiBoldItalic-lf-sc-t1.tfm \
tex-Montserrat-SemiBoldItalic-lf-sc-t1.vf \
tex-Montserrat-SemiBoldItalic-lf-t1--base.tfm \
tex-Montserrat-SemiBoldItalic-lf-t1.tfm \
tex-Montserrat-SemiBoldItalic-lf-t1.vf \
tex-Montserrat-SemiBoldItalic-lf-ts1--base.tfm \
tex-Montserrat-SemiBoldItalic-lf-ts1.tfm \
tex-Montserrat-SemiBoldItalic-lf-ts1.vf \
tex-Montserrat-SemiBoldItalic-numr-ly1--base.tfm \
tex-Montserrat-SemiBoldItalic-numr-ly1.tfm \
tex-Montserrat-SemiBoldItalic-numr-ly1.vf \
tex-Montserrat-SemiBoldItalic-numr-ot1.tfm \
tex-Montserrat-SemiBoldItalic-numr-t1--base.tfm \
tex-Montserrat-SemiBoldItalic-numr-t1.tfm \
tex-Montserrat-SemiBoldItalic-numr-t1.vf \
tex-Montserrat-SemiBoldItalic-osf-ly1--base.tfm \
tex-Montserrat-SemiBoldItalic-osf-ly1.tfm \
tex-Montserrat-SemiBoldItalic-osf-ly1.vf \
tex-Montserrat-SemiBoldItalic-osf-ot1.tfm \
tex-Montserrat-SemiBoldItalic-osf-sc-ly1--base.tfm \
tex-Montserrat-SemiBoldItalic-osf-sc-ly1.tfm \
tex-Montserrat-SemiBoldItalic-osf-sc-ly1.vf \
tex-Montserrat-SemiBoldItalic-osf-sc-ot1--base.tfm \
tex-Montserrat-SemiBoldItalic-osf-sc-ot1.tfm \
tex-Montserrat-SemiBoldItalic-osf-sc-ot1.vf \
tex-Montserrat-SemiBoldItalic-osf-sc-t1--base.tfm \
tex-Montserrat-SemiBoldItalic-osf-sc-t1.tfm \
tex-Montserrat-SemiBoldItalic-osf-sc-t1.vf \
tex-Montserrat-SemiBoldItalic-osf-t1--base.tfm \
tex-Montserrat-SemiBoldItalic-osf-t1.tfm \
tex-Montserrat-SemiBoldItalic-osf-t1.vf \
tex-Montserrat-SemiBoldItalic-osf-ts1--base.tfm \
tex-Montserrat-SemiBoldItalic-osf-ts1.tfm \
tex-Montserrat-SemiBoldItalic-osf-ts1.vf \
tex-Montserrat-SemiBoldItalic-sup-ly1--base.tfm \
tex-Montserrat-SemiBoldItalic-sup-ly1.tfm \
tex-Montserrat-SemiBoldItalic-sup-ly1.vf \
tex-Montserrat-SemiBoldItalic-sup-ot1.tfm \
tex-Montserrat-SemiBoldItalic-sup-t1--base.tfm \
tex-Montserrat-SemiBoldItalic-sup-t1.tfm \
tex-Montserrat-SemiBoldItalic-sup-t1.vf \
tex-Montserrat-SemiBoldItalic-tlf-ly1--base.tfm \
tex-Montserrat-SemiBoldItalic-tlf-ly1.tfm \
tex-Montserrat-SemiBoldItalic-tlf-ly1.vf \
tex-Montserrat-SemiBoldItalic-tlf-ot1.tfm \
tex-Montserrat-SemiBoldItalic-tlf-sc-ly1--base.tfm \
tex-Montserrat-SemiBoldItalic-tlf-sc-ly1.tfm \
tex-Montserrat-SemiBoldItalic-tlf-sc-ly1.vf \
tex-Montserrat-SemiBoldItalic-tlf-sc-ot1--base.tfm \
tex-Montserrat-SemiBoldItalic-tlf-sc-ot1.tfm \
tex-Montserrat-SemiBoldItalic-tlf-sc-ot1.vf \
tex-Montserrat-SemiBoldItalic-tlf-sc-t1--base.tfm \
tex-Montserrat-SemiBoldItalic-tlf-sc-t1.tfm \
tex-Montserrat-SemiBoldItalic-tlf-sc-t1.vf \
tex-Montserrat-SemiBoldItalic-tlf-t1--base.tfm \
tex-Montserrat-SemiBoldItalic-tlf-t1.tfm \
tex-Montserrat-SemiBoldItalic-tlf-t1.vf \
tex-Montserrat-SemiBoldItalic-tlf-ts1--base.tfm \
tex-Montserrat-SemiBoldItalic-tlf-ts1.tfm \
tex-Montserrat-SemiBoldItalic-tlf-ts1.vf \
tex-Montserrat-SemiBoldItalic-tosf-ly1--base.tfm \
tex-Montserrat-SemiBoldItalic-tosf-ly1.tfm \
tex-Montserrat-SemiBoldItalic-tosf-ly1.vf \
tex-Montserrat-SemiBoldItalic-tosf-ot1.tfm \
tex-Montserrat-SemiBoldItalic-tosf-sc-ly1--base.tfm \
tex-Montserrat-SemiBoldItalic-tosf-sc-ly1.tfm \
tex-Montserrat-SemiBoldItalic-tosf-sc-ly1.vf \
tex-Montserrat-SemiBoldItalic-tosf-sc-ot1--base.tfm \
tex-Montserrat-SemiBoldItalic-tosf-sc-ot1.tfm \
tex-Montserrat-SemiBoldItalic-tosf-sc-ot1.vf \
tex-Montserrat-SemiBoldItalic-tosf-sc-t1--base.tfm \
tex-Montserrat-SemiBoldItalic-tosf-sc-t1.tfm \
tex-Montserrat-SemiBoldItalic-tosf-sc-t1.vf \
tex-Montserrat-SemiBoldItalic-tosf-t1--base.tfm \
tex-Montserrat-SemiBoldItalic-tosf-t1.tfm \
tex-Montserrat-SemiBoldItalic-tosf-t1.vf \
tex-Montserrat-SemiBoldItalic-tosf-ts1--base.tfm \
tex-Montserrat-SemiBoldItalic-tosf-ts1.tfm \
tex-Montserrat-SemiBoldItalic-tosf-ts1.vf \
tex-Montserrat-Thin-dnom-ly1--base.tfm \
tex-Montserrat-Thin-dnom-ly1.tfm \
tex-Montserrat-Thin-dnom-ly1.vf \
tex-Montserrat-Thin-dnom-ot1.tfm \
tex-Montserrat-Thin-dnom-t1--base.tfm \
tex-Montserrat-Thin-dnom-t1.tfm \
tex-Montserrat-Thin-dnom-t1.vf \
tex-Montserrat-Thin-inf-ly1--base.tfm \
tex-Montserrat-Thin-inf-ly1.tfm \
tex-Montserrat-Thin-inf-ly1.vf \
tex-Montserrat-Thin-inf-ot1.tfm \
tex-Montserrat-Thin-inf-t1--base.tfm \
tex-Montserrat-Thin-inf-t1.tfm \
tex-Montserrat-Thin-inf-t1.vf \
tex-Montserrat-Thin-lf-ly1--base.tfm \
tex-Montserrat-Thin-lf-ly1.tfm \
tex-Montserrat-Thin-lf-ly1.vf \
tex-Montserrat-Thin-lf-ot1.tfm \
tex-Montserrat-Thin-lf-sc-ly1--base.tfm \
tex-Montserrat-Thin-lf-sc-ly1.tfm \
tex-Montserrat-Thin-lf-sc-ly1.vf \
tex-Montserrat-Thin-lf-sc-ot1--base.tfm \
tex-Montserrat-Thin-lf-sc-ot1.tfm \
tex-Montserrat-Thin-lf-sc-ot1.vf \
tex-Montserrat-Thin-lf-sc-t1--base.tfm \
tex-Montserrat-Thin-lf-sc-t1.tfm \
tex-Montserrat-Thin-lf-sc-t1.vf \
tex-Montserrat-Thin-lf-t1--base.tfm \
tex-Montserrat-Thin-lf-t1.tfm \
tex-Montserrat-Thin-lf-t1.vf \
tex-Montserrat-Thin-lf-ts1--base.tfm \
tex-Montserrat-Thin-lf-ts1.tfm \
tex-Montserrat-Thin-lf-ts1.vf \
tex-Montserrat-Thin-numr-ly1--base.tfm \
tex-Montserrat-Thin-numr-ly1.tfm \
tex-Montserrat-Thin-numr-ly1.vf \
tex-Montserrat-Thin-numr-ot1.tfm \
tex-Montserrat-Thin-numr-t1--base.tfm \
tex-Montserrat-Thin-numr-t1.tfm \
tex-Montserrat-Thin-numr-t1.vf \
tex-Montserrat-Thin-osf-ly1--base.tfm \
tex-Montserrat-Thin-osf-ly1.tfm \
tex-Montserrat-Thin-osf-ly1.vf \
tex-Montserrat-Thin-osf-ot1.tfm \
tex-Montserrat-Thin-osf-sc-ly1--base.tfm \
tex-Montserrat-Thin-osf-sc-ly1.tfm \
tex-Montserrat-Thin-osf-sc-ly1.vf \
tex-Montserrat-Thin-osf-sc-ot1--base.tfm \
tex-Montserrat-Thin-osf-sc-ot1.tfm \
tex-Montserrat-Thin-osf-sc-ot1.vf \
tex-Montserrat-Thin-osf-sc-t1--base.tfm \
tex-Montserrat-Thin-osf-sc-t1.tfm \
tex-Montserrat-Thin-osf-sc-t1.vf \
tex-Montserrat-Thin-osf-t1--base.tfm \
tex-Montserrat-Thin-osf-t1.tfm \
tex-Montserrat-Thin-osf-t1.vf \
tex-Montserrat-Thin-osf-ts1--base.tfm \
tex-Montserrat-Thin-osf-ts1.tfm \
tex-Montserrat-Thin-osf-ts1.vf \
tex-Montserrat-Thin-sup-ly1--base.tfm \
tex-Montserrat-Thin-sup-ly1.tfm \
tex-Montserrat-Thin-sup-ly1.vf \
tex-Montserrat-Thin-sup-ot1.tfm \
tex-Montserrat-Thin-sup-t1--base.tfm \
tex-Montserrat-Thin-sup-t1.tfm \
tex-Montserrat-Thin-sup-t1.vf \
tex-Montserrat-Thin-tlf-ly1--base.tfm \
tex-Montserrat-Thin-tlf-ly1.tfm \
tex-Montserrat-Thin-tlf-ly1.vf \
tex-Montserrat-Thin-tlf-ot1.tfm \
tex-Montserrat-Thin-tlf-sc-ly1--base.tfm \
tex-Montserrat-Thin-tlf-sc-ly1.tfm \
tex-Montserrat-Thin-tlf-sc-ly1.vf \
tex-Montserrat-Thin-tlf-sc-ot1--base.tfm \
tex-Montserrat-Thin-tlf-sc-ot1.tfm \
tex-Montserrat-Thin-tlf-sc-ot1.vf \
tex-Montserrat-Thin-tlf-sc-t1--base.tfm \
tex-Montserrat-Thin-tlf-sc-t1.tfm \
tex-Montserrat-Thin-tlf-sc-t1.vf \
tex-Montserrat-Thin-tlf-t1--base.tfm \
tex-Montserrat-Thin-tlf-t1.tfm \
tex-Montserrat-Thin-tlf-t1.vf \
tex-Montserrat-Thin-tlf-ts1--base.tfm \
tex-Montserrat-Thin-tlf-ts1.tfm \
tex-Montserrat-Thin-tlf-ts1.vf \
tex-Montserrat-Thin-tosf-ly1--base.tfm \
tex-Montserrat-Thin-tosf-ly1.tfm \
tex-Montserrat-Thin-tosf-ly1.vf \
tex-Montserrat-Thin-tosf-ot1.tfm \
tex-Montserrat-Thin-tosf-sc-ly1--base.tfm \
tex-Montserrat-Thin-tosf-sc-ly1.tfm \
tex-Montserrat-Thin-tosf-sc-ly1.vf \
tex-Montserrat-Thin-tosf-sc-ot1--base.tfm \
tex-Montserrat-Thin-tosf-sc-ot1.tfm \
tex-Montserrat-Thin-tosf-sc-ot1.vf \
tex-Montserrat-Thin-tosf-sc-t1--base.tfm \
tex-Montserrat-Thin-tosf-sc-t1.tfm \
tex-Montserrat-Thin-tosf-sc-t1.vf \
tex-Montserrat-Thin-tosf-t1--base.tfm \
tex-Montserrat-Thin-tosf-t1.tfm \
tex-Montserrat-Thin-tosf-t1.vf \
tex-Montserrat-Thin-tosf-ts1--base.tfm \
tex-Montserrat-Thin-tosf-ts1.tfm \
tex-Montserrat-Thin-tosf-ts1.vf \
tex-Montserrat-ThinItalic-dnom-ly1--base.tfm \
tex-Montserrat-ThinItalic-dnom-ly1.tfm \
tex-Montserrat-ThinItalic-dnom-ly1.vf \
tex-Montserrat-ThinItalic-dnom-ot1.tfm \
tex-Montserrat-ThinItalic-dnom-t1--base.tfm \
tex-Montserrat-ThinItalic-dnom-t1.tfm \
tex-Montserrat-ThinItalic-dnom-t1.vf \
tex-Montserrat-ThinItalic-inf-ly1--base.tfm \
tex-Montserrat-ThinItalic-inf-ly1.tfm \
tex-Montserrat-ThinItalic-inf-ly1.vf \
tex-Montserrat-ThinItalic-inf-ot1.tfm \
tex-Montserrat-ThinItalic-inf-t1--base.tfm \
tex-Montserrat-ThinItalic-inf-t1.tfm \
tex-Montserrat-ThinItalic-inf-t1.vf \
tex-Montserrat-ThinItalic-lf-ly1--base.tfm \
tex-Montserrat-ThinItalic-lf-ly1.tfm \
tex-Montserrat-ThinItalic-lf-ly1.vf \
tex-Montserrat-ThinItalic-lf-ot1.tfm \
tex-Montserrat-ThinItalic-lf-sc-ly1--base.tfm \
tex-Montserrat-ThinItalic-lf-sc-ly1.tfm \
tex-Montserrat-ThinItalic-lf-sc-ly1.vf \
tex-Montserrat-ThinItalic-lf-sc-ot1--base.tfm \
tex-Montserrat-ThinItalic-lf-sc-ot1.tfm \
tex-Montserrat-ThinItalic-lf-sc-ot1.vf \
tex-Montserrat-ThinItalic-lf-sc-t1--base.tfm \
tex-Montserrat-ThinItalic-lf-sc-t1.tfm \
tex-Montserrat-ThinItalic-lf-sc-t1.vf \
tex-Montserrat-ThinItalic-lf-t1--base.tfm \
tex-Montserrat-ThinItalic-lf-t1.tfm \
tex-Montserrat-ThinItalic-lf-t1.vf \
tex-Montserrat-ThinItalic-lf-ts1--base.tfm \
tex-Montserrat-ThinItalic-lf-ts1.tfm \
tex-Montserrat-ThinItalic-lf-ts1.vf \
tex-Montserrat-ThinItalic-numr-ly1--base.tfm \
tex-Montserrat-ThinItalic-numr-ly1.tfm \
tex-Montserrat-ThinItalic-numr-ly1.vf \
tex-Montserrat-ThinItalic-numr-ot1.tfm \
tex-Montserrat-ThinItalic-numr-t1--base.tfm \
tex-Montserrat-ThinItalic-numr-t1.tfm \
tex-Montserrat-ThinItalic-numr-t1.vf \
tex-Montserrat-ThinItalic-osf-ly1--base.tfm \
tex-Montserrat-ThinItalic-osf-ly1.tfm \
tex-Montserrat-ThinItalic-osf-ly1.vf \
tex-Montserrat-ThinItalic-osf-ot1.tfm \
tex-Montserrat-ThinItalic-osf-sc-ly1--base.tfm \
tex-Montserrat-ThinItalic-osf-sc-ly1.tfm \
tex-Montserrat-ThinItalic-osf-sc-ly1.vf \
tex-Montserrat-ThinItalic-osf-sc-ot1--base.tfm \
tex-Montserrat-ThinItalic-osf-sc-ot1.tfm \
tex-Montserrat-ThinItalic-osf-sc-ot1.vf \
tex-Montserrat-ThinItalic-osf-sc-t1--base.tfm \
tex-Montserrat-ThinItalic-osf-sc-t1.tfm \
tex-Montserrat-ThinItalic-osf-sc-t1.vf \
tex-Montserrat-ThinItalic-osf-t1--base.tfm \
tex-Montserrat-ThinItalic-osf-t1.tfm \
tex-Montserrat-ThinItalic-osf-t1.vf \
tex-Montserrat-ThinItalic-osf-ts1--base.tfm \
tex-Montserrat-ThinItalic-osf-ts1.tfm \
tex-Montserrat-ThinItalic-osf-ts1.vf \
tex-Montserrat-ThinItalic-sup-ly1--base.tfm \
tex-Montserrat-ThinItalic-sup-ly1.tfm \
tex-Montserrat-ThinItalic-sup-ly1.vf \
tex-Montserrat-ThinItalic-sup-ot1.tfm \
tex-Montserrat-ThinItalic-sup-t1--base.tfm \
tex-Montserrat-ThinItalic-sup-t1.tfm \
tex-Montserrat-ThinItalic-sup-t1.vf \
tex-Montserrat-ThinItalic-tlf-ly1--base.tfm \
tex-Montserrat-ThinItalic-tlf-ly1.tfm \
tex-Montserrat-ThinItalic-tlf-ly1.vf \
tex-Montserrat-ThinItalic-tlf-ot1.tfm \
tex-Montserrat-ThinItalic-tlf-sc-ly1--base.tfm \
tex-Montserrat-ThinItalic-tlf-sc-ly1.tfm \
tex-Montserrat-ThinItalic-tlf-sc-ly1.vf \
tex-Montserrat-ThinItalic-tlf-sc-ot1--base.tfm \
tex-Montserrat-ThinItalic-tlf-sc-ot1.tfm \
tex-Montserrat-ThinItalic-tlf-sc-ot1.vf \
tex-Montserrat-ThinItalic-tlf-sc-t1--base.tfm \
tex-Montserrat-ThinItalic-tlf-sc-t1.tfm \
tex-Montserrat-ThinItalic-tlf-sc-t1.vf \
tex-Montserrat-ThinItalic-tlf-t1--base.tfm \
tex-Montserrat-ThinItalic-tlf-t1.tfm \
tex-Montserrat-ThinItalic-tlf-t1.vf \
tex-Montserrat-ThinItalic-tlf-ts1--base.tfm \
tex-Montserrat-ThinItalic-tlf-ts1.tfm \
tex-Montserrat-ThinItalic-tlf-ts1.vf \
tex-Montserrat-ThinItalic-tosf-ly1--base.tfm \
tex-Montserrat-ThinItalic-tosf-ly1.tfm \
tex-Montserrat-ThinItalic-tosf-ly1.vf \
tex-Montserrat-ThinItalic-tosf-ot1.tfm \
tex-Montserrat-ThinItalic-tosf-sc-ly1--base.tfm \
tex-Montserrat-ThinItalic-tosf-sc-ly1.tfm \
tex-Montserrat-ThinItalic-tosf-sc-ly1.vf \
tex-Montserrat-ThinItalic-tosf-sc-ot1--base.tfm \
tex-Montserrat-ThinItalic-tosf-sc-ot1.tfm \
tex-Montserrat-ThinItalic-tosf-sc-ot1.vf \
tex-Montserrat-ThinItalic-tosf-sc-t1--base.tfm \
tex-Montserrat-ThinItalic-tosf-sc-t1.tfm \
tex-Montserrat-ThinItalic-tosf-sc-t1.vf \
tex-Montserrat-ThinItalic-tosf-t1--base.tfm \
tex-Montserrat-ThinItalic-tosf-t1.tfm \
tex-Montserrat-ThinItalic-tosf-t1.vf \
tex-Montserrat-ThinItalic-tosf-ts1--base.tfm \
tex-Montserrat-ThinItalic-tosf-ts1.tfm \
tex-Montserrat-ThinItalic-tosf-ts1.vf \
tex-Montserrat.map \
tex-MontserratAlternates-Black-dnom-ly1--base.tfm \
tex-MontserratAlternates-Black-dnom-ly1.tfm \
tex-MontserratAlternates-Black-dnom-ly1.vf \
tex-MontserratAlternates-Black-dnom-ot1.tfm \
tex-MontserratAlternates-Black-dnom-t1--base.tfm \
tex-MontserratAlternates-Black-dnom-t1.tfm \
tex-MontserratAlternates-Black-dnom-t1.vf \
tex-MontserratAlternates-Black-inf-ly1--base.tfm \
tex-MontserratAlternates-Black-inf-ly1.tfm \
tex-MontserratAlternates-Black-inf-ly1.vf \
tex-MontserratAlternates-Black-inf-ot1.tfm \
tex-MontserratAlternates-Black-inf-t1--base.tfm \
tex-MontserratAlternates-Black-inf-t1.tfm \
tex-MontserratAlternates-Black-inf-t1.vf \
tex-MontserratAlternates-Black-lf-ly1--base.tfm \
tex-MontserratAlternates-Black-lf-ly1.tfm \
tex-MontserratAlternates-Black-lf-ly1.vf \
tex-MontserratAlternates-Black-lf-ot1.tfm \
tex-MontserratAlternates-Black-lf-sc-ly1--base.tfm \
tex-MontserratAlternates-Black-lf-sc-ly1.tfm \
tex-MontserratAlternates-Black-lf-sc-ly1.vf \
tex-MontserratAlternates-Black-lf-sc-ot1--base.tfm \
tex-MontserratAlternates-Black-lf-sc-ot1.tfm \
tex-MontserratAlternates-Black-lf-sc-ot1.vf \
tex-MontserratAlternates-Black-lf-sc-t1--base.tfm \
tex-MontserratAlternates-Black-lf-sc-t1.tfm \
tex-MontserratAlternates-Black-lf-sc-t1.vf \
tex-MontserratAlternates-Black-lf-t1--base.tfm \
tex-MontserratAlternates-Black-lf-t1.tfm \
tex-MontserratAlternates-Black-lf-t1.vf \
tex-MontserratAlternates-Black-lf-ts1--base.tfm \
tex-MontserratAlternates-Black-lf-ts1.tfm \
tex-MontserratAlternates-Black-lf-ts1.vf \
tex-MontserratAlternates-Black-numr-ly1--base.tfm \
tex-MontserratAlternates-Black-numr-ly1.tfm \
tex-MontserratAlternates-Black-numr-ly1.vf \
tex-MontserratAlternates-Black-numr-ot1.tfm \
tex-MontserratAlternates-Black-numr-t1--base.tfm \
tex-MontserratAlternates-Black-numr-t1.tfm \
tex-MontserratAlternates-Black-numr-t1.vf \
tex-MontserratAlternates-Black-osf-ly1--base.tfm \
tex-MontserratAlternates-Black-osf-ly1.tfm \
tex-MontserratAlternates-Black-osf-ly1.vf \
tex-MontserratAlternates-Black-osf-ot1.tfm \
tex-MontserratAlternates-Black-osf-sc-ly1--base.tfm \
tex-MontserratAlternates-Black-osf-sc-ly1.tfm \
tex-MontserratAlternates-Black-osf-sc-ly1.vf \
tex-MontserratAlternates-Black-osf-sc-ot1--base.tfm \
tex-MontserratAlternates-Black-osf-sc-ot1.tfm \
tex-MontserratAlternates-Black-osf-sc-ot1.vf \
tex-MontserratAlternates-Black-osf-sc-t1--base.tfm \
tex-MontserratAlternates-Black-osf-sc-t1.tfm \
tex-MontserratAlternates-Black-osf-sc-t1.vf \
tex-MontserratAlternates-Black-osf-t1--base.tfm \
tex-MontserratAlternates-Black-osf-t1.tfm \
tex-MontserratAlternates-Black-osf-t1.vf \
tex-MontserratAlternates-Black-osf-ts1--base.tfm \
tex-MontserratAlternates-Black-osf-ts1.tfm \
tex-MontserratAlternates-Black-osf-ts1.vf \
tex-MontserratAlternates-Black-sup-ly1--base.tfm \
tex-MontserratAlternates-Black-sup-ly1.tfm \
tex-MontserratAlternates-Black-sup-ly1.vf \
tex-MontserratAlternates-Black-sup-ot1.tfm \
tex-MontserratAlternates-Black-sup-t1--base.tfm \
tex-MontserratAlternates-Black-sup-t1.tfm \
tex-MontserratAlternates-Black-sup-t1.vf \
tex-MontserratAlternates-Black-tlf-ly1--base.tfm \
tex-MontserratAlternates-Black-tlf-ly1.tfm \
tex-MontserratAlternates-Black-tlf-ly1.vf \
tex-MontserratAlternates-Black-tlf-ot1.tfm \
tex-MontserratAlternates-Black-tlf-sc-ly1--base.tfm \
tex-MontserratAlternates-Black-tlf-sc-ly1.tfm \
tex-MontserratAlternates-Black-tlf-sc-ly1.vf \
tex-MontserratAlternates-Black-tlf-sc-ot1--base.tfm \
tex-MontserratAlternates-Black-tlf-sc-ot1.tfm \
tex-MontserratAlternates-Black-tlf-sc-ot1.vf \
tex-MontserratAlternates-Black-tlf-sc-t1--base.tfm \
tex-MontserratAlternates-Black-tlf-sc-t1.tfm \
tex-MontserratAlternates-Black-tlf-sc-t1.vf \
tex-MontserratAlternates-Black-tlf-t1--base.tfm \
tex-MontserratAlternates-Black-tlf-t1.tfm \
tex-MontserratAlternates-Black-tlf-t1.vf \
tex-MontserratAlternates-Black-tlf-ts1--base.tfm \
tex-MontserratAlternates-Black-tlf-ts1.tfm \
tex-MontserratAlternates-Black-tlf-ts1.vf \
tex-MontserratAlternates-Black-tosf-ly1--base.tfm \
tex-MontserratAlternates-Black-tosf-ly1.tfm \
tex-MontserratAlternates-Black-tosf-ly1.vf \
tex-MontserratAlternates-Black-tosf-ot1.tfm \
tex-MontserratAlternates-Black-tosf-sc-ly1--base.tfm \
tex-MontserratAlternates-Black-tosf-sc-ly1.tfm \
tex-MontserratAlternates-Black-tosf-sc-ly1.vf \
tex-MontserratAlternates-Black-tosf-sc-ot1--base.tfm \
tex-MontserratAlternates-Black-tosf-sc-ot1.tfm \
tex-MontserratAlternates-Black-tosf-sc-ot1.vf \
tex-MontserratAlternates-Black-tosf-sc-t1--base.tfm \
tex-MontserratAlternates-Black-tosf-sc-t1.tfm \
tex-MontserratAlternates-Black-tosf-sc-t1.vf \
tex-MontserratAlternates-Black-tosf-t1--base.tfm \
tex-MontserratAlternates-Black-tosf-t1.tfm \
tex-MontserratAlternates-Black-tosf-t1.vf \
tex-MontserratAlternates-Black-tosf-ts1--base.tfm \
tex-MontserratAlternates-Black-tosf-ts1.tfm \
tex-MontserratAlternates-Black-tosf-ts1.vf \
tex-MontserratAlternates-BlackItalic-dnom-ly1--base.tfm \
tex-MontserratAlternates-BlackItalic-dnom-ly1.tfm \
tex-MontserratAlternates-BlackItalic-dnom-ly1.vf \
tex-MontserratAlternates-BlackItalic-dnom-ot1.tfm \
tex-MontserratAlternates-BlackItalic-dnom-t1--base.tfm \
tex-MontserratAlternates-BlackItalic-dnom-t1.tfm \
tex-MontserratAlternates-BlackItalic-dnom-t1.vf \
tex-MontserratAlternates-BlackItalic-inf-ly1--base.tfm \
tex-MontserratAlternates-BlackItalic-inf-ly1.tfm \
tex-MontserratAlternates-BlackItalic-inf-ly1.vf \
tex-MontserratAlternates-BlackItalic-inf-ot1.tfm \
tex-MontserratAlternates-BlackItalic-inf-t1--base.tfm \
tex-MontserratAlternates-BlackItalic-inf-t1.tfm \
tex-MontserratAlternates-BlackItalic-inf-t1.vf \
tex-MontserratAlternates-BlackItalic-lf-ly1--base.tfm \
tex-MontserratAlternates-BlackItalic-lf-ly1.tfm \
tex-MontserratAlternates-BlackItalic-lf-ly1.vf \
tex-MontserratAlternates-BlackItalic-lf-ot1.tfm \
tex-MontserratAlternates-BlackItalic-lf-sc-ly1--base.tfm \
tex-MontserratAlternates-BlackItalic-lf-sc-ly1.tfm \
tex-MontserratAlternates-BlackItalic-lf-sc-ly1.vf \
tex-MontserratAlternates-BlackItalic-lf-sc-ot1--base.tfm \
tex-MontserratAlternates-BlackItalic-lf-sc-ot1.tfm \
tex-MontserratAlternates-BlackItalic-lf-sc-ot1.vf \
tex-MontserratAlternates-BlackItalic-lf-sc-t1--base.tfm \
tex-MontserratAlternates-BlackItalic-lf-sc-t1.tfm \
tex-MontserratAlternates-BlackItalic-lf-sc-t1.vf \
tex-MontserratAlternates-BlackItalic-lf-t1--base.tfm \
tex-MontserratAlternates-BlackItalic-lf-t1.tfm \
tex-MontserratAlternates-BlackItalic-lf-t1.vf \
tex-MontserratAlternates-BlackItalic-lf-ts1--base.tfm \
tex-MontserratAlternates-BlackItalic-lf-ts1.tfm \
tex-MontserratAlternates-BlackItalic-lf-ts1.vf \
tex-MontserratAlternates-BlackItalic-numr-ly1--base.tfm \
tex-MontserratAlternates-BlackItalic-numr-ly1.tfm \
tex-MontserratAlternates-BlackItalic-numr-ly1.vf \
tex-MontserratAlternates-BlackItalic-numr-ot1.tfm \
tex-MontserratAlternates-BlackItalic-numr-t1--base.tfm \
tex-MontserratAlternates-BlackItalic-numr-t1.tfm \
tex-MontserratAlternates-BlackItalic-numr-t1.vf \
tex-MontserratAlternates-BlackItalic-osf-ly1--base.tfm \
tex-MontserratAlternates-BlackItalic-osf-ly1.tfm \
tex-MontserratAlternates-BlackItalic-osf-ly1.vf \
tex-MontserratAlternates-BlackItalic-osf-ot1.tfm \
tex-MontserratAlternates-BlackItalic-osf-sc-ly1--base.tfm \
tex-MontserratAlternates-BlackItalic-osf-sc-ly1.tfm \
tex-MontserratAlternates-BlackItalic-osf-sc-ly1.vf \
tex-MontserratAlternates-BlackItalic-osf-sc-ot1--base.tfm \
tex-MontserratAlternates-BlackItalic-osf-sc-ot1.tfm \
tex-MontserratAlternates-BlackItalic-osf-sc-ot1.vf \
tex-MontserratAlternates-BlackItalic-osf-sc-t1--base.tfm \
tex-MontserratAlternates-BlackItalic-osf-sc-t1.tfm \
tex-MontserratAlternates-BlackItalic-osf-sc-t1.vf \
tex-MontserratAlternates-BlackItalic-osf-t1--base.tfm \
tex-MontserratAlternates-BlackItalic-osf-t1.tfm \
tex-MontserratAlternates-BlackItalic-osf-t1.vf \
tex-MontserratAlternates-BlackItalic-osf-ts1--base.tfm \
tex-MontserratAlternates-BlackItalic-osf-ts1.tfm \
tex-MontserratAlternates-BlackItalic-osf-ts1.vf \
tex-MontserratAlternates-BlackItalic-sup-ly1--base.tfm \
tex-MontserratAlternates-BlackItalic-sup-ly1.tfm \
tex-MontserratAlternates-BlackItalic-sup-ly1.vf \
tex-MontserratAlternates-BlackItalic-sup-ot1.tfm \
tex-MontserratAlternates-BlackItalic-sup-t1--base.tfm \
tex-MontserratAlternates-BlackItalic-sup-t1.tfm \
tex-MontserratAlternates-BlackItalic-sup-t1.vf \
tex-MontserratAlternates-BlackItalic-tlf-ly1--base.tfm \
tex-MontserratAlternates-BlackItalic-tlf-ly1.tfm \
tex-MontserratAlternates-BlackItalic-tlf-ly1.vf \
tex-MontserratAlternates-BlackItalic-tlf-ot1.tfm \
tex-MontserratAlternates-BlackItalic-tlf-sc-ly1--base.tfm \
tex-MontserratAlternates-BlackItalic-tlf-sc-ly1.tfm \
tex-MontserratAlternates-BlackItalic-tlf-sc-ly1.vf \
tex-MontserratAlternates-BlackItalic-tlf-sc-ot1--base.tfm \
tex-MontserratAlternates-BlackItalic-tlf-sc-ot1.tfm \
tex-MontserratAlternates-BlackItalic-tlf-sc-ot1.vf \
tex-MontserratAlternates-BlackItalic-tlf-sc-t1--base.tfm \
tex-MontserratAlternates-BlackItalic-tlf-sc-t1.tfm \
tex-MontserratAlternates-BlackItalic-tlf-sc-t1.vf \
tex-MontserratAlternates-BlackItalic-tlf-t1--base.tfm \
tex-MontserratAlternates-BlackItalic-tlf-t1.tfm \
tex-MontserratAlternates-BlackItalic-tlf-t1.vf \
tex-MontserratAlternates-BlackItalic-tlf-ts1--base.tfm \
tex-MontserratAlternates-BlackItalic-tlf-ts1.tfm \
tex-MontserratAlternates-BlackItalic-tlf-ts1.vf \
tex-MontserratAlternates-BlackItalic-tosf-ly1--base.tfm \
tex-MontserratAlternates-BlackItalic-tosf-ly1.tfm \
tex-MontserratAlternates-BlackItalic-tosf-ly1.vf \
tex-MontserratAlternates-BlackItalic-tosf-ot1.tfm \
tex-MontserratAlternates-BlackItalic-tosf-sc-ly1--base.tfm \
tex-MontserratAlternates-BlackItalic-tosf-sc-ly1.tfm \
tex-MontserratAlternates-BlackItalic-tosf-sc-ly1.vf \
tex-MontserratAlternates-BlackItalic-tosf-sc-ot1--base.tfm \
tex-MontserratAlternates-BlackItalic-tosf-sc-ot1.tfm \
tex-MontserratAlternates-BlackItalic-tosf-sc-ot1.vf \
tex-MontserratAlternates-BlackItalic-tosf-sc-t1--base.tfm \
tex-MontserratAlternates-BlackItalic-tosf-sc-t1.tfm \
tex-MontserratAlternates-BlackItalic-tosf-sc-t1.vf \
tex-MontserratAlternates-BlackItalic-tosf-t1--base.tfm \
tex-MontserratAlternates-BlackItalic-tosf-t1.tfm \
tex-MontserratAlternates-BlackItalic-tosf-t1.vf \
tex-MontserratAlternates-BlackItalic-tosf-ts1--base.tfm \
tex-MontserratAlternates-BlackItalic-tosf-ts1.tfm \
tex-MontserratAlternates-BlackItalic-tosf-ts1.vf \
tex-MontserratAlternates-Bold-dnom-ly1--base.tfm \
tex-MontserratAlternates-Bold-dnom-ly1.tfm \
tex-MontserratAlternates-Bold-dnom-ly1.vf \
tex-MontserratAlternates-Bold-dnom-ot1.tfm \
tex-MontserratAlternates-Bold-dnom-t1--base.tfm \
tex-MontserratAlternates-Bold-dnom-t1.tfm \
tex-MontserratAlternates-Bold-dnom-t1.vf \
tex-MontserratAlternates-Bold-inf-ly1--base.tfm \
tex-MontserratAlternates-Bold-inf-ly1.tfm \
tex-MontserratAlternates-Bold-inf-ly1.vf \
tex-MontserratAlternates-Bold-inf-ot1.tfm \
tex-MontserratAlternates-Bold-inf-t1--base.tfm \
tex-MontserratAlternates-Bold-inf-t1.tfm \
tex-MontserratAlternates-Bold-inf-t1.vf \
tex-MontserratAlternates-Bold-lf-ly1--base.tfm \
tex-MontserratAlternates-Bold-lf-ly1.tfm \
tex-MontserratAlternates-Bold-lf-ly1.vf \
tex-MontserratAlternates-Bold-lf-ot1.tfm \
tex-MontserratAlternates-Bold-lf-sc-ly1--base.tfm \
tex-MontserratAlternates-Bold-lf-sc-ly1.tfm \
tex-MontserratAlternates-Bold-lf-sc-ly1.vf \
tex-MontserratAlternates-Bold-lf-sc-ot1--base.tfm \
tex-MontserratAlternates-Bold-lf-sc-ot1.tfm \
tex-MontserratAlternates-Bold-lf-sc-ot1.vf \
tex-MontserratAlternates-Bold-lf-sc-t1--base.tfm \
tex-MontserratAlternates-Bold-lf-sc-t1.tfm \
tex-MontserratAlternates-Bold-lf-sc-t1.vf \
tex-MontserratAlternates-Bold-lf-t1--base.tfm \
tex-MontserratAlternates-Bold-lf-t1.tfm \
tex-MontserratAlternates-Bold-lf-t1.vf \
tex-MontserratAlternates-Bold-lf-ts1--base.tfm \
tex-MontserratAlternates-Bold-lf-ts1.tfm \
tex-MontserratAlternates-Bold-lf-ts1.vf \
tex-MontserratAlternates-Bold-numr-ly1--base.tfm \
tex-MontserratAlternates-Bold-numr-ly1.tfm \
tex-MontserratAlternates-Bold-numr-ly1.vf \
tex-MontserratAlternates-Bold-numr-ot1.tfm \
tex-MontserratAlternates-Bold-numr-t1--base.tfm \
tex-MontserratAlternates-Bold-numr-t1.tfm \
tex-MontserratAlternates-Bold-numr-t1.vf \
tex-MontserratAlternates-Bold-osf-ly1--base.tfm \
tex-MontserratAlternates-Bold-osf-ly1.tfm \
tex-MontserratAlternates-Bold-osf-ly1.vf \
tex-MontserratAlternates-Bold-osf-ot1.tfm \
tex-MontserratAlternates-Bold-osf-sc-ly1--base.tfm \
tex-MontserratAlternates-Bold-osf-sc-ly1.tfm \
tex-MontserratAlternates-Bold-osf-sc-ly1.vf \
tex-MontserratAlternates-Bold-osf-sc-ot1--base.tfm \
tex-MontserratAlternates-Bold-osf-sc-ot1.tfm \
tex-MontserratAlternates-Bold-osf-sc-ot1.vf \
tex-MontserratAlternates-Bold-osf-sc-t1--base.tfm \
tex-MontserratAlternates-Bold-osf-sc-t1.tfm \
tex-MontserratAlternates-Bold-osf-sc-t1.vf \
tex-MontserratAlternates-Bold-osf-t1--base.tfm \
tex-MontserratAlternates-Bold-osf-t1.tfm \
tex-MontserratAlternates-Bold-osf-t1.vf \
tex-MontserratAlternates-Bold-osf-ts1--base.tfm \
tex-MontserratAlternates-Bold-osf-ts1.tfm \
tex-MontserratAlternates-Bold-osf-ts1.vf \
tex-MontserratAlternates-Bold-sup-ly1--base.tfm \
tex-MontserratAlternates-Bold-sup-ly1.tfm \
tex-MontserratAlternates-Bold-sup-ly1.vf \
tex-MontserratAlternates-Bold-sup-ot1.tfm \
tex-MontserratAlternates-Bold-sup-t1--base.tfm \
tex-MontserratAlternates-Bold-sup-t1.tfm \
tex-MontserratAlternates-Bold-sup-t1.vf \
tex-MontserratAlternates-Bold-tlf-ly1--base.tfm \
tex-MontserratAlternates-Bold-tlf-ly1.tfm \
tex-MontserratAlternates-Bold-tlf-ly1.vf \
tex-MontserratAlternates-Bold-tlf-ot1.tfm \
tex-MontserratAlternates-Bold-tlf-sc-ly1--base.tfm \
tex-MontserratAlternates-Bold-tlf-sc-ly1.tfm \
tex-MontserratAlternates-Bold-tlf-sc-ly1.vf \
tex-MontserratAlternates-Bold-tlf-sc-ot1--base.tfm \
tex-MontserratAlternates-Bold-tlf-sc-ot1.tfm \
tex-MontserratAlternates-Bold-tlf-sc-ot1.vf \
tex-MontserratAlternates-Bold-tlf-sc-t1--base.tfm \
tex-MontserratAlternates-Bold-tlf-sc-t1.tfm \
tex-MontserratAlternates-Bold-tlf-sc-t1.vf \
tex-MontserratAlternates-Bold-tlf-t1--base.tfm \
tex-MontserratAlternates-Bold-tlf-t1.tfm \
tex-MontserratAlternates-Bold-tlf-t1.vf \
tex-MontserratAlternates-Bold-tlf-ts1--base.tfm \
tex-MontserratAlternates-Bold-tlf-ts1.tfm \
tex-MontserratAlternates-Bold-tlf-ts1.vf \
tex-MontserratAlternates-Bold-tosf-ly1--base.tfm \
tex-MontserratAlternates-Bold-tosf-ly1.tfm \
tex-MontserratAlternates-Bold-tosf-ly1.vf \
tex-MontserratAlternates-Bold-tosf-ot1.tfm \
tex-MontserratAlternates-Bold-tosf-sc-ly1--base.tfm \
tex-MontserratAlternates-Bold-tosf-sc-ly1.tfm \
tex-MontserratAlternates-Bold-tosf-sc-ly1.vf \
tex-MontserratAlternates-Bold-tosf-sc-ot1--base.tfm \
tex-MontserratAlternates-Bold-tosf-sc-ot1.tfm \
tex-MontserratAlternates-Bold-tosf-sc-ot1.vf \
tex-MontserratAlternates-Bold-tosf-sc-t1--base.tfm \
tex-MontserratAlternates-Bold-tosf-sc-t1.tfm \
tex-MontserratAlternates-Bold-tosf-sc-t1.vf \
tex-MontserratAlternates-Bold-tosf-t1--base.tfm \
tex-MontserratAlternates-Bold-tosf-t1.tfm \
tex-MontserratAlternates-Bold-tosf-t1.vf \
tex-MontserratAlternates-Bold-tosf-ts1--base.tfm \
tex-MontserratAlternates-Bold-tosf-ts1.tfm \
tex-MontserratAlternates-Bold-tosf-ts1.vf \
tex-MontserratAlternates-BoldItalic-dnom-ly1--base.tfm \
tex-MontserratAlternates-BoldItalic-dnom-ly1.tfm \
tex-MontserratAlternates-BoldItalic-dnom-ly1.vf \
tex-MontserratAlternates-BoldItalic-dnom-ot1.tfm \
tex-MontserratAlternates-BoldItalic-dnom-t1--base.tfm \
tex-MontserratAlternates-BoldItalic-dnom-t1.tfm \
tex-MontserratAlternates-BoldItalic-dnom-t1.vf \
tex-MontserratAlternates-BoldItalic-inf-ly1--base.tfm \
tex-MontserratAlternates-BoldItalic-inf-ly1.tfm \
tex-MontserratAlternates-BoldItalic-inf-ly1.vf \
tex-MontserratAlternates-BoldItalic-inf-ot1.tfm \
tex-MontserratAlternates-BoldItalic-inf-t1--base.tfm \
tex-MontserratAlternates-BoldItalic-inf-t1.tfm \
tex-MontserratAlternates-BoldItalic-inf-t1.vf \
tex-MontserratAlternates-BoldItalic-lf-ly1--base.tfm \
tex-MontserratAlternates-BoldItalic-lf-ly1.tfm \
tex-MontserratAlternates-BoldItalic-lf-ly1.vf \
tex-MontserratAlternates-BoldItalic-lf-ot1.tfm \
tex-MontserratAlternates-BoldItalic-lf-sc-ly1--base.tfm \
tex-MontserratAlternates-BoldItalic-lf-sc-ly1.tfm \
tex-MontserratAlternates-BoldItalic-lf-sc-ly1.vf \
tex-MontserratAlternates-BoldItalic-lf-sc-ot1--base.tfm \
tex-MontserratAlternates-BoldItalic-lf-sc-ot1.tfm \
tex-MontserratAlternates-BoldItalic-lf-sc-ot1.vf \
tex-MontserratAlternates-BoldItalic-lf-sc-t1--base.tfm \
tex-MontserratAlternates-BoldItalic-lf-sc-t1.tfm \
tex-MontserratAlternates-BoldItalic-lf-sc-t1.vf \
tex-MontserratAlternates-BoldItalic-lf-t1--base.tfm \
tex-MontserratAlternates-BoldItalic-lf-t1.tfm \
tex-MontserratAlternates-BoldItalic-lf-t1.vf \
tex-MontserratAlternates-BoldItalic-lf-ts1--base.tfm \
tex-MontserratAlternates-BoldItalic-lf-ts1.tfm \
tex-MontserratAlternates-BoldItalic-lf-ts1.vf \
tex-MontserratAlternates-BoldItalic-numr-ly1--base.tfm \
tex-MontserratAlternates-BoldItalic-numr-ly1.tfm \
tex-MontserratAlternates-BoldItalic-numr-ly1.vf \
tex-MontserratAlternates-BoldItalic-numr-ot1.tfm \
tex-MontserratAlternates-BoldItalic-numr-t1--base.tfm \
tex-MontserratAlternates-BoldItalic-numr-t1.tfm \
tex-MontserratAlternates-BoldItalic-numr-t1.vf \
tex-MontserratAlternates-BoldItalic-osf-ly1--base.tfm \
tex-MontserratAlternates-BoldItalic-osf-ly1.tfm \
tex-MontserratAlternates-BoldItalic-osf-ly1.vf \
tex-MontserratAlternates-BoldItalic-osf-ot1.tfm \
tex-MontserratAlternates-BoldItalic-osf-sc-ly1--base.tfm \
tex-MontserratAlternates-BoldItalic-osf-sc-ly1.tfm \
tex-MontserratAlternates-BoldItalic-osf-sc-ly1.vf \
tex-MontserratAlternates-BoldItalic-osf-sc-ot1--base.tfm \
tex-MontserratAlternates-BoldItalic-osf-sc-ot1.tfm \
tex-MontserratAlternates-BoldItalic-osf-sc-ot1.vf \
tex-MontserratAlternates-BoldItalic-osf-sc-t1--base.tfm \
tex-MontserratAlternates-BoldItalic-osf-sc-t1.tfm \
tex-MontserratAlternates-BoldItalic-osf-sc-t1.vf \
tex-MontserratAlternates-BoldItalic-osf-t1--base.tfm \
tex-MontserratAlternates-BoldItalic-osf-t1.tfm \
tex-MontserratAlternates-BoldItalic-osf-t1.vf \
tex-MontserratAlternates-BoldItalic-osf-ts1--base.tfm \
tex-MontserratAlternates-BoldItalic-osf-ts1.tfm \
tex-MontserratAlternates-BoldItalic-osf-ts1.vf \
tex-MontserratAlternates-BoldItalic-sup-ly1--base.tfm \
tex-MontserratAlternates-BoldItalic-sup-ly1.tfm \
tex-MontserratAlternates-BoldItalic-sup-ly1.vf \
tex-MontserratAlternates-BoldItalic-sup-ot1.tfm \
tex-MontserratAlternates-BoldItalic-sup-t1--base.tfm \
tex-MontserratAlternates-BoldItalic-sup-t1.tfm \
tex-MontserratAlternates-BoldItalic-sup-t1.vf \
tex-MontserratAlternates-BoldItalic-tlf-ly1--base.tfm \
tex-MontserratAlternates-BoldItalic-tlf-ly1.tfm \
tex-MontserratAlternates-BoldItalic-tlf-ly1.vf \
tex-MontserratAlternates-BoldItalic-tlf-ot1.tfm \
tex-MontserratAlternates-BoldItalic-tlf-sc-ly1--base.tfm \
tex-MontserratAlternates-BoldItalic-tlf-sc-ly1.tfm \
tex-MontserratAlternates-BoldItalic-tlf-sc-ly1.vf \
tex-MontserratAlternates-BoldItalic-tlf-sc-ot1--base.tfm \
tex-MontserratAlternates-BoldItalic-tlf-sc-ot1.tfm \
tex-MontserratAlternates-BoldItalic-tlf-sc-ot1.vf \
tex-MontserratAlternates-BoldItalic-tlf-sc-t1--base.tfm \
tex-MontserratAlternates-BoldItalic-tlf-sc-t1.tfm \
tex-MontserratAlternates-BoldItalic-tlf-sc-t1.vf \
tex-MontserratAlternates-BoldItalic-tlf-t1--base.tfm \
tex-MontserratAlternates-BoldItalic-tlf-t1.tfm \
tex-MontserratAlternates-BoldItalic-tlf-t1.vf \
tex-MontserratAlternates-BoldItalic-tlf-ts1--base.tfm \
tex-MontserratAlternates-BoldItalic-tlf-ts1.tfm \
tex-MontserratAlternates-BoldItalic-tlf-ts1.vf \
tex-MontserratAlternates-BoldItalic-tosf-ly1--base.tfm \
tex-MontserratAlternates-BoldItalic-tosf-ly1.tfm \
tex-MontserratAlternates-BoldItalic-tosf-ly1.vf \
tex-MontserratAlternates-BoldItalic-tosf-ot1.tfm \
tex-MontserratAlternates-BoldItalic-tosf-sc-ly1--base.tfm \
tex-MontserratAlternates-BoldItalic-tosf-sc-ly1.tfm \
tex-MontserratAlternates-BoldItalic-tosf-sc-ly1.vf \
tex-MontserratAlternates-BoldItalic-tosf-sc-ot1--base.tfm \
tex-MontserratAlternates-BoldItalic-tosf-sc-ot1.tfm \
tex-MontserratAlternates-BoldItalic-tosf-sc-ot1.vf \
tex-MontserratAlternates-BoldItalic-tosf-sc-t1--base.tfm \
tex-MontserratAlternates-BoldItalic-tosf-sc-t1.tfm \
tex-MontserratAlternates-BoldItalic-tosf-sc-t1.vf \
tex-MontserratAlternates-BoldItalic-tosf-t1--base.tfm \
tex-MontserratAlternates-BoldItalic-tosf-t1.tfm \
tex-MontserratAlternates-BoldItalic-tosf-t1.vf \
tex-MontserratAlternates-BoldItalic-tosf-ts1--base.tfm \
tex-MontserratAlternates-BoldItalic-tosf-ts1.tfm \
tex-MontserratAlternates-BoldItalic-tosf-ts1.vf \
tex-MontserratAlternates-ExtraBold-dnom-ly1--base.tfm \
tex-MontserratAlternates-ExtraBold-dnom-ly1.tfm \
tex-MontserratAlternates-ExtraBold-dnom-ly1.vf \
tex-MontserratAlternates-ExtraBold-dnom-ot1.tfm \
tex-MontserratAlternates-ExtraBold-dnom-t1--base.tfm \
tex-MontserratAlternates-ExtraBold-dnom-t1.tfm \
tex-MontserratAlternates-ExtraBold-dnom-t1.vf \
tex-MontserratAlternates-ExtraBold-inf-ly1--base.tfm \
tex-MontserratAlternates-ExtraBold-inf-ly1.tfm \
tex-MontserratAlternates-ExtraBold-inf-ly1.vf \
tex-MontserratAlternates-ExtraBold-inf-ot1.tfm \
tex-MontserratAlternates-ExtraBold-inf-t1--base.tfm \
tex-MontserratAlternates-ExtraBold-inf-t1.tfm \
tex-MontserratAlternates-ExtraBold-inf-t1.vf \
tex-MontserratAlternates-ExtraBold-lf-ly1--base.tfm \
tex-MontserratAlternates-ExtraBold-lf-ly1.tfm \
tex-MontserratAlternates-ExtraBold-lf-ly1.vf \
tex-MontserratAlternates-ExtraBold-lf-ot1.tfm \
tex-MontserratAlternates-ExtraBold-lf-sc-ly1--base.tfm \
tex-MontserratAlternates-ExtraBold-lf-sc-ly1.tfm \
tex-MontserratAlternates-ExtraBold-lf-sc-ly1.vf \
tex-MontserratAlternates-ExtraBold-lf-sc-ot1--base.tfm \
tex-MontserratAlternates-ExtraBold-lf-sc-ot1.tfm \
tex-MontserratAlternates-ExtraBold-lf-sc-ot1.vf \
tex-MontserratAlternates-ExtraBold-lf-sc-t1--base.tfm \
tex-MontserratAlternates-ExtraBold-lf-sc-t1.tfm \
tex-MontserratAlternates-ExtraBold-lf-sc-t1.vf \
tex-MontserratAlternates-ExtraBold-lf-t1--base.tfm \
tex-MontserratAlternates-ExtraBold-lf-t1.tfm \
tex-MontserratAlternates-ExtraBold-lf-t1.vf \
tex-MontserratAlternates-ExtraBold-lf-ts1--base.tfm \
tex-MontserratAlternates-ExtraBold-lf-ts1.tfm \
tex-MontserratAlternates-ExtraBold-lf-ts1.vf \
tex-MontserratAlternates-ExtraBold-numr-ly1--base.tfm \
tex-MontserratAlternates-ExtraBold-numr-ly1.tfm \
tex-MontserratAlternates-ExtraBold-numr-ly1.vf \
tex-MontserratAlternates-ExtraBold-numr-ot1.tfm \
tex-MontserratAlternates-ExtraBold-numr-t1--base.tfm \
tex-MontserratAlternates-ExtraBold-numr-t1.tfm \
tex-MontserratAlternates-ExtraBold-numr-t1.vf \
tex-MontserratAlternates-ExtraBold-osf-ly1--base.tfm \
tex-MontserratAlternates-ExtraBold-osf-ly1.tfm \
tex-MontserratAlternates-ExtraBold-osf-ly1.vf \
tex-MontserratAlternates-ExtraBold-osf-ot1.tfm \
tex-MontserratAlternates-ExtraBold-osf-sc-ly1--base.tfm \
tex-MontserratAlternates-ExtraBold-osf-sc-ly1.tfm \
tex-MontserratAlternates-ExtraBold-osf-sc-ly1.vf \
tex-MontserratAlternates-ExtraBold-osf-sc-ot1--base.tfm \
tex-MontserratAlternates-ExtraBold-osf-sc-ot1.tfm \
tex-MontserratAlternates-ExtraBold-osf-sc-ot1.vf \
tex-MontserratAlternates-ExtraBold-osf-sc-t1--base.tfm \
tex-MontserratAlternates-ExtraBold-osf-sc-t1.tfm \
tex-MontserratAlternates-ExtraBold-osf-sc-t1.vf \
tex-MontserratAlternates-ExtraBold-osf-t1--base.tfm \
tex-MontserratAlternates-ExtraBold-osf-t1.tfm \
tex-MontserratAlternates-ExtraBold-osf-t1.vf \
tex-MontserratAlternates-ExtraBold-osf-ts1--base.tfm \
tex-MontserratAlternates-ExtraBold-osf-ts1.tfm \
tex-MontserratAlternates-ExtraBold-osf-ts1.vf \
tex-MontserratAlternates-ExtraBold-sup-ly1--base.tfm \
tex-MontserratAlternates-ExtraBold-sup-ly1.tfm \
tex-MontserratAlternates-ExtraBold-sup-ly1.vf \
tex-MontserratAlternates-ExtraBold-sup-ot1.tfm \
tex-MontserratAlternates-ExtraBold-sup-t1--base.tfm \
tex-MontserratAlternates-ExtraBold-sup-t1.tfm \
tex-MontserratAlternates-ExtraBold-sup-t1.vf \
tex-MontserratAlternates-ExtraBold-tlf-ly1--base.tfm \
tex-MontserratAlternates-ExtraBold-tlf-ly1.tfm \
tex-MontserratAlternates-ExtraBold-tlf-ly1.vf \
tex-MontserratAlternates-ExtraBold-tlf-ot1.tfm \
tex-MontserratAlternates-ExtraBold-tlf-sc-ly1--base.tfm \
tex-MontserratAlternates-ExtraBold-tlf-sc-ly1.tfm \
tex-MontserratAlternates-ExtraBold-tlf-sc-ly1.vf \
tex-MontserratAlternates-ExtraBold-tlf-sc-ot1--base.tfm \
tex-MontserratAlternates-ExtraBold-tlf-sc-ot1.tfm \
tex-MontserratAlternates-ExtraBold-tlf-sc-ot1.vf \
tex-MontserratAlternates-ExtraBold-tlf-sc-t1--base.tfm \
tex-MontserratAlternates-ExtraBold-tlf-sc-t1.tfm \
tex-MontserratAlternates-ExtraBold-tlf-sc-t1.vf \
tex-MontserratAlternates-ExtraBold-tlf-t1--base.tfm \
tex-MontserratAlternates-ExtraBold-tlf-t1.tfm \
tex-MontserratAlternates-ExtraBold-tlf-t1.vf \
tex-MontserratAlternates-ExtraBold-tlf-ts1--base.tfm \
tex-MontserratAlternates-ExtraBold-tlf-ts1.tfm \
tex-MontserratAlternates-ExtraBold-tlf-ts1.vf \
tex-MontserratAlternates-ExtraBold-tosf-ly1--base.tfm \
tex-MontserratAlternates-ExtraBold-tosf-ly1.tfm \
tex-MontserratAlternates-ExtraBold-tosf-ly1.vf \
tex-MontserratAlternates-ExtraBold-tosf-ot1.tfm \
tex-MontserratAlternates-ExtraBold-tosf-sc-ly1--base.tfm \
tex-MontserratAlternates-ExtraBold-tosf-sc-ly1.tfm \
tex-MontserratAlternates-ExtraBold-tosf-sc-ly1.vf \
tex-MontserratAlternates-ExtraBold-tosf-sc-ot1--base.tfm \
tex-MontserratAlternates-ExtraBold-tosf-sc-ot1.tfm \
tex-MontserratAlternates-ExtraBold-tosf-sc-ot1.vf \
tex-MontserratAlternates-ExtraBold-tosf-sc-t1--base.tfm \
tex-MontserratAlternates-ExtraBold-tosf-sc-t1.tfm \
tex-MontserratAlternates-ExtraBold-tosf-sc-t1.vf \
tex-MontserratAlternates-ExtraBold-tosf-t1--base.tfm \
tex-MontserratAlternates-ExtraBold-tosf-t1.tfm \
tex-MontserratAlternates-ExtraBold-tosf-t1.vf \
tex-MontserratAlternates-ExtraBold-tosf-ts1--base.tfm \
tex-MontserratAlternates-ExtraBold-tosf-ts1.tfm \
tex-MontserratAlternates-ExtraBold-tosf-ts1.vf \
tex-MontserratAlternates-ExtraBoldItalic-dnom-ly1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-dnom-ly1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-dnom-ly1.vf \
tex-MontserratAlternates-ExtraBoldItalic-dnom-ot1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-dnom-t1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-dnom-t1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-dnom-t1.vf \
tex-MontserratAlternates-ExtraBoldItalic-inf-ly1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-inf-ly1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-inf-ly1.vf \
tex-MontserratAlternates-ExtraBoldItalic-inf-ot1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-inf-t1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-inf-t1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-inf-t1.vf \
tex-MontserratAlternates-ExtraBoldItalic-lf-ly1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-lf-ly1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-lf-ly1.vf \
tex-MontserratAlternates-ExtraBoldItalic-lf-ot1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-lf-sc-ly1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-lf-sc-ly1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-lf-sc-ly1.vf \
tex-MontserratAlternates-ExtraBoldItalic-lf-sc-ot1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-lf-sc-ot1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-lf-sc-ot1.vf \
tex-MontserratAlternates-ExtraBoldItalic-lf-sc-t1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-lf-sc-t1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-lf-sc-t1.vf \
tex-MontserratAlternates-ExtraBoldItalic-lf-t1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-lf-t1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-lf-t1.vf \
tex-MontserratAlternates-ExtraBoldItalic-lf-ts1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-lf-ts1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-lf-ts1.vf \
tex-MontserratAlternates-ExtraBoldItalic-numr-ly1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-numr-ly1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-numr-ly1.vf \
tex-MontserratAlternates-ExtraBoldItalic-numr-ot1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-numr-t1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-numr-t1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-numr-t1.vf \
tex-MontserratAlternates-ExtraBoldItalic-osf-ly1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-osf-ly1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-osf-ly1.vf \
tex-MontserratAlternates-ExtraBoldItalic-osf-ot1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-osf-sc-ly1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-osf-sc-ly1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-osf-sc-ly1.vf \
tex-MontserratAlternates-ExtraBoldItalic-osf-sc-ot1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-osf-sc-ot1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-osf-sc-ot1.vf \
tex-MontserratAlternates-ExtraBoldItalic-osf-sc-t1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-osf-sc-t1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-osf-sc-t1.vf \
tex-MontserratAlternates-ExtraBoldItalic-osf-t1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-osf-t1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-osf-t1.vf \
tex-MontserratAlternates-ExtraBoldItalic-osf-ts1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-osf-ts1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-osf-ts1.vf \
tex-MontserratAlternates-ExtraBoldItalic-sup-ly1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-sup-ly1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-sup-ly1.vf \
tex-MontserratAlternates-ExtraBoldItalic-sup-ot1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-sup-t1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-sup-t1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-sup-t1.vf \
tex-MontserratAlternates-ExtraBoldItalic-tlf-ly1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-tlf-ly1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-tlf-ly1.vf \
tex-MontserratAlternates-ExtraBoldItalic-tlf-ot1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-tlf-sc-ly1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-tlf-sc-ly1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-tlf-sc-ly1.vf \
tex-MontserratAlternates-ExtraBoldItalic-tlf-sc-ot1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-tlf-sc-ot1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-tlf-sc-ot1.vf \
tex-MontserratAlternates-ExtraBoldItalic-tlf-sc-t1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-tlf-sc-t1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-tlf-sc-t1.vf \
tex-MontserratAlternates-ExtraBoldItalic-tlf-t1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-tlf-t1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-tlf-t1.vf \
tex-MontserratAlternates-ExtraBoldItalic-tlf-ts1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-tlf-ts1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-tlf-ts1.vf \
tex-MontserratAlternates-ExtraBoldItalic-tosf-ly1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-tosf-ly1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-tosf-ly1.vf \
tex-MontserratAlternates-ExtraBoldItalic-tosf-ot1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-tosf-sc-ly1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-tosf-sc-ly1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-tosf-sc-ly1.vf \
tex-MontserratAlternates-ExtraBoldItalic-tosf-sc-ot1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-tosf-sc-ot1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-tosf-sc-ot1.vf \
tex-MontserratAlternates-ExtraBoldItalic-tosf-sc-t1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-tosf-sc-t1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-tosf-sc-t1.vf \
tex-MontserratAlternates-ExtraBoldItalic-tosf-t1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-tosf-t1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-tosf-t1.vf \
tex-MontserratAlternates-ExtraBoldItalic-tosf-ts1--base.tfm \
tex-MontserratAlternates-ExtraBoldItalic-tosf-ts1.tfm \
tex-MontserratAlternates-ExtraBoldItalic-tosf-ts1.vf \
tex-MontserratAlternates-ExtraLight-dnom-ly1--base.tfm \
tex-MontserratAlternates-ExtraLight-dnom-ly1.tfm \
tex-MontserratAlternates-ExtraLight-dnom-ly1.vf \
tex-MontserratAlternates-ExtraLight-dnom-ot1.tfm \
tex-MontserratAlternates-ExtraLight-dnom-t1--base.tfm \
tex-MontserratAlternates-ExtraLight-dnom-t1.tfm \
tex-MontserratAlternates-ExtraLight-dnom-t1.vf \
tex-MontserratAlternates-ExtraLight-inf-ly1--base.tfm \
tex-MontserratAlternates-ExtraLight-inf-ly1.tfm \
tex-MontserratAlternates-ExtraLight-inf-ly1.vf \
tex-MontserratAlternates-ExtraLight-inf-ot1.tfm \
tex-MontserratAlternates-ExtraLight-inf-t1--base.tfm \
tex-MontserratAlternates-ExtraLight-inf-t1.tfm \
tex-MontserratAlternates-ExtraLight-inf-t1.vf \
tex-MontserratAlternates-ExtraLight-lf-ly1--base.tfm \
tex-MontserratAlternates-ExtraLight-lf-ly1.tfm \
tex-MontserratAlternates-ExtraLight-lf-ly1.vf \
tex-MontserratAlternates-ExtraLight-lf-ot1.tfm \
tex-MontserratAlternates-ExtraLight-lf-sc-ly1--base.tfm \
tex-MontserratAlternates-ExtraLight-lf-sc-ly1.tfm \
tex-MontserratAlternates-ExtraLight-lf-sc-ly1.vf \
tex-MontserratAlternates-ExtraLight-lf-sc-ot1--base.tfm \
tex-MontserratAlternates-ExtraLight-lf-sc-ot1.tfm \
tex-MontserratAlternates-ExtraLight-lf-sc-ot1.vf \
tex-MontserratAlternates-ExtraLight-lf-sc-t1--base.tfm \
tex-MontserratAlternates-ExtraLight-lf-sc-t1.tfm \
tex-MontserratAlternates-ExtraLight-lf-sc-t1.vf \
tex-MontserratAlternates-ExtraLight-lf-t1--base.tfm \
tex-MontserratAlternates-ExtraLight-lf-t1.tfm \
tex-MontserratAlternates-ExtraLight-lf-t1.vf \
tex-MontserratAlternates-ExtraLight-lf-ts1--base.tfm \
tex-MontserratAlternates-ExtraLight-lf-ts1.tfm \
tex-MontserratAlternates-ExtraLight-lf-ts1.vf \
tex-MontserratAlternates-ExtraLight-numr-ly1--base.tfm \
tex-MontserratAlternates-ExtraLight-numr-ly1.tfm \
tex-MontserratAlternates-ExtraLight-numr-ly1.vf \
tex-MontserratAlternates-ExtraLight-numr-ot1.tfm \
tex-MontserratAlternates-ExtraLight-numr-t1--base.tfm \
tex-MontserratAlternates-ExtraLight-numr-t1.tfm \
tex-MontserratAlternates-ExtraLight-numr-t1.vf \
tex-MontserratAlternates-ExtraLight-osf-ly1--base.tfm \
tex-MontserratAlternates-ExtraLight-osf-ly1.tfm \
tex-MontserratAlternates-ExtraLight-osf-ly1.vf \
tex-MontserratAlternates-ExtraLight-osf-ot1.tfm \
tex-MontserratAlternates-ExtraLight-osf-sc-ly1--base.tfm \
tex-MontserratAlternates-ExtraLight-osf-sc-ly1.tfm \
tex-MontserratAlternates-ExtraLight-osf-sc-ly1.vf \
tex-MontserratAlternates-ExtraLight-osf-sc-ot1--base.tfm \
tex-MontserratAlternates-ExtraLight-osf-sc-ot1.tfm \
tex-MontserratAlternates-ExtraLight-osf-sc-ot1.vf \
tex-MontserratAlternates-ExtraLight-osf-sc-t1--base.tfm \
tex-MontserratAlternates-ExtraLight-osf-sc-t1.tfm \
tex-MontserratAlternates-ExtraLight-osf-sc-t1.vf \
tex-MontserratAlternates-ExtraLight-osf-t1--base.tfm \
tex-MontserratAlternates-ExtraLight-osf-t1.tfm \
tex-MontserratAlternates-ExtraLight-osf-t1.vf \
tex-MontserratAlternates-ExtraLight-osf-ts1--base.tfm \
tex-MontserratAlternates-ExtraLight-osf-ts1.tfm \
tex-MontserratAlternates-ExtraLight-osf-ts1.vf \
tex-MontserratAlternates-ExtraLight-sup-ly1--base.tfm \
tex-MontserratAlternates-ExtraLight-sup-ly1.tfm \
tex-MontserratAlternates-ExtraLight-sup-ly1.vf \
tex-MontserratAlternates-ExtraLight-sup-ot1.tfm \
tex-MontserratAlternates-ExtraLight-sup-t1--base.tfm \
tex-MontserratAlternates-ExtraLight-sup-t1.tfm \
tex-MontserratAlternates-ExtraLight-sup-t1.vf \
tex-MontserratAlternates-ExtraLight-tlf-ly1--base.tfm \
tex-MontserratAlternates-ExtraLight-tlf-ly1.tfm \
tex-MontserratAlternates-ExtraLight-tlf-ly1.vf \
tex-MontserratAlternates-ExtraLight-tlf-ot1.tfm \
tex-MontserratAlternates-ExtraLight-tlf-sc-ly1--base.tfm \
tex-MontserratAlternates-ExtraLight-tlf-sc-ly1.tfm \
tex-MontserratAlternates-ExtraLight-tlf-sc-ly1.vf \
tex-MontserratAlternates-ExtraLight-tlf-sc-ot1--base.tfm \
tex-MontserratAlternates-ExtraLight-tlf-sc-ot1.tfm \
tex-MontserratAlternates-ExtraLight-tlf-sc-ot1.vf \
tex-MontserratAlternates-ExtraLight-tlf-sc-t1--base.tfm \
tex-MontserratAlternates-ExtraLight-tlf-sc-t1.tfm \
tex-MontserratAlternates-ExtraLight-tlf-sc-t1.vf \
tex-MontserratAlternates-ExtraLight-tlf-t1--base.tfm \
tex-MontserratAlternates-ExtraLight-tlf-t1.tfm \
tex-MontserratAlternates-ExtraLight-tlf-t1.vf \
tex-MontserratAlternates-ExtraLight-tlf-ts1--base.tfm \
tex-MontserratAlternates-ExtraLight-tlf-ts1.tfm \
tex-MontserratAlternates-ExtraLight-tlf-ts1.vf \
tex-MontserratAlternates-ExtraLight-tosf-ly1--base.tfm \
tex-MontserratAlternates-ExtraLight-tosf-ly1.tfm \
tex-MontserratAlternates-ExtraLight-tosf-ly1.vf \
tex-MontserratAlternates-ExtraLight-tosf-ot1.tfm \
tex-MontserratAlternates-ExtraLight-tosf-sc-ly1--base.tfm \
tex-MontserratAlternates-ExtraLight-tosf-sc-ly1.tfm \
tex-MontserratAlternates-ExtraLight-tosf-sc-ly1.vf \
tex-MontserratAlternates-ExtraLight-tosf-sc-ot1--base.tfm \
tex-MontserratAlternates-ExtraLight-tosf-sc-ot1.tfm \
tex-MontserratAlternates-ExtraLight-tosf-sc-ot1.vf \
tex-MontserratAlternates-ExtraLight-tosf-sc-t1--base.tfm \
tex-MontserratAlternates-ExtraLight-tosf-sc-t1.tfm \
tex-MontserratAlternates-ExtraLight-tosf-sc-t1.vf \
tex-MontserratAlternates-ExtraLight-tosf-t1--base.tfm \
tex-MontserratAlternates-ExtraLight-tosf-t1.tfm \
tex-MontserratAlternates-ExtraLight-tosf-t1.vf \
tex-MontserratAlternates-ExtraLight-tosf-ts1--base.tfm \
tex-MontserratAlternates-ExtraLight-tosf-ts1.tfm \
tex-MontserratAlternates-ExtraLight-tosf-ts1.vf \
tex-MontserratAlternates-ExtraLightItalic-dnom-ly1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-dnom-ly1.tfm \
tex-MontserratAlternates-ExtraLightItalic-dnom-ly1.vf \
tex-MontserratAlternates-ExtraLightItalic-dnom-ot1.tfm \
tex-MontserratAlternates-ExtraLightItalic-dnom-t1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-dnom-t1.tfm \
tex-MontserratAlternates-ExtraLightItalic-dnom-t1.vf \
tex-MontserratAlternates-ExtraLightItalic-inf-ly1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-inf-ly1.tfm \
tex-MontserratAlternates-ExtraLightItalic-inf-ly1.vf \
tex-MontserratAlternates-ExtraLightItalic-inf-ot1.tfm \
tex-MontserratAlternates-ExtraLightItalic-inf-t1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-inf-t1.tfm \
tex-MontserratAlternates-ExtraLightItalic-inf-t1.vf \
tex-MontserratAlternates-ExtraLightItalic-lf-ly1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-lf-ly1.tfm \
tex-MontserratAlternates-ExtraLightItalic-lf-ly1.vf \
tex-MontserratAlternates-ExtraLightItalic-lf-ot1.tfm \
tex-MontserratAlternates-ExtraLightItalic-lf-sc-ly1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-lf-sc-ly1.tfm \
tex-MontserratAlternates-ExtraLightItalic-lf-sc-ly1.vf \
tex-MontserratAlternates-ExtraLightItalic-lf-sc-ot1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-lf-sc-ot1.tfm \
tex-MontserratAlternates-ExtraLightItalic-lf-sc-ot1.vf \
tex-MontserratAlternates-ExtraLightItalic-lf-sc-t1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-lf-sc-t1.tfm \
tex-MontserratAlternates-ExtraLightItalic-lf-sc-t1.vf \
tex-MontserratAlternates-ExtraLightItalic-lf-t1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-lf-t1.tfm \
tex-MontserratAlternates-ExtraLightItalic-lf-t1.vf \
tex-MontserratAlternates-ExtraLightItalic-lf-ts1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-lf-ts1.tfm \
tex-MontserratAlternates-ExtraLightItalic-lf-ts1.vf \
tex-MontserratAlternates-ExtraLightItalic-numr-ly1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-numr-ly1.tfm \
tex-MontserratAlternates-ExtraLightItalic-numr-ly1.vf \
tex-MontserratAlternates-ExtraLightItalic-numr-ot1.tfm \
tex-MontserratAlternates-ExtraLightItalic-numr-t1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-numr-t1.tfm \
tex-MontserratAlternates-ExtraLightItalic-numr-t1.vf \
tex-MontserratAlternates-ExtraLightItalic-osf-ly1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-osf-ly1.tfm \
tex-MontserratAlternates-ExtraLightItalic-osf-ly1.vf \
tex-MontserratAlternates-ExtraLightItalic-osf-ot1.tfm \
tex-MontserratAlternates-ExtraLightItalic-osf-sc-ly1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-osf-sc-ly1.tfm \
tex-MontserratAlternates-ExtraLightItalic-osf-sc-ly1.vf \
tex-MontserratAlternates-ExtraLightItalic-osf-sc-ot1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-osf-sc-ot1.tfm \
tex-MontserratAlternates-ExtraLightItalic-osf-sc-ot1.vf \
tex-MontserratAlternates-ExtraLightItalic-osf-sc-t1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-osf-sc-t1.tfm \
tex-MontserratAlternates-ExtraLightItalic-osf-sc-t1.vf \
tex-MontserratAlternates-ExtraLightItalic-osf-t1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-osf-t1.tfm \
tex-MontserratAlternates-ExtraLightItalic-osf-t1.vf \
tex-MontserratAlternates-ExtraLightItalic-osf-ts1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-osf-ts1.tfm \
tex-MontserratAlternates-ExtraLightItalic-osf-ts1.vf \
tex-MontserratAlternates-ExtraLightItalic-sup-ly1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-sup-ly1.tfm \
tex-MontserratAlternates-ExtraLightItalic-sup-ly1.vf \
tex-MontserratAlternates-ExtraLightItalic-sup-ot1.tfm \
tex-MontserratAlternates-ExtraLightItalic-sup-t1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-sup-t1.tfm \
tex-MontserratAlternates-ExtraLightItalic-sup-t1.vf \
tex-MontserratAlternates-ExtraLightItalic-tlf-ly1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-tlf-ly1.tfm \
tex-MontserratAlternates-ExtraLightItalic-tlf-ly1.vf \
tex-MontserratAlternates-ExtraLightItalic-tlf-ot1.tfm \
tex-MontserratAlternates-ExtraLightItalic-tlf-sc-ly1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-tlf-sc-ly1.tfm \
tex-MontserratAlternates-ExtraLightItalic-tlf-sc-ly1.vf \
tex-MontserratAlternates-ExtraLightItalic-tlf-sc-ot1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-tlf-sc-ot1.tfm \
tex-MontserratAlternates-ExtraLightItalic-tlf-sc-ot1.vf \
tex-MontserratAlternates-ExtraLightItalic-tlf-sc-t1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-tlf-sc-t1.tfm \
tex-MontserratAlternates-ExtraLightItalic-tlf-sc-t1.vf \
tex-MontserratAlternates-ExtraLightItalic-tlf-t1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-tlf-t1.tfm \
tex-MontserratAlternates-ExtraLightItalic-tlf-t1.vf \
tex-MontserratAlternates-ExtraLightItalic-tlf-ts1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-tlf-ts1.tfm \
tex-MontserratAlternates-ExtraLightItalic-tlf-ts1.vf \
tex-MontserratAlternates-ExtraLightItalic-tosf-ly1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-tosf-ly1.tfm \
tex-MontserratAlternates-ExtraLightItalic-tosf-ly1.vf \
tex-MontserratAlternates-ExtraLightItalic-tosf-ot1.tfm \
tex-MontserratAlternates-ExtraLightItalic-tosf-sc-ly1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-tosf-sc-ly1.tfm \
tex-MontserratAlternates-ExtraLightItalic-tosf-sc-ly1.vf \
tex-MontserratAlternates-ExtraLightItalic-tosf-sc-ot1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-tosf-sc-ot1.tfm \
tex-MontserratAlternates-ExtraLightItalic-tosf-sc-ot1.vf \
tex-MontserratAlternates-ExtraLightItalic-tosf-sc-t1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-tosf-sc-t1.tfm \
tex-MontserratAlternates-ExtraLightItalic-tosf-sc-t1.vf \
tex-MontserratAlternates-ExtraLightItalic-tosf-t1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-tosf-t1.tfm \
tex-MontserratAlternates-ExtraLightItalic-tosf-t1.vf \
tex-MontserratAlternates-ExtraLightItalic-tosf-ts1--base.tfm \
tex-MontserratAlternates-ExtraLightItalic-tosf-ts1.tfm \
tex-MontserratAlternates-ExtraLightItalic-tosf-ts1.vf \
tex-MontserratAlternates-Italic-dnom-ly1--base.tfm \
tex-MontserratAlternates-Italic-dnom-ly1.tfm \
tex-MontserratAlternates-Italic-dnom-ly1.vf \
tex-MontserratAlternates-Italic-dnom-ot1.tfm \
tex-MontserratAlternates-Italic-dnom-t1--base.tfm \
tex-MontserratAlternates-Italic-dnom-t1.tfm \
tex-MontserratAlternates-Italic-dnom-t1.vf \
tex-MontserratAlternates-Italic-inf-ly1--base.tfm \
tex-MontserratAlternates-Italic-inf-ly1.tfm \
tex-MontserratAlternates-Italic-inf-ly1.vf \
tex-MontserratAlternates-Italic-inf-ot1.tfm \
tex-MontserratAlternates-Italic-inf-t1--base.tfm \
tex-MontserratAlternates-Italic-inf-t1.tfm \
tex-MontserratAlternates-Italic-inf-t1.vf \
tex-MontserratAlternates-Italic-lf-ly1--base.tfm \
tex-MontserratAlternates-Italic-lf-ly1.tfm \
tex-MontserratAlternates-Italic-lf-ly1.vf \
tex-MontserratAlternates-Italic-lf-ot1.tfm \
tex-MontserratAlternates-Italic-lf-sc-ly1--base.tfm \
tex-MontserratAlternates-Italic-lf-sc-ly1.tfm \
tex-MontserratAlternates-Italic-lf-sc-ly1.vf \
tex-MontserratAlternates-Italic-lf-sc-ot1--base.tfm \
tex-MontserratAlternates-Italic-lf-sc-ot1.tfm \
tex-MontserratAlternates-Italic-lf-sc-ot1.vf \
tex-MontserratAlternates-Italic-lf-sc-t1--base.tfm \
tex-MontserratAlternates-Italic-lf-sc-t1.tfm \
tex-MontserratAlternates-Italic-lf-sc-t1.vf \
tex-MontserratAlternates-Italic-lf-t1--base.tfm \
tex-MontserratAlternates-Italic-lf-t1.tfm \
tex-MontserratAlternates-Italic-lf-t1.vf \
tex-MontserratAlternates-Italic-lf-ts1--base.tfm \
tex-MontserratAlternates-Italic-lf-ts1.tfm \
tex-MontserratAlternates-Italic-lf-ts1.vf \
tex-MontserratAlternates-Italic-numr-ly1--base.tfm \
tex-MontserratAlternates-Italic-numr-ly1.tfm \
tex-MontserratAlternates-Italic-numr-ly1.vf \
tex-MontserratAlternates-Italic-numr-ot1.tfm \
tex-MontserratAlternates-Italic-numr-t1--base.tfm \
tex-MontserratAlternates-Italic-numr-t1.tfm \
tex-MontserratAlternates-Italic-numr-t1.vf \
tex-MontserratAlternates-Italic-osf-ly1--base.tfm \
tex-MontserratAlternates-Italic-osf-ly1.tfm \
tex-MontserratAlternates-Italic-osf-ly1.vf \
tex-MontserratAlternates-Italic-osf-ot1.tfm \
tex-MontserratAlternates-Italic-osf-sc-ly1--base.tfm \
tex-MontserratAlternates-Italic-osf-sc-ly1.tfm \
tex-MontserratAlternates-Italic-osf-sc-ly1.vf \
tex-MontserratAlternates-Italic-osf-sc-ot1--base.tfm \
tex-MontserratAlternates-Italic-osf-sc-ot1.tfm \
tex-MontserratAlternates-Italic-osf-sc-ot1.vf \
tex-MontserratAlternates-Italic-osf-sc-t1--base.tfm \
tex-MontserratAlternates-Italic-osf-sc-t1.tfm \
tex-MontserratAlternates-Italic-osf-sc-t1.vf \
tex-MontserratAlternates-Italic-osf-t1--base.tfm \
tex-MontserratAlternates-Italic-osf-t1.tfm \
tex-MontserratAlternates-Italic-osf-t1.vf \
tex-MontserratAlternates-Italic-osf-ts1--base.tfm \
tex-MontserratAlternates-Italic-osf-ts1.tfm \
tex-MontserratAlternates-Italic-osf-ts1.vf \
tex-MontserratAlternates-Italic-sup-ly1--base.tfm \
tex-MontserratAlternates-Italic-sup-ly1.tfm \
tex-MontserratAlternates-Italic-sup-ly1.vf \
tex-MontserratAlternates-Italic-sup-ot1.tfm \
tex-MontserratAlternates-Italic-sup-t1--base.tfm \
tex-MontserratAlternates-Italic-sup-t1.tfm \
tex-MontserratAlternates-Italic-sup-t1.vf \
tex-MontserratAlternates-Italic-tlf-ly1--base.tfm \
tex-MontserratAlternates-Italic-tlf-ly1.tfm \
tex-MontserratAlternates-Italic-tlf-ly1.vf \
tex-MontserratAlternates-Italic-tlf-ot1.tfm \
tex-MontserratAlternates-Italic-tlf-sc-ly1--base.tfm \
tex-MontserratAlternates-Italic-tlf-sc-ly1.tfm \
tex-MontserratAlternates-Italic-tlf-sc-ly1.vf \
tex-MontserratAlternates-Italic-tlf-sc-ot1--base.tfm \
tex-MontserratAlternates-Italic-tlf-sc-ot1.tfm \
tex-MontserratAlternates-Italic-tlf-sc-ot1.vf \
tex-MontserratAlternates-Italic-tlf-sc-t1--base.tfm \
tex-MontserratAlternates-Italic-tlf-sc-t1.tfm \
tex-MontserratAlternates-Italic-tlf-sc-t1.vf \
tex-MontserratAlternates-Italic-tlf-t1--base.tfm \
tex-MontserratAlternates-Italic-tlf-t1.tfm \
tex-MontserratAlternates-Italic-tlf-t1.vf \
tex-MontserratAlternates-Italic-tlf-ts1--base.tfm \
tex-MontserratAlternates-Italic-tlf-ts1.tfm \
tex-MontserratAlternates-Italic-tlf-ts1.vf \
tex-MontserratAlternates-Italic-tosf-ly1--base.tfm \
tex-MontserratAlternates-Italic-tosf-ly1.tfm \
tex-MontserratAlternates-Italic-tosf-ly1.vf \
tex-MontserratAlternates-Italic-tosf-ot1.tfm \
tex-MontserratAlternates-Italic-tosf-sc-ly1--base.tfm \
tex-MontserratAlternates-Italic-tosf-sc-ly1.tfm \
tex-MontserratAlternates-Italic-tosf-sc-ly1.vf \
tex-MontserratAlternates-Italic-tosf-sc-ot1--base.tfm \
tex-MontserratAlternates-Italic-tosf-sc-ot1.tfm \
tex-MontserratAlternates-Italic-tosf-sc-ot1.vf \
tex-MontserratAlternates-Italic-tosf-sc-t1--base.tfm \
tex-MontserratAlternates-Italic-tosf-sc-t1.tfm \
tex-MontserratAlternates-Italic-tosf-sc-t1.vf \
tex-MontserratAlternates-Italic-tosf-t1--base.tfm \
tex-MontserratAlternates-Italic-tosf-t1.tfm \
tex-MontserratAlternates-Italic-tosf-t1.vf \
tex-MontserratAlternates-Italic-tosf-ts1--base.tfm \
tex-MontserratAlternates-Italic-tosf-ts1.tfm \
tex-MontserratAlternates-Italic-tosf-ts1.vf \
tex-MontserratAlternates-Light-dnom-ly1--base.tfm \
tex-MontserratAlternates-Light-dnom-ly1.tfm \
tex-MontserratAlternates-Light-dnom-ly1.vf \
tex-MontserratAlternates-Light-dnom-ot1.tfm \
tex-MontserratAlternates-Light-dnom-t1--base.tfm \
tex-MontserratAlternates-Light-dnom-t1.tfm \
tex-MontserratAlternates-Light-dnom-t1.vf \
tex-MontserratAlternates-Light-inf-ly1--base.tfm \
tex-MontserratAlternates-Light-inf-ly1.tfm \
tex-MontserratAlternates-Light-inf-ly1.vf \
tex-MontserratAlternates-Light-inf-ot1.tfm \
tex-MontserratAlternates-Light-inf-t1--base.tfm \
tex-MontserratAlternates-Light-inf-t1.tfm \
tex-MontserratAlternates-Light-inf-t1.vf \
tex-MontserratAlternates-Light-lf-ly1--base.tfm \
tex-MontserratAlternates-Light-lf-ly1.tfm \
tex-MontserratAlternates-Light-lf-ly1.vf \
tex-MontserratAlternates-Light-lf-ot1.tfm \
tex-MontserratAlternates-Light-lf-sc-ly1--base.tfm \
tex-MontserratAlternates-Light-lf-sc-ly1.tfm \
tex-MontserratAlternates-Light-lf-sc-ly1.vf \
tex-MontserratAlternates-Light-lf-sc-ot1--base.tfm \
tex-MontserratAlternates-Light-lf-sc-ot1.tfm \
tex-MontserratAlternates-Light-lf-sc-ot1.vf \
tex-MontserratAlternates-Light-lf-sc-t1--base.tfm \
tex-MontserratAlternates-Light-lf-sc-t1.tfm \
tex-MontserratAlternates-Light-lf-sc-t1.vf \
tex-MontserratAlternates-Light-lf-t1--base.tfm \
tex-MontserratAlternates-Light-lf-t1.tfm \
tex-MontserratAlternates-Light-lf-t1.vf \
tex-MontserratAlternates-Light-lf-ts1--base.tfm \
tex-MontserratAlternates-Light-lf-ts1.tfm \
tex-MontserratAlternates-Light-lf-ts1.vf \
tex-MontserratAlternates-Light-numr-ly1--base.tfm \
tex-MontserratAlternates-Light-numr-ly1.tfm \
tex-MontserratAlternates-Light-numr-ly1.vf \
tex-MontserratAlternates-Light-numr-ot1.tfm \
tex-MontserratAlternates-Light-numr-t1--base.tfm \
tex-MontserratAlternates-Light-numr-t1.tfm \
tex-MontserratAlternates-Light-numr-t1.vf \
tex-MontserratAlternates-Light-osf-ly1--base.tfm \
tex-MontserratAlternates-Light-osf-ly1.tfm \
tex-MontserratAlternates-Light-osf-ly1.vf \
tex-MontserratAlternates-Light-osf-ot1.tfm \
tex-MontserratAlternates-Light-osf-sc-ly1--base.tfm \
tex-MontserratAlternates-Light-osf-sc-ly1.tfm \
tex-MontserratAlternates-Light-osf-sc-ly1.vf \
tex-MontserratAlternates-Light-osf-sc-ot1--base.tfm \
tex-MontserratAlternates-Light-osf-sc-ot1.tfm \
tex-MontserratAlternates-Light-osf-sc-ot1.vf \
tex-MontserratAlternates-Light-osf-sc-t1--base.tfm \
tex-MontserratAlternates-Light-osf-sc-t1.tfm \
tex-MontserratAlternates-Light-osf-sc-t1.vf \
tex-MontserratAlternates-Light-osf-t1--base.tfm \
tex-MontserratAlternates-Light-osf-t1.tfm \
tex-MontserratAlternates-Light-osf-t1.vf \
tex-MontserratAlternates-Light-osf-ts1--base.tfm \
tex-MontserratAlternates-Light-osf-ts1.tfm \
tex-MontserratAlternates-Light-osf-ts1.vf \
tex-MontserratAlternates-Light-sup-ly1--base.tfm \
tex-MontserratAlternates-Light-sup-ly1.tfm \
tex-MontserratAlternates-Light-sup-ly1.vf \
tex-MontserratAlternates-Light-sup-ot1.tfm \
tex-MontserratAlternates-Light-sup-t1--base.tfm \
tex-MontserratAlternates-Light-sup-t1.tfm \
tex-MontserratAlternates-Light-sup-t1.vf \
tex-MontserratAlternates-Light-tlf-ly1--base.tfm \
tex-MontserratAlternates-Light-tlf-ly1.tfm \
tex-MontserratAlternates-Light-tlf-ly1.vf \
tex-MontserratAlternates-Light-tlf-ot1.tfm \
tex-MontserratAlternates-Light-tlf-sc-ly1--base.tfm \
tex-MontserratAlternates-Light-tlf-sc-ly1.tfm \
tex-MontserratAlternates-Light-tlf-sc-ly1.vf \
tex-MontserratAlternates-Light-tlf-sc-ot1--base.tfm \
tex-MontserratAlternates-Light-tlf-sc-ot1.tfm \
tex-MontserratAlternates-Light-tlf-sc-ot1.vf \
tex-MontserratAlternates-Light-tlf-sc-t1--base.tfm \
tex-MontserratAlternates-Light-tlf-sc-t1.tfm \
tex-MontserratAlternates-Light-tlf-sc-t1.vf \
tex-MontserratAlternates-Light-tlf-t1--base.tfm \
tex-MontserratAlternates-Light-tlf-t1.tfm \
tex-MontserratAlternates-Light-tlf-t1.vf \
tex-MontserratAlternates-Light-tlf-ts1--base.tfm \
tex-MontserratAlternates-Light-tlf-ts1.tfm \
tex-MontserratAlternates-Light-tlf-ts1.vf \
tex-MontserratAlternates-Light-tosf-ly1--base.tfm \
tex-MontserratAlternates-Light-tosf-ly1.tfm \
tex-MontserratAlternates-Light-tosf-ly1.vf \
tex-MontserratAlternates-Light-tosf-ot1.tfm \
tex-MontserratAlternates-Light-tosf-sc-ly1--base.tfm \
tex-MontserratAlternates-Light-tosf-sc-ly1.tfm \
tex-MontserratAlternates-Light-tosf-sc-ly1.vf \
tex-MontserratAlternates-Light-tosf-sc-ot1--base.tfm \
tex-MontserratAlternates-Light-tosf-sc-ot1.tfm \
tex-MontserratAlternates-Light-tosf-sc-ot1.vf \
tex-MontserratAlternates-Light-tosf-sc-t1--base.tfm \
tex-MontserratAlternates-Light-tosf-sc-t1.tfm \
tex-MontserratAlternates-Light-tosf-sc-t1.vf \
tex-MontserratAlternates-Light-tosf-t1--base.tfm \
tex-MontserratAlternates-Light-tosf-t1.tfm \
tex-MontserratAlternates-Light-tosf-t1.vf \
tex-MontserratAlternates-Light-tosf-ts1--base.tfm \
tex-MontserratAlternates-Light-tosf-ts1.tfm \
tex-MontserratAlternates-Light-tosf-ts1.vf \
tex-MontserratAlternates-LightItalic-dnom-ly1--base.tfm \
tex-MontserratAlternates-LightItalic-dnom-ly1.tfm \
tex-MontserratAlternates-LightItalic-dnom-ly1.vf \
tex-MontserratAlternates-LightItalic-dnom-ot1.tfm \
tex-MontserratAlternates-LightItalic-dnom-t1--base.tfm \
tex-MontserratAlternates-LightItalic-dnom-t1.tfm \
tex-MontserratAlternates-LightItalic-dnom-t1.vf \
tex-MontserratAlternates-LightItalic-inf-ly1--base.tfm \
tex-MontserratAlternates-LightItalic-inf-ly1.tfm \
tex-MontserratAlternates-LightItalic-inf-ly1.vf \
tex-MontserratAlternates-LightItalic-inf-ot1.tfm \
tex-MontserratAlternates-LightItalic-inf-t1--base.tfm \
tex-MontserratAlternates-LightItalic-inf-t1.tfm \
tex-MontserratAlternates-LightItalic-inf-t1.vf \
tex-MontserratAlternates-LightItalic-lf-ly1--base.tfm \
tex-MontserratAlternates-LightItalic-lf-ly1.tfm \
tex-MontserratAlternates-LightItalic-lf-ly1.vf \
tex-MontserratAlternates-LightItalic-lf-ot1.tfm \
tex-MontserratAlternates-LightItalic-lf-sc-ly1--base.tfm \
tex-MontserratAlternates-LightItalic-lf-sc-ly1.tfm \
tex-MontserratAlternates-LightItalic-lf-sc-ly1.vf \
tex-MontserratAlternates-LightItalic-lf-sc-ot1--base.tfm \
tex-MontserratAlternates-LightItalic-lf-sc-ot1.tfm \
tex-MontserratAlternates-LightItalic-lf-sc-ot1.vf \
tex-MontserratAlternates-LightItalic-lf-sc-t1--base.tfm \
tex-MontserratAlternates-LightItalic-lf-sc-t1.tfm \
tex-MontserratAlternates-LightItalic-lf-sc-t1.vf \
tex-MontserratAlternates-LightItalic-lf-t1--base.tfm \
tex-MontserratAlternates-LightItalic-lf-t1.tfm \
tex-MontserratAlternates-LightItalic-lf-t1.vf \
tex-MontserratAlternates-LightItalic-lf-ts1--base.tfm \
tex-MontserratAlternates-LightItalic-lf-ts1.tfm \
tex-MontserratAlternates-LightItalic-lf-ts1.vf \
tex-MontserratAlternates-LightItalic-numr-ly1--base.tfm \
tex-MontserratAlternates-LightItalic-numr-ly1.tfm \
tex-MontserratAlternates-LightItalic-numr-ly1.vf \
tex-MontserratAlternates-LightItalic-numr-ot1.tfm \
tex-MontserratAlternates-LightItalic-numr-t1--base.tfm \
tex-MontserratAlternates-LightItalic-numr-t1.tfm \
tex-MontserratAlternates-LightItalic-numr-t1.vf \
tex-MontserratAlternates-LightItalic-osf-ly1--base.tfm \
tex-MontserratAlternates-LightItalic-osf-ly1.tfm \
tex-MontserratAlternates-LightItalic-osf-ly1.vf \
tex-MontserratAlternates-LightItalic-osf-ot1.tfm \
tex-MontserratAlternates-LightItalic-osf-sc-ly1--base.tfm \
tex-MontserratAlternates-LightItalic-osf-sc-ly1.tfm \
tex-MontserratAlternates-LightItalic-osf-sc-ly1.vf \
tex-MontserratAlternates-LightItalic-osf-sc-ot1--base.tfm \
tex-MontserratAlternates-LightItalic-osf-sc-ot1.tfm \
tex-MontserratAlternates-LightItalic-osf-sc-ot1.vf \
tex-MontserratAlternates-LightItalic-osf-sc-t1--base.tfm \
tex-MontserratAlternates-LightItalic-osf-sc-t1.tfm \
tex-MontserratAlternates-LightItalic-osf-sc-t1.vf \
tex-MontserratAlternates-LightItalic-osf-t1--base.tfm \
tex-MontserratAlternates-LightItalic-osf-t1.tfm \
tex-MontserratAlternates-LightItalic-osf-t1.vf \
tex-MontserratAlternates-LightItalic-osf-ts1--base.tfm \
tex-MontserratAlternates-LightItalic-osf-ts1.tfm \
tex-MontserratAlternates-LightItalic-osf-ts1.vf \
tex-MontserratAlternates-LightItalic-sup-ly1--base.tfm \
tex-MontserratAlternates-LightItalic-sup-ly1.tfm \
tex-MontserratAlternates-LightItalic-sup-ly1.vf \
tex-MontserratAlternates-LightItalic-sup-ot1.tfm \
tex-MontserratAlternates-LightItalic-sup-t1--base.tfm \
tex-MontserratAlternates-LightItalic-sup-t1.tfm \
tex-MontserratAlternates-LightItalic-sup-t1.vf \
tex-MontserratAlternates-LightItalic-tlf-ly1--base.tfm \
tex-MontserratAlternates-LightItalic-tlf-ly1.tfm \
tex-MontserratAlternates-LightItalic-tlf-ly1.vf \
tex-MontserratAlternates-LightItalic-tlf-ot1.tfm \
tex-MontserratAlternates-LightItalic-tlf-sc-ly1--base.tfm \
tex-MontserratAlternates-LightItalic-tlf-sc-ly1.tfm \
tex-MontserratAlternates-LightItalic-tlf-sc-ly1.vf \
tex-MontserratAlternates-LightItalic-tlf-sc-ot1--base.tfm \
tex-MontserratAlternates-LightItalic-tlf-sc-ot1.tfm \
tex-MontserratAlternates-LightItalic-tlf-sc-ot1.vf \
tex-MontserratAlternates-LightItalic-tlf-sc-t1--base.tfm \
tex-MontserratAlternates-LightItalic-tlf-sc-t1.tfm \
tex-MontserratAlternates-LightItalic-tlf-sc-t1.vf \
tex-MontserratAlternates-LightItalic-tlf-t1--base.tfm \
tex-MontserratAlternates-LightItalic-tlf-t1.tfm \
tex-MontserratAlternates-LightItalic-tlf-t1.vf \
tex-MontserratAlternates-LightItalic-tlf-ts1--base.tfm \
tex-MontserratAlternates-LightItalic-tlf-ts1.tfm \
tex-MontserratAlternates-LightItalic-tlf-ts1.vf \
tex-MontserratAlternates-LightItalic-tosf-ly1--base.tfm \
tex-MontserratAlternates-LightItalic-tosf-ly1.tfm \
tex-MontserratAlternates-LightItalic-tosf-ly1.vf \
tex-MontserratAlternates-LightItalic-tosf-ot1.tfm \
tex-MontserratAlternates-LightItalic-tosf-sc-ly1--base.tfm \
tex-MontserratAlternates-LightItalic-tosf-sc-ly1.tfm \
tex-MontserratAlternates-LightItalic-tosf-sc-ly1.vf \
tex-MontserratAlternates-LightItalic-tosf-sc-ot1--base.tfm \
tex-MontserratAlternates-LightItalic-tosf-sc-ot1.tfm \
tex-MontserratAlternates-LightItalic-tosf-sc-ot1.vf \
tex-MontserratAlternates-LightItalic-tosf-sc-t1--base.tfm \
tex-MontserratAlternates-LightItalic-tosf-sc-t1.tfm \
tex-MontserratAlternates-LightItalic-tosf-sc-t1.vf \
tex-MontserratAlternates-LightItalic-tosf-t1--base.tfm \
tex-MontserratAlternates-LightItalic-tosf-t1.tfm \
tex-MontserratAlternates-LightItalic-tosf-t1.vf \
tex-MontserratAlternates-LightItalic-tosf-ts1--base.tfm \
tex-MontserratAlternates-LightItalic-tosf-ts1.tfm \
tex-MontserratAlternates-LightItalic-tosf-ts1.vf \
tex-MontserratAlternates-Medium-dnom-ly1--base.tfm \
tex-MontserratAlternates-Medium-dnom-ly1.tfm \
tex-MontserratAlternates-Medium-dnom-ly1.vf \
tex-MontserratAlternates-Medium-dnom-ot1.tfm \
tex-MontserratAlternates-Medium-dnom-t1--base.tfm \
tex-MontserratAlternates-Medium-dnom-t1.tfm \
tex-MontserratAlternates-Medium-dnom-t1.vf \
tex-MontserratAlternates-Medium-inf-ly1--base.tfm \
tex-MontserratAlternates-Medium-inf-ly1.tfm \
tex-MontserratAlternates-Medium-inf-ly1.vf \
tex-MontserratAlternates-Medium-inf-ot1.tfm \
tex-MontserratAlternates-Medium-inf-t1--base.tfm \
tex-MontserratAlternates-Medium-inf-t1.tfm \
tex-MontserratAlternates-Medium-inf-t1.vf \
tex-MontserratAlternates-Medium-lf-ly1--base.tfm \
tex-MontserratAlternates-Medium-lf-ly1.tfm \
tex-MontserratAlternates-Medium-lf-ly1.vf \
tex-MontserratAlternates-Medium-lf-ot1.tfm \
tex-MontserratAlternates-Medium-lf-sc-ly1--base.tfm \
tex-MontserratAlternates-Medium-lf-sc-ly1.tfm \
tex-MontserratAlternates-Medium-lf-sc-ly1.vf \
tex-MontserratAlternates-Medium-lf-sc-ot1--base.tfm \
tex-MontserratAlternates-Medium-lf-sc-ot1.tfm \
tex-MontserratAlternates-Medium-lf-sc-ot1.vf \
tex-MontserratAlternates-Medium-lf-sc-t1--base.tfm \
tex-MontserratAlternates-Medium-lf-sc-t1.tfm \
tex-MontserratAlternates-Medium-lf-sc-t1.vf \
tex-MontserratAlternates-Medium-lf-t1--base.tfm \
tex-MontserratAlternates-Medium-lf-t1.tfm \
tex-MontserratAlternates-Medium-lf-t1.vf \
tex-MontserratAlternates-Medium-lf-ts1--base.tfm \
tex-MontserratAlternates-Medium-lf-ts1.tfm \
tex-MontserratAlternates-Medium-lf-ts1.vf \
tex-MontserratAlternates-Medium-numr-ly1--base.tfm \
tex-MontserratAlternates-Medium-numr-ly1.tfm \
tex-MontserratAlternates-Medium-numr-ly1.vf \
tex-MontserratAlternates-Medium-numr-ot1.tfm \
tex-MontserratAlternates-Medium-numr-t1--base.tfm \
tex-MontserratAlternates-Medium-numr-t1.tfm \
tex-MontserratAlternates-Medium-numr-t1.vf \
tex-MontserratAlternates-Medium-osf-ly1--base.tfm \
tex-MontserratAlternates-Medium-osf-ly1.tfm \
tex-MontserratAlternates-Medium-osf-ly1.vf \
tex-MontserratAlternates-Medium-osf-ot1.tfm \
tex-MontserratAlternates-Medium-osf-sc-ly1--base.tfm \
tex-MontserratAlternates-Medium-osf-sc-ly1.tfm \
tex-MontserratAlternates-Medium-osf-sc-ly1.vf \
tex-MontserratAlternates-Medium-osf-sc-ot1--base.tfm \
tex-MontserratAlternates-Medium-osf-sc-ot1.tfm \
tex-MontserratAlternates-Medium-osf-sc-ot1.vf \
tex-MontserratAlternates-Medium-osf-sc-t1--base.tfm \
tex-MontserratAlternates-Medium-osf-sc-t1.tfm \
tex-MontserratAlternates-Medium-osf-sc-t1.vf \
tex-MontserratAlternates-Medium-osf-t1--base.tfm \
tex-MontserratAlternates-Medium-osf-t1.tfm \
tex-MontserratAlternates-Medium-osf-t1.vf \
tex-MontserratAlternates-Medium-osf-ts1--base.tfm \
tex-MontserratAlternates-Medium-osf-ts1.tfm \
tex-MontserratAlternates-Medium-osf-ts1.vf \
tex-MontserratAlternates-Medium-sup-ly1--base.tfm \
tex-MontserratAlternates-Medium-sup-ly1.tfm \
tex-MontserratAlternates-Medium-sup-ly1.vf \
tex-MontserratAlternates-Medium-sup-ot1.tfm \
tex-MontserratAlternates-Medium-sup-t1--base.tfm \
tex-MontserratAlternates-Medium-sup-t1.tfm \
tex-MontserratAlternates-Medium-sup-t1.vf \
tex-MontserratAlternates-Medium-tlf-ly1--base.tfm \
tex-MontserratAlternates-Medium-tlf-ly1.tfm \
tex-MontserratAlternates-Medium-tlf-ly1.vf \
tex-MontserratAlternates-Medium-tlf-ot1.tfm \
tex-MontserratAlternates-Medium-tlf-sc-ly1--base.tfm \
tex-MontserratAlternates-Medium-tlf-sc-ly1.tfm \
tex-MontserratAlternates-Medium-tlf-sc-ly1.vf \
tex-MontserratAlternates-Medium-tlf-sc-ot1--base.tfm \
tex-MontserratAlternates-Medium-tlf-sc-ot1.tfm \
tex-MontserratAlternates-Medium-tlf-sc-ot1.vf \
tex-MontserratAlternates-Medium-tlf-sc-t1--base.tfm \
tex-MontserratAlternates-Medium-tlf-sc-t1.tfm \
tex-MontserratAlternates-Medium-tlf-sc-t1.vf \
tex-MontserratAlternates-Medium-tlf-t1--base.tfm \
tex-MontserratAlternates-Medium-tlf-t1.tfm \
tex-MontserratAlternates-Medium-tlf-t1.vf \
tex-MontserratAlternates-Medium-tlf-ts1--base.tfm \
tex-MontserratAlternates-Medium-tlf-ts1.tfm \
tex-MontserratAlternates-Medium-tlf-ts1.vf \
tex-MontserratAlternates-Medium-tosf-ly1--base.tfm \
tex-MontserratAlternates-Medium-tosf-ly1.tfm \
tex-MontserratAlternates-Medium-tosf-ly1.vf \
tex-MontserratAlternates-Medium-tosf-ot1.tfm \
tex-MontserratAlternates-Medium-tosf-sc-ly1--base.tfm \
tex-MontserratAlternates-Medium-tosf-sc-ly1.tfm \
tex-MontserratAlternates-Medium-tosf-sc-ly1.vf \
tex-MontserratAlternates-Medium-tosf-sc-ot1--base.tfm \
tex-MontserratAlternates-Medium-tosf-sc-ot1.tfm \
tex-MontserratAlternates-Medium-tosf-sc-ot1.vf \
tex-MontserratAlternates-Medium-tosf-sc-t1--base.tfm \
tex-MontserratAlternates-Medium-tosf-sc-t1.tfm \
tex-MontserratAlternates-Medium-tosf-sc-t1.vf \
tex-MontserratAlternates-Medium-tosf-t1--base.tfm \
tex-MontserratAlternates-Medium-tosf-t1.tfm \
tex-MontserratAlternates-Medium-tosf-t1.vf \
tex-MontserratAlternates-Medium-tosf-ts1--base.tfm \
tex-MontserratAlternates-Medium-tosf-ts1.tfm \
tex-MontserratAlternates-Medium-tosf-ts1.vf \
tex-MontserratAlternates-MediumItalic-dnom-ly1--base.tfm \
tex-MontserratAlternates-MediumItalic-dnom-ly1.tfm \
tex-MontserratAlternates-MediumItalic-dnom-ly1.vf \
tex-MontserratAlternates-MediumItalic-dnom-ot1.tfm \
tex-MontserratAlternates-MediumItalic-dnom-t1--base.tfm \
tex-MontserratAlternates-MediumItalic-dnom-t1.tfm \
tex-MontserratAlternates-MediumItalic-dnom-t1.vf \
tex-MontserratAlternates-MediumItalic-inf-ly1--base.tfm \
tex-MontserratAlternates-MediumItalic-inf-ly1.tfm \
tex-MontserratAlternates-MediumItalic-inf-ly1.vf \
tex-MontserratAlternates-MediumItalic-inf-ot1.tfm \
tex-MontserratAlternates-MediumItalic-inf-t1--base.tfm \
tex-MontserratAlternates-MediumItalic-inf-t1.tfm \
tex-MontserratAlternates-MediumItalic-inf-t1.vf \
tex-MontserratAlternates-MediumItalic-lf-ly1--base.tfm \
tex-MontserratAlternates-MediumItalic-lf-ly1.tfm \
tex-MontserratAlternates-MediumItalic-lf-ly1.vf \
tex-MontserratAlternates-MediumItalic-lf-ot1.tfm \
tex-MontserratAlternates-MediumItalic-lf-sc-ly1--base.tfm \
tex-MontserratAlternates-MediumItalic-lf-sc-ly1.tfm \
tex-MontserratAlternates-MediumItalic-lf-sc-ly1.vf \
tex-MontserratAlternates-MediumItalic-lf-sc-ot1--base.tfm \
tex-MontserratAlternates-MediumItalic-lf-sc-ot1.tfm \
tex-MontserratAlternates-MediumItalic-lf-sc-ot1.vf \
tex-MontserratAlternates-MediumItalic-lf-sc-t1--base.tfm \
tex-MontserratAlternates-MediumItalic-lf-sc-t1.tfm \
tex-MontserratAlternates-MediumItalic-lf-sc-t1.vf \
tex-MontserratAlternates-MediumItalic-lf-t1--base.tfm \
tex-MontserratAlternates-MediumItalic-lf-t1.tfm \
tex-MontserratAlternates-MediumItalic-lf-t1.vf \
tex-MontserratAlternates-MediumItalic-lf-ts1--base.tfm \
tex-MontserratAlternates-MediumItalic-lf-ts1.tfm \
tex-MontserratAlternates-MediumItalic-lf-ts1.vf \
tex-MontserratAlternates-MediumItalic-numr-ly1--base.tfm \
tex-MontserratAlternates-MediumItalic-numr-ly1.tfm \
tex-MontserratAlternates-MediumItalic-numr-ly1.vf \
tex-MontserratAlternates-MediumItalic-numr-ot1.tfm \
tex-MontserratAlternates-MediumItalic-numr-t1--base.tfm \
tex-MontserratAlternates-MediumItalic-numr-t1.tfm \
tex-MontserratAlternates-MediumItalic-numr-t1.vf \
tex-MontserratAlternates-MediumItalic-osf-ly1--base.tfm \
tex-MontserratAlternates-MediumItalic-osf-ly1.tfm \
tex-MontserratAlternates-MediumItalic-osf-ly1.vf \
tex-MontserratAlternates-MediumItalic-osf-ot1.tfm \
tex-MontserratAlternates-MediumItalic-osf-sc-ly1--base.tfm \
tex-MontserratAlternates-MediumItalic-osf-sc-ly1.tfm \
tex-MontserratAlternates-MediumItalic-osf-sc-ly1.vf \
tex-MontserratAlternates-MediumItalic-osf-sc-ot1--base.tfm \
tex-MontserratAlternates-MediumItalic-osf-sc-ot1.tfm \
tex-MontserratAlternates-MediumItalic-osf-sc-ot1.vf \
tex-MontserratAlternates-MediumItalic-osf-sc-t1--base.tfm \
tex-MontserratAlternates-MediumItalic-osf-sc-t1.tfm \
tex-MontserratAlternates-MediumItalic-osf-sc-t1.vf \
tex-MontserratAlternates-MediumItalic-osf-t1--base.tfm \
tex-MontserratAlternates-MediumItalic-osf-t1.tfm \
tex-MontserratAlternates-MediumItalic-osf-t1.vf \
tex-MontserratAlternates-MediumItalic-osf-ts1--base.tfm \
tex-MontserratAlternates-MediumItalic-osf-ts1.tfm \
tex-MontserratAlternates-MediumItalic-osf-ts1.vf \
tex-MontserratAlternates-MediumItalic-sup-ly1--base.tfm \
tex-MontserratAlternates-MediumItalic-sup-ly1.tfm \
tex-MontserratAlternates-MediumItalic-sup-ly1.vf \
tex-MontserratAlternates-MediumItalic-sup-ot1.tfm \
tex-MontserratAlternates-MediumItalic-sup-t1--base.tfm \
tex-MontserratAlternates-MediumItalic-sup-t1.tfm \
tex-MontserratAlternates-MediumItalic-sup-t1.vf \
tex-MontserratAlternates-MediumItalic-tlf-ly1--base.tfm \
tex-MontserratAlternates-MediumItalic-tlf-ly1.tfm \
tex-MontserratAlternates-MediumItalic-tlf-ly1.vf \
tex-MontserratAlternates-MediumItalic-tlf-ot1.tfm \
tex-MontserratAlternates-MediumItalic-tlf-sc-ly1--base.tfm \
tex-MontserratAlternates-MediumItalic-tlf-sc-ly1.tfm \
tex-MontserratAlternates-MediumItalic-tlf-sc-ly1.vf \
tex-MontserratAlternates-MediumItalic-tlf-sc-ot1--base.tfm \
tex-MontserratAlternates-MediumItalic-tlf-sc-ot1.tfm \
tex-MontserratAlternates-MediumItalic-tlf-sc-ot1.vf \
tex-MontserratAlternates-MediumItalic-tlf-sc-t1--base.tfm \
tex-MontserratAlternates-MediumItalic-tlf-sc-t1.tfm \
tex-MontserratAlternates-MediumItalic-tlf-sc-t1.vf \
tex-MontserratAlternates-MediumItalic-tlf-t1--base.tfm \
tex-MontserratAlternates-MediumItalic-tlf-t1.tfm \
tex-MontserratAlternates-MediumItalic-tlf-t1.vf \
tex-MontserratAlternates-MediumItalic-tlf-ts1--base.tfm \
tex-MontserratAlternates-MediumItalic-tlf-ts1.tfm \
tex-MontserratAlternates-MediumItalic-tlf-ts1.vf \
tex-MontserratAlternates-MediumItalic-tosf-ly1--base.tfm \
tex-MontserratAlternates-MediumItalic-tosf-ly1.tfm \
tex-MontserratAlternates-MediumItalic-tosf-ly1.vf \
tex-MontserratAlternates-MediumItalic-tosf-ot1.tfm \
tex-MontserratAlternates-MediumItalic-tosf-sc-ly1--base.tfm \
tex-MontserratAlternates-MediumItalic-tosf-sc-ly1.tfm \
tex-MontserratAlternates-MediumItalic-tosf-sc-ly1.vf \
tex-MontserratAlternates-MediumItalic-tosf-sc-ot1--base.tfm \
tex-MontserratAlternates-MediumItalic-tosf-sc-ot1.tfm \
tex-MontserratAlternates-MediumItalic-tosf-sc-ot1.vf \
tex-MontserratAlternates-MediumItalic-tosf-sc-t1--base.tfm \
tex-MontserratAlternates-MediumItalic-tosf-sc-t1.tfm \
tex-MontserratAlternates-MediumItalic-tosf-sc-t1.vf \
tex-MontserratAlternates-MediumItalic-tosf-t1--base.tfm \
tex-MontserratAlternates-MediumItalic-tosf-t1.tfm \
tex-MontserratAlternates-MediumItalic-tosf-t1.vf \
tex-MontserratAlternates-MediumItalic-tosf-ts1--base.tfm \
tex-MontserratAlternates-MediumItalic-tosf-ts1.tfm \
tex-MontserratAlternates-MediumItalic-tosf-ts1.vf \
tex-MontserratAlternates-Regular-dnom-ly1--base.tfm \
tex-MontserratAlternates-Regular-dnom-ly1.tfm \
tex-MontserratAlternates-Regular-dnom-ly1.vf \
tex-MontserratAlternates-Regular-dnom-ot1.tfm \
tex-MontserratAlternates-Regular-dnom-t1--base.tfm \
tex-MontserratAlternates-Regular-dnom-t1.tfm \
tex-MontserratAlternates-Regular-dnom-t1.vf \
tex-MontserratAlternates-Regular-inf-ly1--base.tfm \
tex-MontserratAlternates-Regular-inf-ly1.tfm \
tex-MontserratAlternates-Regular-inf-ly1.vf \
tex-MontserratAlternates-Regular-inf-ot1.tfm \
tex-MontserratAlternates-Regular-inf-t1--base.tfm \
tex-MontserratAlternates-Regular-inf-t1.tfm \
tex-MontserratAlternates-Regular-inf-t1.vf \
tex-MontserratAlternates-Regular-lf-ly1--base.tfm \
tex-MontserratAlternates-Regular-lf-ly1.tfm \
tex-MontserratAlternates-Regular-lf-ly1.vf \
tex-MontserratAlternates-Regular-lf-ot1.tfm \
tex-MontserratAlternates-Regular-lf-sc-ly1--base.tfm \
tex-MontserratAlternates-Regular-lf-sc-ly1.tfm \
tex-MontserratAlternates-Regular-lf-sc-ly1.vf \
tex-MontserratAlternates-Regular-lf-sc-ot1--base.tfm \
tex-MontserratAlternates-Regular-lf-sc-ot1.tfm \
tex-MontserratAlternates-Regular-lf-sc-ot1.vf \
tex-MontserratAlternates-Regular-lf-sc-t1--base.tfm \
tex-MontserratAlternates-Regular-lf-sc-t1.tfm \
tex-MontserratAlternates-Regular-lf-sc-t1.vf \
tex-MontserratAlternates-Regular-lf-t1--base.tfm \
tex-MontserratAlternates-Regular-lf-t1.tfm \
tex-MontserratAlternates-Regular-lf-t1.vf \
tex-MontserratAlternates-Regular-lf-ts1--base.tfm \
tex-MontserratAlternates-Regular-lf-ts1.tfm \
tex-MontserratAlternates-Regular-lf-ts1.vf \
tex-MontserratAlternates-Regular-numr-ly1--base.tfm \
tex-MontserratAlternates-Regular-numr-ly1.tfm \
tex-MontserratAlternates-Regular-numr-ly1.vf \
tex-MontserratAlternates-Regular-numr-ot1.tfm \
tex-MontserratAlternates-Regular-numr-t1--base.tfm \
tex-MontserratAlternates-Regular-numr-t1.tfm \
tex-MontserratAlternates-Regular-numr-t1.vf \
tex-MontserratAlternates-Regular-osf-ly1--base.tfm \
tex-MontserratAlternates-Regular-osf-ly1.tfm \
tex-MontserratAlternates-Regular-osf-ly1.vf \
tex-MontserratAlternates-Regular-osf-ot1.tfm \
tex-MontserratAlternates-Regular-osf-sc-ly1--base.tfm \
tex-MontserratAlternates-Regular-osf-sc-ly1.tfm \
tex-MontserratAlternates-Regular-osf-sc-ly1.vf \
tex-MontserratAlternates-Regular-osf-sc-ot1--base.tfm \
tex-MontserratAlternates-Regular-osf-sc-ot1.tfm \
tex-MontserratAlternates-Regular-osf-sc-ot1.vf \
tex-MontserratAlternates-Regular-osf-sc-t1--base.tfm \
tex-MontserratAlternates-Regular-osf-sc-t1.tfm \
tex-MontserratAlternates-Regular-osf-sc-t1.vf \
tex-MontserratAlternates-Regular-osf-t1--base.tfm \
tex-MontserratAlternates-Regular-osf-t1.tfm \
tex-MontserratAlternates-Regular-osf-t1.vf \
tex-MontserratAlternates-Regular-osf-ts1--base.tfm \
tex-MontserratAlternates-Regular-osf-ts1.tfm \
tex-MontserratAlternates-Regular-osf-ts1.vf \
tex-MontserratAlternates-Regular-sup-ly1--base.tfm \
tex-MontserratAlternates-Regular-sup-ly1.tfm \
tex-MontserratAlternates-Regular-sup-ly1.vf \
tex-MontserratAlternates-Regular-sup-ot1.tfm \
tex-MontserratAlternates-Regular-sup-t1--base.tfm \
tex-MontserratAlternates-Regular-sup-t1.tfm \
tex-MontserratAlternates-Regular-sup-t1.vf \
tex-MontserratAlternates-Regular-tlf-ly1--base.tfm \
tex-MontserratAlternates-Regular-tlf-ly1.tfm \
tex-MontserratAlternates-Regular-tlf-ly1.vf \
tex-MontserratAlternates-Regular-tlf-ot1.tfm \
tex-MontserratAlternates-Regular-tlf-sc-ly1--base.tfm \
tex-MontserratAlternates-Regular-tlf-sc-ly1.tfm \
tex-MontserratAlternates-Regular-tlf-sc-ly1.vf \
tex-MontserratAlternates-Regular-tlf-sc-ot1--base.tfm \
tex-MontserratAlternates-Regular-tlf-sc-ot1.tfm \
tex-MontserratAlternates-Regular-tlf-sc-ot1.vf \
tex-MontserratAlternates-Regular-tlf-sc-t1--base.tfm \
tex-MontserratAlternates-Regular-tlf-sc-t1.tfm \
tex-MontserratAlternates-Regular-tlf-sc-t1.vf \
tex-MontserratAlternates-Regular-tlf-t1--base.tfm \
tex-MontserratAlternates-Regular-tlf-t1.tfm \
tex-MontserratAlternates-Regular-tlf-t1.vf \
tex-MontserratAlternates-Regular-tlf-ts1--base.tfm \
tex-MontserratAlternates-Regular-tlf-ts1.tfm \
tex-MontserratAlternates-Regular-tlf-ts1.vf \
tex-MontserratAlternates-Regular-tosf-ly1--base.tfm \
tex-MontserratAlternates-Regular-tosf-ly1.tfm \
tex-MontserratAlternates-Regular-tosf-ly1.vf \
tex-MontserratAlternates-Regular-tosf-ot1.tfm \
tex-MontserratAlternates-Regular-tosf-sc-ly1--base.tfm \
tex-MontserratAlternates-Regular-tosf-sc-ly1.tfm \
tex-MontserratAlternates-Regular-tosf-sc-ly1.vf \
tex-MontserratAlternates-Regular-tosf-sc-ot1--base.tfm \
tex-MontserratAlternates-Regular-tosf-sc-ot1.tfm \
tex-MontserratAlternates-Regular-tosf-sc-ot1.vf \
tex-MontserratAlternates-Regular-tosf-sc-t1--base.tfm \
tex-MontserratAlternates-Regular-tosf-sc-t1.tfm \
tex-MontserratAlternates-Regular-tosf-sc-t1.vf \
tex-MontserratAlternates-Regular-tosf-t1--base.tfm \
tex-MontserratAlternates-Regular-tosf-t1.tfm \
tex-MontserratAlternates-Regular-tosf-t1.vf \
tex-MontserratAlternates-Regular-tosf-ts1--base.tfm \
tex-MontserratAlternates-Regular-tosf-ts1.tfm \
tex-MontserratAlternates-Regular-tosf-ts1.vf \
tex-MontserratAlternates-SemiBold-dnom-ly1--base.tfm \
tex-MontserratAlternates-SemiBold-dnom-ly1.tfm \
tex-MontserratAlternates-SemiBold-dnom-ly1.vf \
tex-MontserratAlternates-SemiBold-dnom-ot1.tfm \
tex-MontserratAlternates-SemiBold-dnom-t1--base.tfm \
tex-MontserratAlternates-SemiBold-dnom-t1.tfm \
tex-MontserratAlternates-SemiBold-dnom-t1.vf \
tex-MontserratAlternates-SemiBold-inf-ly1--base.tfm \
tex-MontserratAlternates-SemiBold-inf-ly1.tfm \
tex-MontserratAlternates-SemiBold-inf-ly1.vf \
tex-MontserratAlternates-SemiBold-inf-ot1.tfm \
tex-MontserratAlternates-SemiBold-inf-t1--base.tfm \
tex-MontserratAlternates-SemiBold-inf-t1.tfm \
tex-MontserratAlternates-SemiBold-inf-t1.vf \
tex-MontserratAlternates-SemiBold-lf-ly1--base.tfm \
tex-MontserratAlternates-SemiBold-lf-ly1.tfm \
tex-MontserratAlternates-SemiBold-lf-ly1.vf \
tex-MontserratAlternates-SemiBold-lf-ot1.tfm \
tex-MontserratAlternates-SemiBold-lf-sc-ly1--base.tfm \
tex-MontserratAlternates-SemiBold-lf-sc-ly1.tfm \
tex-MontserratAlternates-SemiBold-lf-sc-ly1.vf \
tex-MontserratAlternates-SemiBold-lf-sc-ot1--base.tfm \
tex-MontserratAlternates-SemiBold-lf-sc-ot1.tfm \
tex-MontserratAlternates-SemiBold-lf-sc-ot1.vf \
tex-MontserratAlternates-SemiBold-lf-sc-t1--base.tfm \
tex-MontserratAlternates-SemiBold-lf-sc-t1.tfm \
tex-MontserratAlternates-SemiBold-lf-sc-t1.vf \
tex-MontserratAlternates-SemiBold-lf-t1--base.tfm \
tex-MontserratAlternates-SemiBold-lf-t1.tfm \
tex-MontserratAlternates-SemiBold-lf-t1.vf \
tex-MontserratAlternates-SemiBold-lf-ts1--base.tfm \
tex-MontserratAlternates-SemiBold-lf-ts1.tfm \
tex-MontserratAlternates-SemiBold-lf-ts1.vf \
tex-MontserratAlternates-SemiBold-numr-ly1--base.tfm \
tex-MontserratAlternates-SemiBold-numr-ly1.tfm \
tex-MontserratAlternates-SemiBold-numr-ly1.vf \
tex-MontserratAlternates-SemiBold-numr-ot1.tfm \
tex-MontserratAlternates-SemiBold-numr-t1--base.tfm \
tex-MontserratAlternates-SemiBold-numr-t1.tfm \
tex-MontserratAlternates-SemiBold-numr-t1.vf \
tex-MontserratAlternates-SemiBold-osf-ly1--base.tfm \
tex-MontserratAlternates-SemiBold-osf-ly1.tfm \
tex-MontserratAlternates-SemiBold-osf-ly1.vf \
tex-MontserratAlternates-SemiBold-osf-ot1.tfm \
tex-MontserratAlternates-SemiBold-osf-sc-ly1--base.tfm \
tex-MontserratAlternates-SemiBold-osf-sc-ly1.tfm \
tex-MontserratAlternates-SemiBold-osf-sc-ly1.vf \
tex-MontserratAlternates-SemiBold-osf-sc-ot1--base.tfm \
tex-MontserratAlternates-SemiBold-osf-sc-ot1.tfm \
tex-MontserratAlternates-SemiBold-osf-sc-ot1.vf \
tex-MontserratAlternates-SemiBold-osf-sc-t1--base.tfm \
tex-MontserratAlternates-SemiBold-osf-sc-t1.tfm \
tex-MontserratAlternates-SemiBold-osf-sc-t1.vf \
tex-MontserratAlternates-SemiBold-osf-t1--base.tfm \
tex-MontserratAlternates-SemiBold-osf-t1.tfm \
tex-MontserratAlternates-SemiBold-osf-t1.vf \
tex-MontserratAlternates-SemiBold-osf-ts1--base.tfm \
tex-MontserratAlternates-SemiBold-osf-ts1.tfm \
tex-MontserratAlternates-SemiBold-osf-ts1.vf \
tex-MontserratAlternates-SemiBold-sup-ly1--base.tfm \
tex-MontserratAlternates-SemiBold-sup-ly1.tfm \
tex-MontserratAlternates-SemiBold-sup-ly1.vf \
tex-MontserratAlternates-SemiBold-sup-ot1.tfm \
tex-MontserratAlternates-SemiBold-sup-t1--base.tfm \
tex-MontserratAlternates-SemiBold-sup-t1.tfm \
tex-MontserratAlternates-SemiBold-sup-t1.vf \
tex-MontserratAlternates-SemiBold-tlf-ly1--base.tfm \
tex-MontserratAlternates-SemiBold-tlf-ly1.tfm \
tex-MontserratAlternates-SemiBold-tlf-ly1.vf \
tex-MontserratAlternates-SemiBold-tlf-ot1.tfm \
tex-MontserratAlternates-SemiBold-tlf-sc-ly1--base.tfm \
tex-MontserratAlternates-SemiBold-tlf-sc-ly1.tfm \
tex-MontserratAlternates-SemiBold-tlf-sc-ly1.vf \
tex-MontserratAlternates-SemiBold-tlf-sc-ot1--base.tfm \
tex-MontserratAlternates-SemiBold-tlf-sc-ot1.tfm \
tex-MontserratAlternates-SemiBold-tlf-sc-ot1.vf \
tex-MontserratAlternates-SemiBold-tlf-sc-t1--base.tfm \
tex-MontserratAlternates-SemiBold-tlf-sc-t1.tfm \
tex-MontserratAlternates-SemiBold-tlf-sc-t1.vf \
tex-MontserratAlternates-SemiBold-tlf-t1--base.tfm \
tex-MontserratAlternates-SemiBold-tlf-t1.tfm \
tex-MontserratAlternates-SemiBold-tlf-t1.vf \
tex-MontserratAlternates-SemiBold-tlf-ts1--base.tfm \
tex-MontserratAlternates-SemiBold-tlf-ts1.tfm \
tex-MontserratAlternates-SemiBold-tlf-ts1.vf \
tex-MontserratAlternates-SemiBold-tosf-ly1--base.tfm \
tex-MontserratAlternates-SemiBold-tosf-ly1.tfm \
tex-MontserratAlternates-SemiBold-tosf-ly1.vf \
tex-MontserratAlternates-SemiBold-tosf-ot1.tfm \
tex-MontserratAlternates-SemiBold-tosf-sc-ly1--base.tfm \
tex-MontserratAlternates-SemiBold-tosf-sc-ly1.tfm \
tex-MontserratAlternates-SemiBold-tosf-sc-ly1.vf \
tex-MontserratAlternates-SemiBold-tosf-sc-ot1--base.tfm \
tex-MontserratAlternates-SemiBold-tosf-sc-ot1.tfm \
tex-MontserratAlternates-SemiBold-tosf-sc-ot1.vf \
tex-MontserratAlternates-SemiBold-tosf-sc-t1--base.tfm \
tex-MontserratAlternates-SemiBold-tosf-sc-t1.tfm \
tex-MontserratAlternates-SemiBold-tosf-sc-t1.vf \
tex-MontserratAlternates-SemiBold-tosf-t1--base.tfm \
tex-MontserratAlternates-SemiBold-tosf-t1.tfm \
tex-MontserratAlternates-SemiBold-tosf-t1.vf \
tex-MontserratAlternates-SemiBold-tosf-ts1--base.tfm \
tex-MontserratAlternates-SemiBold-tosf-ts1.tfm \
tex-MontserratAlternates-SemiBold-tosf-ts1.vf \
tex-MontserratAlternates-SemiBoldItalic-dnom-ly1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-dnom-ly1.tfm \
tex-MontserratAlternates-SemiBoldItalic-dnom-ly1.vf \
tex-MontserratAlternates-SemiBoldItalic-dnom-ot1.tfm \
tex-MontserratAlternates-SemiBoldItalic-dnom-t1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-dnom-t1.tfm \
tex-MontserratAlternates-SemiBoldItalic-dnom-t1.vf \
tex-MontserratAlternates-SemiBoldItalic-inf-ly1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-inf-ly1.tfm \
tex-MontserratAlternates-SemiBoldItalic-inf-ly1.vf \
tex-MontserratAlternates-SemiBoldItalic-inf-ot1.tfm \
tex-MontserratAlternates-SemiBoldItalic-inf-t1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-inf-t1.tfm \
tex-MontserratAlternates-SemiBoldItalic-inf-t1.vf \
tex-MontserratAlternates-SemiBoldItalic-lf-ly1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-lf-ly1.tfm \
tex-MontserratAlternates-SemiBoldItalic-lf-ly1.vf \
tex-MontserratAlternates-SemiBoldItalic-lf-ot1.tfm \
tex-MontserratAlternates-SemiBoldItalic-lf-sc-ly1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-lf-sc-ly1.tfm \
tex-MontserratAlternates-SemiBoldItalic-lf-sc-ly1.vf \
tex-MontserratAlternates-SemiBoldItalic-lf-sc-ot1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-lf-sc-ot1.tfm \
tex-MontserratAlternates-SemiBoldItalic-lf-sc-ot1.vf \
tex-MontserratAlternates-SemiBoldItalic-lf-sc-t1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-lf-sc-t1.tfm \
tex-MontserratAlternates-SemiBoldItalic-lf-sc-t1.vf \
tex-MontserratAlternates-SemiBoldItalic-lf-t1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-lf-t1.tfm \
tex-MontserratAlternates-SemiBoldItalic-lf-t1.vf \
tex-MontserratAlternates-SemiBoldItalic-lf-ts1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-lf-ts1.tfm \
tex-MontserratAlternates-SemiBoldItalic-lf-ts1.vf \
tex-MontserratAlternates-SemiBoldItalic-numr-ly1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-numr-ly1.tfm \
tex-MontserratAlternates-SemiBoldItalic-numr-ly1.vf \
tex-MontserratAlternates-SemiBoldItalic-numr-ot1.tfm \
tex-MontserratAlternates-SemiBoldItalic-numr-t1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-numr-t1.tfm \
tex-MontserratAlternates-SemiBoldItalic-numr-t1.vf \
tex-MontserratAlternates-SemiBoldItalic-osf-ly1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-osf-ly1.tfm \
tex-MontserratAlternates-SemiBoldItalic-osf-ly1.vf \
tex-MontserratAlternates-SemiBoldItalic-osf-ot1.tfm \
tex-MontserratAlternates-SemiBoldItalic-osf-sc-ly1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-osf-sc-ly1.tfm \
tex-MontserratAlternates-SemiBoldItalic-osf-sc-ly1.vf \
tex-MontserratAlternates-SemiBoldItalic-osf-sc-ot1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-osf-sc-ot1.tfm \
tex-MontserratAlternates-SemiBoldItalic-osf-sc-ot1.vf \
tex-MontserratAlternates-SemiBoldItalic-osf-sc-t1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-osf-sc-t1.tfm \
tex-MontserratAlternates-SemiBoldItalic-osf-sc-t1.vf \
tex-MontserratAlternates-SemiBoldItalic-osf-t1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-osf-t1.tfm \
tex-MontserratAlternates-SemiBoldItalic-osf-t1.vf \
tex-MontserratAlternates-SemiBoldItalic-osf-ts1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-osf-ts1.tfm \
tex-MontserratAlternates-SemiBoldItalic-osf-ts1.vf \
tex-MontserratAlternates-SemiBoldItalic-sup-ly1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-sup-ly1.tfm \
tex-MontserratAlternates-SemiBoldItalic-sup-ly1.vf \
tex-MontserratAlternates-SemiBoldItalic-sup-ot1.tfm \
tex-MontserratAlternates-SemiBoldItalic-sup-t1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-sup-t1.tfm \
tex-MontserratAlternates-SemiBoldItalic-sup-t1.vf \
tex-MontserratAlternates-SemiBoldItalic-tlf-ly1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-tlf-ly1.tfm \
tex-MontserratAlternates-SemiBoldItalic-tlf-ly1.vf \
tex-MontserratAlternates-SemiBoldItalic-tlf-ot1.tfm \
tex-MontserratAlternates-SemiBoldItalic-tlf-sc-ly1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-tlf-sc-ly1.tfm \
tex-MontserratAlternates-SemiBoldItalic-tlf-sc-ly1.vf \
tex-MontserratAlternates-SemiBoldItalic-tlf-sc-ot1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-tlf-sc-ot1.tfm \
tex-MontserratAlternates-SemiBoldItalic-tlf-sc-ot1.vf \
tex-MontserratAlternates-SemiBoldItalic-tlf-sc-t1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-tlf-sc-t1.tfm \
tex-MontserratAlternates-SemiBoldItalic-tlf-sc-t1.vf \
tex-MontserratAlternates-SemiBoldItalic-tlf-t1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-tlf-t1.tfm \
tex-MontserratAlternates-SemiBoldItalic-tlf-t1.vf \
tex-MontserratAlternates-SemiBoldItalic-tlf-ts1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-tlf-ts1.tfm \
tex-MontserratAlternates-SemiBoldItalic-tlf-ts1.vf \
tex-MontserratAlternates-SemiBoldItalic-tosf-ly1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-tosf-ly1.tfm \
tex-MontserratAlternates-SemiBoldItalic-tosf-ly1.vf \
tex-MontserratAlternates-SemiBoldItalic-tosf-ot1.tfm \
tex-MontserratAlternates-SemiBoldItalic-tosf-sc-ly1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-tosf-sc-ly1.tfm \
tex-MontserratAlternates-SemiBoldItalic-tosf-sc-ly1.vf \
tex-MontserratAlternates-SemiBoldItalic-tosf-sc-ot1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-tosf-sc-ot1.tfm \
tex-MontserratAlternates-SemiBoldItalic-tosf-sc-ot1.vf \
tex-MontserratAlternates-SemiBoldItalic-tosf-sc-t1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-tosf-sc-t1.tfm \
tex-MontserratAlternates-SemiBoldItalic-tosf-sc-t1.vf \
tex-MontserratAlternates-SemiBoldItalic-tosf-t1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-tosf-t1.tfm \
tex-MontserratAlternates-SemiBoldItalic-tosf-t1.vf \
tex-MontserratAlternates-SemiBoldItalic-tosf-ts1--base.tfm \
tex-MontserratAlternates-SemiBoldItalic-tosf-ts1.tfm \
tex-MontserratAlternates-SemiBoldItalic-tosf-ts1.vf \
tex-MontserratAlternates-Thin-dnom-ly1--base.tfm \
tex-MontserratAlternates-Thin-dnom-ly1.tfm \
tex-MontserratAlternates-Thin-dnom-ly1.vf \
tex-MontserratAlternates-Thin-dnom-ot1.tfm \
tex-MontserratAlternates-Thin-dnom-t1--base.tfm \
tex-MontserratAlternates-Thin-dnom-t1.tfm \
tex-MontserratAlternates-Thin-dnom-t1.vf \
tex-MontserratAlternates-Thin-inf-ly1--base.tfm \
tex-MontserratAlternates-Thin-inf-ly1.tfm \
tex-MontserratAlternates-Thin-inf-ly1.vf \
tex-MontserratAlternates-Thin-inf-ot1.tfm \
tex-MontserratAlternates-Thin-inf-t1--base.tfm \
tex-MontserratAlternates-Thin-inf-t1.tfm \
tex-MontserratAlternates-Thin-inf-t1.vf \
tex-MontserratAlternates-Thin-lf-ly1--base.tfm \
tex-MontserratAlternates-Thin-lf-ly1.tfm \
tex-MontserratAlternates-Thin-lf-ly1.vf \
tex-MontserratAlternates-Thin-lf-ot1.tfm \
tex-MontserratAlternates-Thin-lf-sc-ly1--base.tfm \
tex-MontserratAlternates-Thin-lf-sc-ly1.tfm \
tex-MontserratAlternates-Thin-lf-sc-ly1.vf \
tex-MontserratAlternates-Thin-lf-sc-ot1--base.tfm \
tex-MontserratAlternates-Thin-lf-sc-ot1.tfm \
tex-MontserratAlternates-Thin-lf-sc-ot1.vf \
tex-MontserratAlternates-Thin-lf-sc-t1--base.tfm \
tex-MontserratAlternates-Thin-lf-sc-t1.tfm \
tex-MontserratAlternates-Thin-lf-sc-t1.vf \
tex-MontserratAlternates-Thin-lf-t1--base.tfm \
tex-MontserratAlternates-Thin-lf-t1.tfm \
tex-MontserratAlternates-Thin-lf-t1.vf \
tex-MontserratAlternates-Thin-lf-ts1--base.tfm \
tex-MontserratAlternates-Thin-lf-ts1.tfm \
tex-MontserratAlternates-Thin-lf-ts1.vf \
tex-MontserratAlternates-Thin-numr-ly1--base.tfm \
tex-MontserratAlternates-Thin-numr-ly1.tfm \
tex-MontserratAlternates-Thin-numr-ly1.vf \
tex-MontserratAlternates-Thin-numr-ot1.tfm \
tex-MontserratAlternates-Thin-numr-t1--base.tfm \
tex-MontserratAlternates-Thin-numr-t1.tfm \
tex-MontserratAlternates-Thin-numr-t1.vf \
tex-MontserratAlternates-Thin-osf-ly1--base.tfm \
tex-MontserratAlternates-Thin-osf-ly1.tfm \
tex-MontserratAlternates-Thin-osf-ly1.vf \
tex-MontserratAlternates-Thin-osf-ot1.tfm \
tex-MontserratAlternates-Thin-osf-sc-ly1--base.tfm \
tex-MontserratAlternates-Thin-osf-sc-ly1.tfm \
tex-MontserratAlternates-Thin-osf-sc-ly1.vf \
tex-MontserratAlternates-Thin-osf-sc-ot1--base.tfm \
tex-MontserratAlternates-Thin-osf-sc-ot1.tfm \
tex-MontserratAlternates-Thin-osf-sc-ot1.vf \
tex-MontserratAlternates-Thin-osf-sc-t1--base.tfm \
tex-MontserratAlternates-Thin-osf-sc-t1.tfm \
tex-MontserratAlternates-Thin-osf-sc-t1.vf \
tex-MontserratAlternates-Thin-osf-t1--base.tfm \
tex-MontserratAlternates-Thin-osf-t1.tfm \
tex-MontserratAlternates-Thin-osf-t1.vf \
tex-MontserratAlternates-Thin-osf-ts1--base.tfm \
tex-MontserratAlternates-Thin-osf-ts1.tfm \
tex-MontserratAlternates-Thin-osf-ts1.vf \
tex-MontserratAlternates-Thin-sup-ly1--base.tfm \
tex-MontserratAlternates-Thin-sup-ly1.tfm \
tex-MontserratAlternates-Thin-sup-ly1.vf \
tex-MontserratAlternates-Thin-sup-ot1.tfm \
tex-MontserratAlternates-Thin-sup-t1--base.tfm \
tex-MontserratAlternates-Thin-sup-t1.tfm \
tex-MontserratAlternates-Thin-sup-t1.vf \
tex-MontserratAlternates-Thin-tlf-ly1--base.tfm \
tex-MontserratAlternates-Thin-tlf-ly1.tfm \
tex-MontserratAlternates-Thin-tlf-ly1.vf \
tex-MontserratAlternates-Thin-tlf-ot1.tfm \
tex-MontserratAlternates-Thin-tlf-sc-ly1--base.tfm \
tex-MontserratAlternates-Thin-tlf-sc-ly1.tfm \
tex-MontserratAlternates-Thin-tlf-sc-ly1.vf \
tex-MontserratAlternates-Thin-tlf-sc-ot1--base.tfm \
tex-MontserratAlternates-Thin-tlf-sc-ot1.tfm \
tex-MontserratAlternates-Thin-tlf-sc-ot1.vf \
tex-MontserratAlternates-Thin-tlf-sc-t1--base.tfm \
tex-MontserratAlternates-Thin-tlf-sc-t1.tfm \
tex-MontserratAlternates-Thin-tlf-sc-t1.vf \
tex-MontserratAlternates-Thin-tlf-t1--base.tfm \
tex-MontserratAlternates-Thin-tlf-t1.tfm \
tex-MontserratAlternates-Thin-tlf-t1.vf \
tex-MontserratAlternates-Thin-tlf-ts1--base.tfm \
tex-MontserratAlternates-Thin-tlf-ts1.tfm \
tex-MontserratAlternates-Thin-tlf-ts1.vf \
tex-MontserratAlternates-Thin-tosf-ly1--base.tfm \
tex-MontserratAlternates-Thin-tosf-ly1.tfm \
tex-MontserratAlternates-Thin-tosf-ly1.vf \
tex-MontserratAlternates-Thin-tosf-ot1.tfm \
tex-MontserratAlternates-Thin-tosf-sc-ly1--base.tfm \
tex-MontserratAlternates-Thin-tosf-sc-ly1.tfm \
tex-MontserratAlternates-Thin-tosf-sc-ly1.vf \
tex-MontserratAlternates-Thin-tosf-sc-ot1--base.tfm \
tex-MontserratAlternates-Thin-tosf-sc-ot1.tfm \
tex-MontserratAlternates-Thin-tosf-sc-ot1.vf \
tex-MontserratAlternates-Thin-tosf-sc-t1--base.tfm \
tex-MontserratAlternates-Thin-tosf-sc-t1.tfm \
tex-MontserratAlternates-Thin-tosf-sc-t1.vf \
tex-MontserratAlternates-Thin-tosf-t1--base.tfm \
tex-MontserratAlternates-Thin-tosf-t1.tfm \
tex-MontserratAlternates-Thin-tosf-t1.vf \
tex-MontserratAlternates-Thin-tosf-ts1--base.tfm \
tex-MontserratAlternates-Thin-tosf-ts1.tfm \
tex-MontserratAlternates-Thin-tosf-ts1.vf \
tex-MontserratAlternates-ThinItalic-dnom-ly1--base.tfm \
tex-MontserratAlternates-ThinItalic-dnom-ly1.tfm \
tex-MontserratAlternates-ThinItalic-dnom-ly1.vf \
tex-MontserratAlternates-ThinItalic-dnom-ot1.tfm \
tex-MontserratAlternates-ThinItalic-dnom-t1--base.tfm \
tex-MontserratAlternates-ThinItalic-dnom-t1.tfm \
tex-MontserratAlternates-ThinItalic-dnom-t1.vf \
tex-MontserratAlternates-ThinItalic-inf-ly1--base.tfm \
tex-MontserratAlternates-ThinItalic-inf-ly1.tfm \
tex-MontserratAlternates-ThinItalic-inf-ly1.vf \
tex-MontserratAlternates-ThinItalic-inf-ot1.tfm \
tex-MontserratAlternates-ThinItalic-inf-t1--base.tfm \
tex-MontserratAlternates-ThinItalic-inf-t1.tfm \
tex-MontserratAlternates-ThinItalic-inf-t1.vf \
tex-MontserratAlternates-ThinItalic-lf-ly1--base.tfm \
tex-MontserratAlternates-ThinItalic-lf-ly1.tfm \
tex-MontserratAlternates-ThinItalic-lf-ly1.vf \
tex-MontserratAlternates-ThinItalic-lf-ot1.tfm \
tex-MontserratAlternates-ThinItalic-lf-sc-ly1--base.tfm \
tex-MontserratAlternates-ThinItalic-lf-sc-ly1.tfm \
tex-MontserratAlternates-ThinItalic-lf-sc-ly1.vf \
tex-MontserratAlternates-ThinItalic-lf-sc-ot1--base.tfm \
tex-MontserratAlternates-ThinItalic-lf-sc-ot1.tfm \
tex-MontserratAlternates-ThinItalic-lf-sc-ot1.vf \
tex-MontserratAlternates-ThinItalic-lf-sc-t1--base.tfm \
tex-MontserratAlternates-ThinItalic-lf-sc-t1.tfm \
tex-MontserratAlternates-ThinItalic-lf-sc-t1.vf \
tex-MontserratAlternates-ThinItalic-lf-t1--base.tfm \
tex-MontserratAlternates-ThinItalic-lf-t1.tfm \
tex-MontserratAlternates-ThinItalic-lf-t1.vf \
tex-MontserratAlternates-ThinItalic-lf-ts1--base.tfm \
tex-MontserratAlternates-ThinItalic-lf-ts1.tfm \
tex-MontserratAlternates-ThinItalic-lf-ts1.vf \
tex-MontserratAlternates-ThinItalic-numr-ly1--base.tfm \
tex-MontserratAlternates-ThinItalic-numr-ly1.tfm \
tex-MontserratAlternates-ThinItalic-numr-ly1.vf \
tex-MontserratAlternates-ThinItalic-numr-ot1.tfm \
tex-MontserratAlternates-ThinItalic-numr-t1--base.tfm \
tex-MontserratAlternates-ThinItalic-numr-t1.tfm \
tex-MontserratAlternates-ThinItalic-numr-t1.vf \
tex-MontserratAlternates-ThinItalic-osf-ly1--base.tfm \
tex-MontserratAlternates-ThinItalic-osf-ly1.tfm \
tex-MontserratAlternates-ThinItalic-osf-ly1.vf \
tex-MontserratAlternates-ThinItalic-osf-ot1.tfm \
tex-MontserratAlternates-ThinItalic-osf-sc-ly1--base.tfm \
tex-MontserratAlternates-ThinItalic-osf-sc-ly1.tfm \
tex-MontserratAlternates-ThinItalic-osf-sc-ly1.vf \
tex-MontserratAlternates-ThinItalic-osf-sc-ot1--base.tfm \
tex-MontserratAlternates-ThinItalic-osf-sc-ot1.tfm \
tex-MontserratAlternates-ThinItalic-osf-sc-ot1.vf \
tex-MontserratAlternates-ThinItalic-osf-sc-t1--base.tfm \
tex-MontserratAlternates-ThinItalic-osf-sc-t1.tfm \
tex-MontserratAlternates-ThinItalic-osf-sc-t1.vf \
tex-MontserratAlternates-ThinItalic-osf-t1--base.tfm \
tex-MontserratAlternates-ThinItalic-osf-t1.tfm \
tex-MontserratAlternates-ThinItalic-osf-t1.vf \
tex-MontserratAlternates-ThinItalic-osf-ts1--base.tfm \
tex-MontserratAlternates-ThinItalic-osf-ts1.tfm \
tex-MontserratAlternates-ThinItalic-osf-ts1.vf \
tex-MontserratAlternates-ThinItalic-sup-ly1--base.tfm \
tex-MontserratAlternates-ThinItalic-sup-ly1.tfm \
tex-MontserratAlternates-ThinItalic-sup-ly1.vf \
tex-MontserratAlternates-ThinItalic-sup-ot1.tfm \
tex-MontserratAlternates-ThinItalic-sup-t1--base.tfm \
tex-MontserratAlternates-ThinItalic-sup-t1.tfm \
tex-MontserratAlternates-ThinItalic-sup-t1.vf \
tex-MontserratAlternates-ThinItalic-tlf-ly1--base.tfm \
tex-MontserratAlternates-ThinItalic-tlf-ly1.tfm \
tex-MontserratAlternates-ThinItalic-tlf-ly1.vf \
tex-MontserratAlternates-ThinItalic-tlf-ot1.tfm \
tex-MontserratAlternates-ThinItalic-tlf-sc-ly1--base.tfm \
tex-MontserratAlternates-ThinItalic-tlf-sc-ly1.tfm \
tex-MontserratAlternates-ThinItalic-tlf-sc-ly1.vf \
tex-MontserratAlternates-ThinItalic-tlf-sc-ot1--base.tfm \
tex-MontserratAlternates-ThinItalic-tlf-sc-ot1.tfm \
tex-MontserratAlternates-ThinItalic-tlf-sc-ot1.vf \
tex-MontserratAlternates-ThinItalic-tlf-sc-t1--base.tfm \
tex-MontserratAlternates-ThinItalic-tlf-sc-t1.tfm \
tex-MontserratAlternates-ThinItalic-tlf-sc-t1.vf \
tex-MontserratAlternates-ThinItalic-tlf-t1--base.tfm \
tex-MontserratAlternates-ThinItalic-tlf-t1.tfm \
tex-MontserratAlternates-ThinItalic-tlf-t1.vf \
tex-MontserratAlternates-ThinItalic-tlf-ts1--base.tfm \
tex-MontserratAlternates-ThinItalic-tlf-ts1.tfm \
tex-MontserratAlternates-ThinItalic-tlf-ts1.vf \
tex-MontserratAlternates-ThinItalic-tosf-ly1--base.tfm \
tex-MontserratAlternates-ThinItalic-tosf-ly1.tfm \
tex-MontserratAlternates-ThinItalic-tosf-ly1.vf \
tex-MontserratAlternates-ThinItalic-tosf-ot1.tfm \
tex-MontserratAlternates-ThinItalic-tosf-sc-ly1--base.tfm \
tex-MontserratAlternates-ThinItalic-tosf-sc-ly1.tfm \
tex-MontserratAlternates-ThinItalic-tosf-sc-ly1.vf \
tex-MontserratAlternates-ThinItalic-tosf-sc-ot1--base.tfm \
tex-MontserratAlternates-ThinItalic-tosf-sc-ot1.tfm \
tex-MontserratAlternates-ThinItalic-tosf-sc-ot1.vf \
tex-MontserratAlternates-ThinItalic-tosf-sc-t1--base.tfm \
tex-MontserratAlternates-ThinItalic-tosf-sc-t1.tfm \
tex-MontserratAlternates-ThinItalic-tosf-sc-t1.vf \
tex-MontserratAlternates-ThinItalic-tosf-t1--base.tfm \
tex-MontserratAlternates-ThinItalic-tosf-t1.tfm \
tex-MontserratAlternates-ThinItalic-tosf-t1.vf \
tex-MontserratAlternates-ThinItalic-tosf-ts1--base.tfm \
tex-MontserratAlternates-ThinItalic-tosf-ts1.tfm \
tex-MontserratAlternates-ThinItalic-tosf-ts1.vf \
tex-OT1Montserrat-Dnom.fd \
tex-OT1Montserrat-Inf.fd \
tex-OT1Montserrat-LF.fd \
tex-OT1Montserrat-Numr.fd \
tex-OT1Montserrat-OsF.fd \
tex-OT1Montserrat-Sup.fd \
tex-OT1Montserrat-TLF.fd \
tex-OT1Montserrat-TOsF.fd \
tex-OT1MontserratAlternates-Dnom.fd \
tex-OT1MontserratAlternates-Inf.fd \
tex-OT1MontserratAlternates-LF.fd \
tex-OT1MontserratAlternates-Numr.fd \
tex-OT1MontserratAlternates-OsF.fd \
tex-OT1MontserratAlternates-Sup.fd \
tex-OT1MontserratAlternates-TLF.fd \
tex-OT1MontserratAlternates-TOsF.fd \
tex-T1Montserrat-Dnom.fd \
tex-T1Montserrat-Inf.fd \
tex-T1Montserrat-LF.fd \
tex-T1Montserrat-Numr.fd \
tex-T1Montserrat-OsF.fd \
tex-T1Montserrat-Sup.fd \
tex-T1Montserrat-TLF.fd \
tex-T1Montserrat-TOsF.fd \
tex-T1MontserratAlternates-Dnom.fd \
tex-T1MontserratAlternates-Inf.fd \
tex-T1MontserratAlternates-LF.fd \
tex-T1MontserratAlternates-Numr.fd \
tex-T1MontserratAlternates-OsF.fd \
tex-T1MontserratAlternates-Sup.fd \
tex-T1MontserratAlternates-TLF.fd \
tex-T1MontserratAlternates-TOsF.fd \
tex-TS1Montserrat-LF.fd \
tex-TS1Montserrat-OsF.fd \
tex-TS1Montserrat-TLF.fd \
tex-TS1Montserrat-TOsF.fd \
tex-TS1MontserratAlternates-LF.fd \
tex-TS1MontserratAlternates-OsF.fd \
tex-TS1MontserratAlternates-TLF.fd \
tex-TS1MontserratAlternates-TOsF.fd \
tex-montserrat.sty \
tex-zmo-2lqlus.enc \
tex-zmo-2sgwql.enc \
tex-zmo-35ovjx.enc \
tex-zmo-46isxp.enc \
tex-zmo-5xld5w.enc \
tex-zmo-75k7z2.enc \
tex-zmo-7l4c7j.enc \
tex-zmo-7l6pgo.enc \
tex-zmo-7sawpm.enc \
tex-zmo-7yzfgj.enc \
tex-zmo-b4nxop.enc \
tex-zmo-b657mx.enc \
tex-zmo-bapnwu.enc \
tex-zmo-bhkf55.enc \
tex-zmo-blyc36.enc \
tex-zmo-c4h6ot.enc \
tex-zmo-cm3oqe.enc \
tex-zmo-ctxcke.enc \
tex-zmo-drbxok.enc \
tex-zmo-dvhcr3.enc \
tex-zmo-each7f.enc \
tex-zmo-f6ejpj.enc \
tex-zmo-fbdit4.enc \
tex-zmo-fkzqgd.enc \
tex-zmo-fmi5lv.enc \
tex-zmo-gcixud.enc \
tex-zmo-h6jra2.enc \
tex-zmo-hlvv6p.enc \
tex-zmo-jb2i34.enc \
tex-zmo-jhzg4t.enc \
tex-zmo-jjp77t.enc \
tex-zmo-jjwbah.enc \
tex-zmo-jo7tnr.enc \
tex-zmo-k7iqhv.enc \
tex-zmo-li2ufe.enc \
tex-zmo-lzhlbi.enc \
tex-zmo-mp47y7.enc \
tex-zmo-mwlday.enc \
tex-zmo-n2k42m.enc \
tex-zmo-nszfm3.enc \
tex-zmo-nwaz6g.enc \
tex-zmo-pdf5b7.enc \
tex-zmo-poz7al.enc \
tex-zmo-q22ex3.enc \
tex-zmo-qex2f4.enc \
tex-zmo-qs57ix.enc \
tex-zmo-ro7vi7.enc \
tex-zmo-rrs54x.enc \
tex-zmo-ssrkmg.enc \
tex-zmo-t44pvm.enc \
tex-zmo-tq4ocg.enc \
tex-zmo-tti6co.enc \
tex-zmo-tygrj7.enc \
tex-zmo-umrhwx.enc \
tex-zmo-upca4a.enc \
tex-zmo-w4rwtq.enc \
tex-zmo-wxmaut.enc \
tex-zmo-wzhhkn.enc \
tex-zmo-x2ovsi.enc \
tex-zmo-xcjjqo.enc \
tex-zmo-ylc3fo.enc \
tex-zmo-zmgh2c.enc \
tex-zmo-znhcko.enc \
tex-zmo-zrxj4s.enc \
texlive-montserrat"

RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontaxes.sty \
tex-fontenc.sty \
tex-mweights.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-montserrat-fonts \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
