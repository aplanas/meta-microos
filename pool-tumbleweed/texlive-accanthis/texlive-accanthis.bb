SUMMARY = "Accanthis fonts, with LaTeX support"
DESCRIPTION = "Accanthis No. 3 is designed by Hirwin Harendal and is suitable \
as an alternative to fonts such as Garamond, Galliard, Horley \
old style, Sabon, and Bembo. The support files are suitable for \
use with all LaTeX engines."
LICENSE = "GPL-2.0-or-later"

PV = "2023.209.svn64844"

RPM_NAME = "texlive-accanthis-2023.209.svn64844-55.1.noarch.rpm"
RPM_HASH = "822b64718831fc75307960ed793a5e59bd864bce723eef169e24a967239704892428e074a881dec1f562111490ad42d5fd8b5bac81eebb0b830786257b621421"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-AccanthisADFStdNo3-Bold-lf-ly1--base.tfm \
tex-AccanthisADFStdNo3-Bold-lf-ly1--lcdfj.tfm \
tex-AccanthisADFStdNo3-Bold-lf-ly1.tfm \
tex-AccanthisADFStdNo3-Bold-lf-ly1.vf \
tex-AccanthisADFStdNo3-Bold-lf-ot1--base.tfm \
tex-AccanthisADFStdNo3-Bold-lf-ot1--lcdfj.tfm \
tex-AccanthisADFStdNo3-Bold-lf-ot1.tfm \
tex-AccanthisADFStdNo3-Bold-lf-ot1.vf \
tex-AccanthisADFStdNo3-Bold-lf-t1--base.tfm \
tex-AccanthisADFStdNo3-Bold-lf-t1--lcdfj.tfm \
tex-AccanthisADFStdNo3-Bold-lf-t1.tfm \
tex-AccanthisADFStdNo3-Bold-lf-t1.vf \
tex-AccanthisADFStdNo3-Bold-lf-ts1--base.tfm \
tex-AccanthisADFStdNo3-Bold-lf-ts1.tfm \
tex-AccanthisADFStdNo3-Bold-lf-ts1.vf \
tex-AccanthisADFStdNo3-BoldItalic-lf-ly1--base.tfm \
tex-AccanthisADFStdNo3-BoldItalic-lf-ly1--lcdfj.tfm \
tex-AccanthisADFStdNo3-BoldItalic-lf-ly1.tfm \
tex-AccanthisADFStdNo3-BoldItalic-lf-ly1.vf \
tex-AccanthisADFStdNo3-BoldItalic-lf-ot1--base.tfm \
tex-AccanthisADFStdNo3-BoldItalic-lf-ot1--lcdfj.tfm \
tex-AccanthisADFStdNo3-BoldItalic-lf-ot1.tfm \
tex-AccanthisADFStdNo3-BoldItalic-lf-ot1.vf \
tex-AccanthisADFStdNo3-BoldItalic-lf-t1--base.tfm \
tex-AccanthisADFStdNo3-BoldItalic-lf-t1--lcdfj.tfm \
tex-AccanthisADFStdNo3-BoldItalic-lf-t1.tfm \
tex-AccanthisADFStdNo3-BoldItalic-lf-t1.vf \
tex-AccanthisADFStdNo3-BoldItalic-lf-ts1--base.tfm \
tex-AccanthisADFStdNo3-BoldItalic-lf-ts1.tfm \
tex-AccanthisADFStdNo3-BoldItalic-lf-ts1.vf \
tex-AccanthisADFStdNo3-Italic-lf-ly1--base.tfm \
tex-AccanthisADFStdNo3-Italic-lf-ly1--lcdfj.tfm \
tex-AccanthisADFStdNo3-Italic-lf-ly1.tfm \
tex-AccanthisADFStdNo3-Italic-lf-ly1.vf \
tex-AccanthisADFStdNo3-Italic-lf-ot1--base.tfm \
tex-AccanthisADFStdNo3-Italic-lf-ot1--lcdfj.tfm \
tex-AccanthisADFStdNo3-Italic-lf-ot1.tfm \
tex-AccanthisADFStdNo3-Italic-lf-ot1.vf \
tex-AccanthisADFStdNo3-Italic-lf-t1--base.tfm \
tex-AccanthisADFStdNo3-Italic-lf-t1--lcdfj.tfm \
tex-AccanthisADFStdNo3-Italic-lf-t1.tfm \
tex-AccanthisADFStdNo3-Italic-lf-t1.vf \
tex-AccanthisADFStdNo3-Italic-lf-ts1--base.tfm \
tex-AccanthisADFStdNo3-Italic-lf-ts1.tfm \
tex-AccanthisADFStdNo3-Italic-lf-ts1.vf \
tex-AccanthisADFStdNo3-Regular-lf-ly1--base.tfm \
tex-AccanthisADFStdNo3-Regular-lf-ly1--lcdfj.tfm \
tex-AccanthisADFStdNo3-Regular-lf-ly1.tfm \
tex-AccanthisADFStdNo3-Regular-lf-ly1.vf \
tex-AccanthisADFStdNo3-Regular-lf-ot1--base.tfm \
tex-AccanthisADFStdNo3-Regular-lf-ot1--lcdfj.tfm \
tex-AccanthisADFStdNo3-Regular-lf-ot1.tfm \
tex-AccanthisADFStdNo3-Regular-lf-ot1.vf \
tex-AccanthisADFStdNo3-Regular-lf-t1--base.tfm \
tex-AccanthisADFStdNo3-Regular-lf-t1--lcdfj.tfm \
tex-AccanthisADFStdNo3-Regular-lf-t1.tfm \
tex-AccanthisADFStdNo3-Regular-lf-t1.vf \
tex-AccanthisADFStdNo3-Regular-lf-ts1--base.tfm \
tex-AccanthisADFStdNo3-Regular-lf-ts1.tfm \
tex-AccanthisADFStdNo3-Regular-lf-ts1.vf \
tex-LY1AccanthisADFStdNoThree-LF.fd \
tex-OT1AccanthisADFStdNoThree-LF.fd \
tex-T1AccanthisADFStdNoThree-LF.fd \
tex-TS1AccanthisADFStdNoThree-LF.fd \
tex-accanthis.map \
tex-accanthis.sty \
tex-acnt-m4gnvn.enc \
tex-acnt-qu6a6x.enc \
tex-acnt-sjpjw4.enc \
tex-acnt-z4e4wk.enc \
texlive-accanthis"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontaxes.sty \
tex-fontenc.sty \
tex-fontspec.sty \
tex-ifluatex.sty \
tex-ifxetex.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-accanthis-fonts \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
