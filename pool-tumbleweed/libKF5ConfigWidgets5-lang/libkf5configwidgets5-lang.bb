SUMMARY = "Translations for package libKF5ConfigWidgets5"
DESCRIPTION = "Provides translations for the 'libKF5ConfigWidgets5' package."
LICENSE = "LGPL-2.1-or-later"

PV = "5.107.0"

RPM_NAME = "libKF5ConfigWidgets5-lang-5.107.0-1.1.noarch.rpm"
RPM_HASH = "cbcca7294e79a76991be7075774c46c076977ede8991590aa05f1af3c3b559749e25d51fc42a0a50fe33b5c767456a6ec4c67ee26b0cebbee94a0517d5933a14"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKF5ConfigWidgets5-lang \
libKF5ConfigWidgets5-lang-all \
locale-libKF5ConfigWidgets5-af \
locale-libKF5ConfigWidgets5-ar \
locale-libKF5ConfigWidgets5-as \
locale-libKF5ConfigWidgets5-az \
locale-libKF5ConfigWidgets5-be \
locale-libKF5ConfigWidgets5-be@latin \
locale-libKF5ConfigWidgets5-bg \
locale-libKF5ConfigWidgets5-bn \
locale-libKF5ConfigWidgets5-bn-IN \
locale-libKF5ConfigWidgets5-br \
locale-libKF5ConfigWidgets5-bs \
locale-libKF5ConfigWidgets5-ca \
locale-libKF5ConfigWidgets5-ca@valencia \
locale-libKF5ConfigWidgets5-cs \
locale-libKF5ConfigWidgets5-cy \
locale-libKF5ConfigWidgets5-da \
locale-libKF5ConfigWidgets5-de \
locale-libKF5ConfigWidgets5-el \
locale-libKF5ConfigWidgets5-en-GB \
locale-libKF5ConfigWidgets5-eo \
locale-libKF5ConfigWidgets5-es \
locale-libKF5ConfigWidgets5-et \
locale-libKF5ConfigWidgets5-eu \
locale-libKF5ConfigWidgets5-fa \
locale-libKF5ConfigWidgets5-fi \
locale-libKF5ConfigWidgets5-fr \
locale-libKF5ConfigWidgets5-ga \
locale-libKF5ConfigWidgets5-gd \
locale-libKF5ConfigWidgets5-gl \
locale-libKF5ConfigWidgets5-gu \
locale-libKF5ConfigWidgets5-he \
locale-libKF5ConfigWidgets5-hi \
locale-libKF5ConfigWidgets5-hr \
locale-libKF5ConfigWidgets5-hu \
locale-libKF5ConfigWidgets5-ia \
locale-libKF5ConfigWidgets5-id \
locale-libKF5ConfigWidgets5-is \
locale-libKF5ConfigWidgets5-it \
locale-libKF5ConfigWidgets5-ja \
locale-libKF5ConfigWidgets5-ka \
locale-libKF5ConfigWidgets5-kk \
locale-libKF5ConfigWidgets5-km \
locale-libKF5ConfigWidgets5-kn \
locale-libKF5ConfigWidgets5-ko \
locale-libKF5ConfigWidgets5-lt \
locale-libKF5ConfigWidgets5-lv \
locale-libKF5ConfigWidgets5-mai \
locale-libKF5ConfigWidgets5-mk \
locale-libKF5ConfigWidgets5-ml \
locale-libKF5ConfigWidgets5-mr \
locale-libKF5ConfigWidgets5-ms \
locale-libKF5ConfigWidgets5-nb \
locale-libKF5ConfigWidgets5-nds \
locale-libKF5ConfigWidgets5-ne \
locale-libKF5ConfigWidgets5-nl \
locale-libKF5ConfigWidgets5-nn \
locale-libKF5ConfigWidgets5-oc \
locale-libKF5ConfigWidgets5-or \
locale-libKF5ConfigWidgets5-pa \
locale-libKF5ConfigWidgets5-pl \
locale-libKF5ConfigWidgets5-pt \
locale-libKF5ConfigWidgets5-pt-BR \
locale-libKF5ConfigWidgets5-ro \
locale-libKF5ConfigWidgets5-ru \
locale-libKF5ConfigWidgets5-si \
locale-libKF5ConfigWidgets5-sk \
locale-libKF5ConfigWidgets5-sl \
locale-libKF5ConfigWidgets5-sq \
locale-libKF5ConfigWidgets5-sr \
locale-libKF5ConfigWidgets5-sr@ijekavian \
locale-libKF5ConfigWidgets5-sr@ijekavianlatin \
locale-libKF5ConfigWidgets5-sr@latin \
locale-libKF5ConfigWidgets5-sv \
locale-libKF5ConfigWidgets5-ta \
locale-libKF5ConfigWidgets5-te \
locale-libKF5ConfigWidgets5-th \
locale-libKF5ConfigWidgets5-tr \
locale-libKF5ConfigWidgets5-ug \
locale-libKF5ConfigWidgets5-uk \
locale-libKF5ConfigWidgets5-vi \
locale-libKF5ConfigWidgets5-wa \
locale-libKF5ConfigWidgets5-zh-CN \
locale-libKF5ConfigWidgets5-zh-HK \
locale-libKF5ConfigWidgets5-zh-TW"

RDEPENDS:${PN} += "libKF5ConfigWidgets5"

inherit rpm
