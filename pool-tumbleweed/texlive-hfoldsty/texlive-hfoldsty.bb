SUMMARY = "Old style numerals with EC fonts"
DESCRIPTION = "The hfoldsty package provides virtual fonts for using oldstyle \
(0123456789) figures with the European Computer Modern fonts. \
It does a similar job as the eco package by Sebastian Kirsch \
but includes a couple of improvements, i.e., better kerning \
with guillemets, and support for character protruding using the \
pdfcprot package."
LICENSE = "GPL-2.0-or-later"

PV = "2023.209.1.15svn29349"

RPM_NAME = "texlive-hfoldsty-2023.209.1.15svn29349-54.2.noarch.rpm"
RPM_HASH = "5f0cd7437a3a37221d77e7ebf899300c6410325bc3a1c407ac58b020672d7ecd60de0a2a54e097b056429fd706f11f15868c90af0dca9500525fb34840758e2f"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-hfobi0500.tfm \
tex-hfobi0500.vf \
tex-hfobi0600.tfm \
tex-hfobi0600.vf \
tex-hfobi0700.tfm \
tex-hfobi0700.vf \
tex-hfobi0800.tfm \
tex-hfobi0800.vf \
tex-hfobi0900.tfm \
tex-hfobi0900.vf \
tex-hfobi1000.tfm \
tex-hfobi1000.vf \
tex-hfobi1095.tfm \
tex-hfobi1095.vf \
tex-hfobi1200.tfm \
tex-hfobi1200.vf \
tex-hfobi1440.tfm \
tex-hfobi1440.vf \
tex-hfobi1728.tfm \
tex-hfobi1728.vf \
tex-hfobi2074.tfm \
tex-hfobi2074.vf \
tex-hfobi2488.tfm \
tex-hfobi2488.vf \
tex-hfobi2986.tfm \
tex-hfobi2986.vf \
tex-hfobi3583.tfm \
tex-hfobi3583.vf \
tex-hfobl0500.tfm \
tex-hfobl0500.vf \
tex-hfobl0600.tfm \
tex-hfobl0600.vf \
tex-hfobl0700.tfm \
tex-hfobl0700.vf \
tex-hfobl0800.tfm \
tex-hfobl0800.vf \
tex-hfobl0900.tfm \
tex-hfobl0900.vf \
tex-hfobl1000.tfm \
tex-hfobl1000.vf \
tex-hfobl1095.tfm \
tex-hfobl1095.vf \
tex-hfobl1200.tfm \
tex-hfobl1200.vf \
tex-hfobl1440.tfm \
tex-hfobl1440.vf \
tex-hfobl1728.tfm \
tex-hfobl1728.vf \
tex-hfobl2074.tfm \
tex-hfobl2074.vf \
tex-hfobl2488.tfm \
tex-hfobl2488.vf \
tex-hfobl2986.tfm \
tex-hfobl2986.vf \
tex-hfobl3583.tfm \
tex-hfobl3583.vf \
tex-hfobx0500.tfm \
tex-hfobx0500.vf \
tex-hfobx0600.tfm \
tex-hfobx0600.vf \
tex-hfobx0700.tfm \
tex-hfobx0700.vf \
tex-hfobx0800.tfm \
tex-hfobx0800.vf \
tex-hfobx0900.tfm \
tex-hfobx0900.vf \
tex-hfobx1000.tfm \
tex-hfobx1000.vf \
tex-hfobx1095.tfm \
tex-hfobx1095.vf \
tex-hfobx1200.tfm \
tex-hfobx1200.vf \
tex-hfobx1440.tfm \
tex-hfobx1440.vf \
tex-hfobx1728.tfm \
tex-hfobx1728.vf \
tex-hfobx2074.tfm \
tex-hfobx2074.vf \
tex-hfobx2488.tfm \
tex-hfobx2488.vf \
tex-hfobx2986.tfm \
tex-hfobx2986.vf \
tex-hfobx3583.tfm \
tex-hfobx3583.vf \
tex-hfocc0500.tfm \
tex-hfocc0500.vf \
tex-hfocc0600.tfm \
tex-hfocc0600.vf \
tex-hfocc0700.tfm \
tex-hfocc0700.vf \
tex-hfocc0800.tfm \
tex-hfocc0800.vf \
tex-hfocc0900.tfm \
tex-hfocc0900.vf \
tex-hfocc1000.tfm \
tex-hfocc1000.vf \
tex-hfocc1095.tfm \
tex-hfocc1095.vf \
tex-hfocc1200.tfm \
tex-hfocc1200.vf \
tex-hfocc1440.tfm \
tex-hfocc1440.vf \
tex-hfocc1728.tfm \
tex-hfocc1728.vf \
tex-hfocc2074.tfm \
tex-hfocc2074.vf \
tex-hfocc2488.tfm \
tex-hfocc2488.vf \
tex-hfocc2986.tfm \
tex-hfocc2986.vf \
tex-hfocc3583.tfm \
tex-hfocc3583.vf \
tex-hfodh0500.tfm \
tex-hfodh0500.vf \
tex-hfodh0600.tfm \
tex-hfodh0600.vf \
tex-hfodh0700.tfm \
tex-hfodh0700.vf \
tex-hfodh0800.tfm \
tex-hfodh0800.vf \
tex-hfodh0900.tfm \
tex-hfodh0900.vf \
tex-hfodh1000.tfm \
tex-hfodh1000.vf \
tex-hfodh1095.tfm \
tex-hfodh1095.vf \
tex-hfodh1200.tfm \
tex-hfodh1200.vf \
tex-hfodh1440.tfm \
tex-hfodh1440.vf \
tex-hfodh1728.tfm \
tex-hfodh1728.vf \
tex-hfodh2074.tfm \
tex-hfodh2074.vf \
tex-hfodh2488.tfm \
tex-hfodh2488.vf \
tex-hfodh2986.tfm \
tex-hfodh2986.vf \
tex-hfodh3583.tfm \
tex-hfodh3583.vf \
tex-hfoit0600.tfm \
tex-hfoit0600.vf \
tex-hfoit0700.tfm \
tex-hfoit0700.vf \
tex-hfoit0800.tfm \
tex-hfoit0800.vf \
tex-hfoit0900.tfm \
tex-hfoit0900.vf \
tex-hfoit1000.tfm \
tex-hfoit1000.vf \
tex-hfoit1095.tfm \
tex-hfoit1095.vf \
tex-hfoit1200.tfm \
tex-hfoit1200.vf \
tex-hfoit1440.tfm \
tex-hfoit1440.vf \
tex-hfoit1728.tfm \
tex-hfoit1728.vf \
tex-hfoit2074.tfm \
tex-hfoit2074.vf \
tex-hfoit2488.tfm \
tex-hfoit2488.vf \
tex-hfoit2986.tfm \
tex-hfoit2986.vf \
tex-hfoit3583.tfm \
tex-hfoit3583.vf \
tex-hfoldsty.sty \
tex-hfooc0500.tfm \
tex-hfooc0500.vf \
tex-hfooc0600.tfm \
tex-hfooc0600.vf \
tex-hfooc0700.tfm \
tex-hfooc0700.vf \
tex-hfooc0800.tfm \
tex-hfooc0800.vf \
tex-hfooc0900.tfm \
tex-hfooc0900.vf \
tex-hfooc1000.tfm \
tex-hfooc1000.vf \
tex-hfooc1095.tfm \
tex-hfooc1095.vf \
tex-hfooc1200.tfm \
tex-hfooc1200.vf \
tex-hfooc1440.tfm \
tex-hfooc1440.vf \
tex-hfooc1728.tfm \
tex-hfooc1728.vf \
tex-hfooc2074.tfm \
tex-hfooc2074.vf \
tex-hfooc2488.tfm \
tex-hfooc2488.vf \
tex-hfooc2986.tfm \
tex-hfooc2986.vf \
tex-hfooc3583.tfm \
tex-hfooc3583.vf \
tex-hforb0500.tfm \
tex-hforb0500.vf \
tex-hforb0600.tfm \
tex-hforb0600.vf \
tex-hforb0700.tfm \
tex-hforb0700.vf \
tex-hforb0800.tfm \
tex-hforb0800.vf \
tex-hforb0900.tfm \
tex-hforb0900.vf \
tex-hforb1000.tfm \
tex-hforb1000.vf \
tex-hforb1095.tfm \
tex-hforb1095.vf \
tex-hforb1200.tfm \
tex-hforb1200.vf \
tex-hforb1440.tfm \
tex-hforb1440.vf \
tex-hforb1728.tfm \
tex-hforb1728.vf \
tex-hforb2074.tfm \
tex-hforb2074.vf \
tex-hforb2488.tfm \
tex-hforb2488.vf \
tex-hforb2986.tfm \
tex-hforb2986.vf \
tex-hforb3583.tfm \
tex-hforb3583.vf \
tex-hform0500.tfm \
tex-hform0500.vf \
tex-hform0600.tfm \
tex-hform0600.vf \
tex-hform0700.tfm \
tex-hform0700.vf \
tex-hform0800.tfm \
tex-hform0800.vf \
tex-hform0900.tfm \
tex-hform0900.vf \
tex-hform1000.tfm \
tex-hform1000.vf \
tex-hform1095.tfm \
tex-hform1095.vf \
tex-hform1200.tfm \
tex-hform1200.vf \
tex-hform1440.tfm \
tex-hform1440.vf \
tex-hform1728.tfm \
tex-hform1728.vf \
tex-hform2074.tfm \
tex-hform2074.vf \
tex-hform2488.tfm \
tex-hform2488.vf \
tex-hform2986.tfm \
tex-hform2986.vf \
tex-hform3583.tfm \
tex-hform3583.vf \
tex-hfosc0500.tfm \
tex-hfosc0500.vf \
tex-hfosc0600.tfm \
tex-hfosc0600.vf \
tex-hfosc0700.tfm \
tex-hfosc0700.vf \
tex-hfosc0800.tfm \
tex-hfosc0800.vf \
tex-hfosc0900.tfm \
tex-hfosc0900.vf \
tex-hfosc1000.tfm \
tex-hfosc1000.vf \
tex-hfosc1095.tfm \
tex-hfosc1095.vf \
tex-hfosc1200.tfm \
tex-hfosc1200.vf \
tex-hfosc1440.tfm \
tex-hfosc1440.vf \
tex-hfosc1728.tfm \
tex-hfosc1728.vf \
tex-hfosc2074.tfm \
tex-hfosc2074.vf \
tex-hfosc2488.tfm \
tex-hfosc2488.vf \
tex-hfosc2986.tfm \
tex-hfosc2986.vf \
tex-hfosc3583.tfm \
tex-hfosc3583.vf \
tex-hfosi0500.tfm \
tex-hfosi0500.vf \
tex-hfosi0600.tfm \
tex-hfosi0600.vf \
tex-hfosi0700.tfm \
tex-hfosi0700.vf \
tex-hfosi0800.tfm \
tex-hfosi0800.vf \
tex-hfosi0900.tfm \
tex-hfosi0900.vf \
tex-hfosi1000.tfm \
tex-hfosi1000.vf \
tex-hfosi1095.tfm \
tex-hfosi1095.vf \
tex-hfosi1200.tfm \
tex-hfosi1200.vf \
tex-hfosi1440.tfm \
tex-hfosi1440.vf \
tex-hfosi1728.tfm \
tex-hfosi1728.vf \
tex-hfosi2074.tfm \
tex-hfosi2074.vf \
tex-hfosi2488.tfm \
tex-hfosi2488.vf \
tex-hfosi2986.tfm \
tex-hfosi2986.vf \
tex-hfosi3583.tfm \
tex-hfosi3583.vf \
tex-hfosl0500.tfm \
tex-hfosl0500.vf \
tex-hfosl0600.tfm \
tex-hfosl0600.vf \
tex-hfosl0700.tfm \
tex-hfosl0700.vf \
tex-hfosl0800.tfm \
tex-hfosl0800.vf \
tex-hfosl0900.tfm \
tex-hfosl0900.vf \
tex-hfosl1000.tfm \
tex-hfosl1000.vf \
tex-hfosl1095.tfm \
tex-hfosl1095.vf \
tex-hfosl1200.tfm \
tex-hfosl1200.vf \
tex-hfosl1440.tfm \
tex-hfosl1440.vf \
tex-hfosl1728.tfm \
tex-hfosl1728.vf \
tex-hfosl2074.tfm \
tex-hfosl2074.vf \
tex-hfosl2488.tfm \
tex-hfosl2488.vf \
tex-hfosl2986.tfm \
tex-hfosl2986.vf \
tex-hfosl3583.tfm \
tex-hfosl3583.vf \
tex-hfoso0500.tfm \
tex-hfoso0500.vf \
tex-hfoso0600.tfm \
tex-hfoso0600.vf \
tex-hfoso0700.tfm \
tex-hfoso0700.vf \
tex-hfoso0800.tfm \
tex-hfoso0800.vf \
tex-hfoso0900.tfm \
tex-hfoso0900.vf \
tex-hfoso1000.tfm \
tex-hfoso1000.vf \
tex-hfoso1095.tfm \
tex-hfoso1095.vf \
tex-hfoso1200.tfm \
tex-hfoso1200.vf \
tex-hfoso1440.tfm \
tex-hfoso1440.vf \
tex-hfoso1728.tfm \
tex-hfoso1728.vf \
tex-hfoso2074.tfm \
tex-hfoso2074.vf \
tex-hfoso2488.tfm \
tex-hfoso2488.vf \
tex-hfoso2986.tfm \
tex-hfoso2986.vf \
tex-hfoso3583.tfm \
tex-hfoso3583.vf \
tex-hfoss0500.tfm \
tex-hfoss0500.vf \
tex-hfoss0600.tfm \
tex-hfoss0600.vf \
tex-hfoss0700.tfm \
tex-hfoss0700.vf \
tex-hfoss0800.tfm \
tex-hfoss0800.vf \
tex-hfoss0900.tfm \
tex-hfoss0900.vf \
tex-hfoss1000.tfm \
tex-hfoss1000.vf \
tex-hfoss1095.tfm \
tex-hfoss1095.vf \
tex-hfoss1200.tfm \
tex-hfoss1200.vf \
tex-hfoss1440.tfm \
tex-hfoss1440.vf \
tex-hfoss1728.tfm \
tex-hfoss1728.vf \
tex-hfoss2074.tfm \
tex-hfoss2074.vf \
tex-hfoss2488.tfm \
tex-hfoss2488.vf \
tex-hfoss2986.tfm \
tex-hfoss2986.vf \
tex-hfoss3583.tfm \
tex-hfoss3583.vf \
tex-hfost0600.tfm \
tex-hfost0600.vf \
tex-hfost0700.tfm \
tex-hfost0700.vf \
tex-hfost0800.tfm \
tex-hfost0800.vf \
tex-hfost0900.tfm \
tex-hfost0900.vf \
tex-hfost1000.tfm \
tex-hfost1000.vf \
tex-hfost1095.tfm \
tex-hfost1095.vf \
tex-hfost1200.tfm \
tex-hfost1200.vf \
tex-hfost1440.tfm \
tex-hfost1440.vf \
tex-hfost1728.tfm \
tex-hfost1728.vf \
tex-hfost2074.tfm \
tex-hfost2074.vf \
tex-hfost2488.tfm \
tex-hfost2488.vf \
tex-hfost2986.tfm \
tex-hfost2986.vf \
tex-hfost3583.tfm \
tex-hfost3583.vf \
tex-hfosx0500.tfm \
tex-hfosx0500.vf \
tex-hfosx0600.tfm \
tex-hfosx0600.vf \
tex-hfosx0700.tfm \
tex-hfosx0700.vf \
tex-hfosx0800.tfm \
tex-hfosx0800.vf \
tex-hfosx0900.tfm \
tex-hfosx0900.vf \
tex-hfosx1000.tfm \
tex-hfosx1000.vf \
tex-hfosx1095.tfm \
tex-hfosx1095.vf \
tex-hfosx1200.tfm \
tex-hfosx1200.vf \
tex-hfosx1440.tfm \
tex-hfosx1440.vf \
tex-hfosx1728.tfm \
tex-hfosx1728.vf \
tex-hfosx2074.tfm \
tex-hfosx2074.vf \
tex-hfosx2488.tfm \
tex-hfosx2488.vf \
tex-hfosx2986.tfm \
tex-hfosx2986.vf \
tex-hfosx3583.tfm \
tex-hfosx3583.vf \
tex-hfotc0600.tfm \
tex-hfotc0600.vf \
tex-hfotc0700.tfm \
tex-hfotc0700.vf \
tex-hfotc0800.tfm \
tex-hfotc0800.vf \
tex-hfotc0900.tfm \
tex-hfotc0900.vf \
tex-hfotc1000.tfm \
tex-hfotc1000.vf \
tex-hfotc1095.tfm \
tex-hfotc1095.vf \
tex-hfotc1200.tfm \
tex-hfotc1200.vf \
tex-hfotc1440.tfm \
tex-hfotc1440.vf \
tex-hfotc1728.tfm \
tex-hfotc1728.vf \
tex-hfotc2074.tfm \
tex-hfotc2074.vf \
tex-hfotc2488.tfm \
tex-hfotc2488.vf \
tex-hfotc2986.tfm \
tex-hfotc2986.vf \
tex-hfotc3583.tfm \
tex-hfotc3583.vf \
tex-hfoti0500.tfm \
tex-hfoti0500.vf \
tex-hfoti0600.tfm \
tex-hfoti0600.vf \
tex-hfoti0700.tfm \
tex-hfoti0700.vf \
tex-hfoti0800.tfm \
tex-hfoti0800.vf \
tex-hfoti0900.tfm \
tex-hfoti0900.vf \
tex-hfoti1000.tfm \
tex-hfoti1000.vf \
tex-hfoti1095.tfm \
tex-hfoti1095.vf \
tex-hfoti1200.tfm \
tex-hfoti1200.vf \
tex-hfoti1440.tfm \
tex-hfoti1440.vf \
tex-hfoti1728.tfm \
tex-hfoti1728.vf \
tex-hfoti2074.tfm \
tex-hfoti2074.vf \
tex-hfoti2488.tfm \
tex-hfoti2488.vf \
tex-hfoti2986.tfm \
tex-hfoti2986.vf \
tex-hfoti3583.tfm \
tex-hfoti3583.vf \
tex-hfott0600.tfm \
tex-hfott0600.vf \
tex-hfott0700.tfm \
tex-hfott0700.vf \
tex-hfott0800.tfm \
tex-hfott0800.vf \
tex-hfott0900.tfm \
tex-hfott0900.vf \
tex-hfott1000.tfm \
tex-hfott1000.vf \
tex-hfott1095.tfm \
tex-hfott1095.vf \
tex-hfott1200.tfm \
tex-hfott1200.vf \
tex-hfott1440.tfm \
tex-hfott1440.vf \
tex-hfott1728.tfm \
tex-hfott1728.vf \
tex-hfott2074.tfm \
tex-hfott2074.vf \
tex-hfott2488.tfm \
tex-hfott2488.vf \
tex-hfott2986.tfm \
tex-hfott2986.vf \
tex-hfott3583.tfm \
tex-hfott3583.vf \
tex-hfoui0500.tfm \
tex-hfoui0500.vf \
tex-hfoui0600.tfm \
tex-hfoui0600.vf \
tex-hfoui0700.tfm \
tex-hfoui0700.vf \
tex-hfoui0800.tfm \
tex-hfoui0800.vf \
tex-hfoui0900.tfm \
tex-hfoui0900.vf \
tex-hfoui1000.tfm \
tex-hfoui1000.vf \
tex-hfoui1095.tfm \
tex-hfoui1095.vf \
tex-hfoui1200.tfm \
tex-hfoui1200.vf \
tex-hfoui1440.tfm \
tex-hfoui1440.vf \
tex-hfoui1728.tfm \
tex-hfoui1728.vf \
tex-hfoui2074.tfm \
tex-hfoui2074.vf \
tex-hfoui2488.tfm \
tex-hfoui2488.vf \
tex-hfoui2986.tfm \
tex-hfoui2986.vf \
tex-hfoui3583.tfm \
tex-hfoui3583.vf \
tex-hfovi0600.tfm \
tex-hfovi0600.vf \
tex-hfovi0700.tfm \
tex-hfovi0700.vf \
tex-hfovi0800.tfm \
tex-hfovi0800.vf \
tex-hfovi0900.tfm \
tex-hfovi0900.vf \
tex-hfovi1000.tfm \
tex-hfovi1000.vf \
tex-hfovi1095.tfm \
tex-hfovi1095.vf \
tex-hfovi1200.tfm \
tex-hfovi1200.vf \
tex-hfovi1440.tfm \
tex-hfovi1440.vf \
tex-hfovi1728.tfm \
tex-hfovi1728.vf \
tex-hfovi2074.tfm \
tex-hfovi2074.vf \
tex-hfovi2488.tfm \
tex-hfovi2488.vf \
tex-hfovi2986.tfm \
tex-hfovi2986.vf \
tex-hfovi3583.tfm \
tex-hfovi3583.vf \
tex-hfovt0600.tfm \
tex-hfovt0600.vf \
tex-hfovt0700.tfm \
tex-hfovt0700.vf \
tex-hfovt0800.tfm \
tex-hfovt0800.vf \
tex-hfovt0900.tfm \
tex-hfovt0900.vf \
tex-hfovt1000.tfm \
tex-hfovt1000.vf \
tex-hfovt1095.tfm \
tex-hfovt1095.vf \
tex-hfovt1200.tfm \
tex-hfovt1200.vf \
tex-hfovt1440.tfm \
tex-hfovt1440.vf \
tex-hfovt1728.tfm \
tex-hfovt1728.vf \
tex-hfovt2074.tfm \
tex-hfovt2074.vf \
tex-hfovt2488.tfm \
tex-hfovt2488.vf \
tex-hfovt2986.tfm \
tex-hfovt2986.vf \
tex-hfovt3583.tfm \
tex-hfovt3583.vf \
tex-hfoxc0500.tfm \
tex-hfoxc0500.vf \
tex-hfoxc0600.tfm \
tex-hfoxc0600.vf \
tex-hfoxc0700.tfm \
tex-hfoxc0700.vf \
tex-hfoxc0800.tfm \
tex-hfoxc0800.vf \
tex-hfoxc0900.tfm \
tex-hfoxc0900.vf \
tex-hfoxc1000.tfm \
tex-hfoxc1000.vf \
tex-hfoxc1095.tfm \
tex-hfoxc1095.vf \
tex-hfoxc1200.tfm \
tex-hfoxc1200.vf \
tex-hfoxc1440.tfm \
tex-hfoxc1440.vf \
tex-hfoxc1728.tfm \
tex-hfoxc1728.vf \
tex-hfoxc2074.tfm \
tex-hfoxc2074.vf \
tex-hfoxc2488.tfm \
tex-hfoxc2488.vf \
tex-hfoxc2986.tfm \
tex-hfoxc2986.vf \
tex-hfoxc3583.tfm \
tex-hfoxc3583.vf \
tex-omlhfor.fd \
tex-omshfor.fd \
tex-t1hfodh.fd \
tex-t1hfor.fd \
tex-t1hfoss.fd \
tex-t1hfott.fd \
tex-t1hfovt.fd \
tex-ts1hfor.fd \
tex-ts1hfoss.fd \
tex-ts1hfott.fd \
tex-ts1hfovtt.fd \
texlive-hfoldsty"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-ecbi0500.tfm \
tex-ecbi0600.tfm \
tex-ecbi0700.tfm \
tex-ecbi0800.tfm \
tex-ecbi0900.tfm \
tex-ecbi1000.tfm \
tex-ecbi1095.tfm \
tex-ecbi1200.tfm \
tex-ecbi1440.tfm \
tex-ecbi1728.tfm \
tex-ecbi2074.tfm \
tex-ecbi2488.tfm \
tex-ecbi2986.tfm \
tex-ecbi3583.tfm \
tex-ecbl0500.tfm \
tex-ecbl0600.tfm \
tex-ecbl0700.tfm \
tex-ecbl0800.tfm \
tex-ecbl0900.tfm \
tex-ecbl1000.tfm \
tex-ecbl1095.tfm \
tex-ecbl1200.tfm \
tex-ecbl1440.tfm \
tex-ecbl1728.tfm \
tex-ecbl2074.tfm \
tex-ecbl2488.tfm \
tex-ecbl2986.tfm \
tex-ecbl3583.tfm \
tex-ecbx0500.tfm \
tex-ecbx0600.tfm \
tex-ecbx0700.tfm \
tex-ecbx0800.tfm \
tex-ecbx0900.tfm \
tex-ecbx1000.tfm \
tex-ecbx1095.tfm \
tex-ecbx1200.tfm \
tex-ecbx1440.tfm \
tex-ecbx1728.tfm \
tex-ecbx2074.tfm \
tex-ecbx2488.tfm \
tex-ecbx2986.tfm \
tex-ecbx3583.tfm \
tex-eccc0500.tfm \
tex-eccc0600.tfm \
tex-eccc0700.tfm \
tex-eccc0800.tfm \
tex-eccc0900.tfm \
tex-eccc1000.tfm \
tex-eccc1095.tfm \
tex-eccc1200.tfm \
tex-eccc1440.tfm \
tex-eccc1728.tfm \
tex-eccc2074.tfm \
tex-eccc2488.tfm \
tex-eccc2986.tfm \
tex-eccc3583.tfm \
tex-ecdh0500.tfm \
tex-ecdh0600.tfm \
tex-ecdh0700.tfm \
tex-ecdh0800.tfm \
tex-ecdh0900.tfm \
tex-ecdh1000.tfm \
tex-ecdh1095.tfm \
tex-ecdh1200.tfm \
tex-ecdh1440.tfm \
tex-ecdh1728.tfm \
tex-ecdh2074.tfm \
tex-ecdh2488.tfm \
tex-ecdh2986.tfm \
tex-ecdh3583.tfm \
tex-ecit0800.tfm \
tex-ecit0900.tfm \
tex-ecit1000.tfm \
tex-ecit1095.tfm \
tex-ecit1200.tfm \
tex-ecit1440.tfm \
tex-ecit1728.tfm \
tex-ecit2074.tfm \
tex-ecit2488.tfm \
tex-ecit2986.tfm \
tex-ecit3583.tfm \
tex-ecoc0500.tfm \
tex-ecoc0600.tfm \
tex-ecoc0700.tfm \
tex-ecoc0800.tfm \
tex-ecoc0900.tfm \
tex-ecoc1000.tfm \
tex-ecoc1095.tfm \
tex-ecoc1200.tfm \
tex-ecoc1440.tfm \
tex-ecoc1728.tfm \
tex-ecoc2074.tfm \
tex-ecoc2488.tfm \
tex-ecoc2986.tfm \
tex-ecoc3583.tfm \
tex-ecrb0500.tfm \
tex-ecrb0600.tfm \
tex-ecrb0700.tfm \
tex-ecrb0800.tfm \
tex-ecrb0900.tfm \
tex-ecrb1000.tfm \
tex-ecrb1095.tfm \
tex-ecrb1200.tfm \
tex-ecrb1440.tfm \
tex-ecrb1728.tfm \
tex-ecrb2074.tfm \
tex-ecrb2488.tfm \
tex-ecrb2986.tfm \
tex-ecrb3583.tfm \
tex-ecrm0500.tfm \
tex-ecrm0600.tfm \
tex-ecrm0700.tfm \
tex-ecrm0800.tfm \
tex-ecrm0900.tfm \
tex-ecrm1000.tfm \
tex-ecrm1095.tfm \
tex-ecrm1200.tfm \
tex-ecrm1440.tfm \
tex-ecrm1728.tfm \
tex-ecrm2074.tfm \
tex-ecrm2488.tfm \
tex-ecrm2986.tfm \
tex-ecrm3583.tfm \
tex-ecsc0500.tfm \
tex-ecsc0600.tfm \
tex-ecsc0700.tfm \
tex-ecsc0800.tfm \
tex-ecsc0900.tfm \
tex-ecsc1000.tfm \
tex-ecsc1095.tfm \
tex-ecsc1200.tfm \
tex-ecsc1440.tfm \
tex-ecsc1728.tfm \
tex-ecsc2074.tfm \
tex-ecsc2488.tfm \
tex-ecsc2986.tfm \
tex-ecsc3583.tfm \
tex-ecsi0500.tfm \
tex-ecsi0600.tfm \
tex-ecsi0700.tfm \
tex-ecsi0800.tfm \
tex-ecsi0900.tfm \
tex-ecsi1000.tfm \
tex-ecsi1095.tfm \
tex-ecsi1200.tfm \
tex-ecsi1440.tfm \
tex-ecsi1728.tfm \
tex-ecsi2074.tfm \
tex-ecsi2488.tfm \
tex-ecsi2986.tfm \
tex-ecsi3583.tfm \
tex-ecsl0500.tfm \
tex-ecsl0600.tfm \
tex-ecsl0700.tfm \
tex-ecsl0800.tfm \
tex-ecsl0900.tfm \
tex-ecsl1000.tfm \
tex-ecsl1095.tfm \
tex-ecsl1200.tfm \
tex-ecsl1440.tfm \
tex-ecsl1728.tfm \
tex-ecsl2074.tfm \
tex-ecsl2488.tfm \
tex-ecsl2986.tfm \
tex-ecsl3583.tfm \
tex-ecso0500.tfm \
tex-ecso0600.tfm \
tex-ecso0700.tfm \
tex-ecso0800.tfm \
tex-ecso0900.tfm \
tex-ecso1000.tfm \
tex-ecso1095.tfm \
tex-ecso1200.tfm \
tex-ecso1440.tfm \
tex-ecso1728.tfm \
tex-ecso2074.tfm \
tex-ecso2488.tfm \
tex-ecso2986.tfm \
tex-ecso3583.tfm \
tex-ecss0500.tfm \
tex-ecss0600.tfm \
tex-ecss0700.tfm \
tex-ecss0800.tfm \
tex-ecss0900.tfm \
tex-ecss1000.tfm \
tex-ecss1095.tfm \
tex-ecss1200.tfm \
tex-ecss1440.tfm \
tex-ecss1728.tfm \
tex-ecss2074.tfm \
tex-ecss2488.tfm \
tex-ecss2986.tfm \
tex-ecss3583.tfm \
tex-ecst0800.tfm \
tex-ecst0900.tfm \
tex-ecst1000.tfm \
tex-ecst1095.tfm \
tex-ecst1200.tfm \
tex-ecst1440.tfm \
tex-ecst1728.tfm \
tex-ecst2074.tfm \
tex-ecst2488.tfm \
tex-ecst2986.tfm \
tex-ecst3583.tfm \
tex-ecsx0500.tfm \
tex-ecsx0600.tfm \
tex-ecsx0700.tfm \
tex-ecsx0800.tfm \
tex-ecsx0900.tfm \
tex-ecsx1000.tfm \
tex-ecsx1095.tfm \
tex-ecsx1200.tfm \
tex-ecsx1440.tfm \
tex-ecsx1728.tfm \
tex-ecsx2074.tfm \
tex-ecsx2488.tfm \
tex-ecsx2986.tfm \
tex-ecsx3583.tfm \
tex-ectc0800.tfm \
tex-ectc0900.tfm \
tex-ectc1000.tfm \
tex-ectc1095.tfm \
tex-ectc1200.tfm \
tex-ectc1440.tfm \
tex-ectc1728.tfm \
tex-ectc2074.tfm \
tex-ectc2488.tfm \
tex-ectc2986.tfm \
tex-ectc3583.tfm \
tex-ecti0500.tfm \
tex-ecti0600.tfm \
tex-ecti0700.tfm \
tex-ecti0800.tfm \
tex-ecti0900.tfm \
tex-ecti1000.tfm \
tex-ecti1095.tfm \
tex-ecti1200.tfm \
tex-ecti1440.tfm \
tex-ecti1728.tfm \
tex-ecti2074.tfm \
tex-ecti2488.tfm \
tex-ecti2986.tfm \
tex-ecti3583.tfm \
tex-ectt0800.tfm \
tex-ectt0900.tfm \
tex-ectt1000.tfm \
tex-ectt1095.tfm \
tex-ectt1200.tfm \
tex-ectt1440.tfm \
tex-ectt1728.tfm \
tex-ectt2074.tfm \
tex-ectt2488.tfm \
tex-ectt2986.tfm \
tex-ectt3583.tfm \
tex-ecui0500.tfm \
tex-ecui0600.tfm \
tex-ecui0700.tfm \
tex-ecui0800.tfm \
tex-ecui0900.tfm \
tex-ecui1000.tfm \
tex-ecui1095.tfm \
tex-ecui1200.tfm \
tex-ecui1440.tfm \
tex-ecui1728.tfm \
tex-ecui2074.tfm \
tex-ecui2488.tfm \
tex-ecui2986.tfm \
tex-ecui3583.tfm \
tex-ecvi0800.tfm \
tex-ecvi0900.tfm \
tex-ecvi1000.tfm \
tex-ecvi1095.tfm \
tex-ecvi1200.tfm \
tex-ecvi1440.tfm \
tex-ecvi1728.tfm \
tex-ecvi2074.tfm \
tex-ecvi2488.tfm \
tex-ecvi2986.tfm \
tex-ecvi3583.tfm \
tex-ecvt0800.tfm \
tex-ecvt0900.tfm \
tex-ecvt1000.tfm \
tex-ecvt1095.tfm \
tex-ecvt1200.tfm \
tex-ecvt1440.tfm \
tex-ecvt1728.tfm \
tex-ecvt2074.tfm \
tex-ecvt2488.tfm \
tex-ecvt2986.tfm \
tex-ecvt3583.tfm \
tex-ecxc0500.tfm \
tex-ecxc0600.tfm \
tex-ecxc0700.tfm \
tex-ecxc0800.tfm \
tex-ecxc0900.tfm \
tex-ecxc1000.tfm \
tex-ecxc1095.tfm \
tex-ecxc1200.tfm \
tex-ecxc1440.tfm \
tex-ecxc1728.tfm \
tex-ecxc2074.tfm \
tex-ecxc2488.tfm \
tex-ecxc2986.tfm \
tex-ecxc3583.tfm \
tex-fix-cm.sty \
tex-fontenc.sty \
tex-ifthen.sty \
tex-tcbi0500.tfm \
tex-tcbi0600.tfm \
tex-tcbi0700.tfm \
tex-tcbi0800.tfm \
tex-tcbi0900.tfm \
tex-tcbi1000.tfm \
tex-tcbi1095.tfm \
tex-tcbi1200.tfm \
tex-tcbi1440.tfm \
tex-tcbi1728.tfm \
tex-tcbi2074.tfm \
tex-tcbi2488.tfm \
tex-tcbi2986.tfm \
tex-tcbi3583.tfm \
tex-tcbl0500.tfm \
tex-tcbl0600.tfm \
tex-tcbl0700.tfm \
tex-tcbl0800.tfm \
tex-tcbl0900.tfm \
tex-tcbl1000.tfm \
tex-tcbl1095.tfm \
tex-tcbl1200.tfm \
tex-tcbl1440.tfm \
tex-tcbl1728.tfm \
tex-tcbl2074.tfm \
tex-tcbl2488.tfm \
tex-tcbl2986.tfm \
tex-tcbl3583.tfm \
tex-tcbx0500.tfm \
tex-tcbx0600.tfm \
tex-tcbx0700.tfm \
tex-tcbx0800.tfm \
tex-tcbx0900.tfm \
tex-tcbx1000.tfm \
tex-tcbx1095.tfm \
tex-tcbx1200.tfm \
tex-tcbx1440.tfm \
tex-tcbx1728.tfm \
tex-tcbx2074.tfm \
tex-tcbx2488.tfm \
tex-tcbx2986.tfm \
tex-tcbx3583.tfm \
tex-tcit0800.tfm \
tex-tcit0900.tfm \
tex-tcit1000.tfm \
tex-tcit1095.tfm \
tex-tcit1200.tfm \
tex-tcit1440.tfm \
tex-tcit1728.tfm \
tex-tcit2074.tfm \
tex-tcit2488.tfm \
tex-tcit2986.tfm \
tex-tcit3583.tfm \
tex-tcrb0500.tfm \
tex-tcrb0600.tfm \
tex-tcrb0700.tfm \
tex-tcrb0800.tfm \
tex-tcrb0900.tfm \
tex-tcrb1000.tfm \
tex-tcrb1095.tfm \
tex-tcrb1200.tfm \
tex-tcrb1440.tfm \
tex-tcrb1728.tfm \
tex-tcrb2074.tfm \
tex-tcrb2488.tfm \
tex-tcrb2986.tfm \
tex-tcrb3583.tfm \
tex-tcrm0500.tfm \
tex-tcrm0600.tfm \
tex-tcrm0700.tfm \
tex-tcrm0800.tfm \
tex-tcrm0900.tfm \
tex-tcrm1000.tfm \
tex-tcrm1095.tfm \
tex-tcrm1200.tfm \
tex-tcrm1440.tfm \
tex-tcrm1728.tfm \
tex-tcrm2074.tfm \
tex-tcrm2488.tfm \
tex-tcrm2986.tfm \
tex-tcrm3583.tfm \
tex-tcsi0500.tfm \
tex-tcsi0600.tfm \
tex-tcsi0700.tfm \
tex-tcsi0800.tfm \
tex-tcsi0900.tfm \
tex-tcsi1000.tfm \
tex-tcsi1095.tfm \
tex-tcsi1200.tfm \
tex-tcsi1440.tfm \
tex-tcsi1728.tfm \
tex-tcsi2074.tfm \
tex-tcsi2488.tfm \
tex-tcsi2986.tfm \
tex-tcsi3583.tfm \
tex-tcsl0500.tfm \
tex-tcsl0600.tfm \
tex-tcsl0700.tfm \
tex-tcsl0800.tfm \
tex-tcsl0900.tfm \
tex-tcsl1000.tfm \
tex-tcsl1095.tfm \
tex-tcsl1200.tfm \
tex-tcsl1440.tfm \
tex-tcsl1728.tfm \
tex-tcsl2074.tfm \
tex-tcsl2488.tfm \
tex-tcsl2986.tfm \
tex-tcsl3583.tfm \
tex-tcso0500.tfm \
tex-tcso0600.tfm \
tex-tcso0700.tfm \
tex-tcso0800.tfm \
tex-tcso0900.tfm \
tex-tcso1000.tfm \
tex-tcso1095.tfm \
tex-tcso1200.tfm \
tex-tcso1440.tfm \
tex-tcso1728.tfm \
tex-tcso2074.tfm \
tex-tcso2488.tfm \
tex-tcso2986.tfm \
tex-tcso3583.tfm \
tex-tcss0500.tfm \
tex-tcss0600.tfm \
tex-tcss0700.tfm \
tex-tcss0800.tfm \
tex-tcss0900.tfm \
tex-tcss1000.tfm \
tex-tcss1095.tfm \
tex-tcss1200.tfm \
tex-tcss1440.tfm \
tex-tcss1728.tfm \
tex-tcss2074.tfm \
tex-tcss2488.tfm \
tex-tcss2986.tfm \
tex-tcss3583.tfm \
tex-tcst0800.tfm \
tex-tcst0900.tfm \
tex-tcst1000.tfm \
tex-tcst1095.tfm \
tex-tcst1200.tfm \
tex-tcst1440.tfm \
tex-tcst1728.tfm \
tex-tcst2074.tfm \
tex-tcst2488.tfm \
tex-tcst2986.tfm \
tex-tcst3583.tfm \
tex-tcsx0500.tfm \
tex-tcsx0600.tfm \
tex-tcsx0700.tfm \
tex-tcsx0800.tfm \
tex-tcsx0900.tfm \
tex-tcsx1000.tfm \
tex-tcsx1095.tfm \
tex-tcsx1200.tfm \
tex-tcsx1440.tfm \
tex-tcsx1728.tfm \
tex-tcsx2074.tfm \
tex-tcsx2488.tfm \
tex-tcsx2986.tfm \
tex-tcsx3583.tfm \
tex-tcti0500.tfm \
tex-tcti0600.tfm \
tex-tcti0700.tfm \
tex-tcti0800.tfm \
tex-tcti0900.tfm \
tex-tcti1000.tfm \
tex-tcti1095.tfm \
tex-tcti1200.tfm \
tex-tcti1440.tfm \
tex-tcti1728.tfm \
tex-tcti2074.tfm \
tex-tcti2488.tfm \
tex-tcti2986.tfm \
tex-tcti3583.tfm \
tex-tctt0800.tfm \
tex-tctt0900.tfm \
tex-tctt1000.tfm \
tex-tctt1095.tfm \
tex-tctt1200.tfm \
tex-tctt1440.tfm \
tex-tctt1728.tfm \
tex-tctt2074.tfm \
tex-tctt2488.tfm \
tex-tctt2986.tfm \
tex-tctt3583.tfm \
tex-tcui0500.tfm \
tex-tcui0600.tfm \
tex-tcui0700.tfm \
tex-tcui0800.tfm \
tex-tcui0900.tfm \
tex-tcui1000.tfm \
tex-tcui1095.tfm \
tex-tcui1200.tfm \
tex-tcui1440.tfm \
tex-tcui1728.tfm \
tex-tcui2074.tfm \
tex-tcui2488.tfm \
tex-tcui2986.tfm \
tex-tcui3583.tfm \
tex-tcvi0800.tfm \
tex-tcvi0900.tfm \
tex-tcvi1000.tfm \
tex-tcvi1095.tfm \
tex-tcvi1200.tfm \
tex-tcvi1440.tfm \
tex-tcvi1728.tfm \
tex-tcvi2074.tfm \
tex-tcvi2488.tfm \
tex-tcvi2986.tfm \
tex-tcvi3583.tfm \
tex-tcvt0800.tfm \
tex-tcvt0900.tfm \
tex-tcvt1000.tfm \
tex-tcvt1095.tfm \
tex-tcvt1200.tfm \
tex-tcvt1440.tfm \
tex-tcvt1728.tfm \
tex-tcvt2074.tfm \
tex-tcvt2488.tfm \
tex-tcvt2986.tfm \
tex-tcvt3583.tfm \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
