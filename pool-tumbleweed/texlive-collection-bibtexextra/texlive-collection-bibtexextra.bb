SUMMARY = "BibTeX additional styles"
DESCRIPTION = "Additional BibTeX styles and bibliography data(bases), notably \
including BibLaTeX."
LICENSE = "LPPL-1.0"

PV = "2023.208.svn65257"

RPM_NAME = "texlive-collection-bibtexextra-2023.208.svn65257-58.1.noarch.rpm"
RPM_HASH = "f3aee3ffbf8bce43b6be5bf73ca0d10365466fc63afe46461832b00b85fcc221af2e74da82faf43ff24c10736f7275ac4d1eba9a27e955157cbce37291b04652"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "texlive-collection-bibtexextra"

RDEPENDS:${PN} += "texlive-aaai-named \
texlive-aichej \
texlive-ajl \
texlive-amsrefs \
texlive-annotate \
texlive-apacite \
texlive-apalike-ejor \
texlive-apalike2 \
texlive-archaeologie \
texlive-authordate \
texlive-beebe \
texlive-besjournals \
texlive-bestpapers \
texlive-bib2gls \
texlive-bibarts \
texlive-bibcop \
texlive-biber \
texlive-biber-ms \
texlive-bibexport \
texlive-bibhtml \
texlive-biblatex \
texlive-biblatex-abnt \
texlive-biblatex-ajc2020unofficial \
texlive-biblatex-anonymous \
texlive-biblatex-apa \
texlive-biblatex-apa6 \
texlive-biblatex-archaeology \
texlive-biblatex-arthistory-bonn \
texlive-biblatex-bath \
texlive-biblatex-bookinarticle \
texlive-biblatex-bookinother \
texlive-biblatex-bwl \
texlive-biblatex-caspervector \
texlive-biblatex-chem \
texlive-biblatex-chicago \
texlive-biblatex-claves \
texlive-biblatex-cv \
texlive-biblatex-dw \
texlive-biblatex-enc \
texlive-biblatex-ext \
texlive-biblatex-fiwi \
texlive-biblatex-gb7714-2015 \
texlive-biblatex-german-legal \
texlive-biblatex-gost \
texlive-biblatex-historian \
texlive-biblatex-ieee \
texlive-biblatex-ijsra \
texlive-biblatex-iso690 \
texlive-biblatex-jura2 \
texlive-biblatex-juradiss \
texlive-biblatex-license \
texlive-biblatex-lncs \
texlive-biblatex-lni \
texlive-biblatex-luh-ipw \
texlive-biblatex-manuscripts-philology \
texlive-biblatex-mla \
texlive-biblatex-morenames \
texlive-biblatex-ms \
texlive-biblatex-multiple-dm \
texlive-biblatex-musuos \
texlive-biblatex-nature \
texlive-biblatex-nejm \
texlive-biblatex-nottsclassic \
texlive-biblatex-opcit-booktitle \
texlive-biblatex-oxref \
texlive-biblatex-philosophy \
texlive-biblatex-phys \
texlive-biblatex-publist \
texlive-biblatex-readbbl \
texlive-biblatex-realauthor \
texlive-biblatex-sbl \
texlive-biblatex-science \
texlive-biblatex-shortfields \
texlive-biblatex-socialscienceshuberlin \
texlive-biblatex-software \
texlive-biblatex-source-division \
texlive-biblatex-spbasic \
texlive-biblatex-subseries \
texlive-biblatex-swiss-legal \
texlive-biblatex-trad \
texlive-biblatex-true-citepages-omit \
texlive-biblatex-unified \
texlive-biblatex-vancouver \
texlive-biblatex2bibitem \
texlive-biblist \
texlive-bibtexperllibs \
texlive-bibtopic \
texlive-bibtopicprefix \
texlive-bibunits \
texlive-biolett-bst \
texlive-bookdb \
texlive-breakcites \
texlive-cell \
texlive-chbibref \
texlive-chembst \
texlive-chicago \
texlive-chicago-annote \
texlive-chicagoa \
texlive-chscite \
texlive-citation-style-language \
texlive-citeall \
texlive-citeref \
texlive-collection-latex \
texlive-collref \
texlive-compactbib \
texlive-crossrefware \
texlive-custom-bib \
texlive-din1505 \
texlive-dk-bib \
texlive-doipubmed \
texlive-ecobiblatex \
texlive-econ-bst \
texlive-economic \
texlive-fbs \
texlive-figbib \
texlive-footbib \
texlive-francais-bst \
texlive-gbt7714 \
texlive-geschichtsfrkl \
texlive-harvard \
texlive-harvmac \
texlive-hep-bibliography \
texlive-historische-zeitschrift \
texlive-icite \
texlive-ietfbibs \
texlive-ijqc \
texlive-inlinebib \
texlive-iopart-num \
texlive-is-bst \
texlive-jbact \
texlive-jmb \
texlive-jneurosci \
texlive-jurabib \
texlive-ksfh_nat \
texlive-listbib \
texlive-logreq \
texlive-ltb2bib \
texlive-luabibentry \
texlive-margbib \
texlive-multibib \
texlive-multibibliography \
texlive-munich \
texlive-nar \
texlive-newcastle-bst \
texlive-nmbib \
texlive-notes2bib \
texlive-notex-bst \
texlive-oscola \
texlive-perception \
texlive-plainyr \
texlive-pnas2009 \
texlive-rsc \
texlive-showtags \
texlive-sort-by-letters \
texlive-splitbib \
texlive-turabian-formatting \
texlive-uni-wtal-ger \
texlive-uni-wtal-lin \
texlive-urlbst \
texlive-usebib \
texlive-vak \
texlive-windycity \
texlive-xcite \
texlive-zootaxa-bst"

inherit rpm
