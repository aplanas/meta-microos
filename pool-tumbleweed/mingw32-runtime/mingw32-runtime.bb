SUMMARY = "MinGW-w64 runtime libraries for Win32"
DESCRIPTION = "MinGW Win64 cross-compiler runtime, base libraries."
LICENSE = "SUSE-Public-Domain"

PV = "10.0.0"

RPM_NAME = "mingw32-runtime-10.0.0-1.3.noarch.rpm"
RPM_HASH = "350446dc766557d2add3b824990b4d9672127635640581d32f657941ea0f47e1d25f7e072c6c8f64848f2248027404f5c9ead2c468e81b07e673a529612a5f0a"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "mingw32-lib-aclui \
mingw32-lib-activeds \
mingw32-lib-adsiid \
mingw32-lib-adsldpc \
mingw32-lib-advapi32 \
mingw32-lib-amstrmid \
mingw32-lib-apcups \
mingw32-lib-authz \
mingw32-lib-avicap32 \
mingw32-lib-avifil32 \
mingw32-lib-avrt \
mingw32-lib-bcrypt \
mingw32-lib-bits \
mingw32-lib-bluetoothapis \
mingw32-lib-bootvid \
mingw32-lib-browcli \
mingw32-lib-bthprops \
mingw32-lib-cabinet \
mingw32-lib-cap \
mingw32-lib-cfgmgr32 \
mingw32-lib-classpnp \
mingw32-lib-clfsw32 \
mingw32-lib-clusapi \
mingw32-lib-cmutil \
mingw32-lib-comctl32 \
mingw32-lib-comdlg32 \
mingw32-lib-connect \
mingw32-lib-credui \
mingw32-lib-crtdll \
mingw32-lib-crypt32 \
mingw32-lib-cryptnet \
mingw32-lib-cryptsp \
mingw32-lib-cryptxml \
mingw32-lib-cscapi \
mingw32-lib-ctl3d32 \
mingw32-lib-d2d1 \
mingw32-lib-d3d10 \
mingw32-lib-d3d11 \
mingw32-lib-d3d12 \
mingw32-lib-d3d8 \
mingw32-lib-d3d9 \
mingw32-lib-d3dcompiler \
mingw32-lib-d3dcompiler-33 \
mingw32-lib-d3dcompiler-34 \
mingw32-lib-d3dcompiler-35 \
mingw32-lib-d3dcompiler-36 \
mingw32-lib-d3dcompiler-37 \
mingw32-lib-d3dcompiler-38 \
mingw32-lib-d3dcompiler-39 \
mingw32-lib-d3dcompiler-40 \
mingw32-lib-d3dcompiler-41 \
mingw32-lib-d3dcompiler-42 \
mingw32-lib-d3dcompiler-43 \
mingw32-lib-d3dcompiler-46 \
mingw32-lib-d3dcompiler-47 \
mingw32-lib-d3dcsx-46 \
mingw32-lib-d3dcsxd \
mingw32-lib-d3dcsxd-43 \
mingw32-lib-d3dim \
mingw32-lib-d3drm \
mingw32-lib-d3dx10 \
mingw32-lib-d3dx10-33 \
mingw32-lib-d3dx10-34 \
mingw32-lib-d3dx10-35 \
mingw32-lib-d3dx10-36 \
mingw32-lib-d3dx10-37 \
mingw32-lib-d3dx10-38 \
mingw32-lib-d3dx10-39 \
mingw32-lib-d3dx10-40 \
mingw32-lib-d3dx10-41 \
mingw32-lib-d3dx10-42 \
mingw32-lib-d3dx10-43 \
mingw32-lib-d3dx11 \
mingw32-lib-d3dx11-42 \
mingw32-lib-d3dx11-43 \
mingw32-lib-d3dx8d \
mingw32-lib-d3dx9 \
mingw32-lib-d3dx9-24 \
mingw32-lib-d3dx9-25 \
mingw32-lib-d3dx9-26 \
mingw32-lib-d3dx9-27 \
mingw32-lib-d3dx9-28 \
mingw32-lib-d3dx9-29 \
mingw32-lib-d3dx9-30 \
mingw32-lib-d3dx9-31 \
mingw32-lib-d3dx9-32 \
mingw32-lib-d3dx9-33 \
mingw32-lib-d3dx9-34 \
mingw32-lib-d3dx9-35 \
mingw32-lib-d3dx9-36 \
mingw32-lib-d3dx9-37 \
mingw32-lib-d3dx9-38 \
mingw32-lib-d3dx9-39 \
mingw32-lib-d3dx9-40 \
mingw32-lib-d3dx9-41 \
mingw32-lib-d3dx9-42 \
mingw32-lib-d3dx9-43 \
mingw32-lib-d3dx9d \
mingw32-lib-d3dxof \
mingw32-lib-davclnt \
mingw32-lib-davhlpr \
mingw32-lib-dbgeng \
mingw32-lib-dbghelp \
mingw32-lib-dcomp \
mingw32-lib-ddraw \
mingw32-lib-delayimp \
mingw32-lib-devmgr \
mingw32-lib-devobj \
mingw32-lib-devrtl \
mingw32-lib-dfscli \
mingw32-lib-dhcpcsvc \
mingw32-lib-dhcpcsvc6 \
mingw32-lib-dhcpsapi \
mingw32-lib-dinput \
mingw32-lib-dinput8 \
mingw32-lib-dismapi \
mingw32-lib-dlcapi \
mingw32-lib-dmoguids \
mingw32-lib-dnsapi \
mingw32-lib-dpapi \
mingw32-lib-dplayx \
mingw32-lib-dpnaddr \
mingw32-lib-dpnet \
mingw32-lib-dpnlobby \
mingw32-lib-dpvoice \
mingw32-lib-dsetup \
mingw32-lib-dsound \
mingw32-lib-dsrole \
mingw32-lib-dssec \
mingw32-lib-dwmapi \
mingw32-lib-dwrite \
mingw32-lib-dxapi \
mingw32-lib-dxerr8 \
mingw32-lib-dxerr9 \
mingw32-lib-dxgi \
mingw32-lib-dxguid \
mingw32-lib-dxva2 \
mingw32-lib-eappcfg \
mingw32-lib-eappgnui \
mingw32-lib-eapphost \
mingw32-lib-eappprxy \
mingw32-lib-elscore \
mingw32-lib-esent \
mingw32-lib-evr \
mingw32-lib-faultrep \
mingw32-lib-feclient \
mingw32-lib-fontsub \
mingw32-lib-fwpuclnt \
mingw32-lib-gdi32 \
mingw32-lib-gdiplus \
mingw32-lib-glaux \
mingw32-lib-glu32 \
mingw32-lib-glut \
mingw32-lib-glut32 \
mingw32-lib-gmon \
mingw32-lib-gpapi \
mingw32-lib-gpedit \
mingw32-lib-gpprefcl \
mingw32-lib-gpscript \
mingw32-lib-gptext \
mingw32-lib-hal \
mingw32-lib-hid \
mingw32-lib-hidclass \
mingw32-lib-hidparse \
mingw32-lib-htmlhelp \
mingw32-lib-httpapi \
mingw32-lib-icmui \
mingw32-lib-igmpagnt \
mingw32-lib-imagehlp \
mingw32-lib-imm32 \
mingw32-lib-iphlpapi \
mingw32-lib-iscsidsc \
mingw32-lib-kernel32 \
mingw32-lib-ks \
mingw32-lib-ksecdd \
mingw32-lib-ksguid \
mingw32-lib-ksproxy \
mingw32-lib-ksuser \
mingw32-lib-ktmw32 \
mingw32-lib-largeint \
mingw32-lib-locationapi \
mingw32-lib-logoncli \
mingw32-lib-lz32 \
mingw32-lib-m \
mingw32-lib-mapi32 \
mingw32-lib-mcd \
mingw32-lib-mf \
mingw32-lib-mfcore \
mingw32-lib-mfcuia32 \
mingw32-lib-mfplat \
mingw32-lib-mfplay \
mingw32-lib-mfreadwrite \
mingw32-lib-mfsensorgroup \
mingw32-lib-mfuuid \
mingw32-lib-mgmtapi \
mingw32-lib-mincore \
mingw32-lib-mingw32 \
mingw32-lib-mingwex \
mingw32-lib-mingwthrd \
mingw32-lib-mmdevapi \
mingw32-lib-moldname \
mingw32-lib-mpr \
mingw32-lib-mprapi \
mingw32-lib-mqrt \
mingw32-lib-msacm32 \
mingw32-lib-mscms \
mingw32-lib-msctf \
mingw32-lib-msctfmonitor \
mingw32-lib-msdmo \
mingw32-lib-msdrm \
mingw32-lib-mshtml \
mingw32-lib-mshtmled \
mingw32-lib-msi \
mingw32-lib-msimg32 \
mingw32-lib-msoledbsql \
mingw32-lib-mstask \
mingw32-lib-msvcp120-app \
mingw32-lib-msvcp60 \
mingw32-lib-msvcr100 \
mingw32-lib-msvcr110 \
mingw32-lib-msvcr120 \
mingw32-lib-msvcr120-app \
mingw32-lib-msvcr120d \
mingw32-lib-msvcr70 \
mingw32-lib-msvcr71 \
mingw32-lib-msvcr80 \
mingw32-lib-msvcr90 \
mingw32-lib-msvcr90d \
mingw32-lib-msvcrt \
mingw32-lib-msvcrt-os \
mingw32-lib-msvcrt10 \
mingw32-lib-msvcrt20 \
mingw32-lib-msvcrt40 \
mingw32-lib-msvfw32 \
mingw32-lib-mswsock \
mingw32-lib-ncrypt \
mingw32-lib-nddeapi \
mingw32-lib-ndfapi \
mingw32-lib-ndis \
mingw32-lib-netapi32 \
mingw32-lib-netio \
mingw32-lib-netjoin \
mingw32-lib-netutils \
mingw32-lib-newdev \
mingw32-lib-normaliz \
mingw32-lib-ntdll \
mingw32-lib-ntdllcrt \
mingw32-lib-ntdsapi \
mingw32-lib-ntmsapi \
mingw32-lib-ntoskrnl \
mingw32-lib-ntquery \
mingw32-lib-odbc32 \
mingw32-lib-odbccp32 \
mingw32-lib-ole32 \
mingw32-lib-oleacc \
mingw32-lib-oleaut32 \
mingw32-lib-olecli32 \
mingw32-lib-oledlg \
mingw32-lib-olepro32 \
mingw32-lib-olesvr32 \
mingw32-lib-olethk32 \
mingw32-lib-opends60 \
mingw32-lib-opengl32 \
mingw32-lib-p2p \
mingw32-lib-p2pcollab \
mingw32-lib-p2pgraph \
mingw32-lib-pathcch \
mingw32-lib-pcwum \
mingw32-lib-pdh \
mingw32-lib-pdhui \
mingw32-lib-penwin32 \
mingw32-lib-pkpd32 \
mingw32-lib-portabledeviceguids \
mingw32-lib-powrprof \
mingw32-lib-prntvpt \
mingw32-lib-propsys \
mingw32-lib-psapi \
mingw32-lib-quartz \
mingw32-lib-query \
mingw32-lib-qutil \
mingw32-lib-qwave \
mingw32-lib-rapi \
mingw32-lib-rasapi32 \
mingw32-lib-rasdlg \
mingw32-lib-resutil \
mingw32-lib-rpcdce4 \
mingw32-lib-rpcdiag \
mingw32-lib-rpchttp \
mingw32-lib-rpcns4 \
mingw32-lib-rpcrt4 \
mingw32-lib-rstrtmgr \
mingw32-lib-rtm \
mingw32-lib-rtutils \
mingw32-lib-runtimeobject \
mingw32-lib-samcli \
mingw32-lib-sapi \
mingw32-lib-schannel \
mingw32-lib-schedcli \
mingw32-lib-scrnsave \
mingw32-lib-scrnsavw \
mingw32-lib-scsiport \
mingw32-lib-secur32 \
mingw32-lib-security \
mingw32-lib-sensorsapi \
mingw32-lib-setupapi \
mingw32-lib-shcore \
mingw32-lib-shell32 \
mingw32-lib-shfolder \
mingw32-lib-shlwapi \
mingw32-lib-slc \
mingw32-lib-slcext \
mingw32-lib-slwga \
mingw32-lib-snmpapi \
mingw32-lib-spoolss \
mingw32-lib-srvcli \
mingw32-lib-sspicli \
mingw32-lib-strmiids \
mingw32-lib-svrapi \
mingw32-lib-sxs \
mingw32-lib-synchronization \
mingw32-lib-t2embed \
mingw32-lib-tapi32 \
mingw32-lib-taskschd \
mingw32-lib-tbs \
mingw32-lib-tdh \
mingw32-lib-tdi \
mingw32-lib-txfw32 \
mingw32-lib-ucrt \
mingw32-lib-ucrtapp \
mingw32-lib-ucrtbase \
mingw32-lib-url \
mingw32-lib-urlmon \
mingw32-lib-usbcamd \
mingw32-lib-usbcamd2 \
mingw32-lib-usbd \
mingw32-lib-usbport \
mingw32-lib-user32 \
mingw32-lib-userenv \
mingw32-lib-usp10 \
mingw32-lib-uuid \
mingw32-lib-uxtheme \
mingw32-lib-vcruntime140-app \
mingw32-lib-vdmdbg \
mingw32-lib-version \
mingw32-lib-vfw32 \
mingw32-lib-videoprt \
mingw32-lib-virtdisk \
mingw32-lib-vss-ps \
mingw32-lib-vssapi \
mingw32-lib-wbemuuid \
mingw32-lib-wdsclient \
mingw32-lib-wdsclientapi \
mingw32-lib-wdscore \
mingw32-lib-wdscsl \
mingw32-lib-wdsimage \
mingw32-lib-wdstptc \
mingw32-lib-wdsupgcompl \
mingw32-lib-wdsutil \
mingw32-lib-webauthn \
mingw32-lib-websocket \
mingw32-lib-wecapi \
mingw32-lib-wer \
mingw32-lib-wevtapi \
mingw32-lib-wevtfwd \
mingw32-lib-wiadss \
mingw32-lib-wimgapi \
mingw32-lib-win32k \
mingw32-lib-win32spl \
mingw32-lib-windowsapp \
mingw32-lib-windowscodecs \
mingw32-lib-winhttp \
mingw32-lib-wininet \
mingw32-lib-winmm \
mingw32-lib-winscard \
mingw32-lib-winspool \
mingw32-lib-winstrm \
mingw32-lib-wintrust \
mingw32-lib-winusb \
mingw32-lib-wkscli \
mingw32-lib-wlanapi \
mingw32-lib-wlanui \
mingw32-lib-wlanutil \
mingw32-lib-wldap32 \
mingw32-lib-wmcodecdspuuid \
mingw32-lib-wmilib \
mingw32-lib-wofutil \
mingw32-lib-wow32 \
mingw32-lib-ws2-32 \
mingw32-lib-wsdapi \
mingw32-lib-wsnmp32 \
mingw32-lib-wsock32 \
mingw32-lib-wst \
mingw32-lib-wtsapi32 \
mingw32-lib-x3daudio \
mingw32-lib-x3daudio1-2 \
mingw32-lib-x3daudio1-3 \
mingw32-lib-x3daudio1-4 \
mingw32-lib-x3daudio1-5 \
mingw32-lib-x3daudio1-6 \
mingw32-lib-x3daudio1-7 \
mingw32-lib-x3daudiod1-7 \
mingw32-lib-xapofx \
mingw32-lib-xapofx1-0 \
mingw32-lib-xapofx1-1 \
mingw32-lib-xapofx1-2 \
mingw32-lib-xapofx1-3 \
mingw32-lib-xapofx1-4 \
mingw32-lib-xapofx1-5 \
mingw32-lib-xapofxd1-5 \
mingw32-lib-xaudio2-8 \
mingw32-lib-xinput \
mingw32-lib-xinput1-1 \
mingw32-lib-xinput1-2 \
mingw32-lib-xinput1-3 \
mingw32-lib-xinput1-4 \
mingw32-lib-xinput9-1-0 \
mingw32-runtime"

RDEPENDS:${PN} += "mingw32-headers"

inherit rpm
