SUMMARY = "URW 'Base 35' font pack for LaTeX"
DESCRIPTION = "A set of fonts for use as 'drop-in' replacements for Adobe's \
basic set, comprising: Century Schoolbook (substituting for \
Adobe's New Century Schoolbook); Dingbats (substituting for \
Adobe's Zapf Dingbats); Nimbus Mono L (substituting for Abobe's \
Courier); Nimbus Roman No9 L (substituting for Adobe's Times); \
Nimbus Sans L (substituting for Adobe's Helvetica); Standard \
Symbols L (substituting for Adobe's Symbol); URW Bookman; URW \
Chancery L Medium Italic (substituting for Adobe's Zapf \
Chancery); URW Gothic L Book (substituting for Adobe's Avant \
Garde); and URW Palladio L (substituting for Adobe's Palatino)."
LICENSE = "GPL-2.0-or-later"

PV = "2023.201.svn61719"

RPM_NAME = "texlive-bookman-2023.201.svn61719-52.1.noarch.rpm"
RPM_HASH = "22896645e57b8b8a51fcf6835ca8bfe1bb2d7ef67344e43e04c7be29d9b781c0f7aeb88039daafe62d7fc01f7d9486e4554060d3480e74a75dab8874e8b975ed"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex(8rubk.fd) \
tex(omlubk.fd) \
tex(omsubk.fd) \
tex(ot1ubk.fd) \
tex(pbkd.tfm) \
tex(pbkd.vf) \
tex(pbkd7t.tfm) \
tex(pbkd7t.vf) \
tex(pbkd8c.tfm) \
tex(pbkd8c.vf) \
tex(pbkd8r.tfm) \
tex(pbkd8t.tfm) \
tex(pbkd8t.vf) \
tex(pbkdc.tfm) \
tex(pbkdc.vf) \
tex(pbkdc7t.tfm) \
tex(pbkdc7t.vf) \
tex(pbkdc8t.tfm) \
tex(pbkdc8t.vf) \
tex(pbkdi.tfm) \
tex(pbkdi.vf) \
tex(pbkdi7t.tfm) \
tex(pbkdi7t.vf) \
tex(pbkdi8c.tfm) \
tex(pbkdi8c.vf) \
tex(pbkdi8r.tfm) \
tex(pbkdi8t.tfm) \
tex(pbkdi8t.vf) \
tex(pbkdo.tfm) \
tex(pbkdo.vf) \
tex(pbkdo7t.tfm) \
tex(pbkdo7t.vf) \
tex(pbkdo8c.tfm) \
tex(pbkdo8c.vf) \
tex(pbkdo8r.tfm) \
tex(pbkdo8t.tfm) \
tex(pbkdo8t.vf) \
tex(pbkl.tfm) \
tex(pbkl.vf) \
tex(pbkl7t.tfm) \
tex(pbkl7t.vf) \
tex(pbkl8c.tfm) \
tex(pbkl8c.vf) \
tex(pbkl8r.tfm) \
tex(pbkl8t.tfm) \
tex(pbkl8t.vf) \
tex(pbklc.tfm) \
tex(pbklc.vf) \
tex(pbklc7t.tfm) \
tex(pbklc7t.vf) \
tex(pbklc8t.tfm) \
tex(pbklc8t.vf) \
tex(pbkli.tfm) \
tex(pbkli.vf) \
tex(pbkli7t.tfm) \
tex(pbkli7t.vf) \
tex(pbkli8c.tfm) \
tex(pbkli8c.vf) \
tex(pbkli8r.tfm) \
tex(pbkli8t.tfm) \
tex(pbkli8t.vf) \
tex(pbklo.tfm) \
tex(pbklo.vf) \
tex(pbklo7t.tfm) \
tex(pbklo7t.vf) \
tex(pbklo8c.tfm) \
tex(pbklo8c.vf) \
tex(pbklo8r.tfm) \
tex(pbklo8t.tfm) \
tex(pbklo8t.vf) \
tex(t1ubk.fd) \
tex(ts1ubk.fd) \
tex(ubk.map) \
tex(ubkb7t.tfm) \
tex(ubkb7t.vf) \
tex(ubkb8c.tfm) \
tex(ubkb8c.vf) \
tex(ubkb8r.tfm) \
tex(ubkb8t.tfm) \
tex(ubkb8t.vf) \
tex(ubkbc7t.tfm) \
tex(ubkbc7t.vf) \
tex(ubkbc8t.tfm) \
tex(ubkbc8t.vf) \
tex(ubkbi7t.tfm) \
tex(ubkbi7t.vf) \
tex(ubkbi8c.tfm) \
tex(ubkbi8c.vf) \
tex(ubkbi8r.tfm) \
tex(ubkbi8t.tfm) \
tex(ubkbi8t.vf) \
tex(ubkbo7t.tfm) \
tex(ubkbo7t.vf) \
tex(ubkbo8c.tfm) \
tex(ubkbo8c.vf) \
tex(ubkbo8r.tfm) \
tex(ubkbo8t.tfm) \
tex(ubkbo8t.vf) \
tex(ubkd7t.tfm) \
tex(ubkd7t.vf) \
tex(ubkd8c.tfm) \
tex(ubkd8c.vf) \
tex(ubkd8r.tfm) \
tex(ubkd8t.tfm) \
tex(ubkd8t.vf) \
tex(ubkdc7t.tfm) \
tex(ubkdc7t.vf) \
tex(ubkdc8t.tfm) \
tex(ubkdc8t.vf) \
tex(ubkdi7t.tfm) \
tex(ubkdi7t.vf) \
tex(ubkdi8c.tfm) \
tex(ubkdi8c.vf) \
tex(ubkdi8r.tfm) \
tex(ubkdi8t.tfm) \
tex(ubkdi8t.vf) \
tex(ubkdo7t.tfm) \
tex(ubkdo7t.vf) \
tex(ubkdo8c.tfm) \
tex(ubkdo8c.vf) \
tex(ubkdo8r.tfm) \
tex(ubkdo8t.tfm) \
tex(ubkdo8t.vf) \
tex(ubkl7t.tfm) \
tex(ubkl7t.vf) \
tex(ubkl8c.tfm) \
tex(ubkl8c.vf) \
tex(ubkl8r.tfm) \
tex(ubkl8t.tfm) \
tex(ubkl8t.vf) \
tex(ubklc7t.tfm) \
tex(ubklc7t.vf) \
tex(ubklc8t.tfm) \
tex(ubklc8t.vf) \
tex(ubkli7t.tfm) \
tex(ubkli7t.vf) \
tex(ubkli8c.tfm) \
tex(ubkli8c.vf) \
tex(ubkli8r.tfm) \
tex(ubkli8t.tfm) \
tex(ubkli8t.vf) \
tex(ubklo7t.tfm) \
tex(ubklo7t.vf) \
tex(ubklo8c.tfm) \
tex(ubklo8c.vf) \
tex(ubklo8r.tfm) \
tex(ubklo8t.tfm) \
tex(ubklo8t.vf) \
tex(ubkr7t.tfm) \
tex(ubkr7t.vf) \
tex(ubkr8c.tfm) \
tex(ubkr8c.vf) \
tex(ubkr8r.tfm) \
tex(ubkr8t.tfm) \
tex(ubkr8t.vf) \
tex(ubkrc7t.tfm) \
tex(ubkrc7t.vf) \
tex(ubkrc8t.tfm) \
tex(ubkrc8t.vf) \
tex(ubkri7t.tfm) \
tex(ubkri7t.vf) \
tex(ubkri8c.tfm) \
tex(ubkri8c.vf) \
tex(ubkri8r.tfm) \
tex(ubkri8t.tfm) \
tex(ubkri8t.vf) \
tex(ubkro7t.tfm) \
tex(ubkro7t.vf) \
tex(ubkro8c.tfm) \
tex(ubkro8c.vf) \
tex(ubkro8r.tfm) \
tex(ubkro8t.tfm) \
tex(ubkro8t.vf) \
texlive-bookman"

RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex(updmap.cfg) \
texlive \
texlive-bookman-fonts \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
