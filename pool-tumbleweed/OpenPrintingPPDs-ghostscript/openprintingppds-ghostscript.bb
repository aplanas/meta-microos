SUMMARY = "PPD files from OpenPrinting.org which use Ghostscript built-in drivers"
DESCRIPTION = "PPD files for non-PostScript printers \
which use a Ghostscript built-in driver \
and PPD files for PostScript level 1 printers \
which use the Ghostscript driver pswrite."
LICENSE = "GPL-2.0-or-later & MIT"

PV = "4.0.0.2"

RPM_NAME = "OpenPrintingPPDs-ghostscript-4.0.0.2-6.9.noarch.rpm"
RPM_HASH = "609564b030067af96a89a35637f26280759d407b31fd77fea86ebd13abff2b1f2bf0e5049a43991e34ae7ff1380a3c0e3f9b5de3df059876f371ec966d3fab3c"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "OpenPrintingPPDs-ghostscript \
postscriptdriver-apollo;apollo-p-2200; \
postscriptdriver-brother;brother-hl-1450-series; \
postscriptdriver-brother;brother-hl-1470n-series; \
postscriptdriver-brother;brother-hl-2460-series; \
postscriptdriver-brother;brother-hl-2600cn-series; \
postscriptdriver-brother;brother-hl-3260n-series; \
postscriptdriver-brother;brother-hl-3450cn-series; \
postscriptdriver-brother;brother-hl-4050cdn; \
postscriptdriver-brother;brother-hl-4070cdw; \
postscriptdriver-brother;brother-hl-5050-series; \
postscriptdriver-brother;brother-hl-5070n-series; \
postscriptdriver-brother;brother-hl-5150d-series; \
postscriptdriver-brother;brother-hl-5170dn-series; \
postscriptdriver-brother;brother-hl-7050-series; \
postscriptdriver-brother;brother-mfc-9840cdw; \
postscriptdriver-brother;hl-1050-series; \
postscriptdriver-brother;hl-1070-series; \
postscriptdriver-brother;hl-1230-series; \
postscriptdriver-brother;hl-1240-series; \
postscriptdriver-brother;hl-1250-series; \
postscriptdriver-brother;hl-1430-series; \
postscriptdriver-brother;hl-1440-series; \
postscriptdriver-brother;hl-2030-series; \
postscriptdriver-brother;hl-2040-series; \
postscriptdriver-brother;hl-2140-series; \
postscriptdriver-brother;hl-5040-series; \
postscriptdriver-brother;hl-5140-series; \
postscriptdriver-canon;bjc-1000; \
postscriptdriver-canon;bjc-2100; \
postscriptdriver-canon;bjc-210; \
postscriptdriver-canon;bjc-250; \
postscriptdriver-canon;bjc-3000; \
postscriptdriver-canon;bjc-4100; \
postscriptdriver-canon;bjc-4300; \
postscriptdriver-canon;bjc-4400; \
postscriptdriver-canon;bjc-50; \
postscriptdriver-canon;bjc-55; \
postscriptdriver-canon;bjc-80; \
postscriptdriver-canon;bjc-8200; \
postscriptdriver-canon;bjc-85; \
postscriptdriver-canon;i450; \
postscriptdriver-canon;ir3225-(ufr-ii); \
postscriptdriver-canon;lbp-1000; \
postscriptdriver-canon;multipass-c3500; \
postscriptdriver-canon;s100sp; \
postscriptdriver-canon;s600; \
postscriptdriver-dell;laser-printer-1110; \
postscriptdriver-dell;laser-printer-3000cn; \
postscriptdriver-dell;laser-printer-3100cn; \
postscriptdriver-epson;al-c1900-ps3; \
postscriptdriver-epson;al-c2000-ps3; \
postscriptdriver-epson;al-c4000-ps3; \
postscriptdriver-epson;al-c8600-ps3; \
postscriptdriver-epson;epl-5700; \
postscriptdriver-epson;epl-5900-ps3; \
postscriptdriver-epson;epl-6100-ps3; \
postscriptdriver-epson;epl-n1600; \
postscriptdriver-epson;stylus-color-1520; \
postscriptdriver-epson;stylus-color-440; \
postscriptdriver-epson;stylus-color-600; \
postscriptdriver-epson;stylus-color-670; \
postscriptdriver-epson;stylus-color-740; \
postscriptdriver-epson;stylus-color-800; \
postscriptdriver-epson;stylus-photo-750; \
postscriptdriver-gelsprinter;gx-3050n; \
postscriptdriver-gelsprinter;gx-3050sfn; \
postscriptdriver-gelsprinter;gx-5050n; \
postscriptdriver-gelsprinter;gx-e3350n; \
postscriptdriver-gelsprinter;gx-e5550n; \
postscriptdriver-gestetner;10512; \
postscriptdriver-gestetner;2212; \
postscriptdriver-gestetner;2712; \
postscriptdriver-gestetner;3212; \
postscriptdriver-gestetner;3502; \
postscriptdriver-gestetner;3532/4235g; \
postscriptdriver-gestetner;4502; \
postscriptdriver-gestetner;4532/4245g; \
postscriptdriver-gestetner;6002; \
postscriptdriver-gestetner;7502; \
postscriptdriver-gestetner;9002; \
postscriptdriver-gestetner;cs555; \
postscriptdriver-gestetner;dsc1020; \
postscriptdriver-gestetner;dsc1025; \
postscriptdriver-gestetner;dsc1030; \
postscriptdriver-gestetner;dsc1045; \
postscriptdriver-gestetner;dsc1060; \
postscriptdriver-gestetner;dsc424; \
postscriptdriver-gestetner;dsc428; \
postscriptdriver-gestetner;dsc432; \
postscriptdriver-gestetner;dsc435; \
postscriptdriver-gestetner;dsc445; \
postscriptdriver-gestetner;dsc460; \
postscriptdriver-gestetner;dsm1525; \
postscriptdriver-gestetner;dsm1530; \
postscriptdriver-gestetner;dsm1533; \
postscriptdriver-gestetner;dsm415; \
postscriptdriver-gestetner;dsm615; \
postscriptdriver-gestetner;dsm616; \
postscriptdriver-gestetner;dsm618; \
postscriptdriver-gestetner;dsm618d; \
postscriptdriver-gestetner;dsm620; \
postscriptdriver-gestetner;dsm620d; \
postscriptdriver-gestetner;dsm622; \
postscriptdriver-gestetner;dsm627; \
postscriptdriver-gestetner;dsm635/635g; \
postscriptdriver-gestetner;dsm645/645g; \
postscriptdriver-gestetner;dsm651; \
postscriptdriver-gestetner;dsm660; \
postscriptdriver-gestetner;dsm675; \
postscriptdriver-gestetner;dsm725; \
postscriptdriver-gestetner;dsm730; \
postscriptdriver-gestetner;dsm735/735g; \
postscriptdriver-gestetner;dsm745/745g; \
postscriptdriver-gestetner;mp-161/dsm416; \
postscriptdriver-gestetner;mp-171; \
postscriptdriver-gestetner;mp-2001; \
postscriptdriver-gestetner;mp-2501; \
postscriptdriver-gestetner;mp-2510/dsm725e; \
postscriptdriver-gestetner;mp-2550; \
postscriptdriver-gestetner;mp-2550b; \
postscriptdriver-gestetner;mp-2553; \
postscriptdriver-gestetner;mp-2851; \
postscriptdriver-gestetner;mp-3010/dsm730e; \
postscriptdriver-gestetner;mp-3053; \
postscriptdriver-gestetner;mp-3350; \
postscriptdriver-gestetner;mp-3350b; \
postscriptdriver-gestetner;mp-3351; \
postscriptdriver-gestetner;mp-3353; \
postscriptdriver-gestetner;mp-4000; \
postscriptdriver-gestetner;mp-4000b; \
postscriptdriver-gestetner;mp-4001; \
postscriptdriver-gestetner;mp-4002; \
postscriptdriver-gestetner;mp-5000; \
postscriptdriver-gestetner;mp-5000b; \
postscriptdriver-gestetner;mp-5001; \
postscriptdriver-gestetner;mp-5002; \
postscriptdriver-gestetner;mp-6000; \
postscriptdriver-gestetner;mp-6001; \
postscriptdriver-gestetner;mp-6002; \
postscriptdriver-gestetner;mp-7000; \
postscriptdriver-gestetner;mp-7001; \
postscriptdriver-gestetner;mp-7502; \
postscriptdriver-gestetner;mp-8000; \
postscriptdriver-gestetner;mp-8001; \
postscriptdriver-gestetner;mp-9001; \
postscriptdriver-gestetner;mp-9002; \
postscriptdriver-gestetner;mp-c2003; \
postscriptdriver-gestetner;mp-c2050; \
postscriptdriver-gestetner;mp-c2051; \
postscriptdriver-gestetner;mp-c2503; \
postscriptdriver-gestetner;mp-c2550; \
postscriptdriver-gestetner;mp-c2551; \
postscriptdriver-gestetner;mp-c2800; \
postscriptdriver-gestetner;mp-c3001; \
postscriptdriver-gestetner;mp-c3002; \
postscriptdriver-gestetner;mp-c3003; \
postscriptdriver-gestetner;mp-c300; \
postscriptdriver-gestetner;mp-c300sr; \
postscriptdriver-gestetner;mp-c3300; \
postscriptdriver-gestetner;mp-c3501; \
postscriptdriver-gestetner;mp-c3502; \
postscriptdriver-gestetner;mp-c3503; \
postscriptdriver-gestetner;mp-c4000; \
postscriptdriver-gestetner;mp-c400; \
postscriptdriver-gestetner;mp-c400sr; \
postscriptdriver-gestetner;mp-c4501; \
postscriptdriver-gestetner;mp-c4501a; \
postscriptdriver-gestetner;mp-c4502; \
postscriptdriver-gestetner;mp-c4502a; \
postscriptdriver-gestetner;mp-c4503; \
postscriptdriver-gestetner;mp-c5000; \
postscriptdriver-gestetner;mp-c5501; \
postscriptdriver-gestetner;mp-c5501a; \
postscriptdriver-gestetner;mp-c5502; \
postscriptdriver-gestetner;mp-c5502a; \
postscriptdriver-gestetner;mp-c5503; \
postscriptdriver-gestetner;mp-c6000; \
postscriptdriver-gestetner;mp-c6003; \
postscriptdriver-gestetner;mp-c6501; \
postscriptdriver-gestetner;mp-c6502; \
postscriptdriver-gestetner;mp-c7500; \
postscriptdriver-gestetner;mp-c7501; \
postscriptdriver-gestetner;mp-c8002; \
postscriptdriver-gestetner;mp1100/dsm7110; \
postscriptdriver-gestetner;mp1350/dsm7135; \
postscriptdriver-gestetner;mp1600/dsm716; \
postscriptdriver-gestetner;mp2000/dsm721d; \
postscriptdriver-gestetner;mp2352/dsm923; \
postscriptdriver-gestetner;mp2500/dsm625; \
postscriptdriver-gestetner;mp2852/dsm928; \
postscriptdriver-gestetner;mp3352/dsm933; \
postscriptdriver-gestetner;mp3500/dsm735e; \
postscriptdriver-gestetner;mp4500/dsm745e; \
postscriptdriver-gestetner;mp5500/dsm755; \
postscriptdriver-gestetner;mp6500/dsm765; \
postscriptdriver-gestetner;mp7500/dsm775; \
postscriptdriver-gestetner;mp9000/dsm790; \
postscriptdriver-gestetner;mpc1500/gs106; \
postscriptdriver-gestetner;mpc2500/dsc525; \
postscriptdriver-gestetner;mpc3000/dsc530; \
postscriptdriver-gestetner;mpc3500/dsc535; \
postscriptdriver-gestetner;mpc4500/dsc545; \
postscriptdriver-gestetner;pro-1106ex; \
postscriptdriver-gestetner;pro-1107ex; \
postscriptdriver-gestetner;pro-1356ex; \
postscriptdriver-gestetner;pro-1357ex; \
postscriptdriver-gestetner;pro-906ex; \
postscriptdriver-gestetner;pro-907ex; \
postscriptdriver-hewlett-packard;deskjet-1120c; \
postscriptdriver-hewlett-packard;deskjet-1220c; \
postscriptdriver-hewlett-packard;deskjet-350; \
postscriptdriver-hewlett-packard;deskjet-540; \
postscriptdriver-hewlett-packard;deskjet-600; \
postscriptdriver-hewlett-packard;deskjet-610c; \
postscriptdriver-hewlett-packard;deskjet-660c; \
postscriptdriver-hewlett-packard;deskjet-670c; \
postscriptdriver-hewlett-packard;deskjet-690c; \
postscriptdriver-hewlett-packard;deskjet-810c; \
postscriptdriver-hewlett-packard;deskjet-840c; \
postscriptdriver-hewlett-packard;deskjet-845c; \
postscriptdriver-hewlett-packard;deskjet-850c; \
postscriptdriver-hewlett-packard;deskjet-870c; \
postscriptdriver-hewlett-packard;deskjet-880c; \
postscriptdriver-hewlett-packard;deskjet-890c; \
postscriptdriver-hewlett-packard;deskjet-895c; \
postscriptdriver-hewlett-packard;deskjet-930c; \
postscriptdriver-hewlett-packard;deskjet-940c; \
postscriptdriver-hewlett-packard;deskjet-950c; \
postscriptdriver-hewlett-packard;deskjet-960c; \
postscriptdriver-hewlett-packard;deskjet-970c; \
postscriptdriver-hewlett-packard;deskjet-980c; \
postscriptdriver-hewlett-packard;deskjet-990c; \
postscriptdriver-hewlett-packard;hp-2000c; \
postscriptdriver-hewlett-packard;hp-business-inkjet-2200; \
postscriptdriver-hewlett-packard;hp-color-laserjet-2500; \
postscriptdriver-hewlett-packard;hp-color-laserjet-4550; \
postscriptdriver-hewlett-packard;hp-color-laserjet-4600; \
postscriptdriver-hewlett-packard;hp-deskjet-340; \
postscriptdriver-hewlett-packard;hp-deskjet-400; \
postscriptdriver-hewlett-packard;hp-laserjet-1015; \
postscriptdriver-hewlett-packard;hp-laserjet-1100; \
postscriptdriver-hewlett-packard;hp-laserjet-1150; \
postscriptdriver-hewlett-packard;hp-laserjet-1200; \
postscriptdriver-hewlett-packard;hp-laserjet-1220; \
postscriptdriver-hewlett-packard;hp-laserjet-1300; \
postscriptdriver-hewlett-packard;hp-laserjet-1320-series; \
postscriptdriver-hewlett-packard;hp-laserjet-2100-series; \
postscriptdriver-hewlett-packard;hp-laserjet-2200; \
postscriptdriver-hewlett-packard;hp-laserjet-2300-series; \
postscriptdriver-hewlett-packard;hp-laserjet-3200; \
postscriptdriver-hewlett-packard;hp-laserjet-3200m; \
postscriptdriver-hewlett-packard;hp-laserjet-3300/3310/3320; \
postscriptdriver-hewlett-packard;hp-laserjet-3330; \
postscriptdriver-hewlett-packard;hp-laserjet-3390; \
postscriptdriver-hewlett-packard;hp-laserjet-4-plus; \
postscriptdriver-hewlett-packard;hp-laserjet-4000-series; \
postscriptdriver-hewlett-packard;hp-laserjet-4050-series; \
postscriptdriver-hewlett-packard;hp-laserjet-4100-series; \
postscriptdriver-hewlett-packard;hp-laserjet-4200; \
postscriptdriver-hewlett-packard;hp-laserjet-4300; \
postscriptdriver-hewlett-packard;hp-laserjet-4350; \
postscriptdriver-hewlett-packard;hp-laserjet-5100-series; \
postscriptdriver-hewlett-packard;hp-laserjet-5l; \
postscriptdriver-hewlett-packard;hp-laserjet-5p; \
postscriptdriver-hewlett-packard;hp-laserjet-5si; \
postscriptdriver-hewlett-packard;hp-laserjet-6l; \
postscriptdriver-hewlett-packard;hp-laserjet-6p; \
postscriptdriver-hewlett-packard;hp-laserjet-8150-series; \
postscriptdriver-hewlett-packard;laserjet-4l; \
postscriptdriver-hewlett-packard;laserjet-color-4500; \
postscriptdriver-hewlett-packard;officejet-g55; \
postscriptdriver-hewlett-packard;officejet-g85; \
postscriptdriver-hewlett-packard;officejet-g95; \
postscriptdriver-hewlett-packard;officejet-pro-1150c; \
postscriptdriver-hewlett-packard;officejet-pro-1170c-series; \
postscriptdriver-hewlett-packard;officejet-r40; \
postscriptdriver-hewlett-packard;officejet-series-300; \
postscriptdriver-hewlett-packard;officejet-series-500; \
postscriptdriver-hewlett-packard;officejet-series-600; \
postscriptdriver-hewlett-packard;officejet-t-series; \
postscriptdriver-hewlett-packard;officejet; \
postscriptdriver-hewlett-packard;photosmart-p1000; \
postscriptdriver-hewlett-packard;photosmart-p1100; \
postscriptdriver-hewlett-packard;psc-500; \
postscriptdriver-hp;photosmart-100; \
postscriptdriver-hp;photosmart-1115; \
postscriptdriver-hp;photosmart-1218; \
postscriptdriver-hp;photosmart-1315; \
postscriptdriver-ibm;infoprint; \
postscriptdriver-infoprint;pro-1107ex; \
postscriptdriver-infoprint;pro-1357ex; \
postscriptdriver-infoprint;pro-907ex; \
postscriptdriver-infotec;4353-mf; \
postscriptdriver-infotec;4452-mf; \
postscriptdriver-infotec;is-2015; \
postscriptdriver-infotec;is-2018; \
postscriptdriver-infotec;is-2018d; \
postscriptdriver-infotec;is-2060; \
postscriptdriver-infotec;is-2075; \
postscriptdriver-infotec;is-2122; \
postscriptdriver-infotec;is-2127; \
postscriptdriver-infotec;is-2132; \
postscriptdriver-infotec;is-2135; \
postscriptdriver-infotec;is-2145; \
postscriptdriver-infotec;is-2151; \
postscriptdriver-infotec;is-2160; \
postscriptdriver-infotec;is-2175; \
postscriptdriver-infotec;is-2215; \
postscriptdriver-infotec;is-2216; \
postscriptdriver-infotec;is-2220; \
postscriptdriver-infotec;is-2220d; \
postscriptdriver-infotec;is-2225; \
postscriptdriver-infotec;is-2230; \
postscriptdriver-infotec;is-2235; \
postscriptdriver-infotec;is-2245; \
postscriptdriver-infotec;is-2255; \
postscriptdriver-infotec;is-2265; \
postscriptdriver-infotec;is-2275; \
postscriptdriver-infotec;is-2316; \
postscriptdriver-infotec;is-2320; \
postscriptdriver-infotec;is-2325; \
postscriptdriver-infotec;is-2416; \
postscriptdriver-infotec;is-2425; \
postscriptdriver-infotec;is-2430; \
postscriptdriver-infotec;is-2435; \
postscriptdriver-infotec;is-2445; \
postscriptdriver-infotec;is-3090; \
postscriptdriver-infotec;is-3110; \
postscriptdriver-infotec;is-3135; \
postscriptdriver-infotec;is2022; \
postscriptdriver-infotec;is2027; \
postscriptdriver-infotec;is2032; \
postscriptdriver-infotec;is2035; \
postscriptdriver-infotec;is2045; \
postscriptdriver-infotec;is2090; \
postscriptdriver-infotec;is2105; \
postscriptdriver-infotec;isc-1024c; \
postscriptdriver-infotec;isc-1032c; \
postscriptdriver-infotec;isc-2428; \
postscriptdriver-infotec;isc-2525; \
postscriptdriver-infotec;isc-2835; \
postscriptdriver-infotec;isc-3030; \
postscriptdriver-infotec;isc-3535; \
postscriptdriver-infotec;isc-3545; \
postscriptdriver-infotec;isc-4045; \
postscriptdriver-infotec;isc-4560; \
postscriptdriver-infotec;isc-5560; \
postscriptdriver-infotec;isc-615g; \
postscriptdriver-infotec;mp-171; \
postscriptdriver-infotec;mp-2001; \
postscriptdriver-infotec;mp-201; \
postscriptdriver-infotec;mp-2352; \
postscriptdriver-infotec;mp-2501; \
postscriptdriver-infotec;mp-2550; \
postscriptdriver-infotec;mp-2550b; \
postscriptdriver-infotec;mp-2553; \
postscriptdriver-infotec;mp-2851; \
postscriptdriver-infotec;mp-2852; \
postscriptdriver-infotec;mp-3053; \
postscriptdriver-infotec;mp-3350; \
postscriptdriver-infotec;mp-3350b; \
postscriptdriver-infotec;mp-3351; \
postscriptdriver-infotec;mp-3352; \
postscriptdriver-infotec;mp-3353; \
postscriptdriver-infotec;mp-4000; \
postscriptdriver-infotec;mp-4000b; \
postscriptdriver-infotec;mp-4001; \
postscriptdriver-infotec;mp-4002; \
postscriptdriver-infotec;mp-5000; \
postscriptdriver-infotec;mp-5000b; \
postscriptdriver-infotec;mp-5001; \
postscriptdriver-infotec;mp-5002; \
postscriptdriver-infotec;mp-6000; \
postscriptdriver-infotec;mp-6001; \
postscriptdriver-infotec;mp-6002; \
postscriptdriver-infotec;mp-7000; \
postscriptdriver-infotec;mp-7001; \
postscriptdriver-infotec;mp-7502; \
postscriptdriver-infotec;mp-8000; \
postscriptdriver-infotec;mp-8001; \
postscriptdriver-infotec;mp-9001; \
postscriptdriver-infotec;mp-9002; \
postscriptdriver-infotec;mp-c2003; \
postscriptdriver-infotec;mp-c2003z; \
postscriptdriver-infotec;mp-c2050; \
postscriptdriver-infotec;mp-c2051; \
postscriptdriver-infotec;mp-c2503; \
postscriptdriver-infotec;mp-c2503z; \
postscriptdriver-infotec;mp-c2550; \
postscriptdriver-infotec;mp-c2551; \
postscriptdriver-infotec;mp-c2800; \
postscriptdriver-infotec;mp-c3001; \
postscriptdriver-infotec;mp-c3002; \
postscriptdriver-infotec;mp-c3003; \
postscriptdriver-infotec;mp-c300; \
postscriptdriver-infotec;mp-c300sr; \
postscriptdriver-infotec;mp-c3300; \
postscriptdriver-infotec;mp-c3501; \
postscriptdriver-infotec;mp-c3502; \
postscriptdriver-infotec;mp-c3503; \
postscriptdriver-infotec;mp-c4000; \
postscriptdriver-infotec;mp-c400; \
postscriptdriver-infotec;mp-c400sr; \
postscriptdriver-infotec;mp-c4501; \
postscriptdriver-infotec;mp-c4501a; \
postscriptdriver-infotec;mp-c4502; \
postscriptdriver-infotec;mp-c4502a; \
postscriptdriver-infotec;mp-c4503; \
postscriptdriver-infotec;mp-c5000; \
postscriptdriver-infotec;mp-c5501; \
postscriptdriver-infotec;mp-c5501a; \
postscriptdriver-infotec;mp-c5502; \
postscriptdriver-infotec;mp-c5502a; \
postscriptdriver-infotec;mp-c5503; \
postscriptdriver-infotec;mp-c6000; \
postscriptdriver-infotec;mp-c6003; \
postscriptdriver-infotec;mp-c6501; \
postscriptdriver-infotec;mp-c6502; \
postscriptdriver-infotec;mp-c7500; \
postscriptdriver-infotec;mp-c7501; \
postscriptdriver-infotec;mp-c8002; \
postscriptdriver-infotec;pro-1106ex; \
postscriptdriver-infotec;pro-1107ex; \
postscriptdriver-infotec;pro-1356ex; \
postscriptdriver-infotec;pro-1357ex; \
postscriptdriver-infotec;pro-8100s; \
postscriptdriver-infotec;pro-8110s; \
postscriptdriver-infotec;pro-8120s; \
postscriptdriver-infotec;pro-906ex; \
postscriptdriver-infotec;pro-907ex; \
postscriptdriver-infotec;pro-c5100s; \
postscriptdriver-infotec;pro-c5110s; \
postscriptdriver-kyocera-mita;km-1510; \
postscriptdriver-kyocera-mita;km-1530; \
postscriptdriver-kyocera-mita;km-1810; \
postscriptdriver-kyocera-mita;km-2030; \
postscriptdriver-kyocera-mita;km-2530; \
postscriptdriver-kyocera-mita;km-3530; \
postscriptdriver-kyocera-mita;km-4230/5230; \
postscriptdriver-kyocera-mita;km-4230; \
postscriptdriver-kyocera-mita;km-4530; \
postscriptdriver-kyocera-mita;km-5230; \
postscriptdriver-kyocera-mita;km-5530; \
postscriptdriver-kyocera-mita;km-6230; \
postscriptdriver-kyocera-mita;km-c2630; \
postscriptdriver-kyocera-mita;km-c830; \
postscriptdriver-kyocera-mita;km-c850; \
postscriptdriver-kyocera-mita;kyocera-mita-ci-1100; \
postscriptdriver-kyocera-mita;kyocera-mita-cs-1815; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-1000+; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-1010; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-1018mfp; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-1050; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-1800+; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-1800; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-1900; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-1920; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-3800; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-3820n; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-3830n; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-6020; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-6026; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-6750; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-8000c; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-9100dn; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-9500dn; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-c5016n; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-c8008n; \
postscriptdriver-kyocera-mita;kyocera-mita-km-1815; \
postscriptdriver-kyocera;f-1000; \
postscriptdriver-kyocera;f-1010; \
postscriptdriver-kyocera;f-1200; \
postscriptdriver-kyocera;f-1200s; \
postscriptdriver-kyocera;f-1800; \
postscriptdriver-kyocera;f-2000; \
postscriptdriver-kyocera;f-2010; \
postscriptdriver-kyocera;f-2200; \
postscriptdriver-kyocera;f-2200s; \
postscriptdriver-kyocera;f-3000; \
postscriptdriver-kyocera;f-3010; \
postscriptdriver-kyocera;f-3300; \
postscriptdriver-kyocera;f-5000; \
postscriptdriver-kyocera;f-800; \
postscriptdriver-kyocera;f-800t; \
postscriptdriver-kyocera;f-820; \
postscriptdriver-kyocera;fs-1020d; \
postscriptdriver-kyocera;fs-1500; \
postscriptdriver-kyocera;fs-1550+; \
postscriptdriver-kyocera;fs-1550; \
postscriptdriver-kyocera;fs-1600+; \
postscriptdriver-kyocera;fs-1600; \
postscriptdriver-kyocera;fs-3400+; \
postscriptdriver-kyocera;fs-3400; \
postscriptdriver-kyocera;fs-3500; \
postscriptdriver-kyocera;fs-3600+; \
postscriptdriver-kyocera;fs-3600; \
postscriptdriver-kyocera;fs-400; \
postscriptdriver-kyocera;fs-5500; \
postscriptdriver-kyocera;fs-600; \
postscriptdriver-kyocera;fs-6500; \
postscriptdriver-kyocera;fs-850; \
postscriptdriver-kyocera;kyocera-cs-250ci; \
postscriptdriver-kyocera;kyocera-cs-300ci; \
postscriptdriver-kyocera;kyocera-cs-3050ci; \
postscriptdriver-kyocera;kyocera-cs-3550ci; \
postscriptdriver-kyocera;kyocera-cs-400ci; \
postscriptdriver-kyocera;kyocera-cs-500ci; \
postscriptdriver-kyocera;kyocera-cs-c2525e; \
postscriptdriver-kyocera;kyocera-cs-c3225e; \
postscriptdriver-kyocera;kyocera-cs-c3232e; \
postscriptdriver-kyocera;kyocera-cs-c4035e; \
postscriptdriver-kyocera;kyocera-fs-1000; \
postscriptdriver-kyocera;kyocera-fs-1030d; \
postscriptdriver-kyocera;kyocera-fs-1118mfp; \
postscriptdriver-kyocera;kyocera-fs-1200; \
postscriptdriver-kyocera;kyocera-fs-1700+; \
postscriptdriver-kyocera;kyocera-fs-1700; \
postscriptdriver-kyocera;kyocera-fs-1714m; \
postscriptdriver-kyocera;kyocera-fs-1750; \
postscriptdriver-kyocera;kyocera-fs-2000d; \
postscriptdriver-kyocera;kyocera-fs-2100d; \
postscriptdriver-kyocera;kyocera-fs-2100dn; \
postscriptdriver-kyocera;kyocera-fs-3700+; \
postscriptdriver-kyocera;kyocera-fs-3700; \
postscriptdriver-kyocera;kyocera-fs-3718m; \
postscriptdriver-kyocera;kyocera-fs-3750; \
postscriptdriver-kyocera;kyocera-fs-3900dn; \
postscriptdriver-kyocera;kyocera-fs-4000dn; \
postscriptdriver-kyocera;kyocera-fs-4100dn; \
postscriptdriver-kyocera;kyocera-fs-4200dn; \
postscriptdriver-kyocera;kyocera-fs-4300dn; \
postscriptdriver-kyocera;kyocera-fs-5800c; \
postscriptdriver-kyocera;kyocera-fs-5900c; \
postscriptdriver-kyocera;kyocera-fs-600; \
postscriptdriver-kyocera;kyocera-fs-6300; \
postscriptdriver-kyocera;kyocera-fs-6500+; \
postscriptdriver-kyocera;kyocera-fs-6700; \
postscriptdriver-kyocera;kyocera-fs-680; \
postscriptdriver-kyocera;kyocera-fs-6900; \
postscriptdriver-kyocera;kyocera-fs-6950dn; \
postscriptdriver-kyocera;kyocera-fs-7000+; \
postscriptdriver-kyocera;kyocera-fs-7000; \
postscriptdriver-kyocera;kyocera-fs-7028m; \
postscriptdriver-kyocera;kyocera-fs-800; \
postscriptdriver-kyocera;kyocera-fs-9000; \
postscriptdriver-kyocera;kyocera-fs-9130dn; \
postscriptdriver-kyocera;kyocera-fs-920; \
postscriptdriver-kyocera;kyocera-fs-9530dn; \
postscriptdriver-kyocera;kyocera-fs-c5015n; \
postscriptdriver-kyocera;kyocera-fs-c5020n; \
postscriptdriver-kyocera;kyocera-fs-c5025n; \
postscriptdriver-kyocera;kyocera-fs-c5030n; \
postscriptdriver-kyocera;kyocera-fs-c5100dn; \
postscriptdriver-kyocera;kyocera-fs-c5200dn; \
postscriptdriver-kyocera;kyocera-fs-c5300dn; \
postscriptdriver-kyocera;kyocera-fs-c5350dn; \
postscriptdriver-kyocera;kyocera-fs-c5400dn; \
postscriptdriver-kyocera;kyocera-fs-c8100dn+; \
postscriptdriver-kyocera;kyocera-fs-c8100dn; \
postscriptdriver-kyocera;kyocera-km-1820; \
postscriptdriver-kyocera;kyocera-km-3050; \
postscriptdriver-kyocera;kyocera-km-4050; \
postscriptdriver-kyocera;kyocera-km-5050; \
postscriptdriver-kyocera;kyocera-km-6030; \
postscriptdriver-kyocera;kyocera-km-8030; \
postscriptdriver-kyocera;kyocera-km-c2520; \
postscriptdriver-kyocera;kyocera-km-c2525e; \
postscriptdriver-kyocera;kyocera-km-c3225; \
postscriptdriver-kyocera;kyocera-km-c3225e; \
postscriptdriver-kyocera;kyocera-km-c3232; \
postscriptdriver-kyocera;kyocera-km-c3232e; \
postscriptdriver-kyocera;kyocera-km-c4035e; \
postscriptdriver-kyocera;kyocera-taskalfa-250ci; \
postscriptdriver-kyocera;kyocera-taskalfa-300ci; \
postscriptdriver-kyocera;kyocera-taskalfa-400ci; \
postscriptdriver-kyocera;kyocera-taskalfa-500ci; \
postscriptdriver-kyocera;p-2000; \
postscriptdriver-kyocera;p-2002; \
postscriptdriver-lanier;5622; \
postscriptdriver-lanier;5627; \
postscriptdriver-lanier;5632; \
postscriptdriver-lanier;5635; \
postscriptdriver-lanier;5645; \
postscriptdriver-lanier;lc155; \
postscriptdriver-lanier;ld-130c; \
postscriptdriver-lanier;ld-130csr; \
postscriptdriver-lanier;ld-140c; \
postscriptdriver-lanier;ld-140csr; \
postscriptdriver-lanier;ld-620c; \
postscriptdriver-lanier;ld-625c; \
postscriptdriver-lanier;ld0105; \
postscriptdriver-lanier;ld015; \
postscriptdriver-lanier;ld035; \
postscriptdriver-lanier;ld045; \
postscriptdriver-lanier;ld060; \
postscriptdriver-lanier;ld075; \
postscriptdriver-lanier;ld090; \
postscriptdriver-lanier;ld115; \
postscriptdriver-lanier;ld116; \
postscriptdriver-lanier;ld118; \
postscriptdriver-lanier;ld118d; \
postscriptdriver-lanier;ld120; \
postscriptdriver-lanier;ld120d; \
postscriptdriver-lanier;ld122; \
postscriptdriver-lanier;ld124c; \
postscriptdriver-lanier;ld127; \
postscriptdriver-lanier;ld132; \
postscriptdriver-lanier;ld132c; \
postscriptdriver-lanier;ld135; \
postscriptdriver-lanier;ld145; \
postscriptdriver-lanier;ld151; \
postscriptdriver-lanier;ld160; \
postscriptdriver-lanier;ld160c; \
postscriptdriver-lanier;ld175; \
postscriptdriver-lanier;ld225; \
postscriptdriver-lanier;ld230; \
postscriptdriver-lanier;ld235; \
postscriptdriver-lanier;ld245; \
postscriptdriver-lanier;ld328c; \
postscriptdriver-lanier;ld335c; \
postscriptdriver-lanier;ld345c; \
postscriptdriver-lanier;mp-1100/ld1100; \
postscriptdriver-lanier;mp-1350/ld1135; \
postscriptdriver-lanier;mp-1600/ld316; \
postscriptdriver-lanier;mp-161/ld016; \
postscriptdriver-lanier;mp-171/ld-117; \
postscriptdriver-lanier;mp-2000/ld320d; \
postscriptdriver-lanier;mp-2001; \
postscriptdriver-lanier;mp-201/ld-220; \
postscriptdriver-lanier;mp-2352; \
postscriptdriver-lanier;mp-2501; \
postscriptdriver-lanier;mp-2510/ld325; \
postscriptdriver-lanier;mp-2550/ld425; \
postscriptdriver-lanier;mp-2550b/ld425b; \
postscriptdriver-lanier;mp-2553; \
postscriptdriver-lanier;mp-2851/ld528; \
postscriptdriver-lanier;mp-2852; \
postscriptdriver-lanier;mp-3010/ld330; \
postscriptdriver-lanier;mp-3053; \
postscriptdriver-lanier;mp-3350/ld433; \
postscriptdriver-lanier;mp-3350b/ld433b; \
postscriptdriver-lanier;mp-3351/ld533; \
postscriptdriver-lanier;mp-3352; \
postscriptdriver-lanier;mp-3353; \
postscriptdriver-lanier;mp-3500/ld335; \
postscriptdriver-lanier;mp-4000/ld040; \
postscriptdriver-lanier;mp-4000b/ld040b; \
postscriptdriver-lanier;mp-4001/ld140; \
postscriptdriver-lanier;mp-4002; \
postscriptdriver-lanier;mp-4500/ld345; \
postscriptdriver-lanier;mp-5000/ld050; \
postscriptdriver-lanier;mp-5000b/ld050b; \
postscriptdriver-lanier;mp-5001/ld150; \
postscriptdriver-lanier;mp-5002; \
postscriptdriver-lanier;mp-5500/ld255; \
postscriptdriver-lanier;mp-6000/ld260; \
postscriptdriver-lanier;mp-6001/ld360; \
postscriptdriver-lanier;mp-6002; \
postscriptdriver-lanier;mp-6500/ld265; \
postscriptdriver-lanier;mp-7000/ld270; \
postscriptdriver-lanier;mp-7001/ld370; \
postscriptdriver-lanier;mp-7500/ld275; \
postscriptdriver-lanier;mp-7502; \
postscriptdriver-lanier;mp-8000/ld280; \
postscriptdriver-lanier;mp-8001/ld380; \
postscriptdriver-lanier;mp-9000/ld190; \
postscriptdriver-lanier;mp-9001/ld390; \
postscriptdriver-lanier;mp-9002; \
postscriptdriver-lanier;mp-c2003; \
postscriptdriver-lanier;mp-c2050/ld520c; \
postscriptdriver-lanier;mp-c2500/ld425c; \
postscriptdriver-lanier;mp-c2503; \
postscriptdriver-lanier;mp-c2550/ld525c; \
postscriptdriver-lanier;mp-c2800/ld528c; \
postscriptdriver-lanier;mp-c3000/ld430c; \
postscriptdriver-lanier;mp-c3001/ld630c; \
postscriptdriver-lanier;mp-c3002; \
postscriptdriver-lanier;mp-c3003; \
postscriptdriver-lanier;mp-c300; \
postscriptdriver-lanier;mp-c300sr; \
postscriptdriver-lanier;mp-c3300/ld533c; \
postscriptdriver-lanier;mp-c3500/ld435c; \
postscriptdriver-lanier;mp-c3501/ld635c; \
postscriptdriver-lanier;mp-c3502; \
postscriptdriver-lanier;mp-c3503; \
postscriptdriver-lanier;mp-c4000/ld540c; \
postscriptdriver-lanier;mp-c400; \
postscriptdriver-lanier;mp-c400sr; \
postscriptdriver-lanier;mp-c4500/ld445c; \
postscriptdriver-lanier;mp-c4501/ld645c; \
postscriptdriver-lanier;mp-c4502; \
postscriptdriver-lanier;mp-c4502a; \
postscriptdriver-lanier;mp-c4503; \
postscriptdriver-lanier;mp-c5000/ld550c; \
postscriptdriver-lanier;mp-c5501/ld655c; \
postscriptdriver-lanier;mp-c5502; \
postscriptdriver-lanier;mp-c5502a; \
postscriptdriver-lanier;mp-c5503; \
postscriptdriver-lanier;mp-c6000/ld260c; \
postscriptdriver-lanier;mp-c6003; \
postscriptdriver-lanier;mp-c6501/ld365c; \
postscriptdriver-lanier;mp-c6502; \
postscriptdriver-lanier;mp-c7500/ld275c; \
postscriptdriver-lanier;mp-c7501/ld375c; \
postscriptdriver-lanier;mp-c8002; \
postscriptdriver-lanier;mp2500/ld125; \
postscriptdriver-lanier;mpc1500/ld215c; \
postscriptdriver-lanier;mpc4501a/ld645ca; \
postscriptdriver-lanier;mpc5501a/ld655ca; \
postscriptdriver-lanier;pro-1106ex; \
postscriptdriver-lanier;pro-1107ex; \
postscriptdriver-lanier;pro-1356ex; \
postscriptdriver-lanier;pro-1357ex; \
postscriptdriver-lanier;pro-8100s; \
postscriptdriver-lanier;pro-8110s; \
postscriptdriver-lanier;pro-8120s; \
postscriptdriver-lanier;pro-906ex; \
postscriptdriver-lanier;pro-907ex; \
postscriptdriver-lanier;pro-c5100s; \
postscriptdriver-lanier;pro-c5110s; \
postscriptdriver-lanier;sg3110dn; \
postscriptdriver-lanier;sg3110dnw; \
postscriptdriver-lanier;sg3110sfnw; \
postscriptdriver-lexmark-international;ibm-3112-page-printer; \
postscriptdriver-lexmark-international;lexmark-e120; \
postscriptdriver-lexmark-international;lexmark-e120n; \
postscriptdriver-lexmark-international;lexmark-e230; \
postscriptdriver-lexmark-international;lexmark-e238; \
postscriptdriver-lexmark-international;lexmark-e321; \
postscriptdriver-lexmark-international;lexmark-e350d; \
postscriptdriver-lexmark-international;lexmark-e352dn; \
postscriptdriver-lexmark-international;lexmark-optra-e+-laserprinter; \
postscriptdriver-lexmark;e210; \
postscriptdriver-lexmark;lexmark-3000-color-jetprinter; \
postscriptdriver-lexmark;lexmark-3200; \
postscriptdriver-lexmark;lexmark-5700; \
postscriptdriver-lexmark;lexmark-z22-z32; \
postscriptdriver-minolta;pagepro---6e; \
postscriptdriver-minolta;pagepro-1100; \
postscriptdriver-minolta;pagepro-6; \
postscriptdriver-minolta;pagepro-8; \
postscriptdriver-minolta;pagepro-8l; \
postscriptdriver-nec;superscript-1800; \
postscriptdriver-nec;superscript-870; \
postscriptdriver-nrg;10515/10518/10512; \
postscriptdriver-nrg;2205/2238/2212; \
postscriptdriver-nrg;2705/2738/2712; \
postscriptdriver-nrg;3205/3238/3212; \
postscriptdriver-nrg;3525/3508/3502; \
postscriptdriver-nrg;3545/3518/3532; \
postscriptdriver-nrg;4525/4508/4502; \
postscriptdriver-nrg;4545/4518/4532; \
postscriptdriver-nrg;6002/6005/6008; \
postscriptdriver-nrg;7502/7505/7508; \
postscriptdriver-nrg;9005/9008/9002; \
postscriptdriver-nrg;cs555; \
postscriptdriver-nrg;dsc424; \
postscriptdriver-nrg;dsc428; \
postscriptdriver-nrg;dsc432; \
postscriptdriver-nrg;dsc435; \
postscriptdriver-nrg;dsc445; \
postscriptdriver-nrg;dsc460; \
postscriptdriver-nrg;dsm415; \
postscriptdriver-nrg;dsm615; \
postscriptdriver-nrg;dsm616; \
postscriptdriver-nrg;dsm618; \
postscriptdriver-nrg;dsm618d; \
postscriptdriver-nrg;dsm620; \
postscriptdriver-nrg;dsm620d; \
postscriptdriver-nrg;dsm622; \
postscriptdriver-nrg;dsm627; \
postscriptdriver-nrg;dsm632; \
postscriptdriver-nrg;dsm635; \
postscriptdriver-nrg;dsm645; \
postscriptdriver-nrg;dsm651; \
postscriptdriver-nrg;dsm660; \
postscriptdriver-nrg;dsm675; \
postscriptdriver-nrg;dsm725; \
postscriptdriver-nrg;dsm730; \
postscriptdriver-nrg;dsm735; \
postscriptdriver-nrg;dsm745; \
postscriptdriver-nrg;mp-1100; \
postscriptdriver-nrg;mp-1350; \
postscriptdriver-nrg;mp-1600; \
postscriptdriver-nrg;mp-161; \
postscriptdriver-nrg;mp-171; \
postscriptdriver-nrg;mp-2000; \
postscriptdriver-nrg;mp-2001; \
postscriptdriver-nrg;mp-201; \
postscriptdriver-nrg;mp-2352; \
postscriptdriver-nrg;mp-2500; \
postscriptdriver-nrg;mp-2501; \
postscriptdriver-nrg;mp-2510; \
postscriptdriver-nrg;mp-2550; \
postscriptdriver-nrg;mp-2550b; \
postscriptdriver-nrg;mp-2553; \
postscriptdriver-nrg;mp-2851; \
postscriptdriver-nrg;mp-2852; \
postscriptdriver-nrg;mp-3010; \
postscriptdriver-nrg;mp-3053; \
postscriptdriver-nrg;mp-3350; \
postscriptdriver-nrg;mp-3350b; \
postscriptdriver-nrg;mp-3351; \
postscriptdriver-nrg;mp-3352; \
postscriptdriver-nrg;mp-3353; \
postscriptdriver-nrg;mp-3500; \
postscriptdriver-nrg;mp-4000; \
postscriptdriver-nrg;mp-4000b; \
postscriptdriver-nrg;mp-4001; \
postscriptdriver-nrg;mp-4002; \
postscriptdriver-nrg;mp-4500; \
postscriptdriver-nrg;mp-5000; \
postscriptdriver-nrg;mp-5000b; \
postscriptdriver-nrg;mp-5001; \
postscriptdriver-nrg;mp-5002; \
postscriptdriver-nrg;mp-5500; \
postscriptdriver-nrg;mp-6000; \
postscriptdriver-nrg;mp-6001; \
postscriptdriver-nrg;mp-6002; \
postscriptdriver-nrg;mp-6500; \
postscriptdriver-nrg;mp-7000; \
postscriptdriver-nrg;mp-7001; \
postscriptdriver-nrg;mp-7500; \
postscriptdriver-nrg;mp-7502; \
postscriptdriver-nrg;mp-8000; \
postscriptdriver-nrg;mp-8001; \
postscriptdriver-nrg;mp-9000; \
postscriptdriver-nrg;mp-9001; \
postscriptdriver-nrg;mp-9002; \
postscriptdriver-nrg;mp-c1500sp; \
postscriptdriver-nrg;mp-c2003; \
postscriptdriver-nrg;mp-c2003z; \
postscriptdriver-nrg;mp-c2050; \
postscriptdriver-nrg;mp-c2051; \
postscriptdriver-nrg;mp-c2500; \
postscriptdriver-nrg;mp-c2503; \
postscriptdriver-nrg;mp-c2503z; \
postscriptdriver-nrg;mp-c2550; \
postscriptdriver-nrg;mp-c2551; \
postscriptdriver-nrg;mp-c2800; \
postscriptdriver-nrg;mp-c3000; \
postscriptdriver-nrg;mp-c3001; \
postscriptdriver-nrg;mp-c3002; \
postscriptdriver-nrg;mp-c3003; \
postscriptdriver-nrg;mp-c300; \
postscriptdriver-nrg;mp-c300sr; \
postscriptdriver-nrg;mp-c3300; \
postscriptdriver-nrg;mp-c3500; \
postscriptdriver-nrg;mp-c3501; \
postscriptdriver-nrg;mp-c3502; \
postscriptdriver-nrg;mp-c3503; \
postscriptdriver-nrg;mp-c4000; \
postscriptdriver-nrg;mp-c400; \
postscriptdriver-nrg;mp-c400sr; \
postscriptdriver-nrg;mp-c4500; \
postscriptdriver-nrg;mp-c4501; \
postscriptdriver-nrg;mp-c4501a; \
postscriptdriver-nrg;mp-c4502; \
postscriptdriver-nrg;mp-c4502a; \
postscriptdriver-nrg;mp-c4503; \
postscriptdriver-nrg;mp-c5000; \
postscriptdriver-nrg;mp-c5501; \
postscriptdriver-nrg;mp-c5501a; \
postscriptdriver-nrg;mp-c5502; \
postscriptdriver-nrg;mp-c5502a; \
postscriptdriver-nrg;mp-c5503; \
postscriptdriver-nrg;mp-c6000; \
postscriptdriver-nrg;mp-c6003; \
postscriptdriver-nrg;mp-c6501; \
postscriptdriver-nrg;mp-c6502; \
postscriptdriver-nrg;mp-c7500; \
postscriptdriver-nrg;mp-c7501; \
postscriptdriver-nrg;mp-c8002; \
postscriptdriver-nrg;pro-1106ex; \
postscriptdriver-nrg;pro-1107ex; \
postscriptdriver-nrg;pro-1356ex; \
postscriptdriver-nrg;pro-1357ex; \
postscriptdriver-nrg;pro-8100s; \
postscriptdriver-nrg;pro-8110s; \
postscriptdriver-nrg;pro-8120s; \
postscriptdriver-nrg;pro-906ex; \
postscriptdriver-nrg;pro-907ex; \
postscriptdriver-nrg;pro-c5100s; \
postscriptdriver-nrg;pro-c5110s; \
postscriptdriver-nrg;sg3110dn; \
postscriptdriver-nrg;sg3110dnw; \
postscriptdriver-nrg;sg3110sfnw; \
postscriptdriver-oce;oce-8445; \
postscriptdriver-oce;oce-8465; \
postscriptdriver-oce;oce-varioprint-2050; \
postscriptdriver-oce;oce-varioprint-2060; \
postscriptdriver-oce;oce-varioprint-2070; \
postscriptdriver-oce;oce-varioprint-2090-ps3; \
postscriptdriver-oce;oce-vp2105-ps3; \
postscriptdriver-oki-data-corp;b410; \
postscriptdriver-oki-data-corp;ml320/1turbo; \
postscriptdriver-oki-data-corp;oki-okipage-4w; \
postscriptdriver-oki-data-corp;okidata-okipage-6e; \
postscriptdriver-oki-data-corp;okidata-okipage-6ex; \
postscriptdriver-oki-data-corp;okipage-10e; \
postscriptdriver-oki-data-corp;okipage-10ex; \
postscriptdriver-oki-data-corp;okipage-14ex; \
postscriptdriver-oki-data-corp;okipage-8p; \
postscriptdriver-oki;b4300; \
postscriptdriver-oki;c5300; \
postscriptdriver-oki;c5400; \
postscriptdriver-oki;c6100; \
postscriptdriver-oki;c7300; \
postscriptdriver-oki;c9200; \
postscriptdriver-oki;c9400; \
postscriptdriver-oki;oki; \
postscriptdriver-panasonic;kx-p6500; \
postscriptdriver-ricoh;aficio-1022; \
postscriptdriver-ricoh;aficio-1027; \
postscriptdriver-ricoh;aficio-1032; \
postscriptdriver-ricoh;aficio-1035; \
postscriptdriver-ricoh;aficio-1045; \
postscriptdriver-ricoh;aficio-1060; \
postscriptdriver-ricoh;aficio-1075; \
postscriptdriver-ricoh;aficio-1515; \
postscriptdriver-ricoh;aficio-2015; \
postscriptdriver-ricoh;aficio-2016; \
postscriptdriver-ricoh;aficio-2018; \
postscriptdriver-ricoh;aficio-2018d; \
postscriptdriver-ricoh;aficio-2020; \
postscriptdriver-ricoh;aficio-2020d; \
postscriptdriver-ricoh;aficio-2022; \
postscriptdriver-ricoh;aficio-2027; \
postscriptdriver-ricoh;aficio-2032; \
postscriptdriver-ricoh;aficio-2035; \
postscriptdriver-ricoh;aficio-2035e; \
postscriptdriver-ricoh;aficio-2045; \
postscriptdriver-ricoh;aficio-2045e; \
postscriptdriver-ricoh;aficio-2051; \
postscriptdriver-ricoh;aficio-2060; \
postscriptdriver-ricoh;aficio-2075; \
postscriptdriver-ricoh;aficio-2090; \
postscriptdriver-ricoh;aficio-2105; \
postscriptdriver-ricoh;aficio-3025; \
postscriptdriver-ricoh;aficio-3030; \
postscriptdriver-ricoh;aficio-3035; \
postscriptdriver-ricoh;aficio-3045; \
postscriptdriver-ricoh;aficio-3224c; \
postscriptdriver-ricoh;aficio-3228c; \
postscriptdriver-ricoh;aficio-3232c; \
postscriptdriver-ricoh;aficio-3235c; \
postscriptdriver-ricoh;aficio-3245c; \
postscriptdriver-ricoh;aficio-3260c; \
postscriptdriver-ricoh;aficio-color5560; \
postscriptdriver-ricoh;aficio-mp-1100; \
postscriptdriver-ricoh;aficio-mp-1350; \
postscriptdriver-ricoh;aficio-mp-1600; \
postscriptdriver-ricoh;aficio-mp-161; \
postscriptdriver-ricoh;aficio-mp-171; \
postscriptdriver-ricoh;aficio-mp-2000; \
postscriptdriver-ricoh;aficio-mp-201; \
postscriptdriver-ricoh;aficio-mp-2352; \
postscriptdriver-ricoh;aficio-mp-2500; \
postscriptdriver-ricoh;aficio-mp-2510; \
postscriptdriver-ricoh;aficio-mp-2550; \
postscriptdriver-ricoh;aficio-mp-2550b; \
postscriptdriver-ricoh;aficio-mp-2851; \
postscriptdriver-ricoh;aficio-mp-2852; \
postscriptdriver-ricoh;aficio-mp-3010; \
postscriptdriver-ricoh;aficio-mp-3350; \
postscriptdriver-ricoh;aficio-mp-3350b; \
postscriptdriver-ricoh;aficio-mp-3351; \
postscriptdriver-ricoh;aficio-mp-3352; \
postscriptdriver-ricoh;aficio-mp-3500; \
postscriptdriver-ricoh;aficio-mp-4000; \
postscriptdriver-ricoh;aficio-mp-4000b; \
postscriptdriver-ricoh;aficio-mp-4001; \
postscriptdriver-ricoh;aficio-mp-4002; \
postscriptdriver-ricoh;aficio-mp-4500; \
postscriptdriver-ricoh;aficio-mp-5000; \
postscriptdriver-ricoh;aficio-mp-5000b; \
postscriptdriver-ricoh;aficio-mp-5001; \
postscriptdriver-ricoh;aficio-mp-5002; \
postscriptdriver-ricoh;aficio-mp-5500; \
postscriptdriver-ricoh;aficio-mp-6000; \
postscriptdriver-ricoh;aficio-mp-6001; \
postscriptdriver-ricoh;aficio-mp-6002; \
postscriptdriver-ricoh;aficio-mp-6500; \
postscriptdriver-ricoh;aficio-mp-7000; \
postscriptdriver-ricoh;aficio-mp-7001; \
postscriptdriver-ricoh;aficio-mp-7500; \
postscriptdriver-ricoh;aficio-mp-7502; \
postscriptdriver-ricoh;aficio-mp-8000; \
postscriptdriver-ricoh;aficio-mp-8001; \
postscriptdriver-ricoh;aficio-mp-9000; \
postscriptdriver-ricoh;aficio-mp-9001; \
postscriptdriver-ricoh;aficio-mp-9002; \
postscriptdriver-ricoh;aficio-mp-c2050; \
postscriptdriver-ricoh;aficio-mp-c2051; \
postscriptdriver-ricoh;aficio-mp-c2500; \
postscriptdriver-ricoh;aficio-mp-c2550; \
postscriptdriver-ricoh;aficio-mp-c2551; \
postscriptdriver-ricoh;aficio-mp-c2800; \
postscriptdriver-ricoh;aficio-mp-c3000; \
postscriptdriver-ricoh;aficio-mp-c3001; \
postscriptdriver-ricoh;aficio-mp-c3002; \
postscriptdriver-ricoh;aficio-mp-c300; \
postscriptdriver-ricoh;aficio-mp-c300sr; \
postscriptdriver-ricoh;aficio-mp-c3300; \
postscriptdriver-ricoh;aficio-mp-c3500; \
postscriptdriver-ricoh;aficio-mp-c3501; \
postscriptdriver-ricoh;aficio-mp-c3502; \
postscriptdriver-ricoh;aficio-mp-c4000; \
postscriptdriver-ricoh;aficio-mp-c400; \
postscriptdriver-ricoh;aficio-mp-c400sr; \
postscriptdriver-ricoh;aficio-mp-c4500; \
postscriptdriver-ricoh;aficio-mp-c4501; \
postscriptdriver-ricoh;aficio-mp-c4501a; \
postscriptdriver-ricoh;aficio-mp-c4502; \
postscriptdriver-ricoh;aficio-mp-c4502a; \
postscriptdriver-ricoh;aficio-mp-c5000; \
postscriptdriver-ricoh;aficio-mp-c5501; \
postscriptdriver-ricoh;aficio-mp-c5501a; \
postscriptdriver-ricoh;aficio-mp-c5502; \
postscriptdriver-ricoh;aficio-mp-c5502a; \
postscriptdriver-ricoh;aficio-mp-c6000; \
postscriptdriver-ricoh;aficio-mp-c6501; \
postscriptdriver-ricoh;aficio-mp-c7500; \
postscriptdriver-ricoh;aficio-mp-c7501; \
postscriptdriver-ricoh;aficiosg3110dn; \
postscriptdriver-ricoh;aficiosg3110dnw; \
postscriptdriver-ricoh;aficiosg3110sfnw; \
postscriptdriver-ricoh;mp-2001; \
postscriptdriver-ricoh;mp-2501; \
postscriptdriver-ricoh;mp-2553; \
postscriptdriver-ricoh;mp-3053; \
postscriptdriver-ricoh;mp-3353; \
postscriptdriver-ricoh;mp-c1500/615c; \
postscriptdriver-ricoh;mp-c2003; \
postscriptdriver-ricoh;mp-c2003z; \
postscriptdriver-ricoh;mp-c2503; \
postscriptdriver-ricoh;mp-c2503z; \
postscriptdriver-ricoh;mp-c3003; \
postscriptdriver-ricoh;mp-c3503; \
postscriptdriver-ricoh;mp-c4503; \
postscriptdriver-ricoh;mp-c5503; \
postscriptdriver-ricoh;mp-c6003; \
postscriptdriver-ricoh;mp-c6502; \
postscriptdriver-ricoh;mp-c8002; \
postscriptdriver-ricoh;pro-1106ex; \
postscriptdriver-ricoh;pro-1107ex; \
postscriptdriver-ricoh;pro-1356ex; \
postscriptdriver-ricoh;pro-1357ex; \
postscriptdriver-ricoh;pro-8100s; \
postscriptdriver-ricoh;pro-8110s; \
postscriptdriver-ricoh;pro-8120s; \
postscriptdriver-ricoh;pro-906ex; \
postscriptdriver-ricoh;pro-907ex; \
postscriptdriver-ricoh;pro-c5100s; \
postscriptdriver-ricoh;pro-c5110s; \
postscriptdriver-ricoh;sg3120bsfnw; \
postscriptdriver-samsung;6050; \
postscriptdriver-samsung;clp-350-series; \
postscriptdriver-samsung;clp-550; \
postscriptdriver-samsung;clp-610-series; \
postscriptdriver-samsung;clp-620-series; \
postscriptdriver-samsung;m262x-282x-series; \
postscriptdriver-samsung;m267x-287x-series; \
postscriptdriver-samsung;ml-1430; \
postscriptdriver-samsung;ml-1440; \
postscriptdriver-samsung;ml-1450; \
postscriptdriver-samsung;ml-1510-700; \
postscriptdriver-samsung;ml-1610; \
postscriptdriver-samsung;ml-1650; \
postscriptdriver-samsung;ml-1710; \
postscriptdriver-samsung;ml-1740; \
postscriptdriver-samsung;ml-2010; \
postscriptdriver-samsung;ml-2150-series; \
postscriptdriver-samsung;ml-2550-series; \
postscriptdriver-samsung;ml-2580-series; \
postscriptdriver-samsung;ml-2950-series; \
postscriptdriver-samsung;ml-6060; \
postscriptdriver-samsung;scx-470x-series; \
postscriptdriver-samsung;scx-472x-series; \
postscriptdriver-samsung;scx-4x24-series; \
postscriptdriver-samsung;scx-4x25-series; \
postscriptdriver-samsung;scx-4x26-series; \
postscriptdriver-savin;2522; \
postscriptdriver-savin;2527; \
postscriptdriver-savin;2532; \
postscriptdriver-savin;2535/2235; \
postscriptdriver-savin;2545/2245; \
postscriptdriver-savin;2560; \
postscriptdriver-savin;2575; \
postscriptdriver-savin;3515; \
postscriptdriver-savin;40105; \
postscriptdriver-savin;4015; \
postscriptdriver-savin;4018; \
postscriptdriver-savin;4018d; \
postscriptdriver-savin;4022; \
postscriptdriver-savin;4027; \
postscriptdriver-savin;4035/4135g; \
postscriptdriver-savin;4035e/4135eg; \
postscriptdriver-savin;4045/4145g; \
postscriptdriver-savin;4045e/4145eg; \
postscriptdriver-savin;4051; \
postscriptdriver-savin;4060; \
postscriptdriver-savin;4075; \
postscriptdriver-savin;4090; \
postscriptdriver-savin;7025; \
postscriptdriver-savin;8016; \
postscriptdriver-savin;8020; \
postscriptdriver-savin;8020d; \
postscriptdriver-savin;8025; \
postscriptdriver-savin;8025e; \
postscriptdriver-savin;8030; \
postscriptdriver-savin;8030e; \
postscriptdriver-savin;8035/8035g; \
postscriptdriver-savin;8035e; \
postscriptdriver-savin;8045/8045g; \
postscriptdriver-savin;8045e; \
postscriptdriver-savin;8055; \
postscriptdriver-savin;8060; \
postscriptdriver-savin;8065; \
postscriptdriver-savin;8070; \
postscriptdriver-savin;8075; \
postscriptdriver-savin;8080; \
postscriptdriver-savin;8090; \
postscriptdriver-savin;8110; \
postscriptdriver-savin;8135; \
postscriptdriver-savin;816; \
postscriptdriver-savin;9016; \
postscriptdriver-savin;9021d; \
postscriptdriver-savin;9025; \
postscriptdriver-savin;9025b; \
postscriptdriver-savin;9033; \
postscriptdriver-savin;9033b; \
postscriptdriver-savin;9040; \
postscriptdriver-savin;9040b; \
postscriptdriver-savin;9050; \
postscriptdriver-savin;9050b; \
postscriptdriver-savin;9060; \
postscriptdriver-savin;9070; \
postscriptdriver-savin;9080; \
postscriptdriver-savin;9090; \
postscriptdriver-savin;917; \
postscriptdriver-savin;920; \
postscriptdriver-savin;9228; \
postscriptdriver-savin;9233; \
postscriptdriver-savin;9240; \
postscriptdriver-savin;9250; \
postscriptdriver-savin;c-230; \
postscriptdriver-savin;c-230sr; \
postscriptdriver-savin;c-240; \
postscriptdriver-savin;c-240sr; \
postscriptdriver-savin;c2410; \
postscriptdriver-savin;c2525; \
postscriptdriver-savin;c2824; \
postscriptdriver-savin;c2828; \
postscriptdriver-savin;c3030; \
postscriptdriver-savin;c3210e; \
postscriptdriver-savin;c3333; \
postscriptdriver-savin;c3528; \
postscriptdriver-savin;c3535; \
postscriptdriver-savin;c4040; \
postscriptdriver-savin;c4535; \
postscriptdriver-savin;c4540; \
postscriptdriver-savin;c5050; \
postscriptdriver-savin;c6045; \
postscriptdriver-savin;c6055; \
postscriptdriver-savin;c7570; \
postscriptdriver-savin;c9020; \
postscriptdriver-savin;c9025; \
postscriptdriver-savin;c9065; \
postscriptdriver-savin;c9075; \
postscriptdriver-savin;c9120; \
postscriptdriver-savin;c9125; \
postscriptdriver-savin;c9130; \
postscriptdriver-savin;c9135; \
postscriptdriver-savin;c9145; \
postscriptdriver-savin;c9145a; \
postscriptdriver-savin;c9155; \
postscriptdriver-savin;c9155a; \
postscriptdriver-savin;mp-2352; \
postscriptdriver-savin;mp-2501; \
postscriptdriver-savin;mp-2553; \
postscriptdriver-savin;mp-2852; \
postscriptdriver-savin;mp-3053; \
postscriptdriver-savin;mp-3352; \
postscriptdriver-savin;mp-3353; \
postscriptdriver-savin;mp-4002; \
postscriptdriver-savin;mp-5002; \
postscriptdriver-savin;mp-6002; \
postscriptdriver-savin;mp-7502; \
postscriptdriver-savin;mp-9002; \
postscriptdriver-savin;mp-c2003; \
postscriptdriver-savin;mp-c2503; \
postscriptdriver-savin;mp-c3002; \
postscriptdriver-savin;mp-c3003; \
postscriptdriver-savin;mp-c3502; \
postscriptdriver-savin;mp-c3503; \
postscriptdriver-savin;mp-c4502; \
postscriptdriver-savin;mp-c4502a; \
postscriptdriver-savin;mp-c4503; \
postscriptdriver-savin;mp-c5502; \
postscriptdriver-savin;mp-c5502a; \
postscriptdriver-savin;mp-c5503; \
postscriptdriver-savin;mp-c6003; \
postscriptdriver-savin;mp-c6502; \
postscriptdriver-savin;mp-c8002; \
postscriptdriver-savin;pro-1106ex; \
postscriptdriver-savin;pro-1107ex; \
postscriptdriver-savin;pro-1356ex; \
postscriptdriver-savin;pro-1357ex; \
postscriptdriver-savin;pro-8100s; \
postscriptdriver-savin;pro-8110s; \
postscriptdriver-savin;pro-8120s; \
postscriptdriver-savin;pro-906ex; \
postscriptdriver-savin;pro-907ex; \
postscriptdriver-savin;pro-c5100s; \
postscriptdriver-savin;pro-c5110s; \
postscriptdriver-savin;sdc555; \
postscriptdriver-savin;sg3110dn; \
postscriptdriver-savin;sg3110dnw; \
postscriptdriver-savin;sg3110sfnw; \
postscriptdriver-savin;sgc-1506; \
postscriptdriver-sharp;ar-160/200-series; \
postscriptdriver-sharp;sharp-ar-nb2; \
postscriptdriver-sharp;sharp-ar-p19; \
postscriptdriver-sharp;sharp-ar-p20; \
postscriptdriver-sharp;sharp-ar-pk4; \
postscriptdriver-tektronix;phaser-750dp; \
postscriptdriver-tektronix;phaser-750dx; \
postscriptdriver-tektronix;phaser-750n; \
postscriptdriver-tektronix;phaser-750p; \
postscriptdriver-xerox;document-homecentre; \
postscriptdriver-xerox;docuprint-c11; \
postscriptdriver-xerox;docuprint-c8; \
postscriptdriver-xerox;docuprint-p12; \
postscriptdriver-xerox;docuprint-p8e; \
postscriptdriver-xerox;docuprint; \
postscriptdriver-xerox;phaser-4400b; \
postscriptdriver-xerox;phaser-4400dt; \
postscriptdriver-xerox;phaser-4400dx; \
postscriptdriver-xerox;phaser-4400n; \
postscriptdriver-xerox;phaser-4500b; \
postscriptdriver-xerox;phaser-4500dt; \
postscriptdriver-xerox;phaser-4500dx; \
postscriptdriver-xerox;phaser-4500n; \
postscriptdriver-xerox;phaser-4510b; \
postscriptdriver-xerox;phaser-4510dt; \
postscriptdriver-xerox;phaser-4510dx; \
postscriptdriver-xerox;phaser-4510n; \
postscriptdriver-xerox;phaser-5500b; \
postscriptdriver-xerox;phaser-5500dn; \
postscriptdriver-xerox;phaser-5500dt; \
postscriptdriver-xerox;phaser-5500dx; \
postscriptdriver-xerox;phaser-5500n; \
postscriptdriver-xerox;phaser-6130n; \
postscriptdriver-xerox;phaser-6180dn; \
postscriptdriver-xerox;phaser-6180mfp-d; \
postscriptdriver-xerox;phaser-6200b; \
postscriptdriver-xerox;phaser-6200dp; \
postscriptdriver-xerox;phaser-6200dx; \
postscriptdriver-xerox;phaser-6200n; \
postscriptdriver-xerox;phaser-6250b; \
postscriptdriver-xerox;phaser-6250dp; \
postscriptdriver-xerox;phaser-6250dt; \
postscriptdriver-xerox;phaser-6250dx; \
postscriptdriver-xerox;phaser-6250n; \
postscriptdriver-xerox;phaser-6300dn; \
postscriptdriver-xerox;phaser-6300n; \
postscriptdriver-xerox;phaser-6350dp; \
postscriptdriver-xerox;phaser-6350dt; \
postscriptdriver-xerox;phaser-6350dx; \
postscriptdriver-xerox;phaser-6360dn; \
postscriptdriver-xerox;phaser-6360dx; \
postscriptdriver-xerox;phaser-7300b; \
postscriptdriver-xerox;phaser-7300dn; \
postscriptdriver-xerox;phaser-7300dt; \
postscriptdriver-xerox;phaser-7300dx; \
postscriptdriver-xerox;phaser-7300n; \
postscriptdriver-xerox;phaser-7400dn; \
postscriptdriver-xerox;phaser-7400dt; \
postscriptdriver-xerox;phaser-7400dx; \
postscriptdriver-xerox;phaser-7400dxf; \
postscriptdriver-xerox;phaser-7400n; \
postscriptdriver-xerox;phaser-7700dn; \
postscriptdriver-xerox;phaser-7700dx; \
postscriptdriver-xerox;phaser-7700gx; \
postscriptdriver-xerox;phaser-7750b; \
postscriptdriver-xerox;phaser-7750dn; \
postscriptdriver-xerox;phaser-7750dxf; \
postscriptdriver-xerox;phaser-7750gx; \
postscriptdriver-xerox;phaser-7760dn; \
postscriptdriver-xerox;phaser-7760dx; \
postscriptdriver-xerox;phaser-7760gx; \
postscriptdriver-xerox;phaser-8400b; \
postscriptdriver-xerox;phaser-8400bd; \
postscriptdriver-xerox;phaser-8400dp; \
postscriptdriver-xerox;phaser-8400dx; \
postscriptdriver-xerox;phaser-8400n; \
postscriptdriver-xerox;phaser-8500dn; \
postscriptdriver-xerox;phaser-8500n; \
postscriptdriver-xerox;phaser-8550dp; \
postscriptdriver-xerox;phaser-8550dt; \
postscriptdriver-xerox;phaser-8550dx; \
postscriptdriver-xerox;phaser-8560dn; \
postscriptdriver-xerox;phaser-8860; \
postscriptdriver-xerox;workcentre-c2424; \
postscriptdriver-xerox;xerox-phaser-2135; \
postscriptdriver-xerox;xerox-phaser-3500; \
postscriptdriver-xerox;xerox-wc-pe120;"

RDEPENDS:${PN} += "foomatic-filters \
ghostscript-library"

inherit rpm
