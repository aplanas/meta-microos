SUMMARY = "A simple class for electronic presentations"
DESCRIPTION = "The elpres class is intended to be used for presentations on a \
screen or with a beamer/projector. It is derived from LaTeX's \
article class and can be used with with LaTeX, pdfLaTeX, and \
LuaLaTeX. The default 'virtual paper size' of presentations \
generated by this class corresponds to a 4:3 (width:height) \
aspect ratio. Other aspect ratios for widescreen monitors \
(16:9, 16:10) may be selected."
LICENSE = "LPPL-1.0"

PV = "2023.209.1.0.1svn60209"

RPM_NAME = "texlive-elpres-2023.209.1.0.1svn60209-54.1.noarch.rpm"
RPM_HASH = "21d632fa395dc75bf8c251c5bc97947c37e59b5b6d1486ce741af2fb8abeeb64738a144edda33f431c71629458ab9bd917a3f30fa6291e518a9f335dc445002c"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-elpres.cls \
tex-elpresbluelightgrayscheme.sty \
tex-elpresgrayscheme.sty \
tex-elpreswhitebluescheme.sty \
tex-elpreswhiteredscheme.sty \
tex-elpreswhitetealscheme.sty \
texlive-elpres"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-article.cls \
tex-courier.sty \
tex-fancyhdr.sty \
tex-graphicx.sty \
tex-helvet.sty \
tex-hyperref.sty \
tex-ifthen.sty \
tex-mathptmx.sty \
tex-xcolor.sty \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
