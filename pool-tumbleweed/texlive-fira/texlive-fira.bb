SUMMARY = "Fira fonts with LaTeX support"
DESCRIPTION = "This package provides LaTeX, pdfLaTeX, XeLaTeX and LuaLaTeX \
support for the Fira Sans and Fira Mono families of fonts \
designed by Erik Spiekermann and Ralph du Carrois of Carrois \
Type Design. Fira Sans is available in eleven weights with \
corresponding italics: light, regular, medium, bold, ..."
LICENSE = "OFL-1.1"

PV = "2023.209.4.3svn64422"

RPM_NAME = "texlive-fira-2023.209.4.3svn64422-53.1.noarch.rpm"
RPM_HASH = "3bfce7b06323204f4e3b5d7e92cf39492706ada358a321137bf1e151767330b726ac31750b9b435ef2a731012399d79e0d5e3914f0d3cd98f2a4626114f4aafd"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-FiraMono-Bold-sup-lgr--base.tfm \
tex-FiraMono-Bold-sup-lgr.tfm \
tex-FiraMono-Bold-sup-lgr.vf \
tex-FiraMono-Bold-sup-ly1--base.tfm \
tex-FiraMono-Bold-sup-ly1.tfm \
tex-FiraMono-Bold-sup-ly1.vf \
tex-FiraMono-Bold-sup-ot1.tfm \
tex-FiraMono-Bold-sup-t1--base.tfm \
tex-FiraMono-Bold-sup-t1.tfm \
tex-FiraMono-Bold-sup-t1.vf \
tex-FiraMono-Bold-tlf-lgr--base.tfm \
tex-FiraMono-Bold-tlf-lgr.tfm \
tex-FiraMono-Bold-tlf-lgr.vf \
tex-FiraMono-Bold-tlf-ly1--base.tfm \
tex-FiraMono-Bold-tlf-ly1.tfm \
tex-FiraMono-Bold-tlf-ly1.vf \
tex-FiraMono-Bold-tlf-ot1.tfm \
tex-FiraMono-Bold-tlf-t1--base.tfm \
tex-FiraMono-Bold-tlf-t1.tfm \
tex-FiraMono-Bold-tlf-t1.vf \
tex-FiraMono-Bold-tlf-ts1--base.tfm \
tex-FiraMono-Bold-tlf-ts1.tfm \
tex-FiraMono-Bold-tlf-ts1.vf \
tex-FiraMono-Bold-tosf-lgr--base.tfm \
tex-FiraMono-Bold-tosf-lgr.tfm \
tex-FiraMono-Bold-tosf-lgr.vf \
tex-FiraMono-Bold-tosf-ly1--base.tfm \
tex-FiraMono-Bold-tosf-ly1.tfm \
tex-FiraMono-Bold-tosf-ly1.vf \
tex-FiraMono-Bold-tosf-ot1.tfm \
tex-FiraMono-Bold-tosf-t1--base.tfm \
tex-FiraMono-Bold-tosf-t1.tfm \
tex-FiraMono-Bold-tosf-t1.vf \
tex-FiraMono-Bold-tosf-ts1--base.tfm \
tex-FiraMono-Bold-tosf-ts1.tfm \
tex-FiraMono-Bold-tosf-ts1.vf \
tex-FiraMono-BoldOblique-sup-lgr--base.tfm \
tex-FiraMono-BoldOblique-sup-lgr.tfm \
tex-FiraMono-BoldOblique-sup-lgr.vf \
tex-FiraMono-BoldOblique-sup-ly1--base.tfm \
tex-FiraMono-BoldOblique-sup-ly1.tfm \
tex-FiraMono-BoldOblique-sup-ly1.vf \
tex-FiraMono-BoldOblique-sup-ot1.tfm \
tex-FiraMono-BoldOblique-sup-t1--base.tfm \
tex-FiraMono-BoldOblique-sup-t1.tfm \
tex-FiraMono-BoldOblique-sup-t1.vf \
tex-FiraMono-BoldOblique-tlf-lgr--base.tfm \
tex-FiraMono-BoldOblique-tlf-lgr.tfm \
tex-FiraMono-BoldOblique-tlf-lgr.vf \
tex-FiraMono-BoldOblique-tlf-ly1--base.tfm \
tex-FiraMono-BoldOblique-tlf-ly1.tfm \
tex-FiraMono-BoldOblique-tlf-ly1.vf \
tex-FiraMono-BoldOblique-tlf-ot1.tfm \
tex-FiraMono-BoldOblique-tlf-t1--base.tfm \
tex-FiraMono-BoldOblique-tlf-t1.tfm \
tex-FiraMono-BoldOblique-tlf-t1.vf \
tex-FiraMono-BoldOblique-tlf-ts1--base.tfm \
tex-FiraMono-BoldOblique-tlf-ts1.tfm \
tex-FiraMono-BoldOblique-tlf-ts1.vf \
tex-FiraMono-BoldOblique-tosf-lgr--base.tfm \
tex-FiraMono-BoldOblique-tosf-lgr.tfm \
tex-FiraMono-BoldOblique-tosf-lgr.vf \
tex-FiraMono-BoldOblique-tosf-ly1--base.tfm \
tex-FiraMono-BoldOblique-tosf-ly1.tfm \
tex-FiraMono-BoldOblique-tosf-ly1.vf \
tex-FiraMono-BoldOblique-tosf-ot1.tfm \
tex-FiraMono-BoldOblique-tosf-t1--base.tfm \
tex-FiraMono-BoldOblique-tosf-t1.tfm \
tex-FiraMono-BoldOblique-tosf-t1.vf \
tex-FiraMono-BoldOblique-tosf-ts1--base.tfm \
tex-FiraMono-BoldOblique-tosf-ts1.tfm \
tex-FiraMono-BoldOblique-tosf-ts1.vf \
tex-FiraMono-Medium-sup-lgr--base.tfm \
tex-FiraMono-Medium-sup-lgr.tfm \
tex-FiraMono-Medium-sup-lgr.vf \
tex-FiraMono-Medium-sup-ly1--base.tfm \
tex-FiraMono-Medium-sup-ly1.tfm \
tex-FiraMono-Medium-sup-ly1.vf \
tex-FiraMono-Medium-sup-ot1.tfm \
tex-FiraMono-Medium-sup-t1--base.tfm \
tex-FiraMono-Medium-sup-t1.tfm \
tex-FiraMono-Medium-sup-t1.vf \
tex-FiraMono-Medium-tlf-lgr--base.tfm \
tex-FiraMono-Medium-tlf-lgr.tfm \
tex-FiraMono-Medium-tlf-lgr.vf \
tex-FiraMono-Medium-tlf-ly1--base.tfm \
tex-FiraMono-Medium-tlf-ly1.tfm \
tex-FiraMono-Medium-tlf-ly1.vf \
tex-FiraMono-Medium-tlf-ot1.tfm \
tex-FiraMono-Medium-tlf-t1--base.tfm \
tex-FiraMono-Medium-tlf-t1.tfm \
tex-FiraMono-Medium-tlf-t1.vf \
tex-FiraMono-Medium-tlf-ts1--base.tfm \
tex-FiraMono-Medium-tlf-ts1.tfm \
tex-FiraMono-Medium-tlf-ts1.vf \
tex-FiraMono-Medium-tosf-lgr--base.tfm \
tex-FiraMono-Medium-tosf-lgr.tfm \
tex-FiraMono-Medium-tosf-lgr.vf \
tex-FiraMono-Medium-tosf-ly1--base.tfm \
tex-FiraMono-Medium-tosf-ly1.tfm \
tex-FiraMono-Medium-tosf-ly1.vf \
tex-FiraMono-Medium-tosf-ot1.tfm \
tex-FiraMono-Medium-tosf-t1--base.tfm \
tex-FiraMono-Medium-tosf-t1.tfm \
tex-FiraMono-Medium-tosf-t1.vf \
tex-FiraMono-Medium-tosf-ts1--base.tfm \
tex-FiraMono-Medium-tosf-ts1.tfm \
tex-FiraMono-Medium-tosf-ts1.vf \
tex-FiraMono-MediumOblique-sup-lgr--base.tfm \
tex-FiraMono-MediumOblique-sup-lgr.tfm \
tex-FiraMono-MediumOblique-sup-lgr.vf \
tex-FiraMono-MediumOblique-sup-ly1--base.tfm \
tex-FiraMono-MediumOblique-sup-ly1.tfm \
tex-FiraMono-MediumOblique-sup-ly1.vf \
tex-FiraMono-MediumOblique-sup-ot1.tfm \
tex-FiraMono-MediumOblique-sup-t1--base.tfm \
tex-FiraMono-MediumOblique-sup-t1.tfm \
tex-FiraMono-MediumOblique-sup-t1.vf \
tex-FiraMono-MediumOblique-tlf-lgr--base.tfm \
tex-FiraMono-MediumOblique-tlf-lgr.tfm \
tex-FiraMono-MediumOblique-tlf-lgr.vf \
tex-FiraMono-MediumOblique-tlf-ly1--base.tfm \
tex-FiraMono-MediumOblique-tlf-ly1.tfm \
tex-FiraMono-MediumOblique-tlf-ly1.vf \
tex-FiraMono-MediumOblique-tlf-ot1.tfm \
tex-FiraMono-MediumOblique-tlf-t1--base.tfm \
tex-FiraMono-MediumOblique-tlf-t1.tfm \
tex-FiraMono-MediumOblique-tlf-t1.vf \
tex-FiraMono-MediumOblique-tlf-ts1--base.tfm \
tex-FiraMono-MediumOblique-tlf-ts1.tfm \
tex-FiraMono-MediumOblique-tlf-ts1.vf \
tex-FiraMono-MediumOblique-tosf-lgr--base.tfm \
tex-FiraMono-MediumOblique-tosf-lgr.tfm \
tex-FiraMono-MediumOblique-tosf-lgr.vf \
tex-FiraMono-MediumOblique-tosf-ly1--base.tfm \
tex-FiraMono-MediumOblique-tosf-ly1.tfm \
tex-FiraMono-MediumOblique-tosf-ly1.vf \
tex-FiraMono-MediumOblique-tosf-ot1.tfm \
tex-FiraMono-MediumOblique-tosf-t1--base.tfm \
tex-FiraMono-MediumOblique-tosf-t1.tfm \
tex-FiraMono-MediumOblique-tosf-t1.vf \
tex-FiraMono-MediumOblique-tosf-ts1--base.tfm \
tex-FiraMono-MediumOblique-tosf-ts1.tfm \
tex-FiraMono-MediumOblique-tosf-ts1.vf \
tex-FiraMono-Oblique-sup-lgr--base.tfm \
tex-FiraMono-Oblique-sup-lgr.tfm \
tex-FiraMono-Oblique-sup-lgr.vf \
tex-FiraMono-Oblique-sup-ly1--base.tfm \
tex-FiraMono-Oblique-sup-ly1.tfm \
tex-FiraMono-Oblique-sup-ly1.vf \
tex-FiraMono-Oblique-sup-ot1.tfm \
tex-FiraMono-Oblique-sup-t1--base.tfm \
tex-FiraMono-Oblique-sup-t1.tfm \
tex-FiraMono-Oblique-sup-t1.vf \
tex-FiraMono-Oblique-tlf-lgr--base.tfm \
tex-FiraMono-Oblique-tlf-lgr.tfm \
tex-FiraMono-Oblique-tlf-lgr.vf \
tex-FiraMono-Oblique-tlf-ly1--base.tfm \
tex-FiraMono-Oblique-tlf-ly1.tfm \
tex-FiraMono-Oblique-tlf-ly1.vf \
tex-FiraMono-Oblique-tlf-ot1.tfm \
tex-FiraMono-Oblique-tlf-t1--base.tfm \
tex-FiraMono-Oblique-tlf-t1.tfm \
tex-FiraMono-Oblique-tlf-t1.vf \
tex-FiraMono-Oblique-tlf-ts1--base.tfm \
tex-FiraMono-Oblique-tlf-ts1.tfm \
tex-FiraMono-Oblique-tlf-ts1.vf \
tex-FiraMono-Oblique-tosf-lgr--base.tfm \
tex-FiraMono-Oblique-tosf-lgr.tfm \
tex-FiraMono-Oblique-tosf-lgr.vf \
tex-FiraMono-Oblique-tosf-ly1--base.tfm \
tex-FiraMono-Oblique-tosf-ly1.tfm \
tex-FiraMono-Oblique-tosf-ly1.vf \
tex-FiraMono-Oblique-tosf-ot1.tfm \
tex-FiraMono-Oblique-tosf-t1--base.tfm \
tex-FiraMono-Oblique-tosf-t1.tfm \
tex-FiraMono-Oblique-tosf-t1.vf \
tex-FiraMono-Oblique-tosf-ts1--base.tfm \
tex-FiraMono-Oblique-tosf-ts1.tfm \
tex-FiraMono-Oblique-tosf-ts1.vf \
tex-FiraMono-Regular-sup-lgr--base.tfm \
tex-FiraMono-Regular-sup-lgr.tfm \
tex-FiraMono-Regular-sup-lgr.vf \
tex-FiraMono-Regular-sup-ly1--base.tfm \
tex-FiraMono-Regular-sup-ly1.tfm \
tex-FiraMono-Regular-sup-ly1.vf \
tex-FiraMono-Regular-sup-ot1.tfm \
tex-FiraMono-Regular-sup-t1--base.tfm \
tex-FiraMono-Regular-sup-t1.tfm \
tex-FiraMono-Regular-sup-t1.vf \
tex-FiraMono-Regular-tlf-lgr--base.tfm \
tex-FiraMono-Regular-tlf-lgr.tfm \
tex-FiraMono-Regular-tlf-lgr.vf \
tex-FiraMono-Regular-tlf-ly1--base.tfm \
tex-FiraMono-Regular-tlf-ly1.tfm \
tex-FiraMono-Regular-tlf-ly1.vf \
tex-FiraMono-Regular-tlf-ot1.tfm \
tex-FiraMono-Regular-tlf-t1--base.tfm \
tex-FiraMono-Regular-tlf-t1.tfm \
tex-FiraMono-Regular-tlf-t1.vf \
tex-FiraMono-Regular-tlf-ts1--base.tfm \
tex-FiraMono-Regular-tlf-ts1.tfm \
tex-FiraMono-Regular-tlf-ts1.vf \
tex-FiraMono-Regular-tosf-lgr--base.tfm \
tex-FiraMono-Regular-tosf-lgr.tfm \
tex-FiraMono-Regular-tosf-lgr.vf \
tex-FiraMono-Regular-tosf-ly1--base.tfm \
tex-FiraMono-Regular-tosf-ly1.tfm \
tex-FiraMono-Regular-tosf-ly1.vf \
tex-FiraMono-Regular-tosf-ot1.tfm \
tex-FiraMono-Regular-tosf-t1--base.tfm \
tex-FiraMono-Regular-tosf-t1.tfm \
tex-FiraMono-Regular-tosf-t1.vf \
tex-FiraMono-Regular-tosf-ts1--base.tfm \
tex-FiraMono-Regular-tosf-ts1.tfm \
tex-FiraMono-Regular-tosf-ts1.vf \
tex-FiraMono.sty \
tex-FiraSans-Bold-lf-lgr.tfm \
tex-FiraSans-Bold-lf-ly1.tfm \
tex-FiraSans-Bold-lf-ot1.tfm \
tex-FiraSans-Bold-lf-sc-lgr.tfm \
tex-FiraSans-Bold-lf-sc-ly1--base.tfm \
tex-FiraSans-Bold-lf-sc-ly1.tfm \
tex-FiraSans-Bold-lf-sc-ly1.vf \
tex-FiraSans-Bold-lf-sc-ot1--base.tfm \
tex-FiraSans-Bold-lf-sc-ot1.tfm \
tex-FiraSans-Bold-lf-sc-ot1.vf \
tex-FiraSans-Bold-lf-sc-t1--base.tfm \
tex-FiraSans-Bold-lf-sc-t1.tfm \
tex-FiraSans-Bold-lf-sc-t1.vf \
tex-FiraSans-Bold-lf-t1--base.tfm \
tex-FiraSans-Bold-lf-t1.tfm \
tex-FiraSans-Bold-lf-t1.vf \
tex-FiraSans-Bold-lf-ts1--base.tfm \
tex-FiraSans-Bold-lf-ts1.tfm \
tex-FiraSans-Bold-lf-ts1.vf \
tex-FiraSans-Bold-osf-lgr.tfm \
tex-FiraSans-Bold-osf-ly1.tfm \
tex-FiraSans-Bold-osf-ot1.tfm \
tex-FiraSans-Bold-osf-sc-lgr.tfm \
tex-FiraSans-Bold-osf-sc-ly1--base.tfm \
tex-FiraSans-Bold-osf-sc-ly1.tfm \
tex-FiraSans-Bold-osf-sc-ly1.vf \
tex-FiraSans-Bold-osf-sc-ot1--base.tfm \
tex-FiraSans-Bold-osf-sc-ot1.tfm \
tex-FiraSans-Bold-osf-sc-ot1.vf \
tex-FiraSans-Bold-osf-sc-t1--base.tfm \
tex-FiraSans-Bold-osf-sc-t1.tfm \
tex-FiraSans-Bold-osf-sc-t1.vf \
tex-FiraSans-Bold-osf-t1--base.tfm \
tex-FiraSans-Bold-osf-t1.tfm \
tex-FiraSans-Bold-osf-t1.vf \
tex-FiraSans-Bold-osf-ts1--base.tfm \
tex-FiraSans-Bold-osf-ts1.tfm \
tex-FiraSans-Bold-osf-ts1.vf \
tex-FiraSans-Bold-sup-lgr.tfm \
tex-FiraSans-Bold-sup-ly1.tfm \
tex-FiraSans-Bold-sup-ot1.tfm \
tex-FiraSans-Bold-sup-t1--base.tfm \
tex-FiraSans-Bold-sup-t1.tfm \
tex-FiraSans-Bold-sup-t1.vf \
tex-FiraSans-Bold-tlf-lgr.tfm \
tex-FiraSans-Bold-tlf-ly1.tfm \
tex-FiraSans-Bold-tlf-ot1.tfm \
tex-FiraSans-Bold-tlf-sc-lgr.tfm \
tex-FiraSans-Bold-tlf-sc-ly1--base.tfm \
tex-FiraSans-Bold-tlf-sc-ly1.tfm \
tex-FiraSans-Bold-tlf-sc-ly1.vf \
tex-FiraSans-Bold-tlf-sc-ot1--base.tfm \
tex-FiraSans-Bold-tlf-sc-ot1.tfm \
tex-FiraSans-Bold-tlf-sc-ot1.vf \
tex-FiraSans-Bold-tlf-sc-t1--base.tfm \
tex-FiraSans-Bold-tlf-sc-t1.tfm \
tex-FiraSans-Bold-tlf-sc-t1.vf \
tex-FiraSans-Bold-tlf-t1--base.tfm \
tex-FiraSans-Bold-tlf-t1.tfm \
tex-FiraSans-Bold-tlf-t1.vf \
tex-FiraSans-Bold-tlf-ts1--base.tfm \
tex-FiraSans-Bold-tlf-ts1.tfm \
tex-FiraSans-Bold-tlf-ts1.vf \
tex-FiraSans-Bold-tosf-lgr.tfm \
tex-FiraSans-Bold-tosf-ly1.tfm \
tex-FiraSans-Bold-tosf-ot1.tfm \
tex-FiraSans-Bold-tosf-sc-lgr.tfm \
tex-FiraSans-Bold-tosf-sc-ly1--base.tfm \
tex-FiraSans-Bold-tosf-sc-ly1.tfm \
tex-FiraSans-Bold-tosf-sc-ly1.vf \
tex-FiraSans-Bold-tosf-sc-ot1--base.tfm \
tex-FiraSans-Bold-tosf-sc-ot1.tfm \
tex-FiraSans-Bold-tosf-sc-ot1.vf \
tex-FiraSans-Bold-tosf-sc-t1--base.tfm \
tex-FiraSans-Bold-tosf-sc-t1.tfm \
tex-FiraSans-Bold-tosf-sc-t1.vf \
tex-FiraSans-Bold-tosf-t1--base.tfm \
tex-FiraSans-Bold-tosf-t1.tfm \
tex-FiraSans-Bold-tosf-t1.vf \
tex-FiraSans-Bold-tosf-ts1--base.tfm \
tex-FiraSans-Bold-tosf-ts1.tfm \
tex-FiraSans-Bold-tosf-ts1.vf \
tex-FiraSans-BoldItalic-lf-lgr.tfm \
tex-FiraSans-BoldItalic-lf-ly1.tfm \
tex-FiraSans-BoldItalic-lf-ot1.tfm \
tex-FiraSans-BoldItalic-lf-sc-lgr.tfm \
tex-FiraSans-BoldItalic-lf-sc-ly1--base.tfm \
tex-FiraSans-BoldItalic-lf-sc-ly1.tfm \
tex-FiraSans-BoldItalic-lf-sc-ly1.vf \
tex-FiraSans-BoldItalic-lf-sc-ot1--base.tfm \
tex-FiraSans-BoldItalic-lf-sc-ot1.tfm \
tex-FiraSans-BoldItalic-lf-sc-ot1.vf \
tex-FiraSans-BoldItalic-lf-sc-t1--base.tfm \
tex-FiraSans-BoldItalic-lf-sc-t1.tfm \
tex-FiraSans-BoldItalic-lf-sc-t1.vf \
tex-FiraSans-BoldItalic-lf-t1--base.tfm \
tex-FiraSans-BoldItalic-lf-t1.tfm \
tex-FiraSans-BoldItalic-lf-t1.vf \
tex-FiraSans-BoldItalic-lf-ts1--base.tfm \
tex-FiraSans-BoldItalic-lf-ts1.tfm \
tex-FiraSans-BoldItalic-lf-ts1.vf \
tex-FiraSans-BoldItalic-osf-lgr.tfm \
tex-FiraSans-BoldItalic-osf-ly1.tfm \
tex-FiraSans-BoldItalic-osf-ot1.tfm \
tex-FiraSans-BoldItalic-osf-sc-lgr.tfm \
tex-FiraSans-BoldItalic-osf-sc-ly1--base.tfm \
tex-FiraSans-BoldItalic-osf-sc-ly1.tfm \
tex-FiraSans-BoldItalic-osf-sc-ly1.vf \
tex-FiraSans-BoldItalic-osf-sc-ot1--base.tfm \
tex-FiraSans-BoldItalic-osf-sc-ot1.tfm \
tex-FiraSans-BoldItalic-osf-sc-ot1.vf \
tex-FiraSans-BoldItalic-osf-sc-t1--base.tfm \
tex-FiraSans-BoldItalic-osf-sc-t1.tfm \
tex-FiraSans-BoldItalic-osf-sc-t1.vf \
tex-FiraSans-BoldItalic-osf-t1--base.tfm \
tex-FiraSans-BoldItalic-osf-t1.tfm \
tex-FiraSans-BoldItalic-osf-t1.vf \
tex-FiraSans-BoldItalic-osf-ts1--base.tfm \
tex-FiraSans-BoldItalic-osf-ts1.tfm \
tex-FiraSans-BoldItalic-osf-ts1.vf \
tex-FiraSans-BoldItalic-sup-lgr.tfm \
tex-FiraSans-BoldItalic-sup-ly1.tfm \
tex-FiraSans-BoldItalic-sup-ot1.tfm \
tex-FiraSans-BoldItalic-sup-t1--base.tfm \
tex-FiraSans-BoldItalic-sup-t1.tfm \
tex-FiraSans-BoldItalic-sup-t1.vf \
tex-FiraSans-BoldItalic-tlf-lgr.tfm \
tex-FiraSans-BoldItalic-tlf-ly1.tfm \
tex-FiraSans-BoldItalic-tlf-ot1.tfm \
tex-FiraSans-BoldItalic-tlf-sc-lgr.tfm \
tex-FiraSans-BoldItalic-tlf-sc-ly1--base.tfm \
tex-FiraSans-BoldItalic-tlf-sc-ly1.tfm \
tex-FiraSans-BoldItalic-tlf-sc-ly1.vf \
tex-FiraSans-BoldItalic-tlf-sc-ot1--base.tfm \
tex-FiraSans-BoldItalic-tlf-sc-ot1.tfm \
tex-FiraSans-BoldItalic-tlf-sc-ot1.vf \
tex-FiraSans-BoldItalic-tlf-sc-t1--base.tfm \
tex-FiraSans-BoldItalic-tlf-sc-t1.tfm \
tex-FiraSans-BoldItalic-tlf-sc-t1.vf \
tex-FiraSans-BoldItalic-tlf-t1--base.tfm \
tex-FiraSans-BoldItalic-tlf-t1.tfm \
tex-FiraSans-BoldItalic-tlf-t1.vf \
tex-FiraSans-BoldItalic-tlf-ts1--base.tfm \
tex-FiraSans-BoldItalic-tlf-ts1.tfm \
tex-FiraSans-BoldItalic-tlf-ts1.vf \
tex-FiraSans-BoldItalic-tosf-lgr.tfm \
tex-FiraSans-BoldItalic-tosf-ly1.tfm \
tex-FiraSans-BoldItalic-tosf-ot1.tfm \
tex-FiraSans-BoldItalic-tosf-sc-lgr.tfm \
tex-FiraSans-BoldItalic-tosf-sc-ly1--base.tfm \
tex-FiraSans-BoldItalic-tosf-sc-ly1.tfm \
tex-FiraSans-BoldItalic-tosf-sc-ly1.vf \
tex-FiraSans-BoldItalic-tosf-sc-ot1--base.tfm \
tex-FiraSans-BoldItalic-tosf-sc-ot1.tfm \
tex-FiraSans-BoldItalic-tosf-sc-ot1.vf \
tex-FiraSans-BoldItalic-tosf-sc-t1--base.tfm \
tex-FiraSans-BoldItalic-tosf-sc-t1.tfm \
tex-FiraSans-BoldItalic-tosf-sc-t1.vf \
tex-FiraSans-BoldItalic-tosf-t1--base.tfm \
tex-FiraSans-BoldItalic-tosf-t1.tfm \
tex-FiraSans-BoldItalic-tosf-t1.vf \
tex-FiraSans-BoldItalic-tosf-ts1--base.tfm \
tex-FiraSans-BoldItalic-tosf-ts1.tfm \
tex-FiraSans-BoldItalic-tosf-ts1.vf \
tex-FiraSans-Book-lf-lgr.tfm \
tex-FiraSans-Book-lf-ly1.tfm \
tex-FiraSans-Book-lf-ot1.tfm \
tex-FiraSans-Book-lf-sc-lgr.tfm \
tex-FiraSans-Book-lf-sc-ly1--base.tfm \
tex-FiraSans-Book-lf-sc-ly1.tfm \
tex-FiraSans-Book-lf-sc-ly1.vf \
tex-FiraSans-Book-lf-sc-ot1--base.tfm \
tex-FiraSans-Book-lf-sc-ot1.tfm \
tex-FiraSans-Book-lf-sc-ot1.vf \
tex-FiraSans-Book-lf-sc-t1--base.tfm \
tex-FiraSans-Book-lf-sc-t1.tfm \
tex-FiraSans-Book-lf-sc-t1.vf \
tex-FiraSans-Book-lf-t1--base.tfm \
tex-FiraSans-Book-lf-t1.tfm \
tex-FiraSans-Book-lf-t1.vf \
tex-FiraSans-Book-lf-ts1--base.tfm \
tex-FiraSans-Book-lf-ts1.tfm \
tex-FiraSans-Book-lf-ts1.vf \
tex-FiraSans-Book-osf-lgr.tfm \
tex-FiraSans-Book-osf-ly1.tfm \
tex-FiraSans-Book-osf-ot1.tfm \
tex-FiraSans-Book-osf-sc-lgr.tfm \
tex-FiraSans-Book-osf-sc-ly1--base.tfm \
tex-FiraSans-Book-osf-sc-ly1.tfm \
tex-FiraSans-Book-osf-sc-ly1.vf \
tex-FiraSans-Book-osf-sc-ot1--base.tfm \
tex-FiraSans-Book-osf-sc-ot1.tfm \
tex-FiraSans-Book-osf-sc-ot1.vf \
tex-FiraSans-Book-osf-sc-t1--base.tfm \
tex-FiraSans-Book-osf-sc-t1.tfm \
tex-FiraSans-Book-osf-sc-t1.vf \
tex-FiraSans-Book-osf-t1--base.tfm \
tex-FiraSans-Book-osf-t1.tfm \
tex-FiraSans-Book-osf-t1.vf \
tex-FiraSans-Book-osf-ts1--base.tfm \
tex-FiraSans-Book-osf-ts1.tfm \
tex-FiraSans-Book-osf-ts1.vf \
tex-FiraSans-Book-sup-lgr.tfm \
tex-FiraSans-Book-sup-ly1.tfm \
tex-FiraSans-Book-sup-ot1.tfm \
tex-FiraSans-Book-sup-t1--base.tfm \
tex-FiraSans-Book-sup-t1.tfm \
tex-FiraSans-Book-sup-t1.vf \
tex-FiraSans-Book-tlf-lgr.tfm \
tex-FiraSans-Book-tlf-ly1.tfm \
tex-FiraSans-Book-tlf-ot1.tfm \
tex-FiraSans-Book-tlf-sc-lgr.tfm \
tex-FiraSans-Book-tlf-sc-ly1--base.tfm \
tex-FiraSans-Book-tlf-sc-ly1.tfm \
tex-FiraSans-Book-tlf-sc-ly1.vf \
tex-FiraSans-Book-tlf-sc-ot1--base.tfm \
tex-FiraSans-Book-tlf-sc-ot1.tfm \
tex-FiraSans-Book-tlf-sc-ot1.vf \
tex-FiraSans-Book-tlf-sc-t1--base.tfm \
tex-FiraSans-Book-tlf-sc-t1.tfm \
tex-FiraSans-Book-tlf-sc-t1.vf \
tex-FiraSans-Book-tlf-t1--base.tfm \
tex-FiraSans-Book-tlf-t1.tfm \
tex-FiraSans-Book-tlf-t1.vf \
tex-FiraSans-Book-tlf-ts1--base.tfm \
tex-FiraSans-Book-tlf-ts1.tfm \
tex-FiraSans-Book-tlf-ts1.vf \
tex-FiraSans-Book-tosf-lgr.tfm \
tex-FiraSans-Book-tosf-ly1.tfm \
tex-FiraSans-Book-tosf-ot1.tfm \
tex-FiraSans-Book-tosf-sc-lgr.tfm \
tex-FiraSans-Book-tosf-sc-ly1--base.tfm \
tex-FiraSans-Book-tosf-sc-ly1.tfm \
tex-FiraSans-Book-tosf-sc-ly1.vf \
tex-FiraSans-Book-tosf-sc-ot1--base.tfm \
tex-FiraSans-Book-tosf-sc-ot1.tfm \
tex-FiraSans-Book-tosf-sc-ot1.vf \
tex-FiraSans-Book-tosf-sc-t1--base.tfm \
tex-FiraSans-Book-tosf-sc-t1.tfm \
tex-FiraSans-Book-tosf-sc-t1.vf \
tex-FiraSans-Book-tosf-t1--base.tfm \
tex-FiraSans-Book-tosf-t1.tfm \
tex-FiraSans-Book-tosf-t1.vf \
tex-FiraSans-Book-tosf-ts1--base.tfm \
tex-FiraSans-Book-tosf-ts1.tfm \
tex-FiraSans-Book-tosf-ts1.vf \
tex-FiraSans-BookItalic-lf-lgr.tfm \
tex-FiraSans-BookItalic-lf-ly1.tfm \
tex-FiraSans-BookItalic-lf-ot1.tfm \
tex-FiraSans-BookItalic-lf-sc-lgr.tfm \
tex-FiraSans-BookItalic-lf-sc-ly1--base.tfm \
tex-FiraSans-BookItalic-lf-sc-ly1.tfm \
tex-FiraSans-BookItalic-lf-sc-ly1.vf \
tex-FiraSans-BookItalic-lf-sc-ot1--base.tfm \
tex-FiraSans-BookItalic-lf-sc-ot1.tfm \
tex-FiraSans-BookItalic-lf-sc-ot1.vf \
tex-FiraSans-BookItalic-lf-sc-t1--base.tfm \
tex-FiraSans-BookItalic-lf-sc-t1.tfm \
tex-FiraSans-BookItalic-lf-sc-t1.vf \
tex-FiraSans-BookItalic-lf-t1--base.tfm \
tex-FiraSans-BookItalic-lf-t1.tfm \
tex-FiraSans-BookItalic-lf-t1.vf \
tex-FiraSans-BookItalic-lf-ts1--base.tfm \
tex-FiraSans-BookItalic-lf-ts1.tfm \
tex-FiraSans-BookItalic-lf-ts1.vf \
tex-FiraSans-BookItalic-osf-lgr.tfm \
tex-FiraSans-BookItalic-osf-ly1.tfm \
tex-FiraSans-BookItalic-osf-ot1.tfm \
tex-FiraSans-BookItalic-osf-sc-lgr.tfm \
tex-FiraSans-BookItalic-osf-sc-ly1--base.tfm \
tex-FiraSans-BookItalic-osf-sc-ly1.tfm \
tex-FiraSans-BookItalic-osf-sc-ly1.vf \
tex-FiraSans-BookItalic-osf-sc-ot1--base.tfm \
tex-FiraSans-BookItalic-osf-sc-ot1.tfm \
tex-FiraSans-BookItalic-osf-sc-ot1.vf \
tex-FiraSans-BookItalic-osf-sc-t1--base.tfm \
tex-FiraSans-BookItalic-osf-sc-t1.tfm \
tex-FiraSans-BookItalic-osf-sc-t1.vf \
tex-FiraSans-BookItalic-osf-t1--base.tfm \
tex-FiraSans-BookItalic-osf-t1.tfm \
tex-FiraSans-BookItalic-osf-t1.vf \
tex-FiraSans-BookItalic-osf-ts1--base.tfm \
tex-FiraSans-BookItalic-osf-ts1.tfm \
tex-FiraSans-BookItalic-osf-ts1.vf \
tex-FiraSans-BookItalic-sup-lgr.tfm \
tex-FiraSans-BookItalic-sup-ly1.tfm \
tex-FiraSans-BookItalic-sup-ot1.tfm \
tex-FiraSans-BookItalic-sup-t1--base.tfm \
tex-FiraSans-BookItalic-sup-t1.tfm \
tex-FiraSans-BookItalic-sup-t1.vf \
tex-FiraSans-BookItalic-tlf-lgr.tfm \
tex-FiraSans-BookItalic-tlf-ly1.tfm \
tex-FiraSans-BookItalic-tlf-ot1.tfm \
tex-FiraSans-BookItalic-tlf-sc-lgr.tfm \
tex-FiraSans-BookItalic-tlf-sc-ly1--base.tfm \
tex-FiraSans-BookItalic-tlf-sc-ly1.tfm \
tex-FiraSans-BookItalic-tlf-sc-ly1.vf \
tex-FiraSans-BookItalic-tlf-sc-ot1--base.tfm \
tex-FiraSans-BookItalic-tlf-sc-ot1.tfm \
tex-FiraSans-BookItalic-tlf-sc-ot1.vf \
tex-FiraSans-BookItalic-tlf-sc-t1--base.tfm \
tex-FiraSans-BookItalic-tlf-sc-t1.tfm \
tex-FiraSans-BookItalic-tlf-sc-t1.vf \
tex-FiraSans-BookItalic-tlf-t1--base.tfm \
tex-FiraSans-BookItalic-tlf-t1.tfm \
tex-FiraSans-BookItalic-tlf-t1.vf \
tex-FiraSans-BookItalic-tlf-ts1--base.tfm \
tex-FiraSans-BookItalic-tlf-ts1.tfm \
tex-FiraSans-BookItalic-tlf-ts1.vf \
tex-FiraSans-BookItalic-tosf-lgr.tfm \
tex-FiraSans-BookItalic-tosf-ly1.tfm \
tex-FiraSans-BookItalic-tosf-ot1.tfm \
tex-FiraSans-BookItalic-tosf-sc-lgr.tfm \
tex-FiraSans-BookItalic-tosf-sc-ly1--base.tfm \
tex-FiraSans-BookItalic-tosf-sc-ly1.tfm \
tex-FiraSans-BookItalic-tosf-sc-ly1.vf \
tex-FiraSans-BookItalic-tosf-sc-ot1--base.tfm \
tex-FiraSans-BookItalic-tosf-sc-ot1.tfm \
tex-FiraSans-BookItalic-tosf-sc-ot1.vf \
tex-FiraSans-BookItalic-tosf-sc-t1--base.tfm \
tex-FiraSans-BookItalic-tosf-sc-t1.tfm \
tex-FiraSans-BookItalic-tosf-sc-t1.vf \
tex-FiraSans-BookItalic-tosf-t1--base.tfm \
tex-FiraSans-BookItalic-tosf-t1.tfm \
tex-FiraSans-BookItalic-tosf-t1.vf \
tex-FiraSans-BookItalic-tosf-ts1--base.tfm \
tex-FiraSans-BookItalic-tosf-ts1.tfm \
tex-FiraSans-BookItalic-tosf-ts1.vf \
tex-FiraSans-ExtraBold-lf-lgr.tfm \
tex-FiraSans-ExtraBold-lf-ly1.tfm \
tex-FiraSans-ExtraBold-lf-ot1.tfm \
tex-FiraSans-ExtraBold-lf-sc-lgr.tfm \
tex-FiraSans-ExtraBold-lf-sc-ly1--base.tfm \
tex-FiraSans-ExtraBold-lf-sc-ly1.tfm \
tex-FiraSans-ExtraBold-lf-sc-ly1.vf \
tex-FiraSans-ExtraBold-lf-sc-ot1--base.tfm \
tex-FiraSans-ExtraBold-lf-sc-ot1.tfm \
tex-FiraSans-ExtraBold-lf-sc-ot1.vf \
tex-FiraSans-ExtraBold-lf-sc-t1--base.tfm \
tex-FiraSans-ExtraBold-lf-sc-t1.tfm \
tex-FiraSans-ExtraBold-lf-sc-t1.vf \
tex-FiraSans-ExtraBold-lf-t1--base.tfm \
tex-FiraSans-ExtraBold-lf-t1.tfm \
tex-FiraSans-ExtraBold-lf-t1.vf \
tex-FiraSans-ExtraBold-lf-ts1--base.tfm \
tex-FiraSans-ExtraBold-lf-ts1.tfm \
tex-FiraSans-ExtraBold-lf-ts1.vf \
tex-FiraSans-ExtraBold-osf-lgr.tfm \
tex-FiraSans-ExtraBold-osf-ly1.tfm \
tex-FiraSans-ExtraBold-osf-ot1.tfm \
tex-FiraSans-ExtraBold-osf-sc-lgr.tfm \
tex-FiraSans-ExtraBold-osf-sc-ly1--base.tfm \
tex-FiraSans-ExtraBold-osf-sc-ly1.tfm \
tex-FiraSans-ExtraBold-osf-sc-ly1.vf \
tex-FiraSans-ExtraBold-osf-sc-ot1--base.tfm \
tex-FiraSans-ExtraBold-osf-sc-ot1.tfm \
tex-FiraSans-ExtraBold-osf-sc-ot1.vf \
tex-FiraSans-ExtraBold-osf-sc-t1--base.tfm \
tex-FiraSans-ExtraBold-osf-sc-t1.tfm \
tex-FiraSans-ExtraBold-osf-sc-t1.vf \
tex-FiraSans-ExtraBold-osf-t1--base.tfm \
tex-FiraSans-ExtraBold-osf-t1.tfm \
tex-FiraSans-ExtraBold-osf-t1.vf \
tex-FiraSans-ExtraBold-osf-ts1--base.tfm \
tex-FiraSans-ExtraBold-osf-ts1.tfm \
tex-FiraSans-ExtraBold-osf-ts1.vf \
tex-FiraSans-ExtraBold-sup-lgr.tfm \
tex-FiraSans-ExtraBold-sup-ly1.tfm \
tex-FiraSans-ExtraBold-sup-ot1.tfm \
tex-FiraSans-ExtraBold-sup-t1--base.tfm \
tex-FiraSans-ExtraBold-sup-t1.tfm \
tex-FiraSans-ExtraBold-sup-t1.vf \
tex-FiraSans-ExtraBold-tlf-lgr.tfm \
tex-FiraSans-ExtraBold-tlf-ly1.tfm \
tex-FiraSans-ExtraBold-tlf-ot1.tfm \
tex-FiraSans-ExtraBold-tlf-sc-lgr.tfm \
tex-FiraSans-ExtraBold-tlf-sc-ly1--base.tfm \
tex-FiraSans-ExtraBold-tlf-sc-ly1.tfm \
tex-FiraSans-ExtraBold-tlf-sc-ly1.vf \
tex-FiraSans-ExtraBold-tlf-sc-ot1--base.tfm \
tex-FiraSans-ExtraBold-tlf-sc-ot1.tfm \
tex-FiraSans-ExtraBold-tlf-sc-ot1.vf \
tex-FiraSans-ExtraBold-tlf-sc-t1--base.tfm \
tex-FiraSans-ExtraBold-tlf-sc-t1.tfm \
tex-FiraSans-ExtraBold-tlf-sc-t1.vf \
tex-FiraSans-ExtraBold-tlf-t1--base.tfm \
tex-FiraSans-ExtraBold-tlf-t1.tfm \
tex-FiraSans-ExtraBold-tlf-t1.vf \
tex-FiraSans-ExtraBold-tlf-ts1--base.tfm \
tex-FiraSans-ExtraBold-tlf-ts1.tfm \
tex-FiraSans-ExtraBold-tlf-ts1.vf \
tex-FiraSans-ExtraBold-tosf-lgr.tfm \
tex-FiraSans-ExtraBold-tosf-ly1.tfm \
tex-FiraSans-ExtraBold-tosf-ot1.tfm \
tex-FiraSans-ExtraBold-tosf-sc-lgr.tfm \
tex-FiraSans-ExtraBold-tosf-sc-ly1--base.tfm \
tex-FiraSans-ExtraBold-tosf-sc-ly1.tfm \
tex-FiraSans-ExtraBold-tosf-sc-ly1.vf \
tex-FiraSans-ExtraBold-tosf-sc-ot1--base.tfm \
tex-FiraSans-ExtraBold-tosf-sc-ot1.tfm \
tex-FiraSans-ExtraBold-tosf-sc-ot1.vf \
tex-FiraSans-ExtraBold-tosf-sc-t1--base.tfm \
tex-FiraSans-ExtraBold-tosf-sc-t1.tfm \
tex-FiraSans-ExtraBold-tosf-sc-t1.vf \
tex-FiraSans-ExtraBold-tosf-t1--base.tfm \
tex-FiraSans-ExtraBold-tosf-t1.tfm \
tex-FiraSans-ExtraBold-tosf-t1.vf \
tex-FiraSans-ExtraBold-tosf-ts1--base.tfm \
tex-FiraSans-ExtraBold-tosf-ts1.tfm \
tex-FiraSans-ExtraBold-tosf-ts1.vf \
tex-FiraSans-ExtraBoldItalic-lf-lgr.tfm \
tex-FiraSans-ExtraBoldItalic-lf-ly1.tfm \
tex-FiraSans-ExtraBoldItalic-lf-ot1.tfm \
tex-FiraSans-ExtraBoldItalic-lf-sc-lgr.tfm \
tex-FiraSans-ExtraBoldItalic-lf-sc-ly1--base.tfm \
tex-FiraSans-ExtraBoldItalic-lf-sc-ly1.tfm \
tex-FiraSans-ExtraBoldItalic-lf-sc-ly1.vf \
tex-FiraSans-ExtraBoldItalic-lf-sc-ot1--base.tfm \
tex-FiraSans-ExtraBoldItalic-lf-sc-ot1.tfm \
tex-FiraSans-ExtraBoldItalic-lf-sc-ot1.vf \
tex-FiraSans-ExtraBoldItalic-lf-sc-t1--base.tfm \
tex-FiraSans-ExtraBoldItalic-lf-sc-t1.tfm \
tex-FiraSans-ExtraBoldItalic-lf-sc-t1.vf \
tex-FiraSans-ExtraBoldItalic-lf-t1--base.tfm \
tex-FiraSans-ExtraBoldItalic-lf-t1.tfm \
tex-FiraSans-ExtraBoldItalic-lf-t1.vf \
tex-FiraSans-ExtraBoldItalic-lf-ts1--base.tfm \
tex-FiraSans-ExtraBoldItalic-lf-ts1.tfm \
tex-FiraSans-ExtraBoldItalic-lf-ts1.vf \
tex-FiraSans-ExtraBoldItalic-osf-lgr.tfm \
tex-FiraSans-ExtraBoldItalic-osf-ly1.tfm \
tex-FiraSans-ExtraBoldItalic-osf-ot1.tfm \
tex-FiraSans-ExtraBoldItalic-osf-sc-lgr.tfm \
tex-FiraSans-ExtraBoldItalic-osf-sc-ly1--base.tfm \
tex-FiraSans-ExtraBoldItalic-osf-sc-ly1.tfm \
tex-FiraSans-ExtraBoldItalic-osf-sc-ly1.vf \
tex-FiraSans-ExtraBoldItalic-osf-sc-ot1--base.tfm \
tex-FiraSans-ExtraBoldItalic-osf-sc-ot1.tfm \
tex-FiraSans-ExtraBoldItalic-osf-sc-ot1.vf \
tex-FiraSans-ExtraBoldItalic-osf-sc-t1--base.tfm \
tex-FiraSans-ExtraBoldItalic-osf-sc-t1.tfm \
tex-FiraSans-ExtraBoldItalic-osf-sc-t1.vf \
tex-FiraSans-ExtraBoldItalic-osf-t1--base.tfm \
tex-FiraSans-ExtraBoldItalic-osf-t1.tfm \
tex-FiraSans-ExtraBoldItalic-osf-t1.vf \
tex-FiraSans-ExtraBoldItalic-osf-ts1--base.tfm \
tex-FiraSans-ExtraBoldItalic-osf-ts1.tfm \
tex-FiraSans-ExtraBoldItalic-osf-ts1.vf \
tex-FiraSans-ExtraBoldItalic-sup-lgr.tfm \
tex-FiraSans-ExtraBoldItalic-sup-ly1.tfm \
tex-FiraSans-ExtraBoldItalic-sup-ot1.tfm \
tex-FiraSans-ExtraBoldItalic-sup-t1--base.tfm \
tex-FiraSans-ExtraBoldItalic-sup-t1.tfm \
tex-FiraSans-ExtraBoldItalic-sup-t1.vf \
tex-FiraSans-ExtraBoldItalic-tlf-lgr.tfm \
tex-FiraSans-ExtraBoldItalic-tlf-ly1.tfm \
tex-FiraSans-ExtraBoldItalic-tlf-ot1.tfm \
tex-FiraSans-ExtraBoldItalic-tlf-sc-lgr.tfm \
tex-FiraSans-ExtraBoldItalic-tlf-sc-ly1--base.tfm \
tex-FiraSans-ExtraBoldItalic-tlf-sc-ly1.tfm \
tex-FiraSans-ExtraBoldItalic-tlf-sc-ly1.vf \
tex-FiraSans-ExtraBoldItalic-tlf-sc-ot1--base.tfm \
tex-FiraSans-ExtraBoldItalic-tlf-sc-ot1.tfm \
tex-FiraSans-ExtraBoldItalic-tlf-sc-ot1.vf \
tex-FiraSans-ExtraBoldItalic-tlf-sc-t1--base.tfm \
tex-FiraSans-ExtraBoldItalic-tlf-sc-t1.tfm \
tex-FiraSans-ExtraBoldItalic-tlf-sc-t1.vf \
tex-FiraSans-ExtraBoldItalic-tlf-t1--base.tfm \
tex-FiraSans-ExtraBoldItalic-tlf-t1.tfm \
tex-FiraSans-ExtraBoldItalic-tlf-t1.vf \
tex-FiraSans-ExtraBoldItalic-tlf-ts1--base.tfm \
tex-FiraSans-ExtraBoldItalic-tlf-ts1.tfm \
tex-FiraSans-ExtraBoldItalic-tlf-ts1.vf \
tex-FiraSans-ExtraBoldItalic-tosf-lgr.tfm \
tex-FiraSans-ExtraBoldItalic-tosf-ly1.tfm \
tex-FiraSans-ExtraBoldItalic-tosf-ot1.tfm \
tex-FiraSans-ExtraBoldItalic-tosf-sc-lgr.tfm \
tex-FiraSans-ExtraBoldItalic-tosf-sc-ly1--base.tfm \
tex-FiraSans-ExtraBoldItalic-tosf-sc-ly1.tfm \
tex-FiraSans-ExtraBoldItalic-tosf-sc-ly1.vf \
tex-FiraSans-ExtraBoldItalic-tosf-sc-ot1--base.tfm \
tex-FiraSans-ExtraBoldItalic-tosf-sc-ot1.tfm \
tex-FiraSans-ExtraBoldItalic-tosf-sc-ot1.vf \
tex-FiraSans-ExtraBoldItalic-tosf-sc-t1--base.tfm \
tex-FiraSans-ExtraBoldItalic-tosf-sc-t1.tfm \
tex-FiraSans-ExtraBoldItalic-tosf-sc-t1.vf \
tex-FiraSans-ExtraBoldItalic-tosf-t1--base.tfm \
tex-FiraSans-ExtraBoldItalic-tosf-t1.tfm \
tex-FiraSans-ExtraBoldItalic-tosf-t1.vf \
tex-FiraSans-ExtraBoldItalic-tosf-ts1--base.tfm \
tex-FiraSans-ExtraBoldItalic-tosf-ts1.tfm \
tex-FiraSans-ExtraBoldItalic-tosf-ts1.vf \
tex-FiraSans-ExtraLight-lf-lgr.tfm \
tex-FiraSans-ExtraLight-lf-ly1.tfm \
tex-FiraSans-ExtraLight-lf-ot1.tfm \
tex-FiraSans-ExtraLight-lf-sc-lgr.tfm \
tex-FiraSans-ExtraLight-lf-sc-ly1--base.tfm \
tex-FiraSans-ExtraLight-lf-sc-ly1.tfm \
tex-FiraSans-ExtraLight-lf-sc-ly1.vf \
tex-FiraSans-ExtraLight-lf-sc-ot1--base.tfm \
tex-FiraSans-ExtraLight-lf-sc-ot1.tfm \
tex-FiraSans-ExtraLight-lf-sc-ot1.vf \
tex-FiraSans-ExtraLight-lf-sc-t1--base.tfm \
tex-FiraSans-ExtraLight-lf-sc-t1.tfm \
tex-FiraSans-ExtraLight-lf-sc-t1.vf \
tex-FiraSans-ExtraLight-lf-t1--base.tfm \
tex-FiraSans-ExtraLight-lf-t1.tfm \
tex-FiraSans-ExtraLight-lf-t1.vf \
tex-FiraSans-ExtraLight-lf-ts1--base.tfm \
tex-FiraSans-ExtraLight-lf-ts1.tfm \
tex-FiraSans-ExtraLight-lf-ts1.vf \
tex-FiraSans-ExtraLight-osf-lgr.tfm \
tex-FiraSans-ExtraLight-osf-ly1.tfm \
tex-FiraSans-ExtraLight-osf-ot1.tfm \
tex-FiraSans-ExtraLight-osf-sc-lgr.tfm \
tex-FiraSans-ExtraLight-osf-sc-ly1--base.tfm \
tex-FiraSans-ExtraLight-osf-sc-ly1.tfm \
tex-FiraSans-ExtraLight-osf-sc-ly1.vf \
tex-FiraSans-ExtraLight-osf-sc-ot1--base.tfm \
tex-FiraSans-ExtraLight-osf-sc-ot1.tfm \
tex-FiraSans-ExtraLight-osf-sc-ot1.vf \
tex-FiraSans-ExtraLight-osf-sc-t1--base.tfm \
tex-FiraSans-ExtraLight-osf-sc-t1.tfm \
tex-FiraSans-ExtraLight-osf-sc-t1.vf \
tex-FiraSans-ExtraLight-osf-t1--base.tfm \
tex-FiraSans-ExtraLight-osf-t1.tfm \
tex-FiraSans-ExtraLight-osf-t1.vf \
tex-FiraSans-ExtraLight-osf-ts1--base.tfm \
tex-FiraSans-ExtraLight-osf-ts1.tfm \
tex-FiraSans-ExtraLight-osf-ts1.vf \
tex-FiraSans-ExtraLight-sup-lgr.tfm \
tex-FiraSans-ExtraLight-sup-ly1.tfm \
tex-FiraSans-ExtraLight-sup-ot1.tfm \
tex-FiraSans-ExtraLight-sup-t1--base.tfm \
tex-FiraSans-ExtraLight-sup-t1.tfm \
tex-FiraSans-ExtraLight-sup-t1.vf \
tex-FiraSans-ExtraLight-tlf-lgr.tfm \
tex-FiraSans-ExtraLight-tlf-ly1.tfm \
tex-FiraSans-ExtraLight-tlf-ot1.tfm \
tex-FiraSans-ExtraLight-tlf-sc-lgr.tfm \
tex-FiraSans-ExtraLight-tlf-sc-ly1--base.tfm \
tex-FiraSans-ExtraLight-tlf-sc-ly1.tfm \
tex-FiraSans-ExtraLight-tlf-sc-ly1.vf \
tex-FiraSans-ExtraLight-tlf-sc-ot1--base.tfm \
tex-FiraSans-ExtraLight-tlf-sc-ot1.tfm \
tex-FiraSans-ExtraLight-tlf-sc-ot1.vf \
tex-FiraSans-ExtraLight-tlf-sc-t1--base.tfm \
tex-FiraSans-ExtraLight-tlf-sc-t1.tfm \
tex-FiraSans-ExtraLight-tlf-sc-t1.vf \
tex-FiraSans-ExtraLight-tlf-t1--base.tfm \
tex-FiraSans-ExtraLight-tlf-t1.tfm \
tex-FiraSans-ExtraLight-tlf-t1.vf \
tex-FiraSans-ExtraLight-tlf-ts1--base.tfm \
tex-FiraSans-ExtraLight-tlf-ts1.tfm \
tex-FiraSans-ExtraLight-tlf-ts1.vf \
tex-FiraSans-ExtraLight-tosf-lgr.tfm \
tex-FiraSans-ExtraLight-tosf-ly1.tfm \
tex-FiraSans-ExtraLight-tosf-ot1.tfm \
tex-FiraSans-ExtraLight-tosf-sc-lgr.tfm \
tex-FiraSans-ExtraLight-tosf-sc-ly1--base.tfm \
tex-FiraSans-ExtraLight-tosf-sc-ly1.tfm \
tex-FiraSans-ExtraLight-tosf-sc-ly1.vf \
tex-FiraSans-ExtraLight-tosf-sc-ot1--base.tfm \
tex-FiraSans-ExtraLight-tosf-sc-ot1.tfm \
tex-FiraSans-ExtraLight-tosf-sc-ot1.vf \
tex-FiraSans-ExtraLight-tosf-sc-t1--base.tfm \
tex-FiraSans-ExtraLight-tosf-sc-t1.tfm \
tex-FiraSans-ExtraLight-tosf-sc-t1.vf \
tex-FiraSans-ExtraLight-tosf-t1--base.tfm \
tex-FiraSans-ExtraLight-tosf-t1.tfm \
tex-FiraSans-ExtraLight-tosf-t1.vf \
tex-FiraSans-ExtraLight-tosf-ts1--base.tfm \
tex-FiraSans-ExtraLight-tosf-ts1.tfm \
tex-FiraSans-ExtraLight-tosf-ts1.vf \
tex-FiraSans-ExtraLightItalic-lf-lgr.tfm \
tex-FiraSans-ExtraLightItalic-lf-ly1.tfm \
tex-FiraSans-ExtraLightItalic-lf-ot1.tfm \
tex-FiraSans-ExtraLightItalic-lf-sc-lgr.tfm \
tex-FiraSans-ExtraLightItalic-lf-sc-ly1--base.tfm \
tex-FiraSans-ExtraLightItalic-lf-sc-ly1.tfm \
tex-FiraSans-ExtraLightItalic-lf-sc-ly1.vf \
tex-FiraSans-ExtraLightItalic-lf-sc-ot1--base.tfm \
tex-FiraSans-ExtraLightItalic-lf-sc-ot1.tfm \
tex-FiraSans-ExtraLightItalic-lf-sc-ot1.vf \
tex-FiraSans-ExtraLightItalic-lf-sc-t1--base.tfm \
tex-FiraSans-ExtraLightItalic-lf-sc-t1.tfm \
tex-FiraSans-ExtraLightItalic-lf-sc-t1.vf \
tex-FiraSans-ExtraLightItalic-lf-t1--base.tfm \
tex-FiraSans-ExtraLightItalic-lf-t1.tfm \
tex-FiraSans-ExtraLightItalic-lf-t1.vf \
tex-FiraSans-ExtraLightItalic-lf-ts1--base.tfm \
tex-FiraSans-ExtraLightItalic-lf-ts1.tfm \
tex-FiraSans-ExtraLightItalic-lf-ts1.vf \
tex-FiraSans-ExtraLightItalic-osf-lgr.tfm \
tex-FiraSans-ExtraLightItalic-osf-ly1.tfm \
tex-FiraSans-ExtraLightItalic-osf-ot1.tfm \
tex-FiraSans-ExtraLightItalic-osf-sc-lgr.tfm \
tex-FiraSans-ExtraLightItalic-osf-sc-ly1--base.tfm \
tex-FiraSans-ExtraLightItalic-osf-sc-ly1.tfm \
tex-FiraSans-ExtraLightItalic-osf-sc-ly1.vf \
tex-FiraSans-ExtraLightItalic-osf-sc-ot1--base.tfm \
tex-FiraSans-ExtraLightItalic-osf-sc-ot1.tfm \
tex-FiraSans-ExtraLightItalic-osf-sc-ot1.vf \
tex-FiraSans-ExtraLightItalic-osf-sc-t1--base.tfm \
tex-FiraSans-ExtraLightItalic-osf-sc-t1.tfm \
tex-FiraSans-ExtraLightItalic-osf-sc-t1.vf \
tex-FiraSans-ExtraLightItalic-osf-t1--base.tfm \
tex-FiraSans-ExtraLightItalic-osf-t1.tfm \
tex-FiraSans-ExtraLightItalic-osf-t1.vf \
tex-FiraSans-ExtraLightItalic-osf-ts1--base.tfm \
tex-FiraSans-ExtraLightItalic-osf-ts1.tfm \
tex-FiraSans-ExtraLightItalic-osf-ts1.vf \
tex-FiraSans-ExtraLightItalic-sup-lgr.tfm \
tex-FiraSans-ExtraLightItalic-sup-ly1.tfm \
tex-FiraSans-ExtraLightItalic-sup-ot1.tfm \
tex-FiraSans-ExtraLightItalic-sup-t1--base.tfm \
tex-FiraSans-ExtraLightItalic-sup-t1.tfm \
tex-FiraSans-ExtraLightItalic-sup-t1.vf \
tex-FiraSans-ExtraLightItalic-tlf-lgr.tfm \
tex-FiraSans-ExtraLightItalic-tlf-ly1.tfm \
tex-FiraSans-ExtraLightItalic-tlf-ot1.tfm \
tex-FiraSans-ExtraLightItalic-tlf-sc-lgr.tfm \
tex-FiraSans-ExtraLightItalic-tlf-sc-ly1--base.tfm \
tex-FiraSans-ExtraLightItalic-tlf-sc-ly1.tfm \
tex-FiraSans-ExtraLightItalic-tlf-sc-ly1.vf \
tex-FiraSans-ExtraLightItalic-tlf-sc-ot1--base.tfm \
tex-FiraSans-ExtraLightItalic-tlf-sc-ot1.tfm \
tex-FiraSans-ExtraLightItalic-tlf-sc-ot1.vf \
tex-FiraSans-ExtraLightItalic-tlf-sc-t1--base.tfm \
tex-FiraSans-ExtraLightItalic-tlf-sc-t1.tfm \
tex-FiraSans-ExtraLightItalic-tlf-sc-t1.vf \
tex-FiraSans-ExtraLightItalic-tlf-t1--base.tfm \
tex-FiraSans-ExtraLightItalic-tlf-t1.tfm \
tex-FiraSans-ExtraLightItalic-tlf-t1.vf \
tex-FiraSans-ExtraLightItalic-tlf-ts1--base.tfm \
tex-FiraSans-ExtraLightItalic-tlf-ts1.tfm \
tex-FiraSans-ExtraLightItalic-tlf-ts1.vf \
tex-FiraSans-ExtraLightItalic-tosf-lgr.tfm \
tex-FiraSans-ExtraLightItalic-tosf-ly1.tfm \
tex-FiraSans-ExtraLightItalic-tosf-ot1.tfm \
tex-FiraSans-ExtraLightItalic-tosf-sc-lgr.tfm \
tex-FiraSans-ExtraLightItalic-tosf-sc-ly1--base.tfm \
tex-FiraSans-ExtraLightItalic-tosf-sc-ly1.tfm \
tex-FiraSans-ExtraLightItalic-tosf-sc-ly1.vf \
tex-FiraSans-ExtraLightItalic-tosf-sc-ot1--base.tfm \
tex-FiraSans-ExtraLightItalic-tosf-sc-ot1.tfm \
tex-FiraSans-ExtraLightItalic-tosf-sc-ot1.vf \
tex-FiraSans-ExtraLightItalic-tosf-sc-t1--base.tfm \
tex-FiraSans-ExtraLightItalic-tosf-sc-t1.tfm \
tex-FiraSans-ExtraLightItalic-tosf-sc-t1.vf \
tex-FiraSans-ExtraLightItalic-tosf-t1--base.tfm \
tex-FiraSans-ExtraLightItalic-tosf-t1.tfm \
tex-FiraSans-ExtraLightItalic-tosf-t1.vf \
tex-FiraSans-ExtraLightItalic-tosf-ts1--base.tfm \
tex-FiraSans-ExtraLightItalic-tosf-ts1.tfm \
tex-FiraSans-ExtraLightItalic-tosf-ts1.vf \
tex-FiraSans-Heavy-lf-lgr.tfm \
tex-FiraSans-Heavy-lf-ly1.tfm \
tex-FiraSans-Heavy-lf-ot1.tfm \
tex-FiraSans-Heavy-lf-sc-lgr.tfm \
tex-FiraSans-Heavy-lf-sc-ly1--base.tfm \
tex-FiraSans-Heavy-lf-sc-ly1.tfm \
tex-FiraSans-Heavy-lf-sc-ly1.vf \
tex-FiraSans-Heavy-lf-sc-ot1--base.tfm \
tex-FiraSans-Heavy-lf-sc-ot1.tfm \
tex-FiraSans-Heavy-lf-sc-ot1.vf \
tex-FiraSans-Heavy-lf-sc-t1--base.tfm \
tex-FiraSans-Heavy-lf-sc-t1.tfm \
tex-FiraSans-Heavy-lf-sc-t1.vf \
tex-FiraSans-Heavy-lf-t1--base.tfm \
tex-FiraSans-Heavy-lf-t1.tfm \
tex-FiraSans-Heavy-lf-t1.vf \
tex-FiraSans-Heavy-lf-ts1--base.tfm \
tex-FiraSans-Heavy-lf-ts1.tfm \
tex-FiraSans-Heavy-lf-ts1.vf \
tex-FiraSans-Heavy-osf-lgr.tfm \
tex-FiraSans-Heavy-osf-ly1.tfm \
tex-FiraSans-Heavy-osf-ot1.tfm \
tex-FiraSans-Heavy-osf-sc-lgr.tfm \
tex-FiraSans-Heavy-osf-sc-ly1--base.tfm \
tex-FiraSans-Heavy-osf-sc-ly1.tfm \
tex-FiraSans-Heavy-osf-sc-ly1.vf \
tex-FiraSans-Heavy-osf-sc-ot1--base.tfm \
tex-FiraSans-Heavy-osf-sc-ot1.tfm \
tex-FiraSans-Heavy-osf-sc-ot1.vf \
tex-FiraSans-Heavy-osf-sc-t1--base.tfm \
tex-FiraSans-Heavy-osf-sc-t1.tfm \
tex-FiraSans-Heavy-osf-sc-t1.vf \
tex-FiraSans-Heavy-osf-t1--base.tfm \
tex-FiraSans-Heavy-osf-t1.tfm \
tex-FiraSans-Heavy-osf-t1.vf \
tex-FiraSans-Heavy-osf-ts1--base.tfm \
tex-FiraSans-Heavy-osf-ts1.tfm \
tex-FiraSans-Heavy-osf-ts1.vf \
tex-FiraSans-Heavy-sup-lgr.tfm \
tex-FiraSans-Heavy-sup-ly1.tfm \
tex-FiraSans-Heavy-sup-ot1.tfm \
tex-FiraSans-Heavy-sup-t1--base.tfm \
tex-FiraSans-Heavy-sup-t1.tfm \
tex-FiraSans-Heavy-sup-t1.vf \
tex-FiraSans-Heavy-tlf-lgr.tfm \
tex-FiraSans-Heavy-tlf-ly1.tfm \
tex-FiraSans-Heavy-tlf-ot1.tfm \
tex-FiraSans-Heavy-tlf-sc-lgr.tfm \
tex-FiraSans-Heavy-tlf-sc-ly1--base.tfm \
tex-FiraSans-Heavy-tlf-sc-ly1.tfm \
tex-FiraSans-Heavy-tlf-sc-ly1.vf \
tex-FiraSans-Heavy-tlf-sc-ot1--base.tfm \
tex-FiraSans-Heavy-tlf-sc-ot1.tfm \
tex-FiraSans-Heavy-tlf-sc-ot1.vf \
tex-FiraSans-Heavy-tlf-sc-t1--base.tfm \
tex-FiraSans-Heavy-tlf-sc-t1.tfm \
tex-FiraSans-Heavy-tlf-sc-t1.vf \
tex-FiraSans-Heavy-tlf-t1--base.tfm \
tex-FiraSans-Heavy-tlf-t1.tfm \
tex-FiraSans-Heavy-tlf-t1.vf \
tex-FiraSans-Heavy-tlf-ts1--base.tfm \
tex-FiraSans-Heavy-tlf-ts1.tfm \
tex-FiraSans-Heavy-tlf-ts1.vf \
tex-FiraSans-Heavy-tosf-lgr.tfm \
tex-FiraSans-Heavy-tosf-ly1.tfm \
tex-FiraSans-Heavy-tosf-ot1.tfm \
tex-FiraSans-Heavy-tosf-sc-lgr.tfm \
tex-FiraSans-Heavy-tosf-sc-ly1--base.tfm \
tex-FiraSans-Heavy-tosf-sc-ly1.tfm \
tex-FiraSans-Heavy-tosf-sc-ly1.vf \
tex-FiraSans-Heavy-tosf-sc-ot1--base.tfm \
tex-FiraSans-Heavy-tosf-sc-ot1.tfm \
tex-FiraSans-Heavy-tosf-sc-ot1.vf \
tex-FiraSans-Heavy-tosf-sc-t1--base.tfm \
tex-FiraSans-Heavy-tosf-sc-t1.tfm \
tex-FiraSans-Heavy-tosf-sc-t1.vf \
tex-FiraSans-Heavy-tosf-t1--base.tfm \
tex-FiraSans-Heavy-tosf-t1.tfm \
tex-FiraSans-Heavy-tosf-t1.vf \
tex-FiraSans-Heavy-tosf-ts1--base.tfm \
tex-FiraSans-Heavy-tosf-ts1.tfm \
tex-FiraSans-Heavy-tosf-ts1.vf \
tex-FiraSans-HeavyItalic-lf-lgr.tfm \
tex-FiraSans-HeavyItalic-lf-ly1.tfm \
tex-FiraSans-HeavyItalic-lf-ot1.tfm \
tex-FiraSans-HeavyItalic-lf-sc-lgr.tfm \
tex-FiraSans-HeavyItalic-lf-sc-ly1--base.tfm \
tex-FiraSans-HeavyItalic-lf-sc-ly1.tfm \
tex-FiraSans-HeavyItalic-lf-sc-ly1.vf \
tex-FiraSans-HeavyItalic-lf-sc-ot1--base.tfm \
tex-FiraSans-HeavyItalic-lf-sc-ot1.tfm \
tex-FiraSans-HeavyItalic-lf-sc-ot1.vf \
tex-FiraSans-HeavyItalic-lf-sc-t1--base.tfm \
tex-FiraSans-HeavyItalic-lf-sc-t1.tfm \
tex-FiraSans-HeavyItalic-lf-sc-t1.vf \
tex-FiraSans-HeavyItalic-lf-t1--base.tfm \
tex-FiraSans-HeavyItalic-lf-t1.tfm \
tex-FiraSans-HeavyItalic-lf-t1.vf \
tex-FiraSans-HeavyItalic-lf-ts1--base.tfm \
tex-FiraSans-HeavyItalic-lf-ts1.tfm \
tex-FiraSans-HeavyItalic-lf-ts1.vf \
tex-FiraSans-HeavyItalic-osf-lgr.tfm \
tex-FiraSans-HeavyItalic-osf-ly1.tfm \
tex-FiraSans-HeavyItalic-osf-ot1.tfm \
tex-FiraSans-HeavyItalic-osf-sc-lgr.tfm \
tex-FiraSans-HeavyItalic-osf-sc-ly1--base.tfm \
tex-FiraSans-HeavyItalic-osf-sc-ly1.tfm \
tex-FiraSans-HeavyItalic-osf-sc-ly1.vf \
tex-FiraSans-HeavyItalic-osf-sc-ot1--base.tfm \
tex-FiraSans-HeavyItalic-osf-sc-ot1.tfm \
tex-FiraSans-HeavyItalic-osf-sc-ot1.vf \
tex-FiraSans-HeavyItalic-osf-sc-t1--base.tfm \
tex-FiraSans-HeavyItalic-osf-sc-t1.tfm \
tex-FiraSans-HeavyItalic-osf-sc-t1.vf \
tex-FiraSans-HeavyItalic-osf-t1--base.tfm \
tex-FiraSans-HeavyItalic-osf-t1.tfm \
tex-FiraSans-HeavyItalic-osf-t1.vf \
tex-FiraSans-HeavyItalic-osf-ts1--base.tfm \
tex-FiraSans-HeavyItalic-osf-ts1.tfm \
tex-FiraSans-HeavyItalic-osf-ts1.vf \
tex-FiraSans-HeavyItalic-sup-lgr.tfm \
tex-FiraSans-HeavyItalic-sup-ly1.tfm \
tex-FiraSans-HeavyItalic-sup-ot1.tfm \
tex-FiraSans-HeavyItalic-sup-t1--base.tfm \
tex-FiraSans-HeavyItalic-sup-t1.tfm \
tex-FiraSans-HeavyItalic-sup-t1.vf \
tex-FiraSans-HeavyItalic-tlf-lgr.tfm \
tex-FiraSans-HeavyItalic-tlf-ly1.tfm \
tex-FiraSans-HeavyItalic-tlf-ot1.tfm \
tex-FiraSans-HeavyItalic-tlf-sc-lgr.tfm \
tex-FiraSans-HeavyItalic-tlf-sc-ly1--base.tfm \
tex-FiraSans-HeavyItalic-tlf-sc-ly1.tfm \
tex-FiraSans-HeavyItalic-tlf-sc-ly1.vf \
tex-FiraSans-HeavyItalic-tlf-sc-ot1--base.tfm \
tex-FiraSans-HeavyItalic-tlf-sc-ot1.tfm \
tex-FiraSans-HeavyItalic-tlf-sc-ot1.vf \
tex-FiraSans-HeavyItalic-tlf-sc-t1--base.tfm \
tex-FiraSans-HeavyItalic-tlf-sc-t1.tfm \
tex-FiraSans-HeavyItalic-tlf-sc-t1.vf \
tex-FiraSans-HeavyItalic-tlf-t1--base.tfm \
tex-FiraSans-HeavyItalic-tlf-t1.tfm \
tex-FiraSans-HeavyItalic-tlf-t1.vf \
tex-FiraSans-HeavyItalic-tlf-ts1--base.tfm \
tex-FiraSans-HeavyItalic-tlf-ts1.tfm \
tex-FiraSans-HeavyItalic-tlf-ts1.vf \
tex-FiraSans-HeavyItalic-tosf-lgr.tfm \
tex-FiraSans-HeavyItalic-tosf-ly1.tfm \
tex-FiraSans-HeavyItalic-tosf-ot1.tfm \
tex-FiraSans-HeavyItalic-tosf-sc-lgr.tfm \
tex-FiraSans-HeavyItalic-tosf-sc-ly1--base.tfm \
tex-FiraSans-HeavyItalic-tosf-sc-ly1.tfm \
tex-FiraSans-HeavyItalic-tosf-sc-ly1.vf \
tex-FiraSans-HeavyItalic-tosf-sc-ot1--base.tfm \
tex-FiraSans-HeavyItalic-tosf-sc-ot1.tfm \
tex-FiraSans-HeavyItalic-tosf-sc-ot1.vf \
tex-FiraSans-HeavyItalic-tosf-sc-t1--base.tfm \
tex-FiraSans-HeavyItalic-tosf-sc-t1.tfm \
tex-FiraSans-HeavyItalic-tosf-sc-t1.vf \
tex-FiraSans-HeavyItalic-tosf-t1--base.tfm \
tex-FiraSans-HeavyItalic-tosf-t1.tfm \
tex-FiraSans-HeavyItalic-tosf-t1.vf \
tex-FiraSans-HeavyItalic-tosf-ts1--base.tfm \
tex-FiraSans-HeavyItalic-tosf-ts1.tfm \
tex-FiraSans-HeavyItalic-tosf-ts1.vf \
tex-FiraSans-Italic-lf-lgr.tfm \
tex-FiraSans-Italic-lf-ly1.tfm \
tex-FiraSans-Italic-lf-ot1.tfm \
tex-FiraSans-Italic-lf-sc-lgr.tfm \
tex-FiraSans-Italic-lf-sc-ly1--base.tfm \
tex-FiraSans-Italic-lf-sc-ly1.tfm \
tex-FiraSans-Italic-lf-sc-ly1.vf \
tex-FiraSans-Italic-lf-sc-ot1--base.tfm \
tex-FiraSans-Italic-lf-sc-ot1.tfm \
tex-FiraSans-Italic-lf-sc-ot1.vf \
tex-FiraSans-Italic-lf-sc-t1--base.tfm \
tex-FiraSans-Italic-lf-sc-t1.tfm \
tex-FiraSans-Italic-lf-sc-t1.vf \
tex-FiraSans-Italic-lf-t1--base.tfm \
tex-FiraSans-Italic-lf-t1.tfm \
tex-FiraSans-Italic-lf-t1.vf \
tex-FiraSans-Italic-lf-ts1--base.tfm \
tex-FiraSans-Italic-lf-ts1.tfm \
tex-FiraSans-Italic-lf-ts1.vf \
tex-FiraSans-Italic-osf-lgr.tfm \
tex-FiraSans-Italic-osf-ly1.tfm \
tex-FiraSans-Italic-osf-ot1.tfm \
tex-FiraSans-Italic-osf-sc-lgr.tfm \
tex-FiraSans-Italic-osf-sc-ly1--base.tfm \
tex-FiraSans-Italic-osf-sc-ly1.tfm \
tex-FiraSans-Italic-osf-sc-ly1.vf \
tex-FiraSans-Italic-osf-sc-ot1--base.tfm \
tex-FiraSans-Italic-osf-sc-ot1.tfm \
tex-FiraSans-Italic-osf-sc-ot1.vf \
tex-FiraSans-Italic-osf-sc-t1--base.tfm \
tex-FiraSans-Italic-osf-sc-t1.tfm \
tex-FiraSans-Italic-osf-sc-t1.vf \
tex-FiraSans-Italic-osf-t1--base.tfm \
tex-FiraSans-Italic-osf-t1.tfm \
tex-FiraSans-Italic-osf-t1.vf \
tex-FiraSans-Italic-osf-ts1--base.tfm \
tex-FiraSans-Italic-osf-ts1.tfm \
tex-FiraSans-Italic-osf-ts1.vf \
tex-FiraSans-Italic-sup-lgr.tfm \
tex-FiraSans-Italic-sup-ly1.tfm \
tex-FiraSans-Italic-sup-ot1.tfm \
tex-FiraSans-Italic-sup-t1--base.tfm \
tex-FiraSans-Italic-sup-t1.tfm \
tex-FiraSans-Italic-sup-t1.vf \
tex-FiraSans-Italic-tlf-lgr.tfm \
tex-FiraSans-Italic-tlf-ly1.tfm \
tex-FiraSans-Italic-tlf-ot1.tfm \
tex-FiraSans-Italic-tlf-sc-lgr.tfm \
tex-FiraSans-Italic-tlf-sc-ly1--base.tfm \
tex-FiraSans-Italic-tlf-sc-ly1.tfm \
tex-FiraSans-Italic-tlf-sc-ly1.vf \
tex-FiraSans-Italic-tlf-sc-ot1--base.tfm \
tex-FiraSans-Italic-tlf-sc-ot1.tfm \
tex-FiraSans-Italic-tlf-sc-ot1.vf \
tex-FiraSans-Italic-tlf-sc-t1--base.tfm \
tex-FiraSans-Italic-tlf-sc-t1.tfm \
tex-FiraSans-Italic-tlf-sc-t1.vf \
tex-FiraSans-Italic-tlf-t1--base.tfm \
tex-FiraSans-Italic-tlf-t1.tfm \
tex-FiraSans-Italic-tlf-t1.vf \
tex-FiraSans-Italic-tlf-ts1--base.tfm \
tex-FiraSans-Italic-tlf-ts1.tfm \
tex-FiraSans-Italic-tlf-ts1.vf \
tex-FiraSans-Italic-tosf-lgr.tfm \
tex-FiraSans-Italic-tosf-ly1.tfm \
tex-FiraSans-Italic-tosf-ot1.tfm \
tex-FiraSans-Italic-tosf-sc-lgr.tfm \
tex-FiraSans-Italic-tosf-sc-ly1--base.tfm \
tex-FiraSans-Italic-tosf-sc-ly1.tfm \
tex-FiraSans-Italic-tosf-sc-ly1.vf \
tex-FiraSans-Italic-tosf-sc-ot1--base.tfm \
tex-FiraSans-Italic-tosf-sc-ot1.tfm \
tex-FiraSans-Italic-tosf-sc-ot1.vf \
tex-FiraSans-Italic-tosf-sc-t1--base.tfm \
tex-FiraSans-Italic-tosf-sc-t1.tfm \
tex-FiraSans-Italic-tosf-sc-t1.vf \
tex-FiraSans-Italic-tosf-t1--base.tfm \
tex-FiraSans-Italic-tosf-t1.tfm \
tex-FiraSans-Italic-tosf-t1.vf \
tex-FiraSans-Italic-tosf-ts1--base.tfm \
tex-FiraSans-Italic-tosf-ts1.tfm \
tex-FiraSans-Italic-tosf-ts1.vf \
tex-FiraSans-Light-lf-lgr.tfm \
tex-FiraSans-Light-lf-ly1.tfm \
tex-FiraSans-Light-lf-ot1.tfm \
tex-FiraSans-Light-lf-sc-lgr.tfm \
tex-FiraSans-Light-lf-sc-ly1--base.tfm \
tex-FiraSans-Light-lf-sc-ly1.tfm \
tex-FiraSans-Light-lf-sc-ly1.vf \
tex-FiraSans-Light-lf-sc-ot1--base.tfm \
tex-FiraSans-Light-lf-sc-ot1.tfm \
tex-FiraSans-Light-lf-sc-ot1.vf \
tex-FiraSans-Light-lf-sc-t1--base.tfm \
tex-FiraSans-Light-lf-sc-t1.tfm \
tex-FiraSans-Light-lf-sc-t1.vf \
tex-FiraSans-Light-lf-t1--base.tfm \
tex-FiraSans-Light-lf-t1.tfm \
tex-FiraSans-Light-lf-t1.vf \
tex-FiraSans-Light-lf-ts1--base.tfm \
tex-FiraSans-Light-lf-ts1.tfm \
tex-FiraSans-Light-lf-ts1.vf \
tex-FiraSans-Light-osf-lgr.tfm \
tex-FiraSans-Light-osf-ly1.tfm \
tex-FiraSans-Light-osf-ot1.tfm \
tex-FiraSans-Light-osf-sc-lgr.tfm \
tex-FiraSans-Light-osf-sc-ly1--base.tfm \
tex-FiraSans-Light-osf-sc-ly1.tfm \
tex-FiraSans-Light-osf-sc-ly1.vf \
tex-FiraSans-Light-osf-sc-ot1--base.tfm \
tex-FiraSans-Light-osf-sc-ot1.tfm \
tex-FiraSans-Light-osf-sc-ot1.vf \
tex-FiraSans-Light-osf-sc-t1--base.tfm \
tex-FiraSans-Light-osf-sc-t1.tfm \
tex-FiraSans-Light-osf-sc-t1.vf \
tex-FiraSans-Light-osf-t1--base.tfm \
tex-FiraSans-Light-osf-t1.tfm \
tex-FiraSans-Light-osf-t1.vf \
tex-FiraSans-Light-osf-ts1--base.tfm \
tex-FiraSans-Light-osf-ts1.tfm \
tex-FiraSans-Light-osf-ts1.vf \
tex-FiraSans-Light-sup-lgr.tfm \
tex-FiraSans-Light-sup-ly1.tfm \
tex-FiraSans-Light-sup-ot1.tfm \
tex-FiraSans-Light-sup-t1--base.tfm \
tex-FiraSans-Light-sup-t1.tfm \
tex-FiraSans-Light-sup-t1.vf \
tex-FiraSans-Light-tlf-lgr.tfm \
tex-FiraSans-Light-tlf-ly1.tfm \
tex-FiraSans-Light-tlf-ot1.tfm \
tex-FiraSans-Light-tlf-sc-lgr.tfm \
tex-FiraSans-Light-tlf-sc-ly1--base.tfm \
tex-FiraSans-Light-tlf-sc-ly1.tfm \
tex-FiraSans-Light-tlf-sc-ly1.vf \
tex-FiraSans-Light-tlf-sc-ot1--base.tfm \
tex-FiraSans-Light-tlf-sc-ot1.tfm \
tex-FiraSans-Light-tlf-sc-ot1.vf \
tex-FiraSans-Light-tlf-sc-t1--base.tfm \
tex-FiraSans-Light-tlf-sc-t1.tfm \
tex-FiraSans-Light-tlf-sc-t1.vf \
tex-FiraSans-Light-tlf-t1--base.tfm \
tex-FiraSans-Light-tlf-t1.tfm \
tex-FiraSans-Light-tlf-t1.vf \
tex-FiraSans-Light-tlf-ts1--base.tfm \
tex-FiraSans-Light-tlf-ts1.tfm \
tex-FiraSans-Light-tlf-ts1.vf \
tex-FiraSans-Light-tosf-lgr.tfm \
tex-FiraSans-Light-tosf-ly1.tfm \
tex-FiraSans-Light-tosf-ot1.tfm \
tex-FiraSans-Light-tosf-sc-lgr.tfm \
tex-FiraSans-Light-tosf-sc-ly1--base.tfm \
tex-FiraSans-Light-tosf-sc-ly1.tfm \
tex-FiraSans-Light-tosf-sc-ly1.vf \
tex-FiraSans-Light-tosf-sc-ot1--base.tfm \
tex-FiraSans-Light-tosf-sc-ot1.tfm \
tex-FiraSans-Light-tosf-sc-ot1.vf \
tex-FiraSans-Light-tosf-sc-t1--base.tfm \
tex-FiraSans-Light-tosf-sc-t1.tfm \
tex-FiraSans-Light-tosf-sc-t1.vf \
tex-FiraSans-Light-tosf-t1--base.tfm \
tex-FiraSans-Light-tosf-t1.tfm \
tex-FiraSans-Light-tosf-t1.vf \
tex-FiraSans-Light-tosf-ts1--base.tfm \
tex-FiraSans-Light-tosf-ts1.tfm \
tex-FiraSans-Light-tosf-ts1.vf \
tex-FiraSans-LightItalic-lf-lgr.tfm \
tex-FiraSans-LightItalic-lf-ly1.tfm \
tex-FiraSans-LightItalic-lf-ot1.tfm \
tex-FiraSans-LightItalic-lf-sc-lgr.tfm \
tex-FiraSans-LightItalic-lf-sc-ly1--base.tfm \
tex-FiraSans-LightItalic-lf-sc-ly1.tfm \
tex-FiraSans-LightItalic-lf-sc-ly1.vf \
tex-FiraSans-LightItalic-lf-sc-ot1--base.tfm \
tex-FiraSans-LightItalic-lf-sc-ot1.tfm \
tex-FiraSans-LightItalic-lf-sc-ot1.vf \
tex-FiraSans-LightItalic-lf-sc-t1--base.tfm \
tex-FiraSans-LightItalic-lf-sc-t1.tfm \
tex-FiraSans-LightItalic-lf-sc-t1.vf \
tex-FiraSans-LightItalic-lf-t1--base.tfm \
tex-FiraSans-LightItalic-lf-t1.tfm \
tex-FiraSans-LightItalic-lf-t1.vf \
tex-FiraSans-LightItalic-lf-ts1--base.tfm \
tex-FiraSans-LightItalic-lf-ts1.tfm \
tex-FiraSans-LightItalic-lf-ts1.vf \
tex-FiraSans-LightItalic-osf-lgr.tfm \
tex-FiraSans-LightItalic-osf-ly1.tfm \
tex-FiraSans-LightItalic-osf-ot1.tfm \
tex-FiraSans-LightItalic-osf-sc-lgr.tfm \
tex-FiraSans-LightItalic-osf-sc-ly1--base.tfm \
tex-FiraSans-LightItalic-osf-sc-ly1.tfm \
tex-FiraSans-LightItalic-osf-sc-ly1.vf \
tex-FiraSans-LightItalic-osf-sc-ot1--base.tfm \
tex-FiraSans-LightItalic-osf-sc-ot1.tfm \
tex-FiraSans-LightItalic-osf-sc-ot1.vf \
tex-FiraSans-LightItalic-osf-sc-t1--base.tfm \
tex-FiraSans-LightItalic-osf-sc-t1.tfm \
tex-FiraSans-LightItalic-osf-sc-t1.vf \
tex-FiraSans-LightItalic-osf-t1--base.tfm \
tex-FiraSans-LightItalic-osf-t1.tfm \
tex-FiraSans-LightItalic-osf-t1.vf \
tex-FiraSans-LightItalic-osf-ts1--base.tfm \
tex-FiraSans-LightItalic-osf-ts1.tfm \
tex-FiraSans-LightItalic-osf-ts1.vf \
tex-FiraSans-LightItalic-sup-lgr.tfm \
tex-FiraSans-LightItalic-sup-ly1.tfm \
tex-FiraSans-LightItalic-sup-ot1.tfm \
tex-FiraSans-LightItalic-sup-t1--base.tfm \
tex-FiraSans-LightItalic-sup-t1.tfm \
tex-FiraSans-LightItalic-sup-t1.vf \
tex-FiraSans-LightItalic-tlf-lgr.tfm \
tex-FiraSans-LightItalic-tlf-ly1.tfm \
tex-FiraSans-LightItalic-tlf-ot1.tfm \
tex-FiraSans-LightItalic-tlf-sc-lgr.tfm \
tex-FiraSans-LightItalic-tlf-sc-ly1--base.tfm \
tex-FiraSans-LightItalic-tlf-sc-ly1.tfm \
tex-FiraSans-LightItalic-tlf-sc-ly1.vf \
tex-FiraSans-LightItalic-tlf-sc-ot1--base.tfm \
tex-FiraSans-LightItalic-tlf-sc-ot1.tfm \
tex-FiraSans-LightItalic-tlf-sc-ot1.vf \
tex-FiraSans-LightItalic-tlf-sc-t1--base.tfm \
tex-FiraSans-LightItalic-tlf-sc-t1.tfm \
tex-FiraSans-LightItalic-tlf-sc-t1.vf \
tex-FiraSans-LightItalic-tlf-t1--base.tfm \
tex-FiraSans-LightItalic-tlf-t1.tfm \
tex-FiraSans-LightItalic-tlf-t1.vf \
tex-FiraSans-LightItalic-tlf-ts1--base.tfm \
tex-FiraSans-LightItalic-tlf-ts1.tfm \
tex-FiraSans-LightItalic-tlf-ts1.vf \
tex-FiraSans-LightItalic-tosf-lgr.tfm \
tex-FiraSans-LightItalic-tosf-ly1.tfm \
tex-FiraSans-LightItalic-tosf-ot1.tfm \
tex-FiraSans-LightItalic-tosf-sc-lgr.tfm \
tex-FiraSans-LightItalic-tosf-sc-ly1--base.tfm \
tex-FiraSans-LightItalic-tosf-sc-ly1.tfm \
tex-FiraSans-LightItalic-tosf-sc-ly1.vf \
tex-FiraSans-LightItalic-tosf-sc-ot1--base.tfm \
tex-FiraSans-LightItalic-tosf-sc-ot1.tfm \
tex-FiraSans-LightItalic-tosf-sc-ot1.vf \
tex-FiraSans-LightItalic-tosf-sc-t1--base.tfm \
tex-FiraSans-LightItalic-tosf-sc-t1.tfm \
tex-FiraSans-LightItalic-tosf-sc-t1.vf \
tex-FiraSans-LightItalic-tosf-t1--base.tfm \
tex-FiraSans-LightItalic-tosf-t1.tfm \
tex-FiraSans-LightItalic-tosf-t1.vf \
tex-FiraSans-LightItalic-tosf-ts1--base.tfm \
tex-FiraSans-LightItalic-tosf-ts1.tfm \
tex-FiraSans-LightItalic-tosf-ts1.vf \
tex-FiraSans-Medium-lf-lgr.tfm \
tex-FiraSans-Medium-lf-ly1.tfm \
tex-FiraSans-Medium-lf-ot1.tfm \
tex-FiraSans-Medium-lf-sc-lgr.tfm \
tex-FiraSans-Medium-lf-sc-ly1--base.tfm \
tex-FiraSans-Medium-lf-sc-ly1.tfm \
tex-FiraSans-Medium-lf-sc-ly1.vf \
tex-FiraSans-Medium-lf-sc-ot1--base.tfm \
tex-FiraSans-Medium-lf-sc-ot1.tfm \
tex-FiraSans-Medium-lf-sc-ot1.vf \
tex-FiraSans-Medium-lf-sc-t1--base.tfm \
tex-FiraSans-Medium-lf-sc-t1.tfm \
tex-FiraSans-Medium-lf-sc-t1.vf \
tex-FiraSans-Medium-lf-t1--base.tfm \
tex-FiraSans-Medium-lf-t1.tfm \
tex-FiraSans-Medium-lf-t1.vf \
tex-FiraSans-Medium-lf-ts1--base.tfm \
tex-FiraSans-Medium-lf-ts1.tfm \
tex-FiraSans-Medium-lf-ts1.vf \
tex-FiraSans-Medium-osf-lgr.tfm \
tex-FiraSans-Medium-osf-ly1.tfm \
tex-FiraSans-Medium-osf-ot1.tfm \
tex-FiraSans-Medium-osf-sc-lgr.tfm \
tex-FiraSans-Medium-osf-sc-ly1--base.tfm \
tex-FiraSans-Medium-osf-sc-ly1.tfm \
tex-FiraSans-Medium-osf-sc-ly1.vf \
tex-FiraSans-Medium-osf-sc-ot1--base.tfm \
tex-FiraSans-Medium-osf-sc-ot1.tfm \
tex-FiraSans-Medium-osf-sc-ot1.vf \
tex-FiraSans-Medium-osf-sc-t1--base.tfm \
tex-FiraSans-Medium-osf-sc-t1.tfm \
tex-FiraSans-Medium-osf-sc-t1.vf \
tex-FiraSans-Medium-osf-t1--base.tfm \
tex-FiraSans-Medium-osf-t1.tfm \
tex-FiraSans-Medium-osf-t1.vf \
tex-FiraSans-Medium-osf-ts1--base.tfm \
tex-FiraSans-Medium-osf-ts1.tfm \
tex-FiraSans-Medium-osf-ts1.vf \
tex-FiraSans-Medium-sup-lgr.tfm \
tex-FiraSans-Medium-sup-ly1.tfm \
tex-FiraSans-Medium-sup-ot1.tfm \
tex-FiraSans-Medium-sup-t1--base.tfm \
tex-FiraSans-Medium-sup-t1.tfm \
tex-FiraSans-Medium-sup-t1.vf \
tex-FiraSans-Medium-tlf-lgr.tfm \
tex-FiraSans-Medium-tlf-ly1.tfm \
tex-FiraSans-Medium-tlf-ot1.tfm \
tex-FiraSans-Medium-tlf-sc-lgr.tfm \
tex-FiraSans-Medium-tlf-sc-ly1--base.tfm \
tex-FiraSans-Medium-tlf-sc-ly1.tfm \
tex-FiraSans-Medium-tlf-sc-ly1.vf \
tex-FiraSans-Medium-tlf-sc-ot1--base.tfm \
tex-FiraSans-Medium-tlf-sc-ot1.tfm \
tex-FiraSans-Medium-tlf-sc-ot1.vf \
tex-FiraSans-Medium-tlf-sc-t1--base.tfm \
tex-FiraSans-Medium-tlf-sc-t1.tfm \
tex-FiraSans-Medium-tlf-sc-t1.vf \
tex-FiraSans-Medium-tlf-t1--base.tfm \
tex-FiraSans-Medium-tlf-t1.tfm \
tex-FiraSans-Medium-tlf-t1.vf \
tex-FiraSans-Medium-tlf-ts1--base.tfm \
tex-FiraSans-Medium-tlf-ts1.tfm \
tex-FiraSans-Medium-tlf-ts1.vf \
tex-FiraSans-Medium-tosf-lgr.tfm \
tex-FiraSans-Medium-tosf-ly1.tfm \
tex-FiraSans-Medium-tosf-ot1.tfm \
tex-FiraSans-Medium-tosf-sc-lgr.tfm \
tex-FiraSans-Medium-tosf-sc-ly1--base.tfm \
tex-FiraSans-Medium-tosf-sc-ly1.tfm \
tex-FiraSans-Medium-tosf-sc-ly1.vf \
tex-FiraSans-Medium-tosf-sc-ot1--base.tfm \
tex-FiraSans-Medium-tosf-sc-ot1.tfm \
tex-FiraSans-Medium-tosf-sc-ot1.vf \
tex-FiraSans-Medium-tosf-sc-t1--base.tfm \
tex-FiraSans-Medium-tosf-sc-t1.tfm \
tex-FiraSans-Medium-tosf-sc-t1.vf \
tex-FiraSans-Medium-tosf-t1--base.tfm \
tex-FiraSans-Medium-tosf-t1.tfm \
tex-FiraSans-Medium-tosf-t1.vf \
tex-FiraSans-Medium-tosf-ts1--base.tfm \
tex-FiraSans-Medium-tosf-ts1.tfm \
tex-FiraSans-Medium-tosf-ts1.vf \
tex-FiraSans-MediumItalic-lf-lgr.tfm \
tex-FiraSans-MediumItalic-lf-ly1.tfm \
tex-FiraSans-MediumItalic-lf-ot1.tfm \
tex-FiraSans-MediumItalic-lf-sc-lgr.tfm \
tex-FiraSans-MediumItalic-lf-sc-ly1--base.tfm \
tex-FiraSans-MediumItalic-lf-sc-ly1.tfm \
tex-FiraSans-MediumItalic-lf-sc-ly1.vf \
tex-FiraSans-MediumItalic-lf-sc-ot1--base.tfm \
tex-FiraSans-MediumItalic-lf-sc-ot1.tfm \
tex-FiraSans-MediumItalic-lf-sc-ot1.vf \
tex-FiraSans-MediumItalic-lf-sc-t1--base.tfm \
tex-FiraSans-MediumItalic-lf-sc-t1.tfm \
tex-FiraSans-MediumItalic-lf-sc-t1.vf \
tex-FiraSans-MediumItalic-lf-t1--base.tfm \
tex-FiraSans-MediumItalic-lf-t1.tfm \
tex-FiraSans-MediumItalic-lf-t1.vf \
tex-FiraSans-MediumItalic-lf-ts1--base.tfm \
tex-FiraSans-MediumItalic-lf-ts1.tfm \
tex-FiraSans-MediumItalic-lf-ts1.vf \
tex-FiraSans-MediumItalic-osf-lgr.tfm \
tex-FiraSans-MediumItalic-osf-ly1.tfm \
tex-FiraSans-MediumItalic-osf-ot1.tfm \
tex-FiraSans-MediumItalic-osf-sc-lgr.tfm \
tex-FiraSans-MediumItalic-osf-sc-ly1--base.tfm \
tex-FiraSans-MediumItalic-osf-sc-ly1.tfm \
tex-FiraSans-MediumItalic-osf-sc-ly1.vf \
tex-FiraSans-MediumItalic-osf-sc-ot1--base.tfm \
tex-FiraSans-MediumItalic-osf-sc-ot1.tfm \
tex-FiraSans-MediumItalic-osf-sc-ot1.vf \
tex-FiraSans-MediumItalic-osf-sc-t1--base.tfm \
tex-FiraSans-MediumItalic-osf-sc-t1.tfm \
tex-FiraSans-MediumItalic-osf-sc-t1.vf \
tex-FiraSans-MediumItalic-osf-t1--base.tfm \
tex-FiraSans-MediumItalic-osf-t1.tfm \
tex-FiraSans-MediumItalic-osf-t1.vf \
tex-FiraSans-MediumItalic-osf-ts1--base.tfm \
tex-FiraSans-MediumItalic-osf-ts1.tfm \
tex-FiraSans-MediumItalic-osf-ts1.vf \
tex-FiraSans-MediumItalic-sup-lgr.tfm \
tex-FiraSans-MediumItalic-sup-ly1.tfm \
tex-FiraSans-MediumItalic-sup-ot1.tfm \
tex-FiraSans-MediumItalic-sup-t1--base.tfm \
tex-FiraSans-MediumItalic-sup-t1.tfm \
tex-FiraSans-MediumItalic-sup-t1.vf \
tex-FiraSans-MediumItalic-tlf-lgr.tfm \
tex-FiraSans-MediumItalic-tlf-ly1.tfm \
tex-FiraSans-MediumItalic-tlf-ot1.tfm \
tex-FiraSans-MediumItalic-tlf-sc-lgr.tfm \
tex-FiraSans-MediumItalic-tlf-sc-ly1--base.tfm \
tex-FiraSans-MediumItalic-tlf-sc-ly1.tfm \
tex-FiraSans-MediumItalic-tlf-sc-ly1.vf \
tex-FiraSans-MediumItalic-tlf-sc-ot1--base.tfm \
tex-FiraSans-MediumItalic-tlf-sc-ot1.tfm \
tex-FiraSans-MediumItalic-tlf-sc-ot1.vf \
tex-FiraSans-MediumItalic-tlf-sc-t1--base.tfm \
tex-FiraSans-MediumItalic-tlf-sc-t1.tfm \
tex-FiraSans-MediumItalic-tlf-sc-t1.vf \
tex-FiraSans-MediumItalic-tlf-t1--base.tfm \
tex-FiraSans-MediumItalic-tlf-t1.tfm \
tex-FiraSans-MediumItalic-tlf-t1.vf \
tex-FiraSans-MediumItalic-tlf-ts1--base.tfm \
tex-FiraSans-MediumItalic-tlf-ts1.tfm \
tex-FiraSans-MediumItalic-tlf-ts1.vf \
tex-FiraSans-MediumItalic-tosf-lgr.tfm \
tex-FiraSans-MediumItalic-tosf-ly1.tfm \
tex-FiraSans-MediumItalic-tosf-ot1.tfm \
tex-FiraSans-MediumItalic-tosf-sc-lgr.tfm \
tex-FiraSans-MediumItalic-tosf-sc-ly1--base.tfm \
tex-FiraSans-MediumItalic-tosf-sc-ly1.tfm \
tex-FiraSans-MediumItalic-tosf-sc-ly1.vf \
tex-FiraSans-MediumItalic-tosf-sc-ot1--base.tfm \
tex-FiraSans-MediumItalic-tosf-sc-ot1.tfm \
tex-FiraSans-MediumItalic-tosf-sc-ot1.vf \
tex-FiraSans-MediumItalic-tosf-sc-t1--base.tfm \
tex-FiraSans-MediumItalic-tosf-sc-t1.tfm \
tex-FiraSans-MediumItalic-tosf-sc-t1.vf \
tex-FiraSans-MediumItalic-tosf-t1--base.tfm \
tex-FiraSans-MediumItalic-tosf-t1.tfm \
tex-FiraSans-MediumItalic-tosf-t1.vf \
tex-FiraSans-MediumItalic-tosf-ts1--base.tfm \
tex-FiraSans-MediumItalic-tosf-ts1.tfm \
tex-FiraSans-MediumItalic-tosf-ts1.vf \
tex-FiraSans-Regular-lf-lgr.tfm \
tex-FiraSans-Regular-lf-ly1.tfm \
tex-FiraSans-Regular-lf-ot1.tfm \
tex-FiraSans-Regular-lf-sc-lgr.tfm \
tex-FiraSans-Regular-lf-sc-ly1--base.tfm \
tex-FiraSans-Regular-lf-sc-ly1.tfm \
tex-FiraSans-Regular-lf-sc-ly1.vf \
tex-FiraSans-Regular-lf-sc-ot1--base.tfm \
tex-FiraSans-Regular-lf-sc-ot1.tfm \
tex-FiraSans-Regular-lf-sc-ot1.vf \
tex-FiraSans-Regular-lf-sc-t1--base.tfm \
tex-FiraSans-Regular-lf-sc-t1.tfm \
tex-FiraSans-Regular-lf-sc-t1.vf \
tex-FiraSans-Regular-lf-t1--base.tfm \
tex-FiraSans-Regular-lf-t1.tfm \
tex-FiraSans-Regular-lf-t1.vf \
tex-FiraSans-Regular-lf-ts1--base.tfm \
tex-FiraSans-Regular-lf-ts1.tfm \
tex-FiraSans-Regular-lf-ts1.vf \
tex-FiraSans-Regular-osf-lgr.tfm \
tex-FiraSans-Regular-osf-ly1.tfm \
tex-FiraSans-Regular-osf-ot1.tfm \
tex-FiraSans-Regular-osf-sc-lgr.tfm \
tex-FiraSans-Regular-osf-sc-ly1--base.tfm \
tex-FiraSans-Regular-osf-sc-ly1.tfm \
tex-FiraSans-Regular-osf-sc-ly1.vf \
tex-FiraSans-Regular-osf-sc-ot1--base.tfm \
tex-FiraSans-Regular-osf-sc-ot1.tfm \
tex-FiraSans-Regular-osf-sc-ot1.vf \
tex-FiraSans-Regular-osf-sc-t1--base.tfm \
tex-FiraSans-Regular-osf-sc-t1.tfm \
tex-FiraSans-Regular-osf-sc-t1.vf \
tex-FiraSans-Regular-osf-t1--base.tfm \
tex-FiraSans-Regular-osf-t1.tfm \
tex-FiraSans-Regular-osf-t1.vf \
tex-FiraSans-Regular-osf-ts1--base.tfm \
tex-FiraSans-Regular-osf-ts1.tfm \
tex-FiraSans-Regular-osf-ts1.vf \
tex-FiraSans-Regular-sup-lgr.tfm \
tex-FiraSans-Regular-sup-ly1.tfm \
tex-FiraSans-Regular-sup-ot1.tfm \
tex-FiraSans-Regular-sup-t1--base.tfm \
tex-FiraSans-Regular-sup-t1.tfm \
tex-FiraSans-Regular-sup-t1.vf \
tex-FiraSans-Regular-tlf-lgr.tfm \
tex-FiraSans-Regular-tlf-ly1.tfm \
tex-FiraSans-Regular-tlf-ot1.tfm \
tex-FiraSans-Regular-tlf-sc-lgr.tfm \
tex-FiraSans-Regular-tlf-sc-ly1--base.tfm \
tex-FiraSans-Regular-tlf-sc-ly1.tfm \
tex-FiraSans-Regular-tlf-sc-ly1.vf \
tex-FiraSans-Regular-tlf-sc-ot1--base.tfm \
tex-FiraSans-Regular-tlf-sc-ot1.tfm \
tex-FiraSans-Regular-tlf-sc-ot1.vf \
tex-FiraSans-Regular-tlf-sc-t1--base.tfm \
tex-FiraSans-Regular-tlf-sc-t1.tfm \
tex-FiraSans-Regular-tlf-sc-t1.vf \
tex-FiraSans-Regular-tlf-t1--base.tfm \
tex-FiraSans-Regular-tlf-t1.tfm \
tex-FiraSans-Regular-tlf-t1.vf \
tex-FiraSans-Regular-tlf-ts1--base.tfm \
tex-FiraSans-Regular-tlf-ts1.tfm \
tex-FiraSans-Regular-tlf-ts1.vf \
tex-FiraSans-Regular-tosf-lgr.tfm \
tex-FiraSans-Regular-tosf-ly1.tfm \
tex-FiraSans-Regular-tosf-ot1.tfm \
tex-FiraSans-Regular-tosf-sc-lgr.tfm \
tex-FiraSans-Regular-tosf-sc-ly1--base.tfm \
tex-FiraSans-Regular-tosf-sc-ly1.tfm \
tex-FiraSans-Regular-tosf-sc-ly1.vf \
tex-FiraSans-Regular-tosf-sc-ot1--base.tfm \
tex-FiraSans-Regular-tosf-sc-ot1.tfm \
tex-FiraSans-Regular-tosf-sc-ot1.vf \
tex-FiraSans-Regular-tosf-sc-t1--base.tfm \
tex-FiraSans-Regular-tosf-sc-t1.tfm \
tex-FiraSans-Regular-tosf-sc-t1.vf \
tex-FiraSans-Regular-tosf-t1--base.tfm \
tex-FiraSans-Regular-tosf-t1.tfm \
tex-FiraSans-Regular-tosf-t1.vf \
tex-FiraSans-Regular-tosf-ts1--base.tfm \
tex-FiraSans-Regular-tosf-ts1.tfm \
tex-FiraSans-Regular-tosf-ts1.vf \
tex-FiraSans-SemiBold-lf-lgr.tfm \
tex-FiraSans-SemiBold-lf-ly1.tfm \
tex-FiraSans-SemiBold-lf-ot1.tfm \
tex-FiraSans-SemiBold-lf-sc-lgr.tfm \
tex-FiraSans-SemiBold-lf-sc-ly1--base.tfm \
tex-FiraSans-SemiBold-lf-sc-ly1.tfm \
tex-FiraSans-SemiBold-lf-sc-ly1.vf \
tex-FiraSans-SemiBold-lf-sc-ot1--base.tfm \
tex-FiraSans-SemiBold-lf-sc-ot1.tfm \
tex-FiraSans-SemiBold-lf-sc-ot1.vf \
tex-FiraSans-SemiBold-lf-sc-t1--base.tfm \
tex-FiraSans-SemiBold-lf-sc-t1.tfm \
tex-FiraSans-SemiBold-lf-sc-t1.vf \
tex-FiraSans-SemiBold-lf-t1--base.tfm \
tex-FiraSans-SemiBold-lf-t1.tfm \
tex-FiraSans-SemiBold-lf-t1.vf \
tex-FiraSans-SemiBold-lf-ts1--base.tfm \
tex-FiraSans-SemiBold-lf-ts1.tfm \
tex-FiraSans-SemiBold-lf-ts1.vf \
tex-FiraSans-SemiBold-osf-lgr.tfm \
tex-FiraSans-SemiBold-osf-ly1.tfm \
tex-FiraSans-SemiBold-osf-ot1.tfm \
tex-FiraSans-SemiBold-osf-sc-lgr.tfm \
tex-FiraSans-SemiBold-osf-sc-ly1--base.tfm \
tex-FiraSans-SemiBold-osf-sc-ly1.tfm \
tex-FiraSans-SemiBold-osf-sc-ly1.vf \
tex-FiraSans-SemiBold-osf-sc-ot1--base.tfm \
tex-FiraSans-SemiBold-osf-sc-ot1.tfm \
tex-FiraSans-SemiBold-osf-sc-ot1.vf \
tex-FiraSans-SemiBold-osf-sc-t1--base.tfm \
tex-FiraSans-SemiBold-osf-sc-t1.tfm \
tex-FiraSans-SemiBold-osf-sc-t1.vf \
tex-FiraSans-SemiBold-osf-t1--base.tfm \
tex-FiraSans-SemiBold-osf-t1.tfm \
tex-FiraSans-SemiBold-osf-t1.vf \
tex-FiraSans-SemiBold-osf-ts1--base.tfm \
tex-FiraSans-SemiBold-osf-ts1.tfm \
tex-FiraSans-SemiBold-osf-ts1.vf \
tex-FiraSans-SemiBold-sup-lgr.tfm \
tex-FiraSans-SemiBold-sup-ly1.tfm \
tex-FiraSans-SemiBold-sup-ot1.tfm \
tex-FiraSans-SemiBold-sup-t1--base.tfm \
tex-FiraSans-SemiBold-sup-t1.tfm \
tex-FiraSans-SemiBold-sup-t1.vf \
tex-FiraSans-SemiBold-tlf-lgr.tfm \
tex-FiraSans-SemiBold-tlf-ly1.tfm \
tex-FiraSans-SemiBold-tlf-ot1.tfm \
tex-FiraSans-SemiBold-tlf-sc-lgr.tfm \
tex-FiraSans-SemiBold-tlf-sc-ly1--base.tfm \
tex-FiraSans-SemiBold-tlf-sc-ly1.tfm \
tex-FiraSans-SemiBold-tlf-sc-ly1.vf \
tex-FiraSans-SemiBold-tlf-sc-ot1--base.tfm \
tex-FiraSans-SemiBold-tlf-sc-ot1.tfm \
tex-FiraSans-SemiBold-tlf-sc-ot1.vf \
tex-FiraSans-SemiBold-tlf-sc-t1--base.tfm \
tex-FiraSans-SemiBold-tlf-sc-t1.tfm \
tex-FiraSans-SemiBold-tlf-sc-t1.vf \
tex-FiraSans-SemiBold-tlf-t1--base.tfm \
tex-FiraSans-SemiBold-tlf-t1.tfm \
tex-FiraSans-SemiBold-tlf-t1.vf \
tex-FiraSans-SemiBold-tlf-ts1--base.tfm \
tex-FiraSans-SemiBold-tlf-ts1.tfm \
tex-FiraSans-SemiBold-tlf-ts1.vf \
tex-FiraSans-SemiBold-tosf-lgr.tfm \
tex-FiraSans-SemiBold-tosf-ly1.tfm \
tex-FiraSans-SemiBold-tosf-ot1.tfm \
tex-FiraSans-SemiBold-tosf-sc-lgr.tfm \
tex-FiraSans-SemiBold-tosf-sc-ly1--base.tfm \
tex-FiraSans-SemiBold-tosf-sc-ly1.tfm \
tex-FiraSans-SemiBold-tosf-sc-ly1.vf \
tex-FiraSans-SemiBold-tosf-sc-ot1--base.tfm \
tex-FiraSans-SemiBold-tosf-sc-ot1.tfm \
tex-FiraSans-SemiBold-tosf-sc-ot1.vf \
tex-FiraSans-SemiBold-tosf-sc-t1--base.tfm \
tex-FiraSans-SemiBold-tosf-sc-t1.tfm \
tex-FiraSans-SemiBold-tosf-sc-t1.vf \
tex-FiraSans-SemiBold-tosf-t1--base.tfm \
tex-FiraSans-SemiBold-tosf-t1.tfm \
tex-FiraSans-SemiBold-tosf-t1.vf \
tex-FiraSans-SemiBold-tosf-ts1--base.tfm \
tex-FiraSans-SemiBold-tosf-ts1.tfm \
tex-FiraSans-SemiBold-tosf-ts1.vf \
tex-FiraSans-SemiBoldItalic-lf-lgr.tfm \
tex-FiraSans-SemiBoldItalic-lf-ly1.tfm \
tex-FiraSans-SemiBoldItalic-lf-ot1.tfm \
tex-FiraSans-SemiBoldItalic-lf-sc-lgr.tfm \
tex-FiraSans-SemiBoldItalic-lf-sc-ly1--base.tfm \
tex-FiraSans-SemiBoldItalic-lf-sc-ly1.tfm \
tex-FiraSans-SemiBoldItalic-lf-sc-ly1.vf \
tex-FiraSans-SemiBoldItalic-lf-sc-ot1--base.tfm \
tex-FiraSans-SemiBoldItalic-lf-sc-ot1.tfm \
tex-FiraSans-SemiBoldItalic-lf-sc-ot1.vf \
tex-FiraSans-SemiBoldItalic-lf-sc-t1--base.tfm \
tex-FiraSans-SemiBoldItalic-lf-sc-t1.tfm \
tex-FiraSans-SemiBoldItalic-lf-sc-t1.vf \
tex-FiraSans-SemiBoldItalic-lf-t1--base.tfm \
tex-FiraSans-SemiBoldItalic-lf-t1.tfm \
tex-FiraSans-SemiBoldItalic-lf-t1.vf \
tex-FiraSans-SemiBoldItalic-lf-ts1--base.tfm \
tex-FiraSans-SemiBoldItalic-lf-ts1.tfm \
tex-FiraSans-SemiBoldItalic-lf-ts1.vf \
tex-FiraSans-SemiBoldItalic-osf-lgr.tfm \
tex-FiraSans-SemiBoldItalic-osf-ly1.tfm \
tex-FiraSans-SemiBoldItalic-osf-ot1.tfm \
tex-FiraSans-SemiBoldItalic-osf-sc-lgr.tfm \
tex-FiraSans-SemiBoldItalic-osf-sc-ly1--base.tfm \
tex-FiraSans-SemiBoldItalic-osf-sc-ly1.tfm \
tex-FiraSans-SemiBoldItalic-osf-sc-ly1.vf \
tex-FiraSans-SemiBoldItalic-osf-sc-ot1--base.tfm \
tex-FiraSans-SemiBoldItalic-osf-sc-ot1.tfm \
tex-FiraSans-SemiBoldItalic-osf-sc-ot1.vf \
tex-FiraSans-SemiBoldItalic-osf-sc-t1--base.tfm \
tex-FiraSans-SemiBoldItalic-osf-sc-t1.tfm \
tex-FiraSans-SemiBoldItalic-osf-sc-t1.vf \
tex-FiraSans-SemiBoldItalic-osf-t1--base.tfm \
tex-FiraSans-SemiBoldItalic-osf-t1.tfm \
tex-FiraSans-SemiBoldItalic-osf-t1.vf \
tex-FiraSans-SemiBoldItalic-osf-ts1--base.tfm \
tex-FiraSans-SemiBoldItalic-osf-ts1.tfm \
tex-FiraSans-SemiBoldItalic-osf-ts1.vf \
tex-FiraSans-SemiBoldItalic-sup-lgr.tfm \
tex-FiraSans-SemiBoldItalic-sup-ly1.tfm \
tex-FiraSans-SemiBoldItalic-sup-ot1.tfm \
tex-FiraSans-SemiBoldItalic-sup-t1--base.tfm \
tex-FiraSans-SemiBoldItalic-sup-t1.tfm \
tex-FiraSans-SemiBoldItalic-sup-t1.vf \
tex-FiraSans-SemiBoldItalic-tlf-lgr.tfm \
tex-FiraSans-SemiBoldItalic-tlf-ly1.tfm \
tex-FiraSans-SemiBoldItalic-tlf-ot1.tfm \
tex-FiraSans-SemiBoldItalic-tlf-sc-lgr.tfm \
tex-FiraSans-SemiBoldItalic-tlf-sc-ly1--base.tfm \
tex-FiraSans-SemiBoldItalic-tlf-sc-ly1.tfm \
tex-FiraSans-SemiBoldItalic-tlf-sc-ly1.vf \
tex-FiraSans-SemiBoldItalic-tlf-sc-ot1--base.tfm \
tex-FiraSans-SemiBoldItalic-tlf-sc-ot1.tfm \
tex-FiraSans-SemiBoldItalic-tlf-sc-ot1.vf \
tex-FiraSans-SemiBoldItalic-tlf-sc-t1--base.tfm \
tex-FiraSans-SemiBoldItalic-tlf-sc-t1.tfm \
tex-FiraSans-SemiBoldItalic-tlf-sc-t1.vf \
tex-FiraSans-SemiBoldItalic-tlf-t1--base.tfm \
tex-FiraSans-SemiBoldItalic-tlf-t1.tfm \
tex-FiraSans-SemiBoldItalic-tlf-t1.vf \
tex-FiraSans-SemiBoldItalic-tlf-ts1--base.tfm \
tex-FiraSans-SemiBoldItalic-tlf-ts1.tfm \
tex-FiraSans-SemiBoldItalic-tlf-ts1.vf \
tex-FiraSans-SemiBoldItalic-tosf-lgr.tfm \
tex-FiraSans-SemiBoldItalic-tosf-ly1.tfm \
tex-FiraSans-SemiBoldItalic-tosf-ot1.tfm \
tex-FiraSans-SemiBoldItalic-tosf-sc-lgr.tfm \
tex-FiraSans-SemiBoldItalic-tosf-sc-ly1--base.tfm \
tex-FiraSans-SemiBoldItalic-tosf-sc-ly1.tfm \
tex-FiraSans-SemiBoldItalic-tosf-sc-ly1.vf \
tex-FiraSans-SemiBoldItalic-tosf-sc-ot1--base.tfm \
tex-FiraSans-SemiBoldItalic-tosf-sc-ot1.tfm \
tex-FiraSans-SemiBoldItalic-tosf-sc-ot1.vf \
tex-FiraSans-SemiBoldItalic-tosf-sc-t1--base.tfm \
tex-FiraSans-SemiBoldItalic-tosf-sc-t1.tfm \
tex-FiraSans-SemiBoldItalic-tosf-sc-t1.vf \
tex-FiraSans-SemiBoldItalic-tosf-t1--base.tfm \
tex-FiraSans-SemiBoldItalic-tosf-t1.tfm \
tex-FiraSans-SemiBoldItalic-tosf-t1.vf \
tex-FiraSans-SemiBoldItalic-tosf-ts1--base.tfm \
tex-FiraSans-SemiBoldItalic-tosf-ts1.tfm \
tex-FiraSans-SemiBoldItalic-tosf-ts1.vf \
tex-FiraSans-Thin-lf-lgr.tfm \
tex-FiraSans-Thin-lf-ly1.tfm \
tex-FiraSans-Thin-lf-ot1.tfm \
tex-FiraSans-Thin-lf-sc-lgr.tfm \
tex-FiraSans-Thin-lf-sc-ly1--base.tfm \
tex-FiraSans-Thin-lf-sc-ly1.tfm \
tex-FiraSans-Thin-lf-sc-ly1.vf \
tex-FiraSans-Thin-lf-sc-ot1--base.tfm \
tex-FiraSans-Thin-lf-sc-ot1.tfm \
tex-FiraSans-Thin-lf-sc-ot1.vf \
tex-FiraSans-Thin-lf-sc-t1--base.tfm \
tex-FiraSans-Thin-lf-sc-t1.tfm \
tex-FiraSans-Thin-lf-sc-t1.vf \
tex-FiraSans-Thin-lf-t1--base.tfm \
tex-FiraSans-Thin-lf-t1.tfm \
tex-FiraSans-Thin-lf-t1.vf \
tex-FiraSans-Thin-lf-ts1--base.tfm \
tex-FiraSans-Thin-lf-ts1.tfm \
tex-FiraSans-Thin-lf-ts1.vf \
tex-FiraSans-Thin-osf-lgr.tfm \
tex-FiraSans-Thin-osf-ly1.tfm \
tex-FiraSans-Thin-osf-ot1.tfm \
tex-FiraSans-Thin-osf-sc-lgr.tfm \
tex-FiraSans-Thin-osf-sc-ly1--base.tfm \
tex-FiraSans-Thin-osf-sc-ly1.tfm \
tex-FiraSans-Thin-osf-sc-ly1.vf \
tex-FiraSans-Thin-osf-sc-ot1--base.tfm \
tex-FiraSans-Thin-osf-sc-ot1.tfm \
tex-FiraSans-Thin-osf-sc-ot1.vf \
tex-FiraSans-Thin-osf-sc-t1--base.tfm \
tex-FiraSans-Thin-osf-sc-t1.tfm \
tex-FiraSans-Thin-osf-sc-t1.vf \
tex-FiraSans-Thin-osf-t1--base.tfm \
tex-FiraSans-Thin-osf-t1.tfm \
tex-FiraSans-Thin-osf-t1.vf \
tex-FiraSans-Thin-osf-ts1--base.tfm \
tex-FiraSans-Thin-osf-ts1.tfm \
tex-FiraSans-Thin-osf-ts1.vf \
tex-FiraSans-Thin-sup-lgr.tfm \
tex-FiraSans-Thin-sup-ly1.tfm \
tex-FiraSans-Thin-sup-ot1.tfm \
tex-FiraSans-Thin-sup-t1--base.tfm \
tex-FiraSans-Thin-sup-t1.tfm \
tex-FiraSans-Thin-sup-t1.vf \
tex-FiraSans-Thin-tlf-lgr.tfm \
tex-FiraSans-Thin-tlf-ly1.tfm \
tex-FiraSans-Thin-tlf-ot1.tfm \
tex-FiraSans-Thin-tlf-sc-lgr.tfm \
tex-FiraSans-Thin-tlf-sc-ly1--base.tfm \
tex-FiraSans-Thin-tlf-sc-ly1.tfm \
tex-FiraSans-Thin-tlf-sc-ly1.vf \
tex-FiraSans-Thin-tlf-sc-ot1--base.tfm \
tex-FiraSans-Thin-tlf-sc-ot1.tfm \
tex-FiraSans-Thin-tlf-sc-ot1.vf \
tex-FiraSans-Thin-tlf-sc-t1--base.tfm \
tex-FiraSans-Thin-tlf-sc-t1.tfm \
tex-FiraSans-Thin-tlf-sc-t1.vf \
tex-FiraSans-Thin-tlf-t1--base.tfm \
tex-FiraSans-Thin-tlf-t1.tfm \
tex-FiraSans-Thin-tlf-t1.vf \
tex-FiraSans-Thin-tlf-ts1--base.tfm \
tex-FiraSans-Thin-tlf-ts1.tfm \
tex-FiraSans-Thin-tlf-ts1.vf \
tex-FiraSans-Thin-tosf-lgr.tfm \
tex-FiraSans-Thin-tosf-ly1.tfm \
tex-FiraSans-Thin-tosf-ot1.tfm \
tex-FiraSans-Thin-tosf-sc-lgr.tfm \
tex-FiraSans-Thin-tosf-sc-ly1--base.tfm \
tex-FiraSans-Thin-tosf-sc-ly1.tfm \
tex-FiraSans-Thin-tosf-sc-ly1.vf \
tex-FiraSans-Thin-tosf-sc-ot1--base.tfm \
tex-FiraSans-Thin-tosf-sc-ot1.tfm \
tex-FiraSans-Thin-tosf-sc-ot1.vf \
tex-FiraSans-Thin-tosf-sc-t1--base.tfm \
tex-FiraSans-Thin-tosf-sc-t1.tfm \
tex-FiraSans-Thin-tosf-sc-t1.vf \
tex-FiraSans-Thin-tosf-t1--base.tfm \
tex-FiraSans-Thin-tosf-t1.tfm \
tex-FiraSans-Thin-tosf-t1.vf \
tex-FiraSans-Thin-tosf-ts1--base.tfm \
tex-FiraSans-Thin-tosf-ts1.tfm \
tex-FiraSans-Thin-tosf-ts1.vf \
tex-FiraSans-ThinItalic-lf-lgr.tfm \
tex-FiraSans-ThinItalic-lf-ly1.tfm \
tex-FiraSans-ThinItalic-lf-ot1.tfm \
tex-FiraSans-ThinItalic-lf-sc-lgr.tfm \
tex-FiraSans-ThinItalic-lf-sc-ly1--base.tfm \
tex-FiraSans-ThinItalic-lf-sc-ly1.tfm \
tex-FiraSans-ThinItalic-lf-sc-ly1.vf \
tex-FiraSans-ThinItalic-lf-sc-ot1--base.tfm \
tex-FiraSans-ThinItalic-lf-sc-ot1.tfm \
tex-FiraSans-ThinItalic-lf-sc-ot1.vf \
tex-FiraSans-ThinItalic-lf-sc-t1--base.tfm \
tex-FiraSans-ThinItalic-lf-sc-t1.tfm \
tex-FiraSans-ThinItalic-lf-sc-t1.vf \
tex-FiraSans-ThinItalic-lf-t1--base.tfm \
tex-FiraSans-ThinItalic-lf-t1.tfm \
tex-FiraSans-ThinItalic-lf-t1.vf \
tex-FiraSans-ThinItalic-lf-ts1--base.tfm \
tex-FiraSans-ThinItalic-lf-ts1.tfm \
tex-FiraSans-ThinItalic-lf-ts1.vf \
tex-FiraSans-ThinItalic-osf-lgr.tfm \
tex-FiraSans-ThinItalic-osf-ly1.tfm \
tex-FiraSans-ThinItalic-osf-ot1.tfm \
tex-FiraSans-ThinItalic-osf-sc-lgr.tfm \
tex-FiraSans-ThinItalic-osf-sc-ly1--base.tfm \
tex-FiraSans-ThinItalic-osf-sc-ly1.tfm \
tex-FiraSans-ThinItalic-osf-sc-ly1.vf \
tex-FiraSans-ThinItalic-osf-sc-ot1--base.tfm \
tex-FiraSans-ThinItalic-osf-sc-ot1.tfm \
tex-FiraSans-ThinItalic-osf-sc-ot1.vf \
tex-FiraSans-ThinItalic-osf-sc-t1--base.tfm \
tex-FiraSans-ThinItalic-osf-sc-t1.tfm \
tex-FiraSans-ThinItalic-osf-sc-t1.vf \
tex-FiraSans-ThinItalic-osf-t1--base.tfm \
tex-FiraSans-ThinItalic-osf-t1.tfm \
tex-FiraSans-ThinItalic-osf-t1.vf \
tex-FiraSans-ThinItalic-osf-ts1--base.tfm \
tex-FiraSans-ThinItalic-osf-ts1.tfm \
tex-FiraSans-ThinItalic-osf-ts1.vf \
tex-FiraSans-ThinItalic-sup-lgr.tfm \
tex-FiraSans-ThinItalic-sup-ly1.tfm \
tex-FiraSans-ThinItalic-sup-ot1.tfm \
tex-FiraSans-ThinItalic-sup-t1--base.tfm \
tex-FiraSans-ThinItalic-sup-t1.tfm \
tex-FiraSans-ThinItalic-sup-t1.vf \
tex-FiraSans-ThinItalic-tlf-lgr.tfm \
tex-FiraSans-ThinItalic-tlf-ly1.tfm \
tex-FiraSans-ThinItalic-tlf-ot1.tfm \
tex-FiraSans-ThinItalic-tlf-sc-lgr.tfm \
tex-FiraSans-ThinItalic-tlf-sc-ly1--base.tfm \
tex-FiraSans-ThinItalic-tlf-sc-ly1.tfm \
tex-FiraSans-ThinItalic-tlf-sc-ly1.vf \
tex-FiraSans-ThinItalic-tlf-sc-ot1--base.tfm \
tex-FiraSans-ThinItalic-tlf-sc-ot1.tfm \
tex-FiraSans-ThinItalic-tlf-sc-ot1.vf \
tex-FiraSans-ThinItalic-tlf-sc-t1--base.tfm \
tex-FiraSans-ThinItalic-tlf-sc-t1.tfm \
tex-FiraSans-ThinItalic-tlf-sc-t1.vf \
tex-FiraSans-ThinItalic-tlf-t1--base.tfm \
tex-FiraSans-ThinItalic-tlf-t1.tfm \
tex-FiraSans-ThinItalic-tlf-t1.vf \
tex-FiraSans-ThinItalic-tlf-ts1--base.tfm \
tex-FiraSans-ThinItalic-tlf-ts1.tfm \
tex-FiraSans-ThinItalic-tlf-ts1.vf \
tex-FiraSans-ThinItalic-tosf-lgr.tfm \
tex-FiraSans-ThinItalic-tosf-ly1.tfm \
tex-FiraSans-ThinItalic-tosf-ot1.tfm \
tex-FiraSans-ThinItalic-tosf-sc-lgr.tfm \
tex-FiraSans-ThinItalic-tosf-sc-ly1--base.tfm \
tex-FiraSans-ThinItalic-tosf-sc-ly1.tfm \
tex-FiraSans-ThinItalic-tosf-sc-ly1.vf \
tex-FiraSans-ThinItalic-tosf-sc-ot1--base.tfm \
tex-FiraSans-ThinItalic-tosf-sc-ot1.tfm \
tex-FiraSans-ThinItalic-tosf-sc-ot1.vf \
tex-FiraSans-ThinItalic-tosf-sc-t1--base.tfm \
tex-FiraSans-ThinItalic-tosf-sc-t1.tfm \
tex-FiraSans-ThinItalic-tosf-sc-t1.vf \
tex-FiraSans-ThinItalic-tosf-t1--base.tfm \
tex-FiraSans-ThinItalic-tosf-t1.tfm \
tex-FiraSans-ThinItalic-tosf-t1.vf \
tex-FiraSans-ThinItalic-tosf-ts1--base.tfm \
tex-FiraSans-ThinItalic-tosf-ts1.tfm \
tex-FiraSans-ThinItalic-tosf-ts1.vf \
tex-FiraSans-UltraLight-lf-lgr.tfm \
tex-FiraSans-UltraLight-lf-ly1.tfm \
tex-FiraSans-UltraLight-lf-ot1.tfm \
tex-FiraSans-UltraLight-lf-sc-lgr.tfm \
tex-FiraSans-UltraLight-lf-sc-ly1--base.tfm \
tex-FiraSans-UltraLight-lf-sc-ly1.tfm \
tex-FiraSans-UltraLight-lf-sc-ly1.vf \
tex-FiraSans-UltraLight-lf-sc-ot1--base.tfm \
tex-FiraSans-UltraLight-lf-sc-ot1.tfm \
tex-FiraSans-UltraLight-lf-sc-ot1.vf \
tex-FiraSans-UltraLight-lf-sc-t1--base.tfm \
tex-FiraSans-UltraLight-lf-sc-t1.tfm \
tex-FiraSans-UltraLight-lf-sc-t1.vf \
tex-FiraSans-UltraLight-lf-t1--base.tfm \
tex-FiraSans-UltraLight-lf-t1.tfm \
tex-FiraSans-UltraLight-lf-t1.vf \
tex-FiraSans-UltraLight-lf-ts1--base.tfm \
tex-FiraSans-UltraLight-lf-ts1.tfm \
tex-FiraSans-UltraLight-lf-ts1.vf \
tex-FiraSans-UltraLight-osf-lgr.tfm \
tex-FiraSans-UltraLight-osf-ly1.tfm \
tex-FiraSans-UltraLight-osf-ot1.tfm \
tex-FiraSans-UltraLight-osf-sc-lgr.tfm \
tex-FiraSans-UltraLight-osf-sc-ly1--base.tfm \
tex-FiraSans-UltraLight-osf-sc-ly1.tfm \
tex-FiraSans-UltraLight-osf-sc-ly1.vf \
tex-FiraSans-UltraLight-osf-sc-ot1--base.tfm \
tex-FiraSans-UltraLight-osf-sc-ot1.tfm \
tex-FiraSans-UltraLight-osf-sc-ot1.vf \
tex-FiraSans-UltraLight-osf-sc-t1--base.tfm \
tex-FiraSans-UltraLight-osf-sc-t1.tfm \
tex-FiraSans-UltraLight-osf-sc-t1.vf \
tex-FiraSans-UltraLight-osf-t1--base.tfm \
tex-FiraSans-UltraLight-osf-t1.tfm \
tex-FiraSans-UltraLight-osf-t1.vf \
tex-FiraSans-UltraLight-osf-ts1--base.tfm \
tex-FiraSans-UltraLight-osf-ts1.tfm \
tex-FiraSans-UltraLight-osf-ts1.vf \
tex-FiraSans-UltraLight-sup-lgr.tfm \
tex-FiraSans-UltraLight-sup-ly1.tfm \
tex-FiraSans-UltraLight-sup-ot1.tfm \
tex-FiraSans-UltraLight-sup-t1--base.tfm \
tex-FiraSans-UltraLight-sup-t1.tfm \
tex-FiraSans-UltraLight-sup-t1.vf \
tex-FiraSans-UltraLight-tlf-lgr.tfm \
tex-FiraSans-UltraLight-tlf-ly1.tfm \
tex-FiraSans-UltraLight-tlf-ot1.tfm \
tex-FiraSans-UltraLight-tlf-sc-lgr.tfm \
tex-FiraSans-UltraLight-tlf-sc-ly1--base.tfm \
tex-FiraSans-UltraLight-tlf-sc-ly1.tfm \
tex-FiraSans-UltraLight-tlf-sc-ly1.vf \
tex-FiraSans-UltraLight-tlf-sc-ot1--base.tfm \
tex-FiraSans-UltraLight-tlf-sc-ot1.tfm \
tex-FiraSans-UltraLight-tlf-sc-ot1.vf \
tex-FiraSans-UltraLight-tlf-sc-t1--base.tfm \
tex-FiraSans-UltraLight-tlf-sc-t1.tfm \
tex-FiraSans-UltraLight-tlf-sc-t1.vf \
tex-FiraSans-UltraLight-tlf-t1--base.tfm \
tex-FiraSans-UltraLight-tlf-t1.tfm \
tex-FiraSans-UltraLight-tlf-t1.vf \
tex-FiraSans-UltraLight-tlf-ts1--base.tfm \
tex-FiraSans-UltraLight-tlf-ts1.tfm \
tex-FiraSans-UltraLight-tlf-ts1.vf \
tex-FiraSans-UltraLight-tosf-lgr.tfm \
tex-FiraSans-UltraLight-tosf-ly1.tfm \
tex-FiraSans-UltraLight-tosf-ot1.tfm \
tex-FiraSans-UltraLight-tosf-sc-lgr.tfm \
tex-FiraSans-UltraLight-tosf-sc-ly1--base.tfm \
tex-FiraSans-UltraLight-tosf-sc-ly1.tfm \
tex-FiraSans-UltraLight-tosf-sc-ly1.vf \
tex-FiraSans-UltraLight-tosf-sc-ot1--base.tfm \
tex-FiraSans-UltraLight-tosf-sc-ot1.tfm \
tex-FiraSans-UltraLight-tosf-sc-ot1.vf \
tex-FiraSans-UltraLight-tosf-sc-t1--base.tfm \
tex-FiraSans-UltraLight-tosf-sc-t1.tfm \
tex-FiraSans-UltraLight-tosf-sc-t1.vf \
tex-FiraSans-UltraLight-tosf-t1--base.tfm \
tex-FiraSans-UltraLight-tosf-t1.tfm \
tex-FiraSans-UltraLight-tosf-t1.vf \
tex-FiraSans-UltraLight-tosf-ts1--base.tfm \
tex-FiraSans-UltraLight-tosf-ts1.tfm \
tex-FiraSans-UltraLight-tosf-ts1.vf \
tex-FiraSans-UltraLightItalic-lf-lgr.tfm \
tex-FiraSans-UltraLightItalic-lf-ly1.tfm \
tex-FiraSans-UltraLightItalic-lf-ot1.tfm \
tex-FiraSans-UltraLightItalic-lf-sc-lgr.tfm \
tex-FiraSans-UltraLightItalic-lf-sc-ly1--base.tfm \
tex-FiraSans-UltraLightItalic-lf-sc-ly1.tfm \
tex-FiraSans-UltraLightItalic-lf-sc-ly1.vf \
tex-FiraSans-UltraLightItalic-lf-sc-ot1--base.tfm \
tex-FiraSans-UltraLightItalic-lf-sc-ot1.tfm \
tex-FiraSans-UltraLightItalic-lf-sc-ot1.vf \
tex-FiraSans-UltraLightItalic-lf-sc-t1--base.tfm \
tex-FiraSans-UltraLightItalic-lf-sc-t1.tfm \
tex-FiraSans-UltraLightItalic-lf-sc-t1.vf \
tex-FiraSans-UltraLightItalic-lf-t1--base.tfm \
tex-FiraSans-UltraLightItalic-lf-t1.tfm \
tex-FiraSans-UltraLightItalic-lf-t1.vf \
tex-FiraSans-UltraLightItalic-lf-ts1--base.tfm \
tex-FiraSans-UltraLightItalic-lf-ts1.tfm \
tex-FiraSans-UltraLightItalic-lf-ts1.vf \
tex-FiraSans-UltraLightItalic-osf-lgr.tfm \
tex-FiraSans-UltraLightItalic-osf-ly1.tfm \
tex-FiraSans-UltraLightItalic-osf-ot1.tfm \
tex-FiraSans-UltraLightItalic-osf-sc-lgr.tfm \
tex-FiraSans-UltraLightItalic-osf-sc-ly1--base.tfm \
tex-FiraSans-UltraLightItalic-osf-sc-ly1.tfm \
tex-FiraSans-UltraLightItalic-osf-sc-ly1.vf \
tex-FiraSans-UltraLightItalic-osf-sc-ot1--base.tfm \
tex-FiraSans-UltraLightItalic-osf-sc-ot1.tfm \
tex-FiraSans-UltraLightItalic-osf-sc-ot1.vf \
tex-FiraSans-UltraLightItalic-osf-sc-t1--base.tfm \
tex-FiraSans-UltraLightItalic-osf-sc-t1.tfm \
tex-FiraSans-UltraLightItalic-osf-sc-t1.vf \
tex-FiraSans-UltraLightItalic-osf-t1--base.tfm \
tex-FiraSans-UltraLightItalic-osf-t1.tfm \
tex-FiraSans-UltraLightItalic-osf-t1.vf \
tex-FiraSans-UltraLightItalic-osf-ts1--base.tfm \
tex-FiraSans-UltraLightItalic-osf-ts1.tfm \
tex-FiraSans-UltraLightItalic-osf-ts1.vf \
tex-FiraSans-UltraLightItalic-sup-lgr.tfm \
tex-FiraSans-UltraLightItalic-sup-ly1.tfm \
tex-FiraSans-UltraLightItalic-sup-ot1.tfm \
tex-FiraSans-UltraLightItalic-sup-t1--base.tfm \
tex-FiraSans-UltraLightItalic-sup-t1.tfm \
tex-FiraSans-UltraLightItalic-sup-t1.vf \
tex-FiraSans-UltraLightItalic-tlf-lgr.tfm \
tex-FiraSans-UltraLightItalic-tlf-ly1.tfm \
tex-FiraSans-UltraLightItalic-tlf-ot1.tfm \
tex-FiraSans-UltraLightItalic-tlf-sc-lgr.tfm \
tex-FiraSans-UltraLightItalic-tlf-sc-ly1--base.tfm \
tex-FiraSans-UltraLightItalic-tlf-sc-ly1.tfm \
tex-FiraSans-UltraLightItalic-tlf-sc-ly1.vf \
tex-FiraSans-UltraLightItalic-tlf-sc-ot1--base.tfm \
tex-FiraSans-UltraLightItalic-tlf-sc-ot1.tfm \
tex-FiraSans-UltraLightItalic-tlf-sc-ot1.vf \
tex-FiraSans-UltraLightItalic-tlf-sc-t1--base.tfm \
tex-FiraSans-UltraLightItalic-tlf-sc-t1.tfm \
tex-FiraSans-UltraLightItalic-tlf-sc-t1.vf \
tex-FiraSans-UltraLightItalic-tlf-t1--base.tfm \
tex-FiraSans-UltraLightItalic-tlf-t1.tfm \
tex-FiraSans-UltraLightItalic-tlf-t1.vf \
tex-FiraSans-UltraLightItalic-tlf-ts1--base.tfm \
tex-FiraSans-UltraLightItalic-tlf-ts1.tfm \
tex-FiraSans-UltraLightItalic-tlf-ts1.vf \
tex-FiraSans-UltraLightItalic-tosf-lgr.tfm \
tex-FiraSans-UltraLightItalic-tosf-ly1.tfm \
tex-FiraSans-UltraLightItalic-tosf-ot1.tfm \
tex-FiraSans-UltraLightItalic-tosf-sc-lgr.tfm \
tex-FiraSans-UltraLightItalic-tosf-sc-ly1--base.tfm \
tex-FiraSans-UltraLightItalic-tosf-sc-ly1.tfm \
tex-FiraSans-UltraLightItalic-tosf-sc-ly1.vf \
tex-FiraSans-UltraLightItalic-tosf-sc-ot1--base.tfm \
tex-FiraSans-UltraLightItalic-tosf-sc-ot1.tfm \
tex-FiraSans-UltraLightItalic-tosf-sc-ot1.vf \
tex-FiraSans-UltraLightItalic-tosf-sc-t1--base.tfm \
tex-FiraSans-UltraLightItalic-tosf-sc-t1.tfm \
tex-FiraSans-UltraLightItalic-tosf-sc-t1.vf \
tex-FiraSans-UltraLightItalic-tosf-t1--base.tfm \
tex-FiraSans-UltraLightItalic-tosf-t1.tfm \
tex-FiraSans-UltraLightItalic-tosf-t1.vf \
tex-FiraSans-UltraLightItalic-tosf-ts1--base.tfm \
tex-FiraSans-UltraLightItalic-tosf-ts1.tfm \
tex-FiraSans-UltraLightItalic-tosf-ts1.vf \
tex-FiraSans.sty \
tex-LGRFiraMono-Sup.fd \
tex-LGRFiraMono-TLF.fd \
tex-LGRFiraMono-TOsF.fd \
tex-LGRFiraSans-LF.fd \
tex-LGRFiraSans-OsF.fd \
tex-LGRFiraSans-Sup.fd \
tex-LGRFiraSans-TLF.fd \
tex-LGRFiraSans-TOsF.fd \
tex-LY1FiraMono-Sup.fd \
tex-LY1FiraMono-TLF.fd \
tex-LY1FiraMono-TOsF.fd \
tex-LY1FiraSans-LF.fd \
tex-LY1FiraSans-OsF.fd \
tex-LY1FiraSans-Sup.fd \
tex-LY1FiraSans-TLF.fd \
tex-LY1FiraSans-TOsF.fd \
tex-OT1FiraMono-Sup.fd \
tex-OT1FiraMono-TLF.fd \
tex-OT1FiraMono-TOsF.fd \
tex-OT1FiraSans-LF.fd \
tex-OT1FiraSans-OsF.fd \
tex-OT1FiraSans-Sup.fd \
tex-OT1FiraSans-TLF.fd \
tex-OT1FiraSans-TOsF.fd \
tex-T1FiraMono-Sup.fd \
tex-T1FiraMono-TLF.fd \
tex-T1FiraMono-TOsF.fd \
tex-T1FiraSans-LF.fd \
tex-T1FiraSans-OsF.fd \
tex-T1FiraSans-Sup.fd \
tex-T1FiraSans-TLF.fd \
tex-T1FiraSans-TOsF.fd \
tex-TS1FiraMono-TLF.fd \
tex-TS1FiraMono-TOsF.fd \
tex-TS1FiraSans-LF.fd \
tex-TS1FiraSans-OsF.fd \
tex-TS1FiraSans-TLF.fd \
tex-TS1FiraSans-TOsF.fd \
tex-fir-277p54.enc \
tex-fir-2mfh3o.enc \
tex-fir-337jzs.enc \
tex-fir-35cirm.enc \
tex-fir-3rjtzj.enc \
tex-fir-4amwxz.enc \
tex-fir-64bwtp.enc \
tex-fir-6a7jni.enc \
tex-fir-6pmvcj.enc \
tex-fir-752xwd.enc \
tex-fir-77v2wz.enc \
tex-fir-a7qib3.enc \
tex-fir-ato6be.enc \
tex-fir-bdsk4z.enc \
tex-fir-bweh26.enc \
tex-fir-ctfgmy.enc \
tex-fir-d4q673.enc \
tex-fir-d67aat.enc \
tex-fir-drwkde.enc \
tex-fir-embvrf.enc \
tex-fir-fdi65k.enc \
tex-fir-fkitua.enc \
tex-fir-fmuqgy.enc \
tex-fir-fp7bit.enc \
tex-fir-fugcbc.enc \
tex-fir-i3ioen.enc \
tex-fir-ikmdpu.enc \
tex-fir-iln36p.enc \
tex-fir-ipx2pi.enc \
tex-fir-iuj4v6.enc \
tex-fir-l5plul.enc \
tex-fir-lyxrxe.enc \
tex-fir-mg765t.enc \
tex-fir-mp24xm.enc \
tex-fir-muxyzp.enc \
tex-fir-nlwzva.enc \
tex-fir-nqd3t2.enc \
tex-fir-ogsljj.enc \
tex-fir-pn4j44.enc \
tex-fir-pqsnfd.enc \
tex-fir-q4uag2.enc \
tex-fir-q72bhc.enc \
tex-fir-qz5ryr.enc \
tex-fir-rqul6i.enc \
tex-fir-tz2nek.enc \
tex-fir-ugbesn.enc \
tex-fir-uhzub2.enc \
tex-fir-utelx5.enc \
tex-fir-wpkht5.enc \
tex-fir-yz65wh.enc \
tex-fir-znzycj.enc \
tex-fira.map \
texlive-fira"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontaxes.sty \
tex-fontenc.sty \
tex-fontspec.sty \
tex-ifluatex.sty \
tex-ifxetex.sty \
tex-mweights.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-filesystem \
texlive-fira-fonts \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
