SUMMARY = "Quattrocento and Quattrocento Sans fonts with LaTeX support"
DESCRIPTION = "The package provides LaTeX, pdfLaTeX, XeLaTeX and LuaLaTeX \
support for the Quattrocento and Quattrocento Sans families of \
fonts, designed by Pablo Impallari; the fonts themselves are \
also provided, in both TrueType and Type1 format. Quattrocento \
is a classic typeface with wide and open letterforms, and great \
x-height, which makes it very legible for body text at small \
sizes. Tiny details that only show up at bigger sizes make it \
also great for display use. Quattrocento Sans is the perfect \
sans-serif companion for Quattrocento."
LICENSE = "OFL-1.1"

PV = "2023.201.svn64372"

RPM_NAME = "texlive-quattrocento-2023.201.svn64372-53.1.noarch.rpm"
RPM_HASH = "408e05ec1ce304f85b82266f3976e8f4a8f1ab0fc2d30ddc27c7856cfbd7f190c8c54faf49a417583ae5b3fe8518f14be0696cdd34d5df88bdc39647cd7d2044"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-LY1Quattro-LF.fd \
tex-LY1Quattro-Sup.fd \
tex-LY1QuattroSans-LF.fd \
tex-LY1QuattroSans-Sup.fd \
tex-OT1Quattro-LF.fd \
tex-OT1Quattro-Sup.fd \
tex-OT1QuattroSans-LF.fd \
tex-OT1QuattroSans-Sup.fd \
tex-Quattro-Bold-lf-ly1--base.tfm \
tex-Quattro-Bold-lf-ly1.tfm \
tex-Quattro-Bold-lf-ly1.vf \
tex-Quattro-Bold-lf-ot1.tfm \
tex-Quattro-Bold-lf-t1--base.tfm \
tex-Quattro-Bold-lf-t1.tfm \
tex-Quattro-Bold-lf-t1.vf \
tex-Quattro-Bold-lf-ts1--base.tfm \
tex-Quattro-Bold-lf-ts1.tfm \
tex-Quattro-Bold-lf-ts1.vf \
tex-Quattro-Bold-sup-ly1--base.tfm \
tex-Quattro-Bold-sup-ly1.tfm \
tex-Quattro-Bold-sup-ly1.vf \
tex-Quattro-Bold-sup-ot1.tfm \
tex-Quattro-Bold-sup-t1--base.tfm \
tex-Quattro-Bold-sup-t1.tfm \
tex-Quattro-Bold-sup-t1.vf \
tex-Quattro-BoldItalic-lf-ly1--base.tfm \
tex-Quattro-BoldItalic-lf-ly1.tfm \
tex-Quattro-BoldItalic-lf-ly1.vf \
tex-Quattro-BoldItalic-lf-ot1.tfm \
tex-Quattro-BoldItalic-lf-t1--base.tfm \
tex-Quattro-BoldItalic-lf-t1.tfm \
tex-Quattro-BoldItalic-lf-t1.vf \
tex-Quattro-BoldItalic-lf-ts1--base.tfm \
tex-Quattro-BoldItalic-lf-ts1.tfm \
tex-Quattro-BoldItalic-lf-ts1.vf \
tex-Quattro-BoldItalic-sup-ly1--base.tfm \
tex-Quattro-BoldItalic-sup-ly1.tfm \
tex-Quattro-BoldItalic-sup-ly1.vf \
tex-Quattro-BoldItalic-sup-ot1.tfm \
tex-Quattro-BoldItalic-sup-t1--base.tfm \
tex-Quattro-BoldItalic-sup-t1.tfm \
tex-Quattro-BoldItalic-sup-t1.vf \
tex-Quattro-Italic-lf-ly1--base.tfm \
tex-Quattro-Italic-lf-ly1.tfm \
tex-Quattro-Italic-lf-ly1.vf \
tex-Quattro-Italic-lf-ot1.tfm \
tex-Quattro-Italic-lf-t1--base.tfm \
tex-Quattro-Italic-lf-t1.tfm \
tex-Quattro-Italic-lf-t1.vf \
tex-Quattro-Italic-lf-ts1--base.tfm \
tex-Quattro-Italic-lf-ts1.tfm \
tex-Quattro-Italic-lf-ts1.vf \
tex-Quattro-Italic-sup-ly1--base.tfm \
tex-Quattro-Italic-sup-ly1.tfm \
tex-Quattro-Italic-sup-ly1.vf \
tex-Quattro-Italic-sup-ot1.tfm \
tex-Quattro-Italic-sup-t1--base.tfm \
tex-Quattro-Italic-sup-t1.tfm \
tex-Quattro-Italic-sup-t1.vf \
tex-Quattro-Regular-lf-ly1--base.tfm \
tex-Quattro-Regular-lf-ly1.tfm \
tex-Quattro-Regular-lf-ly1.vf \
tex-Quattro-Regular-lf-ot1.tfm \
tex-Quattro-Regular-lf-t1--base.tfm \
tex-Quattro-Regular-lf-t1.tfm \
tex-Quattro-Regular-lf-t1.vf \
tex-Quattro-Regular-lf-ts1--base.tfm \
tex-Quattro-Regular-lf-ts1.tfm \
tex-Quattro-Regular-lf-ts1.vf \
tex-Quattro-Regular-sup-ly1--base.tfm \
tex-Quattro-Regular-sup-ly1.tfm \
tex-Quattro-Regular-sup-ly1.vf \
tex-Quattro-Regular-sup-ot1.tfm \
tex-Quattro-Regular-sup-t1--base.tfm \
tex-Quattro-Regular-sup-t1.tfm \
tex-Quattro-Regular-sup-t1.vf \
tex-QuattroSans-Bold-lf-ly1--base.tfm \
tex-QuattroSans-Bold-lf-ly1.tfm \
tex-QuattroSans-Bold-lf-ly1.vf \
tex-QuattroSans-Bold-lf-ot1.tfm \
tex-QuattroSans-Bold-lf-t1--base.tfm \
tex-QuattroSans-Bold-lf-t1.tfm \
tex-QuattroSans-Bold-lf-t1.vf \
tex-QuattroSans-Bold-lf-ts1--base.tfm \
tex-QuattroSans-Bold-lf-ts1.tfm \
tex-QuattroSans-Bold-lf-ts1.vf \
tex-QuattroSans-Bold-sup-ly1--base.tfm \
tex-QuattroSans-Bold-sup-ly1.tfm \
tex-QuattroSans-Bold-sup-ly1.vf \
tex-QuattroSans-Bold-sup-ot1.tfm \
tex-QuattroSans-Bold-sup-t1--base.tfm \
tex-QuattroSans-Bold-sup-t1.tfm \
tex-QuattroSans-Bold-sup-t1.vf \
tex-QuattroSans-BoldItalic-lf-ly1--base.tfm \
tex-QuattroSans-BoldItalic-lf-ly1.tfm \
tex-QuattroSans-BoldItalic-lf-ly1.vf \
tex-QuattroSans-BoldItalic-lf-ot1.tfm \
tex-QuattroSans-BoldItalic-lf-t1--base.tfm \
tex-QuattroSans-BoldItalic-lf-t1.tfm \
tex-QuattroSans-BoldItalic-lf-t1.vf \
tex-QuattroSans-BoldItalic-lf-ts1--base.tfm \
tex-QuattroSans-BoldItalic-lf-ts1.tfm \
tex-QuattroSans-BoldItalic-lf-ts1.vf \
tex-QuattroSans-BoldItalic-sup-ly1--base.tfm \
tex-QuattroSans-BoldItalic-sup-ly1.tfm \
tex-QuattroSans-BoldItalic-sup-ly1.vf \
tex-QuattroSans-BoldItalic-sup-ot1.tfm \
tex-QuattroSans-BoldItalic-sup-t1--base.tfm \
tex-QuattroSans-BoldItalic-sup-t1.tfm \
tex-QuattroSans-BoldItalic-sup-t1.vf \
tex-QuattroSans-Italic-lf-ly1--base.tfm \
tex-QuattroSans-Italic-lf-ly1.tfm \
tex-QuattroSans-Italic-lf-ly1.vf \
tex-QuattroSans-Italic-lf-ot1.tfm \
tex-QuattroSans-Italic-lf-t1--base.tfm \
tex-QuattroSans-Italic-lf-t1.tfm \
tex-QuattroSans-Italic-lf-t1.vf \
tex-QuattroSans-Italic-lf-ts1--base.tfm \
tex-QuattroSans-Italic-lf-ts1.tfm \
tex-QuattroSans-Italic-lf-ts1.vf \
tex-QuattroSans-Italic-sup-ly1--base.tfm \
tex-QuattroSans-Italic-sup-ly1.tfm \
tex-QuattroSans-Italic-sup-ly1.vf \
tex-QuattroSans-Italic-sup-ot1.tfm \
tex-QuattroSans-Italic-sup-t1--base.tfm \
tex-QuattroSans-Italic-sup-t1.tfm \
tex-QuattroSans-Italic-sup-t1.vf \
tex-QuattroSans-Regular-lf-ly1--base.tfm \
tex-QuattroSans-Regular-lf-ly1.tfm \
tex-QuattroSans-Regular-lf-ly1.vf \
tex-QuattroSans-Regular-lf-ot1.tfm \
tex-QuattroSans-Regular-lf-t1--base.tfm \
tex-QuattroSans-Regular-lf-t1.tfm \
tex-QuattroSans-Regular-lf-t1.vf \
tex-QuattroSans-Regular-lf-ts1--base.tfm \
tex-QuattroSans-Regular-lf-ts1.tfm \
tex-QuattroSans-Regular-lf-ts1.vf \
tex-QuattroSans-Regular-sup-ly1--base.tfm \
tex-QuattroSans-Regular-sup-ly1.tfm \
tex-QuattroSans-Regular-sup-ly1.vf \
tex-QuattroSans-Regular-sup-ot1.tfm \
tex-QuattroSans-Regular-sup-t1--base.tfm \
tex-QuattroSans-Regular-sup-t1.tfm \
tex-QuattroSans-Regular-sup-t1.vf \
tex-T1Quattro-LF.fd \
tex-T1Quattro-Sup.fd \
tex-T1QuattroSans-LF.fd \
tex-T1QuattroSans-Sup.fd \
tex-TS1Quattro-LF.fd \
tex-TS1QuattroSans-LF.fd \
tex-qcntr-3fwis5.enc \
tex-qcntr-464xel.enc \
tex-qcntr-4btof3.enc \
tex-qcntr-564kqe.enc \
tex-qcntr-6abmaa.enc \
tex-qcntr-arxkdo.enc \
tex-qcntr-bwr4r4.enc \
tex-qcntr-cpzb4n.enc \
tex-qcntr-dn5k7b.enc \
tex-qcntr-ezrk6a.enc \
tex-qcntr-iyhp72.enc \
tex-qcntr-lten7n.enc \
tex-qcntr-lzgh2n.enc \
tex-qcntr-mamppr.enc \
tex-qcntr-mizmmx.enc \
tex-qcntr-mntdbg.enc \
tex-qcntr-qwkegf.enc \
tex-qcntr-rf6b27.enc \
tex-qcntr-tldjzh.enc \
tex-qcntr-vzn2dc.enc \
tex-qcntr-wczi5x.enc \
tex-qcntr-xvywtm.enc \
tex-qcntr-y54nu7.enc \
tex-qcntr-zievlx.enc \
tex-qcntr-zq54sp.enc \
tex-quattrocento.map \
tex-quattrocento.sty \
texlive-quattrocento"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontaxes.sty \
tex-fontenc.sty \
tex-fontspec.sty \
tex-ifluatex.sty \
tex-ifxetex.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-quattrocento-fonts \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
