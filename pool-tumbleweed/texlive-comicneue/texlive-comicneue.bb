SUMMARY = "Use Comic Neue with TeX(-alike) systems"
DESCRIPTION = "Comic Neue is a well-known redesign of the (in)famous Comic \
Sans font. The package provides the original OpenType font for \
XeTeX and LuaTeX users, and also has converted Type1 files for \
pdfTeX users. Issues with this package can be reported on \
GitHub or emailed to tex@slxh.nl."
LICENSE = "OFL-1.1"

PV = "2023.209.1.2svn54891"

RPM_NAME = "texlive-comicneue-2023.209.1.2svn54891-54.1.noarch.rpm"
RPM_HASH = "5ae79a8dfd87c098d750d079f1d5dbbe5fdec1053153579d5843029f589440f75d42cd63ac15d7ae4cfd2b917a7d3ee8d6ba38f9272d710d170128632b252f91"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-ComicNeue-Bold-tlf-ly1--base.tfm \
tex-ComicNeue-Bold-tlf-ly1.tfm \
tex-ComicNeue-Bold-tlf-ly1.vf \
tex-ComicNeue-Bold-tlf-ot1.tfm \
tex-ComicNeue-Bold-tlf-t1--base.tfm \
tex-ComicNeue-Bold-tlf-t1.tfm \
tex-ComicNeue-Bold-tlf-t1.vf \
tex-ComicNeue-Bold-tlf-ts1--base.tfm \
tex-ComicNeue-Bold-tlf-ts1.tfm \
tex-ComicNeue-Bold-tlf-ts1.vf \
tex-ComicNeue-BoldItalic-tlf-ly1--base.tfm \
tex-ComicNeue-BoldItalic-tlf-ly1.tfm \
tex-ComicNeue-BoldItalic-tlf-ly1.vf \
tex-ComicNeue-BoldItalic-tlf-ot1.tfm \
tex-ComicNeue-BoldItalic-tlf-t1--base.tfm \
tex-ComicNeue-BoldItalic-tlf-t1.tfm \
tex-ComicNeue-BoldItalic-tlf-t1.vf \
tex-ComicNeue-BoldItalic-tlf-ts1--base.tfm \
tex-ComicNeue-BoldItalic-tlf-ts1.tfm \
tex-ComicNeue-BoldItalic-tlf-ts1.vf \
tex-ComicNeue-Italic-tlf-ly1--base.tfm \
tex-ComicNeue-Italic-tlf-ly1.tfm \
tex-ComicNeue-Italic-tlf-ly1.vf \
tex-ComicNeue-Italic-tlf-ot1.tfm \
tex-ComicNeue-Italic-tlf-t1--base.tfm \
tex-ComicNeue-Italic-tlf-t1.tfm \
tex-ComicNeue-Italic-tlf-t1.vf \
tex-ComicNeue-Italic-tlf-ts1--base.tfm \
tex-ComicNeue-Italic-tlf-ts1.tfm \
tex-ComicNeue-Italic-tlf-ts1.vf \
tex-ComicNeue-Light-tlf-ly1--base.tfm \
tex-ComicNeue-Light-tlf-ly1.tfm \
tex-ComicNeue-Light-tlf-ly1.vf \
tex-ComicNeue-Light-tlf-ot1.tfm \
tex-ComicNeue-Light-tlf-t1--base.tfm \
tex-ComicNeue-Light-tlf-t1.tfm \
tex-ComicNeue-Light-tlf-t1.vf \
tex-ComicNeue-Light-tlf-ts1--base.tfm \
tex-ComicNeue-Light-tlf-ts1.tfm \
tex-ComicNeue-Light-tlf-ts1.vf \
tex-ComicNeue-LightItalic-tlf-ly1--base.tfm \
tex-ComicNeue-LightItalic-tlf-ly1.tfm \
tex-ComicNeue-LightItalic-tlf-ly1.vf \
tex-ComicNeue-LightItalic-tlf-ot1.tfm \
tex-ComicNeue-LightItalic-tlf-t1--base.tfm \
tex-ComicNeue-LightItalic-tlf-t1.tfm \
tex-ComicNeue-LightItalic-tlf-t1.vf \
tex-ComicNeue-LightItalic-tlf-ts1--base.tfm \
tex-ComicNeue-LightItalic-tlf-ts1.tfm \
tex-ComicNeue-LightItalic-tlf-ts1.vf \
tex-ComicNeue-Regular-tlf-ly1--base.tfm \
tex-ComicNeue-Regular-tlf-ly1.tfm \
tex-ComicNeue-Regular-tlf-ly1.vf \
tex-ComicNeue-Regular-tlf-ot1.tfm \
tex-ComicNeue-Regular-tlf-t1--base.tfm \
tex-ComicNeue-Regular-tlf-t1.tfm \
tex-ComicNeue-Regular-tlf-t1.vf \
tex-ComicNeue-Regular-tlf-ts1--base.tfm \
tex-ComicNeue-Regular-tlf-ts1.tfm \
tex-ComicNeue-Regular-tlf-ts1.vf \
tex-ComicNeue.map \
tex-ComicNeueAngular-Bold-tlf-ly1--base.tfm \
tex-ComicNeueAngular-Bold-tlf-ly1--lcdfj.tfm \
tex-ComicNeueAngular-Bold-tlf-ly1.tfm \
tex-ComicNeueAngular-Bold-tlf-ly1.vf \
tex-ComicNeueAngular-Bold-tlf-ot1--base.tfm \
tex-ComicNeueAngular-Bold-tlf-ot1--lcdfj.tfm \
tex-ComicNeueAngular-Bold-tlf-ot1.tfm \
tex-ComicNeueAngular-Bold-tlf-ot1.vf \
tex-ComicNeueAngular-Bold-tlf-t1--base.tfm \
tex-ComicNeueAngular-Bold-tlf-t1--lcdfj.tfm \
tex-ComicNeueAngular-Bold-tlf-t1.tfm \
tex-ComicNeueAngular-Bold-tlf-t1.vf \
tex-ComicNeueAngular-Bold-tlf-ts1--base.tfm \
tex-ComicNeueAngular-Bold-tlf-ts1.tfm \
tex-ComicNeueAngular-Bold-tlf-ts1.vf \
tex-ComicNeueAngular-BoldItalic-tlf-ly1--base.tfm \
tex-ComicNeueAngular-BoldItalic-tlf-ly1--lcdfj.tfm \
tex-ComicNeueAngular-BoldItalic-tlf-ly1.tfm \
tex-ComicNeueAngular-BoldItalic-tlf-ly1.vf \
tex-ComicNeueAngular-BoldItalic-tlf-ot1--base.tfm \
tex-ComicNeueAngular-BoldItalic-tlf-ot1--lcdfj.tfm \
tex-ComicNeueAngular-BoldItalic-tlf-ot1.tfm \
tex-ComicNeueAngular-BoldItalic-tlf-ot1.vf \
tex-ComicNeueAngular-BoldItalic-tlf-t1--base.tfm \
tex-ComicNeueAngular-BoldItalic-tlf-t1--lcdfj.tfm \
tex-ComicNeueAngular-BoldItalic-tlf-t1.tfm \
tex-ComicNeueAngular-BoldItalic-tlf-t1.vf \
tex-ComicNeueAngular-BoldItalic-tlf-ts1--base.tfm \
tex-ComicNeueAngular-BoldItalic-tlf-ts1.tfm \
tex-ComicNeueAngular-BoldItalic-tlf-ts1.vf \
tex-ComicNeueAngular-Italic-tlf-ly1--base.tfm \
tex-ComicNeueAngular-Italic-tlf-ly1--lcdfj.tfm \
tex-ComicNeueAngular-Italic-tlf-ly1.tfm \
tex-ComicNeueAngular-Italic-tlf-ly1.vf \
tex-ComicNeueAngular-Italic-tlf-ot1--base.tfm \
tex-ComicNeueAngular-Italic-tlf-ot1--lcdfj.tfm \
tex-ComicNeueAngular-Italic-tlf-ot1.tfm \
tex-ComicNeueAngular-Italic-tlf-ot1.vf \
tex-ComicNeueAngular-Italic-tlf-t1--base.tfm \
tex-ComicNeueAngular-Italic-tlf-t1--lcdfj.tfm \
tex-ComicNeueAngular-Italic-tlf-t1.tfm \
tex-ComicNeueAngular-Italic-tlf-t1.vf \
tex-ComicNeueAngular-Italic-tlf-ts1--base.tfm \
tex-ComicNeueAngular-Italic-tlf-ts1.tfm \
tex-ComicNeueAngular-Italic-tlf-ts1.vf \
tex-ComicNeueAngular-Light-tlf-ly1--base.tfm \
tex-ComicNeueAngular-Light-tlf-ly1--lcdfj.tfm \
tex-ComicNeueAngular-Light-tlf-ly1.tfm \
tex-ComicNeueAngular-Light-tlf-ly1.vf \
tex-ComicNeueAngular-Light-tlf-ot1--base.tfm \
tex-ComicNeueAngular-Light-tlf-ot1--lcdfj.tfm \
tex-ComicNeueAngular-Light-tlf-ot1.tfm \
tex-ComicNeueAngular-Light-tlf-ot1.vf \
tex-ComicNeueAngular-Light-tlf-t1--base.tfm \
tex-ComicNeueAngular-Light-tlf-t1--lcdfj.tfm \
tex-ComicNeueAngular-Light-tlf-t1.tfm \
tex-ComicNeueAngular-Light-tlf-t1.vf \
tex-ComicNeueAngular-Light-tlf-ts1--base.tfm \
tex-ComicNeueAngular-Light-tlf-ts1.tfm \
tex-ComicNeueAngular-Light-tlf-ts1.vf \
tex-ComicNeueAngular-LightItalic-tlf-ly1--base.tfm \
tex-ComicNeueAngular-LightItalic-tlf-ly1--lcdfj.tfm \
tex-ComicNeueAngular-LightItalic-tlf-ly1.tfm \
tex-ComicNeueAngular-LightItalic-tlf-ly1.vf \
tex-ComicNeueAngular-LightItalic-tlf-ot1--base.tfm \
tex-ComicNeueAngular-LightItalic-tlf-ot1--lcdfj.tfm \
tex-ComicNeueAngular-LightItalic-tlf-ot1.tfm \
tex-ComicNeueAngular-LightItalic-tlf-ot1.vf \
tex-ComicNeueAngular-LightItalic-tlf-t1--base.tfm \
tex-ComicNeueAngular-LightItalic-tlf-t1--lcdfj.tfm \
tex-ComicNeueAngular-LightItalic-tlf-t1.tfm \
tex-ComicNeueAngular-LightItalic-tlf-t1.vf \
tex-ComicNeueAngular-LightItalic-tlf-ts1--base.tfm \
tex-ComicNeueAngular-LightItalic-tlf-ts1.tfm \
tex-ComicNeueAngular-LightItalic-tlf-ts1.vf \
tex-ComicNeueAngular-Regular-tlf-ly1--base.tfm \
tex-ComicNeueAngular-Regular-tlf-ly1--lcdfj.tfm \
tex-ComicNeueAngular-Regular-tlf-ly1.tfm \
tex-ComicNeueAngular-Regular-tlf-ly1.vf \
tex-ComicNeueAngular-Regular-tlf-ot1--base.tfm \
tex-ComicNeueAngular-Regular-tlf-ot1--lcdfj.tfm \
tex-ComicNeueAngular-Regular-tlf-ot1.tfm \
tex-ComicNeueAngular-Regular-tlf-ot1.vf \
tex-ComicNeueAngular-Regular-tlf-t1--base.tfm \
tex-ComicNeueAngular-Regular-tlf-t1--lcdfj.tfm \
tex-ComicNeueAngular-Regular-tlf-t1.tfm \
tex-ComicNeueAngular-Regular-tlf-t1.vf \
tex-ComicNeueAngular-Regular-tlf-ts1--base.tfm \
tex-ComicNeueAngular-Regular-tlf-ts1.tfm \
tex-ComicNeueAngular-Regular-tlf-ts1.vf \
tex-ComicNeueAngular.map \
tex-LY1ComicNeue-TLF.fd \
tex-LY1ComicNeueAngular-TLF.fd \
tex-OT1ComicNeue-TLF.fd \
tex-OT1ComicNeueAngular-TLF.fd \
tex-T1ComicNeue-TLF.fd \
tex-T1ComicNeueAngular-TLF.fd \
tex-TS1ComicNeue-TLF.fd \
tex-TS1ComicNeueAngular-TLF.fd \
tex-a-3f3vls.enc \
tex-a-d7lrxj.enc \
tex-a-fqjac7.enc \
tex-a-ixwebc.enc \
tex-a-ncyf37.enc \
tex-a-nhwyv3.enc \
tex-a-trnund.enc \
tex-a-upn2ip.enc \
tex-a-wfs66e.enc \
tex-comicneue.sty \
texlive-comicneue"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontenc.sty \
tex-fontspec.sty \
tex-l3keys2e.sty \
tex-mweights.sty \
tex-updmap.cfg \
tex-xparse.sty \
texlive \
texlive-comicneue-fonts \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
