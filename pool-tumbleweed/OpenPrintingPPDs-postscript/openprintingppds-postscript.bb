SUMMARY = "PPD files from OpenPrinting.org for PostScript printers"
DESCRIPTION = "PPD files for PostScript printers \
which do not use a driver but \
may use the foomatic-rip filter."
LICENSE = "GPL-2.0-or-later & MIT"

PV = "4.0.0.2"

RPM_NAME = "OpenPrintingPPDs-postscript-4.0.0.2-6.9.noarch.rpm"
RPM_HASH = "fedd820b13f2bd57936e306e38e29ddc1ed4303f381e1ad5d9d372a72aa5f0457e332524a37c9ebf6cd137880cb7b500846b56fdd51a84509f36c981bdf0b218"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "OpenPrintingPPDs-postscript \
postscriptdriver-brother;brother-dcp-7025; \
postscriptdriver-brother;brother-dcp-7045n; \
postscriptdriver-brother;brother-dcp-8020; \
postscriptdriver-brother;brother-dcp-8025d; \
postscriptdriver-brother;brother-dcp-8040; \
postscriptdriver-brother;brother-dcp-8080dn; \
postscriptdriver-brother;brother-dcp-8085dn; \
postscriptdriver-brother;brother-dcp-9010cn; \
postscriptdriver-brother;brother-dcp-9040cn; \
postscriptdriver-brother;brother-dcp-9045cdn; \
postscriptdriver-brother;brother-hl-1450-series; \
postscriptdriver-brother;brother-hl-1470n-series; \
postscriptdriver-brother;brother-hl-1650-1670n-series; \
postscriptdriver-brother;brother-hl-1850-1870n-series; \
postscriptdriver-brother;brother-hl-2460-series; \
postscriptdriver-brother;brother-hl-2600cn-series; \
postscriptdriver-brother;brother-hl-2700cn-series; \
postscriptdriver-brother;brother-hl-3070cw; \
postscriptdriver-brother;brother-hl-3260n-series; \
postscriptdriver-brother;brother-hl-3450cn-series; \
postscriptdriver-brother;brother-hl-4050cdn; \
postscriptdriver-brother;brother-hl-4070cdw; \
postscriptdriver-brother;brother-hl-5050-series; \
postscriptdriver-brother;brother-hl-5070n-series; \
postscriptdriver-brother;brother-hl-5150d-series; \
postscriptdriver-brother;brother-hl-5170dn-series; \
postscriptdriver-brother;brother-hl-5240-series; \
postscriptdriver-brother;brother-hl-5270dn-series; \
postscriptdriver-brother;brother-hl-5350dn-series; \
postscriptdriver-brother;brother-hl-5370dw-series; \
postscriptdriver-brother;brother-hl-5380dn-series; \
postscriptdriver-brother;brother-hl-6050-series; \
postscriptdriver-brother;brother-hl-6050d-dn-series; \
postscriptdriver-brother;brother-hl-7050-series; \
postscriptdriver-brother;brother-hl-8050n-series; \
postscriptdriver-brother;brother-mfc-7225n; \
postscriptdriver-brother;brother-mfc-7450; \
postscriptdriver-brother;brother-mfc-7820n; \
postscriptdriver-brother;brother-mfc-7840n; \
postscriptdriver-brother;brother-mfc-7840w; \
postscriptdriver-brother;brother-mfc-8220; \
postscriptdriver-brother;brother-mfc-8370dn; \
postscriptdriver-brother;brother-mfc-8380dn; \
postscriptdriver-brother;brother-mfc-8420; \
postscriptdriver-brother;brother-mfc-8440; \
postscriptdriver-brother;brother-mfc-8480dn; \
postscriptdriver-brother;brother-mfc-8640d; \
postscriptdriver-brother;brother-mfc-8670dn-series; \
postscriptdriver-brother;brother-mfc-8680dn; \
postscriptdriver-brother;brother-mfc-8820d; \
postscriptdriver-brother;brother-mfc-8840d; \
postscriptdriver-brother;brother-mfc-8880dn; \
postscriptdriver-brother;brother-mfc-8890dw; \
postscriptdriver-brother;brother-mfc-9010cn; \
postscriptdriver-brother;brother-mfc-9120cn; \
postscriptdriver-brother;brother-mfc-9320cw; \
postscriptdriver-brother;brother-mfc-9420cn-series; \
postscriptdriver-brother;brother-mfc-9440cn; \
postscriptdriver-brother;brother-mfc-9450cdn; \
postscriptdriver-brother;brother-mfc-9840cdw; \
postscriptdriver-brother;hl-1070-series; \
postscriptdriver-brother;hl-2040-series; \
postscriptdriver-brother;hl-2140-series; \
postscriptdriver-brother;hl-5250dn-series; \
postscriptdriver-canon;ir3225-(ufr-ii); \
postscriptdriver-epson;al-2600; \
postscriptdriver-epson;al-c1900-ps3; \
postscriptdriver-epson;al-c2000-ps3; \
postscriptdriver-epson;al-c2600; \
postscriptdriver-epson;al-c2800; \
postscriptdriver-epson;al-c3800; \
postscriptdriver-epson;al-c4000-ps3; \
postscriptdriver-epson;al-c4200; \
postscriptdriver-epson;al-c8600-ps3; \
postscriptdriver-epson;al-c9100; \
postscriptdriver-epson;al-c9200; \
postscriptdriver-epson;al-cx21; \
postscriptdriver-epson;al-m2000; \
postscriptdriver-epson;al-m2010; \
postscriptdriver-epson;al-m2400; \
postscriptdriver-epson;al-m2410; \
postscriptdriver-epson;al-m4000; \
postscriptdriver-epson;al-m8000; \
postscriptdriver-epson;al-mx20; \
postscriptdriver-epson;al-mx21; \
postscriptdriver-epson;epl-5900-ps3; \
postscriptdriver-epson;epl-6100-ps3; \
postscriptdriver-epson;epl-6200; \
postscriptdriver-epson;epl-n2550; \
postscriptdriver-epson;epl-n2700; \
postscriptdriver-epson;epl-n3000; \
postscriptdriver-epson;epl-n7000; \
postscriptdriver-epson;lp-8300cpd; \
postscriptdriver-epson;lp-8500cpd; \
postscriptdriver-epson;lp-9600spd; \
postscriptdriver-fuji-xerox;docuprint-cm305-df; \
postscriptdriver-generic;25c-1; \
postscriptdriver-gestetner;10512; \
postscriptdriver-gestetner;2212; \
postscriptdriver-gestetner;2712; \
postscriptdriver-gestetner;3212; \
postscriptdriver-gestetner;3502; \
postscriptdriver-gestetner;3532/4235g; \
postscriptdriver-gestetner;4502; \
postscriptdriver-gestetner;4532/4245g; \
postscriptdriver-gestetner;6002; \
postscriptdriver-gestetner;7502; \
postscriptdriver-gestetner;9002; \
postscriptdriver-gestetner;c7010; \
postscriptdriver-gestetner;c7116; \
postscriptdriver-gestetner;c7416; \
postscriptdriver-gestetner;c7417; \
postscriptdriver-gestetner;c7425dn; \
postscriptdriver-gestetner;c7435n; \
postscriptdriver-gestetner;c7521n; \
postscriptdriver-gestetner;c7526dn; \
postscriptdriver-gestetner;c7528n; \
postscriptdriver-gestetner;c7531dn; \
postscriptdriver-gestetner;c7535n; \
postscriptdriver-gestetner;c7640nd; \
postscriptdriver-gestetner;c8140nd; \
postscriptdriver-gestetner;c8150nd; \
postscriptdriver-gestetner;cs555; \
postscriptdriver-gestetner;dsc1020; \
postscriptdriver-gestetner;dsc1025; \
postscriptdriver-gestetner;dsc1030; \
postscriptdriver-gestetner;dsc1045; \
postscriptdriver-gestetner;dsc1060; \
postscriptdriver-gestetner;dsc224; \
postscriptdriver-gestetner;dsc232; \
postscriptdriver-gestetner;dsc328; \
postscriptdriver-gestetner;dsc332; \
postscriptdriver-gestetner;dsc338; \
postscriptdriver-gestetner;dsc38; \
postscriptdriver-gestetner;dsc38u; \
postscriptdriver-gestetner;dsc424; \
postscriptdriver-gestetner;dsc428; \
postscriptdriver-gestetner;dsc432; \
postscriptdriver-gestetner;dsc435; \
postscriptdriver-gestetner;dsc445; \
postscriptdriver-gestetner;dsc460; \
postscriptdriver-gestetner;dsc524; \
postscriptdriver-gestetner;dsc532; \
postscriptdriver-gestetner;dsm1525; \
postscriptdriver-gestetner;dsm1530; \
postscriptdriver-gestetner;dsm1533; \
postscriptdriver-gestetner;dsm415; \
postscriptdriver-gestetner;dsm615; \
postscriptdriver-gestetner;dsm616; \
postscriptdriver-gestetner;dsm618; \
postscriptdriver-gestetner;dsm618d; \
postscriptdriver-gestetner;dsm620; \
postscriptdriver-gestetner;dsm620d; \
postscriptdriver-gestetner;dsm622; \
postscriptdriver-gestetner;dsm627; \
postscriptdriver-gestetner;dsm635/635g; \
postscriptdriver-gestetner;dsm645/645g; \
postscriptdriver-gestetner;dsm651; \
postscriptdriver-gestetner;dsm660; \
postscriptdriver-gestetner;dsm675; \
postscriptdriver-gestetner;dsm725; \
postscriptdriver-gestetner;dsm730; \
postscriptdriver-gestetner;dsm735/735g; \
postscriptdriver-gestetner;dsm745/745g; \
postscriptdriver-gestetner;f9199/9199nf; \
postscriptdriver-gestetner;gwd2004; \
postscriptdriver-gestetner;gwd2006; \
postscriptdriver-gestetner;gwd3006; \
postscriptdriver-gestetner;gwd5100; \
postscriptdriver-gestetner;gwd7140; \
postscriptdriver-gestetner;mp-161/dsm416; \
postscriptdriver-gestetner;mp-171; \
postscriptdriver-gestetner;mp-2001; \
postscriptdriver-gestetner;mp-2501; \
postscriptdriver-gestetner;mp-2510/dsm725e; \
postscriptdriver-gestetner;mp-2550; \
postscriptdriver-gestetner;mp-2550b; \
postscriptdriver-gestetner;mp-2553; \
postscriptdriver-gestetner;mp-2851; \
postscriptdriver-gestetner;mp-3010/dsm730e; \
postscriptdriver-gestetner;mp-301; \
postscriptdriver-gestetner;mp-3053; \
postscriptdriver-gestetner;mp-3350; \
postscriptdriver-gestetner;mp-3350b; \
postscriptdriver-gestetner;mp-3351; \
postscriptdriver-gestetner;mp-3353; \
postscriptdriver-gestetner;mp-4000; \
postscriptdriver-gestetner;mp-4000b; \
postscriptdriver-gestetner;mp-4001; \
postscriptdriver-gestetner;mp-4002; \
postscriptdriver-gestetner;mp-5000; \
postscriptdriver-gestetner;mp-5000b; \
postscriptdriver-gestetner;mp-5001; \
postscriptdriver-gestetner;mp-5002; \
postscriptdriver-gestetner;mp-6000; \
postscriptdriver-gestetner;mp-6001; \
postscriptdriver-gestetner;mp-6002; \
postscriptdriver-gestetner;mp-7000; \
postscriptdriver-gestetner;mp-7001; \
postscriptdriver-gestetner;mp-7502; \
postscriptdriver-gestetner;mp-8000; \
postscriptdriver-gestetner;mp-8001; \
postscriptdriver-gestetner;mp-9001; \
postscriptdriver-gestetner;mp-9002; \
postscriptdriver-gestetner;mp-c2003; \
postscriptdriver-gestetner;mp-c2050; \
postscriptdriver-gestetner;mp-c2051; \
postscriptdriver-gestetner;mp-c2503; \
postscriptdriver-gestetner;mp-c2550; \
postscriptdriver-gestetner;mp-c2551; \
postscriptdriver-gestetner;mp-c2800; \
postscriptdriver-gestetner;mp-c3001; \
postscriptdriver-gestetner;mp-c3002; \
postscriptdriver-gestetner;mp-c3003; \
postscriptdriver-gestetner;mp-c300; \
postscriptdriver-gestetner;mp-c300sr; \
postscriptdriver-gestetner;mp-c305; \
postscriptdriver-gestetner;mp-c3300; \
postscriptdriver-gestetner;mp-c3501; \
postscriptdriver-gestetner;mp-c3502; \
postscriptdriver-gestetner;mp-c3503; \
postscriptdriver-gestetner;mp-c4000; \
postscriptdriver-gestetner;mp-c400; \
postscriptdriver-gestetner;mp-c400sr; \
postscriptdriver-gestetner;mp-c4501; \
postscriptdriver-gestetner;mp-c4501a; \
postscriptdriver-gestetner;mp-c4502; \
postscriptdriver-gestetner;mp-c4502a; \
postscriptdriver-gestetner;mp-c4503; \
postscriptdriver-gestetner;mp-c5000; \
postscriptdriver-gestetner;mp-c5501; \
postscriptdriver-gestetner;mp-c5501a; \
postscriptdriver-gestetner;mp-c5502; \
postscriptdriver-gestetner;mp-c5502a; \
postscriptdriver-gestetner;mp-c5503; \
postscriptdriver-gestetner;mp-c6000; \
postscriptdriver-gestetner;mp-c6003; \
postscriptdriver-gestetner;mp-c6501; \
postscriptdriver-gestetner;mp-c6502; \
postscriptdriver-gestetner;mp-c7500; \
postscriptdriver-gestetner;mp-c7501; \
postscriptdriver-gestetner;mp-c8002; \
postscriptdriver-gestetner;mp-cw2200; \
postscriptdriver-gestetner;mp1100/dsm7110; \
postscriptdriver-gestetner;mp1350/dsm7135; \
postscriptdriver-gestetner;mp1600/dsm716; \
postscriptdriver-gestetner;mp2000/dsm721d; \
postscriptdriver-gestetner;mp2352/dsm923; \
postscriptdriver-gestetner;mp2500/dsm625; \
postscriptdriver-gestetner;mp2852/dsm928; \
postscriptdriver-gestetner;mp3352/dsm933; \
postscriptdriver-gestetner;mp3500/dsm735e; \
postscriptdriver-gestetner;mp4500/dsm745e; \
postscriptdriver-gestetner;mp5500/dsm755; \
postscriptdriver-gestetner;mp6500/dsm765; \
postscriptdriver-gestetner;mp7500/dsm775; \
postscriptdriver-gestetner;mp9000/dsm790; \
postscriptdriver-gestetner;mpc1500/gs106; \
postscriptdriver-gestetner;mpc2500/dsc525; \
postscriptdriver-gestetner;mpc3000/dsc530; \
postscriptdriver-gestetner;mpc3500/dsc535; \
postscriptdriver-gestetner;mpc4500/dsc545; \
postscriptdriver-gestetner;p7026; \
postscriptdriver-gestetner;p7026n; \
postscriptdriver-gestetner;p7031n; \
postscriptdriver-gestetner;p7031nl; \
postscriptdriver-gestetner;p7032; \
postscriptdriver-gestetner;p7035n; \
postscriptdriver-gestetner;p7126; \
postscriptdriver-gestetner;p7126n; \
postscriptdriver-gestetner;p7132n; \
postscriptdriver-gestetner;p7145; \
postscriptdriver-gestetner;p7245; \
postscriptdriver-gestetner;p7325; \
postscriptdriver-gestetner;p7325n; \
postscriptdriver-gestetner;p7431cn; \
postscriptdriver-gestetner;p7527; \
postscriptdriver-gestetner;p7527n; \
postscriptdriver-gestetner;p7535n; \
postscriptdriver-gestetner;p7575; \
postscriptdriver-gestetner;p7675; \
postscriptdriver-gestetner;pro-1106ex; \
postscriptdriver-gestetner;pro-1107ex; \
postscriptdriver-gestetner;pro-1356ex; \
postscriptdriver-gestetner;pro-1357ex; \
postscriptdriver-gestetner;pro-906ex; \
postscriptdriver-gestetner;pro-907ex; \
postscriptdriver-gestetner;sp-4210n; \
postscriptdriver-gestetner;sp-6330n; \
postscriptdriver-gestetner;sp-8200dn; \
postscriptdriver-gestetner;sp-c320dn; \
postscriptdriver-gestetner;sp-c420dn; \
postscriptdriver-gestetner;sp-c430dn; \
postscriptdriver-gestetner;sp-c431dn; \
postscriptdriver-gestetner;sp-w2470; \
postscriptdriver-hewlett-packard;hp-business-inkjet-2250; \
postscriptdriver-hewlett-packard;hp-business-inkjet-2280; \
postscriptdriver-hewlett-packard;hp-business-inkjet-2300; \
postscriptdriver-hewlett-packard;hp-business-inkjet-2800; \
postscriptdriver-hewlett-packard;hp-color-laserjet-2500; \
postscriptdriver-hewlett-packard;hp-color-laserjet-2550-series; \
postscriptdriver-hewlett-packard;hp-color-laserjet-2605; \
postscriptdriver-hewlett-packard;hp-color-laserjet-2605dn; \
postscriptdriver-hewlett-packard;hp-color-laserjet-2800-series; \
postscriptdriver-hewlett-packard;hp-color-laserjet-3700; \
postscriptdriver-hewlett-packard;hp-color-laserjet-3800; \
postscriptdriver-hewlett-packard;hp-color-laserjet-4550; \
postscriptdriver-hewlett-packard;hp-color-laserjet-4600; \
postscriptdriver-hewlett-packard;hp-color-laserjet-4650; \
postscriptdriver-hewlett-packard;hp-color-laserjet-4700; \
postscriptdriver-hewlett-packard;hp-color-laserjet-5550; \
postscriptdriver-hewlett-packard;hp-laserjet-1200; \
postscriptdriver-hewlett-packard;hp-laserjet-1220; \
postscriptdriver-hewlett-packard;hp-laserjet-1300; \
postscriptdriver-hewlett-packard;hp-laserjet-1320-series; \
postscriptdriver-hewlett-packard;hp-laserjet-2100-series; \
postscriptdriver-hewlett-packard;hp-laserjet-2200; \
postscriptdriver-hewlett-packard;hp-laserjet-2300-series; \
postscriptdriver-hewlett-packard;hp-laserjet-2420; \
postscriptdriver-hewlett-packard;hp-laserjet-2430; \
postscriptdriver-hewlett-packard;hp-laserjet-3015; \
postscriptdriver-hewlett-packard;hp-laserjet-3020; \
postscriptdriver-hewlett-packard;hp-laserjet-3030; \
postscriptdriver-hewlett-packard;hp-laserjet-3200; \
postscriptdriver-hewlett-packard;hp-laserjet-3200m; \
postscriptdriver-hewlett-packard;hp-laserjet-3300/3310/3320; \
postscriptdriver-hewlett-packard;hp-laserjet-3330; \
postscriptdriver-hewlett-packard;hp-laserjet-3380; \
postscriptdriver-hewlett-packard;hp-laserjet-3390; \
postscriptdriver-hewlett-packard;hp-laserjet-4-plus; \
postscriptdriver-hewlett-packard;hp-laserjet-4000-series; \
postscriptdriver-hewlett-packard;hp-laserjet-4050-series; \
postscriptdriver-hewlett-packard;hp-laserjet-4100-series; \
postscriptdriver-hewlett-packard;hp-laserjet-4200; \
postscriptdriver-hewlett-packard;hp-laserjet-4250; \
postscriptdriver-hewlett-packard;hp-laserjet-4300; \
postscriptdriver-hewlett-packard;hp-laserjet-4345-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-4350; \
postscriptdriver-hewlett-packard;hp-laserjet-5000-series; \
postscriptdriver-hewlett-packard;hp-laserjet-5100-series; \
postscriptdriver-hewlett-packard;hp-laserjet-5mp; \
postscriptdriver-hewlett-packard;hp-laserjet-5si; \
postscriptdriver-hewlett-packard;hp-laserjet-6mp; \
postscriptdriver-hewlett-packard;hp-laserjet-8000-series; \
postscriptdriver-hewlett-packard;hp-laserjet-8150-series; \
postscriptdriver-hewlett-packard;laserjet-color-4500; \
postscriptdriver-hewlett-packard;officejet-9100-series; \
postscriptdriver-hp;designjet-1055cm-(c6075a); \
postscriptdriver-hp;hp-cm8050-color-mfp; \
postscriptdriver-hp;hp-cm8050-mfp-with-edgeline; \
postscriptdriver-hp;hp-cm8060-color-mfp; \
postscriptdriver-hp;hp-cm8060-mfp-with-edgeline; \
postscriptdriver-hp;hp-color-laserjet; \
postscriptdriver-hp;hp-designjet-1050c; \
postscriptdriver-hp;hp-designjet-5000ps-(c6096v); \
postscriptdriver-hp;hp-designjet-800ps-(c7780c); \
postscriptdriver-hp;hp-laserjet-4100-mfp; \
postscriptdriver-hp;hp-laserjet-4mp; \
postscriptdriver-hp;hp-laserjet-5si; \
postscriptdriver-hp;hp9100; \
postscriptdriver-imagistics;imagistics-im8530; \
postscriptdriver-infoprint;pro-1107ex; \
postscriptdriver-infoprint;pro-1357ex; \
postscriptdriver-infoprint;pro-907ex; \
postscriptdriver-infotec;4353-mf; \
postscriptdriver-infotec;4452-mf; \
postscriptdriver-infotec;ip-280; \
postscriptdriver-infotec;ipc-2525; \
postscriptdriver-infotec;ipc-2525dn; \
postscriptdriver-infotec;ipc-2525e; \
postscriptdriver-infotec;ipc-3030dn; \
postscriptdriver-infotec;ipc-3535; \
postscriptdriver-infotec;ipc-4040dn; \
postscriptdriver-infotec;ipc1036; \
postscriptdriver-infotec;ipc2838; \
postscriptdriver-infotec;is-2015; \
postscriptdriver-infotec;is-2018; \
postscriptdriver-infotec;is-2018d; \
postscriptdriver-infotec;is-2060; \
postscriptdriver-infotec;is-2075; \
postscriptdriver-infotec;is-2122; \
postscriptdriver-infotec;is-2127; \
postscriptdriver-infotec;is-2132; \
postscriptdriver-infotec;is-2135; \
postscriptdriver-infotec;is-2145; \
postscriptdriver-infotec;is-2151; \
postscriptdriver-infotec;is-2160; \
postscriptdriver-infotec;is-2175; \
postscriptdriver-infotec;is-2215; \
postscriptdriver-infotec;is-2216; \
postscriptdriver-infotec;is-2220; \
postscriptdriver-infotec;is-2220d; \
postscriptdriver-infotec;is-2225; \
postscriptdriver-infotec;is-2230; \
postscriptdriver-infotec;is-2235; \
postscriptdriver-infotec;is-2245; \
postscriptdriver-infotec;is-2255; \
postscriptdriver-infotec;is-2265; \
postscriptdriver-infotec;is-2275; \
postscriptdriver-infotec;is-2316; \
postscriptdriver-infotec;is-2320; \
postscriptdriver-infotec;is-2325; \
postscriptdriver-infotec;is-2416; \
postscriptdriver-infotec;is-2425; \
postscriptdriver-infotec;is-2430; \
postscriptdriver-infotec;is-2435; \
postscriptdriver-infotec;is-2445; \
postscriptdriver-infotec;is-3090; \
postscriptdriver-infotec;is-3110; \
postscriptdriver-infotec;is-3135; \
postscriptdriver-infotec;is2022; \
postscriptdriver-infotec;is2027; \
postscriptdriver-infotec;is2032; \
postscriptdriver-infotec;is2035; \
postscriptdriver-infotec;is2045; \
postscriptdriver-infotec;is2090; \
postscriptdriver-infotec;is2105; \
postscriptdriver-infotec;isc-1024c; \
postscriptdriver-infotec;isc-1032c; \
postscriptdriver-infotec;isc-2028; \
postscriptdriver-infotec;isc-2428; \
postscriptdriver-infotec;isc-2432; \
postscriptdriver-infotec;isc-2525; \
postscriptdriver-infotec;isc-2835; \
postscriptdriver-infotec;isc-2838; \
postscriptdriver-infotec;isc-3030; \
postscriptdriver-infotec;isc-3535; \
postscriptdriver-infotec;isc-3545; \
postscriptdriver-infotec;isc-4045; \
postscriptdriver-infotec;isc-4560; \
postscriptdriver-infotec;isc-5560; \
postscriptdriver-infotec;isc-615g; \
postscriptdriver-infotec;isc1032; \
postscriptdriver-infotec;isc824; \
postscriptdriver-infotec;mp-171; \
postscriptdriver-infotec;mp-2001; \
postscriptdriver-infotec;mp-201; \
postscriptdriver-infotec;mp-2352; \
postscriptdriver-infotec;mp-2501; \
postscriptdriver-infotec;mp-2550; \
postscriptdriver-infotec;mp-2550b; \
postscriptdriver-infotec;mp-2553; \
postscriptdriver-infotec;mp-2851; \
postscriptdriver-infotec;mp-2852; \
postscriptdriver-infotec;mp-301; \
postscriptdriver-infotec;mp-3053; \
postscriptdriver-infotec;mp-3350; \
postscriptdriver-infotec;mp-3350b; \
postscriptdriver-infotec;mp-3351; \
postscriptdriver-infotec;mp-3352; \
postscriptdriver-infotec;mp-3353; \
postscriptdriver-infotec;mp-4000; \
postscriptdriver-infotec;mp-4000b; \
postscriptdriver-infotec;mp-4001; \
postscriptdriver-infotec;mp-4002; \
postscriptdriver-infotec;mp-5000; \
postscriptdriver-infotec;mp-5000b; \
postscriptdriver-infotec;mp-5001; \
postscriptdriver-infotec;mp-5002; \
postscriptdriver-infotec;mp-6000; \
postscriptdriver-infotec;mp-6001; \
postscriptdriver-infotec;mp-6002; \
postscriptdriver-infotec;mp-7000; \
postscriptdriver-infotec;mp-7001; \
postscriptdriver-infotec;mp-7502; \
postscriptdriver-infotec;mp-8000; \
postscriptdriver-infotec;mp-8001; \
postscriptdriver-infotec;mp-9001; \
postscriptdriver-infotec;mp-9002; \
postscriptdriver-infotec;mp-c2003; \
postscriptdriver-infotec;mp-c2003z; \
postscriptdriver-infotec;mp-c2050; \
postscriptdriver-infotec;mp-c2051; \
postscriptdriver-infotec;mp-c2503; \
postscriptdriver-infotec;mp-c2503z; \
postscriptdriver-infotec;mp-c2550; \
postscriptdriver-infotec;mp-c2551; \
postscriptdriver-infotec;mp-c2800; \
postscriptdriver-infotec;mp-c3001; \
postscriptdriver-infotec;mp-c3002; \
postscriptdriver-infotec;mp-c3003; \
postscriptdriver-infotec;mp-c300; \
postscriptdriver-infotec;mp-c300sr; \
postscriptdriver-infotec;mp-c305; \
postscriptdriver-infotec;mp-c3300; \
postscriptdriver-infotec;mp-c3501; \
postscriptdriver-infotec;mp-c3502; \
postscriptdriver-infotec;mp-c3503; \
postscriptdriver-infotec;mp-c4000; \
postscriptdriver-infotec;mp-c400; \
postscriptdriver-infotec;mp-c400sr; \
postscriptdriver-infotec;mp-c4501; \
postscriptdriver-infotec;mp-c4501a; \
postscriptdriver-infotec;mp-c4502; \
postscriptdriver-infotec;mp-c4502a; \
postscriptdriver-infotec;mp-c4503; \
postscriptdriver-infotec;mp-c5000; \
postscriptdriver-infotec;mp-c5501; \
postscriptdriver-infotec;mp-c5501a; \
postscriptdriver-infotec;mp-c5502; \
postscriptdriver-infotec;mp-c5502a; \
postscriptdriver-infotec;mp-c5503; \
postscriptdriver-infotec;mp-c6000; \
postscriptdriver-infotec;mp-c6003; \
postscriptdriver-infotec;mp-c6501; \
postscriptdriver-infotec;mp-c6502; \
postscriptdriver-infotec;mp-c7500; \
postscriptdriver-infotec;mp-c7501; \
postscriptdriver-infotec;mp-c8002; \
postscriptdriver-infotec;pro-1106ex; \
postscriptdriver-infotec;pro-1107ex; \
postscriptdriver-infotec;pro-1356ex; \
postscriptdriver-infotec;pro-1357ex; \
postscriptdriver-infotec;pro-8100s; \
postscriptdriver-infotec;pro-8110s; \
postscriptdriver-infotec;pro-8120s; \
postscriptdriver-infotec;pro-906ex; \
postscriptdriver-infotec;pro-907ex; \
postscriptdriver-infotec;pro-c5100s; \
postscriptdriver-infotec;pro-c5110s; \
postscriptdriver-konica-minolta;phaser-6120-ps; \
postscriptdriver-kyocera-mita;cs-1650; \
postscriptdriver-kyocera-mita;cs-2050; \
postscriptdriver-kyocera-mita;cs-2550; \
postscriptdriver-kyocera-mita;fs-9120dn; \
postscriptdriver-kyocera-mita;fs-9520dn; \
postscriptdriver-kyocera-mita;fs-c8026n; \
postscriptdriver-kyocera-mita;km-1510; \
postscriptdriver-kyocera-mita;km-1530; \
postscriptdriver-kyocera-mita;km-1650; \
postscriptdriver-kyocera-mita;km-1810; \
postscriptdriver-kyocera-mita;km-2030; \
postscriptdriver-kyocera-mita;km-2050; \
postscriptdriver-kyocera-mita;km-2530; \
postscriptdriver-kyocera-mita;km-2550; \
postscriptdriver-kyocera-mita;km-3035; \
postscriptdriver-kyocera-mita;km-3530; \
postscriptdriver-kyocera-mita;km-4030; \
postscriptdriver-kyocera-mita;km-4035; \
postscriptdriver-kyocera-mita;km-4230/5230; \
postscriptdriver-kyocera-mita;km-4230; \
postscriptdriver-kyocera-mita;km-4530; \
postscriptdriver-kyocera-mita;km-5035; \
postscriptdriver-kyocera-mita;km-5230; \
postscriptdriver-kyocera-mita;km-5530; \
postscriptdriver-kyocera-mita;km-6230; \
postscriptdriver-kyocera-mita;km-6330; \
postscriptdriver-kyocera-mita;km-7530; \
postscriptdriver-kyocera-mita;km-c2630; \
postscriptdriver-kyocera-mita;km-c830; \
postscriptdriver-kyocera-mita;km-c850; \
postscriptdriver-kyocera-mita;kyocera-mita-ci-1100; \
postscriptdriver-kyocera-mita;kyocera-mita-cs-1815; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-1000+; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-1010; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-1018mfp; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-1050; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-1800+; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-1800; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-1900; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-1920; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-3800; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-3820n; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-3830n; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-6020; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-6026; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-6750; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-8000c; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-9100dn; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-9500dn; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-c5016n; \
postscriptdriver-kyocera-mita;kyocera-mita-fs-c8008n; \
postscriptdriver-kyocera-mita;kyocera-mita-km-1815; \
postscriptdriver-kyocera;cs-1815; \
postscriptdriver-kyocera;fs-1020d; \
postscriptdriver-kyocera;fs-1500; \
postscriptdriver-kyocera;fs-1550+; \
postscriptdriver-kyocera;fs-1550; \
postscriptdriver-kyocera;fs-1600+; \
postscriptdriver-kyocera;fs-1600; \
postscriptdriver-kyocera;fs-3400+; \
postscriptdriver-kyocera;fs-3400; \
postscriptdriver-kyocera;fs-3500; \
postscriptdriver-kyocera;fs-3600+; \
postscriptdriver-kyocera;fs-3600; \
postscriptdriver-kyocera;fs-400; \
postscriptdriver-kyocera;fs-600; \
postscriptdriver-kyocera;fs-6500; \
postscriptdriver-kyocera;fs-8000c; \
postscriptdriver-kyocera;fs-850; \
postscriptdriver-kyocera;fs-9100dn; \
postscriptdriver-kyocera;fs-9500dn; \
postscriptdriver-kyocera;fs-c5016n; \
postscriptdriver-kyocera;fs-c8008n; \
postscriptdriver-kyocera;km-1815; \
postscriptdriver-kyocera;km-6030; \
postscriptdriver-kyocera;km-8030; \
postscriptdriver-kyocera;kyocera-cs-250ci; \
postscriptdriver-kyocera;kyocera-cs-300ci; \
postscriptdriver-kyocera;kyocera-cs-3050ci; \
postscriptdriver-kyocera;kyocera-cs-3550ci; \
postscriptdriver-kyocera;kyocera-cs-400ci; \
postscriptdriver-kyocera;kyocera-cs-500ci; \
postscriptdriver-kyocera;kyocera-cs-c2525e; \
postscriptdriver-kyocera;kyocera-cs-c3225e; \
postscriptdriver-kyocera;kyocera-cs-c3232e; \
postscriptdriver-kyocera;kyocera-cs-c4035e; \
postscriptdriver-kyocera;kyocera-fs-1000; \
postscriptdriver-kyocera;kyocera-fs-1030d; \
postscriptdriver-kyocera;kyocera-fs-1118mfp; \
postscriptdriver-kyocera;kyocera-fs-1200; \
postscriptdriver-kyocera;kyocera-fs-1700+; \
postscriptdriver-kyocera;kyocera-fs-1700; \
postscriptdriver-kyocera;kyocera-fs-1714m; \
postscriptdriver-kyocera;kyocera-fs-1750; \
postscriptdriver-kyocera;kyocera-fs-2000d; \
postscriptdriver-kyocera;kyocera-fs-2100d; \
postscriptdriver-kyocera;kyocera-fs-2100dn; \
postscriptdriver-kyocera;kyocera-fs-3700+; \
postscriptdriver-kyocera;kyocera-fs-3700; \
postscriptdriver-kyocera;kyocera-fs-3718m; \
postscriptdriver-kyocera;kyocera-fs-3750; \
postscriptdriver-kyocera;kyocera-fs-3900dn; \
postscriptdriver-kyocera;kyocera-fs-4000dn; \
postscriptdriver-kyocera;kyocera-fs-4100dn; \
postscriptdriver-kyocera;kyocera-fs-4200dn; \
postscriptdriver-kyocera;kyocera-fs-4300dn; \
postscriptdriver-kyocera;kyocera-fs-5800c; \
postscriptdriver-kyocera;kyocera-fs-5900c; \
postscriptdriver-kyocera;kyocera-fs-600; \
postscriptdriver-kyocera;kyocera-fs-6300; \
postscriptdriver-kyocera;kyocera-fs-6500+; \
postscriptdriver-kyocera;kyocera-fs-6700; \
postscriptdriver-kyocera;kyocera-fs-680; \
postscriptdriver-kyocera;kyocera-fs-6900; \
postscriptdriver-kyocera;kyocera-fs-6950dn; \
postscriptdriver-kyocera;kyocera-fs-7000+; \
postscriptdriver-kyocera;kyocera-fs-7000; \
postscriptdriver-kyocera;kyocera-fs-7028m; \
postscriptdriver-kyocera;kyocera-fs-800; \
postscriptdriver-kyocera;kyocera-fs-9000; \
postscriptdriver-kyocera;kyocera-fs-9130dn; \
postscriptdriver-kyocera;kyocera-fs-920; \
postscriptdriver-kyocera;kyocera-fs-9530dn; \
postscriptdriver-kyocera;kyocera-fs-c5015n; \
postscriptdriver-kyocera;kyocera-fs-c5020n; \
postscriptdriver-kyocera;kyocera-fs-c5025n; \
postscriptdriver-kyocera;kyocera-fs-c5030n; \
postscriptdriver-kyocera;kyocera-fs-c5100dn; \
postscriptdriver-kyocera;kyocera-fs-c5200dn; \
postscriptdriver-kyocera;kyocera-fs-c5300dn; \
postscriptdriver-kyocera;kyocera-fs-c5350dn; \
postscriptdriver-kyocera;kyocera-fs-c5400dn; \
postscriptdriver-kyocera;kyocera-fs-c8100dn+; \
postscriptdriver-kyocera;kyocera-fs-c8100dn; \
postscriptdriver-kyocera;kyocera-km-1820; \
postscriptdriver-kyocera;kyocera-km-3050; \
postscriptdriver-kyocera;kyocera-km-4050; \
postscriptdriver-kyocera;kyocera-km-5050; \
postscriptdriver-kyocera;kyocera-km-6030; \
postscriptdriver-kyocera;kyocera-km-8030; \
postscriptdriver-kyocera;kyocera-km-c2520; \
postscriptdriver-kyocera;kyocera-km-c2525e; \
postscriptdriver-kyocera;kyocera-km-c3225; \
postscriptdriver-kyocera;kyocera-km-c3225e; \
postscriptdriver-kyocera;kyocera-km-c3232; \
postscriptdriver-kyocera;kyocera-km-c3232e; \
postscriptdriver-kyocera;kyocera-km-c4035e; \
postscriptdriver-kyocera;kyocera-taskalfa-250ci; \
postscriptdriver-kyocera;kyocera-taskalfa-300ci; \
postscriptdriver-kyocera;kyocera-taskalfa-400ci; \
postscriptdriver-kyocera;kyocera-taskalfa-500ci; \
postscriptdriver-kyocera;p-2000; \
postscriptdriver-kyocera;p-2002; \
postscriptdriver-lanier;2132; \
postscriptdriver-lanier;2138; \
postscriptdriver-lanier;2145; \
postscriptdriver-lanier;5622; \
postscriptdriver-lanier;5627; \
postscriptdriver-lanier;5632; \
postscriptdriver-lanier;5635; \
postscriptdriver-lanier;5645; \
postscriptdriver-lanier;lc155; \
postscriptdriver-lanier;ld-130c; \
postscriptdriver-lanier;ld-130csr; \
postscriptdriver-lanier;ld-140c; \
postscriptdriver-lanier;ld-140csr; \
postscriptdriver-lanier;ld-620c; \
postscriptdriver-lanier;ld-625c; \
postscriptdriver-lanier;ld0105; \
postscriptdriver-lanier;ld015; \
postscriptdriver-lanier;ld024c; \
postscriptdriver-lanier;ld032c; \
postscriptdriver-lanier;ld035; \
postscriptdriver-lanier;ld045; \
postscriptdriver-lanier;ld060; \
postscriptdriver-lanier;ld075; \
postscriptdriver-lanier;ld090; \
postscriptdriver-lanier;ld115; \
postscriptdriver-lanier;ld116; \
postscriptdriver-lanier;ld118; \
postscriptdriver-lanier;ld118d; \
postscriptdriver-lanier;ld120; \
postscriptdriver-lanier;ld120d; \
postscriptdriver-lanier;ld122; \
postscriptdriver-lanier;ld124c; \
postscriptdriver-lanier;ld127; \
postscriptdriver-lanier;ld132; \
postscriptdriver-lanier;ld132c; \
postscriptdriver-lanier;ld135; \
postscriptdriver-lanier;ld145; \
postscriptdriver-lanier;ld151; \
postscriptdriver-lanier;ld160; \
postscriptdriver-lanier;ld160c; \
postscriptdriver-lanier;ld175; \
postscriptdriver-lanier;ld225; \
postscriptdriver-lanier;ld228c; \
postscriptdriver-lanier;ld230; \
postscriptdriver-lanier;ld232c; \
postscriptdriver-lanier;ld235; \
postscriptdriver-lanier;ld238c; \
postscriptdriver-lanier;ld245; \
postscriptdriver-lanier;ld328c; \
postscriptdriver-lanier;ld335c; \
postscriptdriver-lanier;ld345c; \
postscriptdriver-lanier;lf510/515e; \
postscriptdriver-lanier;lp-020c; \
postscriptdriver-lanier;lp-036c; \
postscriptdriver-lanier;lp025/lp026; \
postscriptdriver-lanier;lp025n/lp026n; \
postscriptdriver-lanier;lp031c; \
postscriptdriver-lanier;lp032; \
postscriptdriver-lanier;lp116c; \
postscriptdriver-lanier;lp122c/lp121c; \
postscriptdriver-lanier;lp124w; \
postscriptdriver-lanier;lp125cx/lp126cn; \
postscriptdriver-lanier;lp127n/lp128n; \
postscriptdriver-lanier;lp128; \
postscriptdriver-lanier;lp131n; \
postscriptdriver-lanier;lp131nl; \
postscriptdriver-lanier;lp135n; \
postscriptdriver-lanier;lp136n; \
postscriptdriver-lanier;lp137cn; \
postscriptdriver-lanier;lp138c; \
postscriptdriver-lanier;lp142cn; \
postscriptdriver-lanier;lp145n/sp-8100dn; \
postscriptdriver-lanier;lp150dn/sp8200dn; \
postscriptdriver-lanier;lp175/lp175hdn; \
postscriptdriver-lanier;lp222cn/lp221c; \
postscriptdriver-lanier;lp226c/sp-c410; \
postscriptdriver-lanier;lp231c/sp-c411; \
postscriptdriver-lanier;lp235c; \
postscriptdriver-lanier;lp235n; \
postscriptdriver-lanier;lp331cn/sp-c420; \
postscriptdriver-lanier;lp332c; \
postscriptdriver-lanier;lp335c; \
postscriptdriver-lanier;lp37n; \
postscriptdriver-lanier;lp440c/sp-c811dn; \
postscriptdriver-lanier;lp540c/spc820dn; \
postscriptdriver-lanier;lp550c/spc821dn; \
postscriptdriver-lanier;lw324; \
postscriptdriver-lanier;lw326; \
postscriptdriver-lanier;lw426; \
postscriptdriver-lanier;lw5100; \
postscriptdriver-lanier;lw7140; \
postscriptdriver-lanier;mp-1100/ld1100; \
postscriptdriver-lanier;mp-1350/ld1135; \
postscriptdriver-lanier;mp-1600/ld316; \
postscriptdriver-lanier;mp-161/ld016; \
postscriptdriver-lanier;mp-171/ld-117; \
postscriptdriver-lanier;mp-2000/ld320d; \
postscriptdriver-lanier;mp-2001; \
postscriptdriver-lanier;mp-201/ld-220; \
postscriptdriver-lanier;mp-2352; \
postscriptdriver-lanier;mp-2501; \
postscriptdriver-lanier;mp-2510/ld325; \
postscriptdriver-lanier;mp-2550/ld425; \
postscriptdriver-lanier;mp-2550b/ld425b; \
postscriptdriver-lanier;mp-2553; \
postscriptdriver-lanier;mp-2851/ld528; \
postscriptdriver-lanier;mp-2852; \
postscriptdriver-lanier;mp-3010/ld330; \
postscriptdriver-lanier;mp-301; \
postscriptdriver-lanier;mp-3053; \
postscriptdriver-lanier;mp-3350/ld433; \
postscriptdriver-lanier;mp-3350b/ld433b; \
postscriptdriver-lanier;mp-3351/ld533; \
postscriptdriver-lanier;mp-3352; \
postscriptdriver-lanier;mp-3353; \
postscriptdriver-lanier;mp-3500/ld335; \
postscriptdriver-lanier;mp-4000/ld040; \
postscriptdriver-lanier;mp-4000b/ld040b; \
postscriptdriver-lanier;mp-4001/ld140; \
postscriptdriver-lanier;mp-4002; \
postscriptdriver-lanier;mp-4500/ld345; \
postscriptdriver-lanier;mp-5000/ld050; \
postscriptdriver-lanier;mp-5000b/ld050b; \
postscriptdriver-lanier;mp-5001/ld150; \
postscriptdriver-lanier;mp-5002; \
postscriptdriver-lanier;mp-5500/ld255; \
postscriptdriver-lanier;mp-6000/ld260; \
postscriptdriver-lanier;mp-6001/ld360; \
postscriptdriver-lanier;mp-6002; \
postscriptdriver-lanier;mp-6500/ld265; \
postscriptdriver-lanier;mp-7000/ld270; \
postscriptdriver-lanier;mp-7001/ld370; \
postscriptdriver-lanier;mp-7500/ld275; \
postscriptdriver-lanier;mp-7502; \
postscriptdriver-lanier;mp-8000/ld280; \
postscriptdriver-lanier;mp-8001/ld380; \
postscriptdriver-lanier;mp-9000/ld190; \
postscriptdriver-lanier;mp-9001/ld390; \
postscriptdriver-lanier;mp-9002; \
postscriptdriver-lanier;mp-c2003; \
postscriptdriver-lanier;mp-c2050/ld520c; \
postscriptdriver-lanier;mp-c2500/ld425c; \
postscriptdriver-lanier;mp-c2503; \
postscriptdriver-lanier;mp-c2550/ld525c; \
postscriptdriver-lanier;mp-c2800/ld528c; \
postscriptdriver-lanier;mp-c3000/ld430c; \
postscriptdriver-lanier;mp-c3001/ld630c; \
postscriptdriver-lanier;mp-c3002; \
postscriptdriver-lanier;mp-c3003; \
postscriptdriver-lanier;mp-c300; \
postscriptdriver-lanier;mp-c300sr; \
postscriptdriver-lanier;mp-c305; \
postscriptdriver-lanier;mp-c3300/ld533c; \
postscriptdriver-lanier;mp-c3500/ld435c; \
postscriptdriver-lanier;mp-c3501/ld635c; \
postscriptdriver-lanier;mp-c3502; \
postscriptdriver-lanier;mp-c3503; \
postscriptdriver-lanier;mp-c4000/ld540c; \
postscriptdriver-lanier;mp-c400; \
postscriptdriver-lanier;mp-c400sr; \
postscriptdriver-lanier;mp-c4500/ld445c; \
postscriptdriver-lanier;mp-c4501/ld645c; \
postscriptdriver-lanier;mp-c4502; \
postscriptdriver-lanier;mp-c4502a; \
postscriptdriver-lanier;mp-c4503; \
postscriptdriver-lanier;mp-c5000/ld550c; \
postscriptdriver-lanier;mp-c5501/ld655c; \
postscriptdriver-lanier;mp-c5502; \
postscriptdriver-lanier;mp-c5502a; \
postscriptdriver-lanier;mp-c5503; \
postscriptdriver-lanier;mp-c6000/ld260c; \
postscriptdriver-lanier;mp-c6003; \
postscriptdriver-lanier;mp-c6501/ld365c; \
postscriptdriver-lanier;mp-c6502; \
postscriptdriver-lanier;mp-c7500/ld275c; \
postscriptdriver-lanier;mp-c7501/ld375c; \
postscriptdriver-lanier;mp-c8002; \
postscriptdriver-lanier;mp-cw2200; \
postscriptdriver-lanier;mp2500/ld125; \
postscriptdriver-lanier;mpc1500/ld215c; \
postscriptdriver-lanier;mpc4501a/ld645ca; \
postscriptdriver-lanier;mpc5501a/ld655ca; \
postscriptdriver-lanier;pro-1106ex; \
postscriptdriver-lanier;pro-1107ex; \
postscriptdriver-lanier;pro-1356ex; \
postscriptdriver-lanier;pro-1357ex; \
postscriptdriver-lanier;pro-8100s; \
postscriptdriver-lanier;pro-8110s; \
postscriptdriver-lanier;pro-8120s; \
postscriptdriver-lanier;pro-906ex; \
postscriptdriver-lanier;pro-907ex; \
postscriptdriver-lanier;pro-c5100s; \
postscriptdriver-lanier;pro-c5110s; \
postscriptdriver-lanier;sp-4100n; \
postscriptdriver-lanier;sp-4100nl; \
postscriptdriver-lanier;sp-4110n; \
postscriptdriver-lanier;sp-4210n; \
postscriptdriver-lanier;sp-4310n; \
postscriptdriver-lanier;sp-5200dn; \
postscriptdriver-lanier;sp-5200s; \
postscriptdriver-lanier;sp-5210dn; \
postscriptdriver-lanier;sp-5210sf; \
postscriptdriver-lanier;sp-5210sr; \
postscriptdriver-lanier;sp-6330n; \
postscriptdriver-lanier;sp-8300dn; \
postscriptdriver-lanier;sp-9100/lp275; \
postscriptdriver-lanier;sp-c320dn; \
postscriptdriver-lanier;sp-c400dn; \
postscriptdriver-lanier;sp-c430dn; \
postscriptdriver-lanier;sp-c431dn; \
postscriptdriver-lanier;sp-c730dn; \
postscriptdriver-lanier;sp-c830dn; \
postscriptdriver-lanier;sp-c831dn; \
postscriptdriver-lexmark-international;ibm-3112-page-printer; \
postscriptdriver-lexmark-international;ibm-laserprinter-4039-plus; \
postscriptdriver-lexmark-international;lexmark-c510; \
postscriptdriver-lexmark-international;lexmark-c520; \
postscriptdriver-lexmark-international;lexmark-c522; \
postscriptdriver-lexmark-international;lexmark-c524; \
postscriptdriver-lexmark-international;lexmark-c750; \
postscriptdriver-lexmark-international;lexmark-c752; \
postscriptdriver-lexmark-international;lexmark-c780; \
postscriptdriver-lexmark-international;lexmark-c782; \
postscriptdriver-lexmark-international;lexmark-c910; \
postscriptdriver-lexmark-international;lexmark-c912; \
postscriptdriver-lexmark-international;lexmark-c930; \
postscriptdriver-lexmark-international;lexmark-c935; \
postscriptdriver-lexmark-international;lexmark-e260d; \
postscriptdriver-lexmark-international;lexmark-e350d; \
postscriptdriver-lexmark-international;lexmark-e352dn; \
postscriptdriver-lexmark-international;lexmark-e360dn; \
postscriptdriver-lexmark-international;lexmark-e460dn; \
postscriptdriver-lexmark-international;lexmark-optra-e310; \
postscriptdriver-lexmark-international;lexmark-optra-e312; \
postscriptdriver-lexmark-international;lexmark-optra-ep-laserprinter; \
postscriptdriver-lexmark-international;lexmark-optra-laserprinter; \
postscriptdriver-lexmark-international;lexmark-optra-s-1250; \
postscriptdriver-lexmark-international;lexmark-optracolor-40; \
postscriptdriver-lexmark-international;lexmark-t430; \
postscriptdriver-lexmark-international;lexmark-x940e; \
postscriptdriver-lexmark-international;lexmark-x945e; \
postscriptdriver-lexmark;lexmark-6500e-series; \
postscriptdriver-lexmark;lexmark-6500e; \
postscriptdriver-lexmark;lexmark-c2100-series; \
postscriptdriver-lexmark;lexmark-c2132; \
postscriptdriver-lexmark;lexmark-c520; \
postscriptdriver-lexmark;lexmark-c522; \
postscriptdriver-lexmark;lexmark-c524; \
postscriptdriver-lexmark;lexmark-c540; \
postscriptdriver-lexmark;lexmark-c543; \
postscriptdriver-lexmark;lexmark-c544; \
postscriptdriver-lexmark;lexmark-c546; \
postscriptdriver-lexmark;lexmark-c734; \
postscriptdriver-lexmark;lexmark-c736; \
postscriptdriver-lexmark;lexmark-c740-series; \
postscriptdriver-lexmark;lexmark-c746; \
postscriptdriver-lexmark;lexmark-c748; \
postscriptdriver-lexmark;lexmark-c790-series; \
postscriptdriver-lexmark;lexmark-c792; \
postscriptdriver-lexmark;lexmark-c920-series; \
postscriptdriver-lexmark;lexmark-c925; \
postscriptdriver-lexmark;lexmark-c950-series; \
postscriptdriver-lexmark;lexmark-c950; \
postscriptdriver-lexmark;lexmark-cs310-series; \
postscriptdriver-lexmark;lexmark-cs310dn; \
postscriptdriver-lexmark;lexmark-cs310n; \
postscriptdriver-lexmark;lexmark-cs410-series; \
postscriptdriver-lexmark;lexmark-cs410dn; \
postscriptdriver-lexmark;lexmark-cs410n; \
postscriptdriver-lexmark;lexmark-cs510-series; \
postscriptdriver-lexmark;lexmark-cs510de; \
postscriptdriver-lexmark;lexmark-cx310-series; \
postscriptdriver-lexmark;lexmark-cx310dn; \
postscriptdriver-lexmark;lexmark-cx310n; \
postscriptdriver-lexmark;lexmark-cx410-series; \
postscriptdriver-lexmark;lexmark-cx410de; \
postscriptdriver-lexmark;lexmark-cx410e; \
postscriptdriver-lexmark;lexmark-cx510-series; \
postscriptdriver-lexmark;lexmark-cx510de; \
postscriptdriver-lexmark;lexmark-m1100-series; \
postscriptdriver-lexmark;lexmark-m1140-plus; \
postscriptdriver-lexmark;lexmark-m1140; \
postscriptdriver-lexmark;lexmark-m1145; \
postscriptdriver-lexmark;lexmark-m3100-series; \
postscriptdriver-lexmark;lexmark-m3150; \
postscriptdriver-lexmark;lexmark-m5100-series; \
postscriptdriver-lexmark;lexmark-m5155; \
postscriptdriver-lexmark;lexmark-m5163; \
postscriptdriver-lexmark;lexmark-m5170; \
postscriptdriver-lexmark;lexmark-ms310-series; \
postscriptdriver-lexmark;lexmark-ms310d; \
postscriptdriver-lexmark;lexmark-ms310dn; \
postscriptdriver-lexmark;lexmark-ms312dn; \
postscriptdriver-lexmark;lexmark-ms315dn; \
postscriptdriver-lexmark;lexmark-ms410-series; \
postscriptdriver-lexmark;lexmark-ms410d; \
postscriptdriver-lexmark;lexmark-ms410dn; \
postscriptdriver-lexmark;lexmark-ms415dn; \
postscriptdriver-lexmark;lexmark-ms510-series; \
postscriptdriver-lexmark;lexmark-ms510dn; \
postscriptdriver-lexmark;lexmark-ms610-series; \
postscriptdriver-lexmark;lexmark-ms610de; \
postscriptdriver-lexmark;lexmark-ms610dn; \
postscriptdriver-lexmark;lexmark-ms710-series; \
postscriptdriver-lexmark;lexmark-ms710; \
postscriptdriver-lexmark;lexmark-ms711; \
postscriptdriver-lexmark;lexmark-ms810-series; \
postscriptdriver-lexmark;lexmark-ms810; \
postscriptdriver-lexmark;lexmark-ms811; \
postscriptdriver-lexmark;lexmark-ms812; \
postscriptdriver-lexmark;lexmark-mx310-series; \
postscriptdriver-lexmark;lexmark-mx310dn; \
postscriptdriver-lexmark;lexmark-mx410-series; \
postscriptdriver-lexmark;lexmark-mx410de; \
postscriptdriver-lexmark;lexmark-mx510-series; \
postscriptdriver-lexmark;lexmark-mx510de; \
postscriptdriver-lexmark;lexmark-mx511de; \
postscriptdriver-lexmark;lexmark-mx511dhe; \
postscriptdriver-lexmark;lexmark-mx610-series; \
postscriptdriver-lexmark;lexmark-mx610de; \
postscriptdriver-lexmark;lexmark-mx611de; \
postscriptdriver-lexmark;lexmark-mx611dhe; \
postscriptdriver-lexmark;lexmark-mx6500e-series; \
postscriptdriver-lexmark;lexmark-mx6500e; \
postscriptdriver-lexmark;lexmark-mx710-series; \
postscriptdriver-lexmark;lexmark-mx710; \
postscriptdriver-lexmark;lexmark-mx711; \
postscriptdriver-lexmark;lexmark-mx810-series; \
postscriptdriver-lexmark;lexmark-mx810; \
postscriptdriver-lexmark;lexmark-mx811; \
postscriptdriver-lexmark;lexmark-mx812; \
postscriptdriver-lexmark;lexmark-t650; \
postscriptdriver-lexmark;lexmark-t652; \
postscriptdriver-lexmark;lexmark-t654; \
postscriptdriver-lexmark;lexmark-t656; \
postscriptdriver-lexmark;lexmark-tg654; \
postscriptdriver-lexmark;lexmark-w850; \
postscriptdriver-lexmark;lexmark-x203n; \
postscriptdriver-lexmark;lexmark-x204n; \
postscriptdriver-lexmark;lexmark-x264dn; \
postscriptdriver-lexmark;lexmark-x363dn; \
postscriptdriver-lexmark;lexmark-x364dn; \
postscriptdriver-lexmark;lexmark-x364dw; \
postscriptdriver-lexmark;lexmark-x463de; \
postscriptdriver-lexmark;lexmark-x464de; \
postscriptdriver-lexmark;lexmark-x466de; \
postscriptdriver-lexmark;lexmark-x466dte; \
postscriptdriver-lexmark;lexmark-x466dwe; \
postscriptdriver-lexmark;lexmark-x543; \
postscriptdriver-lexmark;lexmark-x544; \
postscriptdriver-lexmark;lexmark-x546; \
postscriptdriver-lexmark;lexmark-x548-series; \
postscriptdriver-lexmark;lexmark-x548; \
postscriptdriver-lexmark;lexmark-x651de; \
postscriptdriver-lexmark;lexmark-x652de; \
postscriptdriver-lexmark;lexmark-x654de; \
postscriptdriver-lexmark;lexmark-x656de; \
postscriptdriver-lexmark;lexmark-x658de; \
postscriptdriver-lexmark;lexmark-x734de; \
postscriptdriver-lexmark;lexmark-x736de; \
postscriptdriver-lexmark;lexmark-x738de; \
postscriptdriver-lexmark;lexmark-x740-series; \
postscriptdriver-lexmark;lexmark-x746; \
postscriptdriver-lexmark;lexmark-x748; \
postscriptdriver-lexmark;lexmark-x790-series; \
postscriptdriver-lexmark;lexmark-x792; \
postscriptdriver-lexmark;lexmark-x860de; \
postscriptdriver-lexmark;lexmark-x862de; \
postscriptdriver-lexmark;lexmark-x864de; \
postscriptdriver-lexmark;lexmark-x920-series; \
postscriptdriver-lexmark;lexmark-x925; \
postscriptdriver-lexmark;lexmark-x950-series; \
postscriptdriver-lexmark;lexmark-x950; \
postscriptdriver-lexmark;lexmark-x952; \
postscriptdriver-lexmark;lexmark-x954; \
postscriptdriver-lexmark;lexmark-xc2100-series; \
postscriptdriver-lexmark;lexmark-xc2130; \
postscriptdriver-lexmark;lexmark-xc2132; \
postscriptdriver-lexmark;lexmark-xm1100-series; \
postscriptdriver-lexmark;lexmark-xm1135; \
postscriptdriver-lexmark;lexmark-xm1140; \
postscriptdriver-lexmark;lexmark-xm1145; \
postscriptdriver-lexmark;lexmark-xm3100-series; \
postscriptdriver-lexmark;lexmark-xm3150; \
postscriptdriver-lexmark;lexmark-xm5100-series; \
postscriptdriver-lexmark;lexmark-xm5163; \
postscriptdriver-lexmark;lexmark-xm5170; \
postscriptdriver-lexmark;lexmark-xm7100-series; \
postscriptdriver-lexmark;lexmark-xm7155; \
postscriptdriver-lexmark;lexmark-xm7163; \
postscriptdriver-lexmark;lexmark-xm7170; \
postscriptdriver-nrg;10515/10518/10512; \
postscriptdriver-nrg;2205/2238/2212; \
postscriptdriver-nrg;2705/2738/2712; \
postscriptdriver-nrg;3205/3238/3212; \
postscriptdriver-nrg;3525/3508/3502; \
postscriptdriver-nrg;3545/3518/3532; \
postscriptdriver-nrg;4525/4508/4502; \
postscriptdriver-nrg;4545/4518/4532; \
postscriptdriver-nrg;6002/6005/6008; \
postscriptdriver-nrg;7502/7505/7508; \
postscriptdriver-nrg;9005/9008/9002; \
postscriptdriver-nrg;c7010; \
postscriptdriver-nrg;c7116; \
postscriptdriver-nrg;c7416; \
postscriptdriver-nrg;c7425dn; \
postscriptdriver-nrg;c7425hdn; \
postscriptdriver-nrg;c7435n; \
postscriptdriver-nrg;c7521n; \
postscriptdriver-nrg;c7528n; \
postscriptdriver-nrg;c7535hdn; \
postscriptdriver-nrg;cc7417; \
postscriptdriver-nrg;cs555; \
postscriptdriver-nrg;dsc224; \
postscriptdriver-nrg;dsc232; \
postscriptdriver-nrg;dsc328; \
postscriptdriver-nrg;dsc332; \
postscriptdriver-nrg;dsc338; \
postscriptdriver-nrg;dsc38; \
postscriptdriver-nrg;dsc38u; \
postscriptdriver-nrg;dsc424; \
postscriptdriver-nrg;dsc428; \
postscriptdriver-nrg;dsc432; \
postscriptdriver-nrg;dsc435; \
postscriptdriver-nrg;dsc445; \
postscriptdriver-nrg;dsc460; \
postscriptdriver-nrg;dsm415; \
postscriptdriver-nrg;dsm615; \
postscriptdriver-nrg;dsm616; \
postscriptdriver-nrg;dsm618; \
postscriptdriver-nrg;dsm618d; \
postscriptdriver-nrg;dsm620; \
postscriptdriver-nrg;dsm620d; \
postscriptdriver-nrg;dsm622; \
postscriptdriver-nrg;dsm627; \
postscriptdriver-nrg;dsm632; \
postscriptdriver-nrg;dsm635; \
postscriptdriver-nrg;dsm645; \
postscriptdriver-nrg;dsm651; \
postscriptdriver-nrg;dsm660; \
postscriptdriver-nrg;dsm675; \
postscriptdriver-nrg;dsm725; \
postscriptdriver-nrg;dsm730; \
postscriptdriver-nrg;dsm735; \
postscriptdriver-nrg;dsm745; \
postscriptdriver-nrg;mp-1100; \
postscriptdriver-nrg;mp-1350; \
postscriptdriver-nrg;mp-1600; \
postscriptdriver-nrg;mp-161; \
postscriptdriver-nrg;mp-171; \
postscriptdriver-nrg;mp-2000; \
postscriptdriver-nrg;mp-2001; \
postscriptdriver-nrg;mp-201; \
postscriptdriver-nrg;mp-2352; \
postscriptdriver-nrg;mp-2500; \
postscriptdriver-nrg;mp-2501; \
postscriptdriver-nrg;mp-2510; \
postscriptdriver-nrg;mp-2550; \
postscriptdriver-nrg;mp-2550b; \
postscriptdriver-nrg;mp-2553; \
postscriptdriver-nrg;mp-2851; \
postscriptdriver-nrg;mp-2852; \
postscriptdriver-nrg;mp-3010; \
postscriptdriver-nrg;mp-301; \
postscriptdriver-nrg;mp-3053; \
postscriptdriver-nrg;mp-3350; \
postscriptdriver-nrg;mp-3350b; \
postscriptdriver-nrg;mp-3351; \
postscriptdriver-nrg;mp-3352; \
postscriptdriver-nrg;mp-3353; \
postscriptdriver-nrg;mp-3500; \
postscriptdriver-nrg;mp-4000; \
postscriptdriver-nrg;mp-4000b; \
postscriptdriver-nrg;mp-4001; \
postscriptdriver-nrg;mp-4002; \
postscriptdriver-nrg;mp-4500; \
postscriptdriver-nrg;mp-5000; \
postscriptdriver-nrg;mp-5000b; \
postscriptdriver-nrg;mp-5001; \
postscriptdriver-nrg;mp-5002; \
postscriptdriver-nrg;mp-5500; \
postscriptdriver-nrg;mp-6000; \
postscriptdriver-nrg;mp-6001; \
postscriptdriver-nrg;mp-6002; \
postscriptdriver-nrg;mp-6500; \
postscriptdriver-nrg;mp-7000; \
postscriptdriver-nrg;mp-7001; \
postscriptdriver-nrg;mp-7500; \
postscriptdriver-nrg;mp-7502; \
postscriptdriver-nrg;mp-8000; \
postscriptdriver-nrg;mp-8001; \
postscriptdriver-nrg;mp-9000; \
postscriptdriver-nrg;mp-9001; \
postscriptdriver-nrg;mp-9002; \
postscriptdriver-nrg;mp-c1500sp; \
postscriptdriver-nrg;mp-c2003; \
postscriptdriver-nrg;mp-c2003z; \
postscriptdriver-nrg;mp-c2050; \
postscriptdriver-nrg;mp-c2051; \
postscriptdriver-nrg;mp-c2500; \
postscriptdriver-nrg;mp-c2503; \
postscriptdriver-nrg;mp-c2503z; \
postscriptdriver-nrg;mp-c2550; \
postscriptdriver-nrg;mp-c2551; \
postscriptdriver-nrg;mp-c2800; \
postscriptdriver-nrg;mp-c3000; \
postscriptdriver-nrg;mp-c3001; \
postscriptdriver-nrg;mp-c3002; \
postscriptdriver-nrg;mp-c3003; \
postscriptdriver-nrg;mp-c300; \
postscriptdriver-nrg;mp-c300sr; \
postscriptdriver-nrg;mp-c305; \
postscriptdriver-nrg;mp-c3300; \
postscriptdriver-nrg;mp-c3500; \
postscriptdriver-nrg;mp-c3501; \
postscriptdriver-nrg;mp-c3502; \
postscriptdriver-nrg;mp-c3503; \
postscriptdriver-nrg;mp-c4000; \
postscriptdriver-nrg;mp-c400; \
postscriptdriver-nrg;mp-c400sr; \
postscriptdriver-nrg;mp-c4500; \
postscriptdriver-nrg;mp-c4501; \
postscriptdriver-nrg;mp-c4501a; \
postscriptdriver-nrg;mp-c4502; \
postscriptdriver-nrg;mp-c4502a; \
postscriptdriver-nrg;mp-c4503; \
postscriptdriver-nrg;mp-c5000; \
postscriptdriver-nrg;mp-c5501; \
postscriptdriver-nrg;mp-c5501a; \
postscriptdriver-nrg;mp-c5502; \
postscriptdriver-nrg;mp-c5502a; \
postscriptdriver-nrg;mp-c5503; \
postscriptdriver-nrg;mp-c6000; \
postscriptdriver-nrg;mp-c6003; \
postscriptdriver-nrg;mp-c6501; \
postscriptdriver-nrg;mp-c6502; \
postscriptdriver-nrg;mp-c7500; \
postscriptdriver-nrg;mp-c7501; \
postscriptdriver-nrg;mp-c8002; \
postscriptdriver-nrg;mp-cw2200; \
postscriptdriver-nrg;mp-w2400; \
postscriptdriver-nrg;mp-w2401; \
postscriptdriver-nrg;mp-w3600; \
postscriptdriver-nrg;mp-w3601; \
postscriptdriver-nrg;mp-w5100; \
postscriptdriver-nrg;mp-w7140; \
postscriptdriver-nrg;p7026; \
postscriptdriver-nrg;p7026n; \
postscriptdriver-nrg;p7032; \
postscriptdriver-nrg;p7126; \
postscriptdriver-nrg;p7126n; \
postscriptdriver-nrg;p7132n; \
postscriptdriver-nrg;p7145; \
postscriptdriver-nrg;p7325; \
postscriptdriver-nrg;p7325n; \
postscriptdriver-nrg;p7431cn; \
postscriptdriver-nrg;p7527; \
postscriptdriver-nrg;p7527n; \
postscriptdriver-nrg;p7535n; \
postscriptdriver-nrg;p7575; \
postscriptdriver-nrg;pro-1106ex; \
postscriptdriver-nrg;pro-1107ex; \
postscriptdriver-nrg;pro-1356ex; \
postscriptdriver-nrg;pro-1357ex; \
postscriptdriver-nrg;pro-8100s; \
postscriptdriver-nrg;pro-8110s; \
postscriptdriver-nrg;pro-8120s; \
postscriptdriver-nrg;pro-906ex; \
postscriptdriver-nrg;pro-907ex; \
postscriptdriver-nrg;pro-c5100s; \
postscriptdriver-nrg;pro-c5110s; \
postscriptdriver-nrg;sp-4100n; \
postscriptdriver-nrg;sp-4100nl; \
postscriptdriver-nrg;sp-4110n; \
postscriptdriver-nrg;sp-4210n; \
postscriptdriver-nrg;sp-4310n; \
postscriptdriver-nrg;sp-5200dn; \
postscriptdriver-nrg;sp-5200s; \
postscriptdriver-nrg;sp-5210dn; \
postscriptdriver-nrg;sp-5210sf; \
postscriptdriver-nrg;sp-5210sr; \
postscriptdriver-nrg;sp-6330n; \
postscriptdriver-nrg;sp-8100dn; \
postscriptdriver-nrg;sp-8200dn; \
postscriptdriver-nrg;sp-8300dn; \
postscriptdriver-nrg;sp-9100dn; \
postscriptdriver-nrg;sp-c320dn; \
postscriptdriver-nrg;sp-c410dn; \
postscriptdriver-nrg;sp-c411dn; \
postscriptdriver-nrg;sp-c420dn; \
postscriptdriver-nrg;sp-c430dn; \
postscriptdriver-nrg;sp-c431dn; \
postscriptdriver-nrg;sp-c730dn; \
postscriptdriver-nrg;sp-c811dn; \
postscriptdriver-nrg;sp-c820dn; \
postscriptdriver-nrg;sp-c821dn; \
postscriptdriver-nrg;sp-c830dn; \
postscriptdriver-nrg;sp-c831dn; \
postscriptdriver-nrg;sp-w2470; \
postscriptdriver-oce;oce-8445; \
postscriptdriver-oce;oce-8465; \
postscriptdriver-oce;oce-9230; \
postscriptdriver-oce;oce-9245; \
postscriptdriver-oce;oce-9260; \
postscriptdriver-oce;oce-varioprint-2050; \
postscriptdriver-oce;oce-varioprint-2060; \
postscriptdriver-oce;oce-varioprint-2070; \
postscriptdriver-oce;oce-varioprint-2090-ps3; \
postscriptdriver-oce;oce-vp2105-ps3; \
postscriptdriver-oki;b4300; \
postscriptdriver-oki;c5300; \
postscriptdriver-oki;c5400; \
postscriptdriver-oki;c5450; \
postscriptdriver-oki;c5700; \
postscriptdriver-oki;c5900; \
postscriptdriver-oki;c6100; \
postscriptdriver-oki;c7100; \
postscriptdriver-oki;c7200; \
postscriptdriver-oki;c7300; \
postscriptdriver-oki;c7400; \
postscriptdriver-oki;c7500; \
postscriptdriver-oki;c9200; \
postscriptdriver-oki;c9300; \
postscriptdriver-oki;c9400; \
postscriptdriver-oki;c9500; \
postscriptdriver-oki;c9600; \
postscriptdriver-oki;okipage-14i; \
postscriptdriver-ricoh;aficio-1022; \
postscriptdriver-ricoh;aficio-1027; \
postscriptdriver-ricoh;aficio-1032; \
postscriptdriver-ricoh;aficio-1035; \
postscriptdriver-ricoh;aficio-1045; \
postscriptdriver-ricoh;aficio-1060; \
postscriptdriver-ricoh;aficio-1075; \
postscriptdriver-ricoh;aficio-1224c; \
postscriptdriver-ricoh;aficio-1232c; \
postscriptdriver-ricoh;aficio-1515; \
postscriptdriver-ricoh;aficio-2015; \
postscriptdriver-ricoh;aficio-2016; \
postscriptdriver-ricoh;aficio-2018; \
postscriptdriver-ricoh;aficio-2018d; \
postscriptdriver-ricoh;aficio-2020; \
postscriptdriver-ricoh;aficio-2020d; \
postscriptdriver-ricoh;aficio-2022; \
postscriptdriver-ricoh;aficio-2027; \
postscriptdriver-ricoh;aficio-2032; \
postscriptdriver-ricoh;aficio-2035; \
postscriptdriver-ricoh;aficio-2035e; \
postscriptdriver-ricoh;aficio-2045; \
postscriptdriver-ricoh;aficio-2045e; \
postscriptdriver-ricoh;aficio-2051; \
postscriptdriver-ricoh;aficio-2060; \
postscriptdriver-ricoh;aficio-2075; \
postscriptdriver-ricoh;aficio-2090; \
postscriptdriver-ricoh;aficio-2105; \
postscriptdriver-ricoh;aficio-2228c; \
postscriptdriver-ricoh;aficio-2232c; \
postscriptdriver-ricoh;aficio-2238c; \
postscriptdriver-ricoh;aficio-3025; \
postscriptdriver-ricoh;aficio-3030; \
postscriptdriver-ricoh;aficio-3035; \
postscriptdriver-ricoh;aficio-3045; \
postscriptdriver-ricoh;aficio-3224c; \
postscriptdriver-ricoh;aficio-3228c; \
postscriptdriver-ricoh;aficio-3232c; \
postscriptdriver-ricoh;aficio-3235c; \
postscriptdriver-ricoh;aficio-3245c; \
postscriptdriver-ricoh;aficio-3260c; \
postscriptdriver-ricoh;aficio-ap2600; \
postscriptdriver-ricoh;aficio-ap2600n; \
postscriptdriver-ricoh;aficio-ap2610; \
postscriptdriver-ricoh;aficio-ap2610n; \
postscriptdriver-ricoh;aficio-ap3200; \
postscriptdriver-ricoh;aficio-ap3800c; \
postscriptdriver-ricoh;aficio-ap400; \
postscriptdriver-ricoh;aficio-ap400n; \
postscriptdriver-ricoh;aficio-ap410; \
postscriptdriver-ricoh;aficio-ap410n; \
postscriptdriver-ricoh;aficio-ap4510; \
postscriptdriver-ricoh;aficio-ap600n; \
postscriptdriver-ricoh;aficio-ap610n; \
postscriptdriver-ricoh;aficio-ap900; \
postscriptdriver-ricoh;aficio-cl1000n; \
postscriptdriver-ricoh;aficio-cl2000; \
postscriptdriver-ricoh;aficio-cl3000; \
postscriptdriver-ricoh;aficio-cl3000e; \
postscriptdriver-ricoh;aficio-cl3100; \
postscriptdriver-ricoh;aficio-cl3500n; \
postscriptdriver-ricoh;aficio-cl4000dn; \
postscriptdriver-ricoh;aficio-cl4000hdn; \
postscriptdriver-ricoh;aficio-cl5000; \
postscriptdriver-ricoh;aficio-cl7000; \
postscriptdriver-ricoh;aficio-cl7100; \
postscriptdriver-ricoh;aficio-cl7200; \
postscriptdriver-ricoh;aficio-cl7300; \
postscriptdriver-ricoh;aficio-color5560; \
postscriptdriver-ricoh;aficio-mp-1100; \
postscriptdriver-ricoh;aficio-mp-1350; \
postscriptdriver-ricoh;aficio-mp-1600; \
postscriptdriver-ricoh;aficio-mp-161; \
postscriptdriver-ricoh;aficio-mp-171; \
postscriptdriver-ricoh;aficio-mp-2000; \
postscriptdriver-ricoh;aficio-mp-201; \
postscriptdriver-ricoh;aficio-mp-2352; \
postscriptdriver-ricoh;aficio-mp-2500; \
postscriptdriver-ricoh;aficio-mp-2510; \
postscriptdriver-ricoh;aficio-mp-2550; \
postscriptdriver-ricoh;aficio-mp-2550b; \
postscriptdriver-ricoh;aficio-mp-2851; \
postscriptdriver-ricoh;aficio-mp-2852; \
postscriptdriver-ricoh;aficio-mp-3010; \
postscriptdriver-ricoh;aficio-mp-301; \
postscriptdriver-ricoh;aficio-mp-3350; \
postscriptdriver-ricoh;aficio-mp-3350b; \
postscriptdriver-ricoh;aficio-mp-3351; \
postscriptdriver-ricoh;aficio-mp-3352; \
postscriptdriver-ricoh;aficio-mp-3500; \
postscriptdriver-ricoh;aficio-mp-4000; \
postscriptdriver-ricoh;aficio-mp-4000b; \
postscriptdriver-ricoh;aficio-mp-4001; \
postscriptdriver-ricoh;aficio-mp-4002; \
postscriptdriver-ricoh;aficio-mp-4500; \
postscriptdriver-ricoh;aficio-mp-5000; \
postscriptdriver-ricoh;aficio-mp-5000b; \
postscriptdriver-ricoh;aficio-mp-5001; \
postscriptdriver-ricoh;aficio-mp-5002; \
postscriptdriver-ricoh;aficio-mp-5500; \
postscriptdriver-ricoh;aficio-mp-6000; \
postscriptdriver-ricoh;aficio-mp-6001; \
postscriptdriver-ricoh;aficio-mp-6002; \
postscriptdriver-ricoh;aficio-mp-6500; \
postscriptdriver-ricoh;aficio-mp-7000; \
postscriptdriver-ricoh;aficio-mp-7001; \
postscriptdriver-ricoh;aficio-mp-7500; \
postscriptdriver-ricoh;aficio-mp-7502; \
postscriptdriver-ricoh;aficio-mp-8000; \
postscriptdriver-ricoh;aficio-mp-8001; \
postscriptdriver-ricoh;aficio-mp-9000; \
postscriptdriver-ricoh;aficio-mp-9001; \
postscriptdriver-ricoh;aficio-mp-9002; \
postscriptdriver-ricoh;aficio-mp-c2050; \
postscriptdriver-ricoh;aficio-mp-c2051; \
postscriptdriver-ricoh;aficio-mp-c2500; \
postscriptdriver-ricoh;aficio-mp-c2550; \
postscriptdriver-ricoh;aficio-mp-c2551; \
postscriptdriver-ricoh;aficio-mp-c2800; \
postscriptdriver-ricoh;aficio-mp-c3000; \
postscriptdriver-ricoh;aficio-mp-c3001; \
postscriptdriver-ricoh;aficio-mp-c3002; \
postscriptdriver-ricoh;aficio-mp-c300; \
postscriptdriver-ricoh;aficio-mp-c300sr; \
postscriptdriver-ricoh;aficio-mp-c305; \
postscriptdriver-ricoh;aficio-mp-c3300; \
postscriptdriver-ricoh;aficio-mp-c3500; \
postscriptdriver-ricoh;aficio-mp-c3501; \
postscriptdriver-ricoh;aficio-mp-c3502; \
postscriptdriver-ricoh;aficio-mp-c4000; \
postscriptdriver-ricoh;aficio-mp-c400; \
postscriptdriver-ricoh;aficio-mp-c400sr; \
postscriptdriver-ricoh;aficio-mp-c4500; \
postscriptdriver-ricoh;aficio-mp-c4501; \
postscriptdriver-ricoh;aficio-mp-c4501a; \
postscriptdriver-ricoh;aficio-mp-c4502; \
postscriptdriver-ricoh;aficio-mp-c4502a; \
postscriptdriver-ricoh;aficio-mp-c5000; \
postscriptdriver-ricoh;aficio-mp-c5501; \
postscriptdriver-ricoh;aficio-mp-c5501a; \
postscriptdriver-ricoh;aficio-mp-c5502; \
postscriptdriver-ricoh;aficio-mp-c5502a; \
postscriptdriver-ricoh;aficio-mp-c6000; \
postscriptdriver-ricoh;aficio-mp-c6501; \
postscriptdriver-ricoh;aficio-mp-c7500; \
postscriptdriver-ricoh;aficio-mp-c7501; \
postscriptdriver-ricoh;aficio-mp-w2400; \
postscriptdriver-ricoh;aficio-mp-w2401; \
postscriptdriver-ricoh;aficio-mp-w3600; \
postscriptdriver-ricoh;aficio-mp-w3601; \
postscriptdriver-ricoh;aficio-mp-w5100; \
postscriptdriver-ricoh;aficio-mp-w7140; \
postscriptdriver-ricoh;aficio-sp-4100n; \
postscriptdriver-ricoh;aficio-sp-4100nl; \
postscriptdriver-ricoh;aficio-sp-4110n; \
postscriptdriver-ricoh;aficio-sp-4210n; \
postscriptdriver-ricoh;aficio-sp-4310n; \
postscriptdriver-ricoh;aficio-sp-5200dn; \
postscriptdriver-ricoh;aficio-sp-5200s; \
postscriptdriver-ricoh;aficio-sp-5210dn; \
postscriptdriver-ricoh;aficio-sp-5210sf; \
postscriptdriver-ricoh;aficio-sp-5210sr; \
postscriptdriver-ricoh;aficio-sp-6330n; \
postscriptdriver-ricoh;aficio-sp-8100dn; \
postscriptdriver-ricoh;aficio-sp-8200dn; \
postscriptdriver-ricoh;aficio-sp-8300dn; \
postscriptdriver-ricoh;aficio-sp-9100dn; \
postscriptdriver-ricoh;aficio-sp-c320dn; \
postscriptdriver-ricoh;aficio-sp-c400dn; \
postscriptdriver-ricoh;aficio-sp-c410dn; \
postscriptdriver-ricoh;aficio-sp-c411dn; \
postscriptdriver-ricoh;aficio-sp-c420dn; \
postscriptdriver-ricoh;aficio-sp-c430dn; \
postscriptdriver-ricoh;aficio-sp-c431dn; \
postscriptdriver-ricoh;aficio-sp-c730dn; \
postscriptdriver-ricoh;aficio-sp-c811dn; \
postscriptdriver-ricoh;aficio-sp-c820dn; \
postscriptdriver-ricoh;aficio-sp-c821dn; \
postscriptdriver-ricoh;aficio-sp-c830dn; \
postscriptdriver-ricoh;aficio-sp-c831dn; \
postscriptdriver-ricoh;aficio-sp-w2470; \
postscriptdriver-ricoh;colorlaser-ap828; \
postscriptdriver-ricoh;fax5510l/5510nf; \
postscriptdriver-ricoh;laser-ap2600; \
postscriptdriver-ricoh;laser-ap2600n; \
postscriptdriver-ricoh;laser-ap2610; \
postscriptdriver-ricoh;laser-ap2610n; \
postscriptdriver-ricoh;mp-2001; \
postscriptdriver-ricoh;mp-2501; \
postscriptdriver-ricoh;mp-2553; \
postscriptdriver-ricoh;mp-3053; \
postscriptdriver-ricoh;mp-3353; \
postscriptdriver-ricoh;mp-c1500/615c; \
postscriptdriver-ricoh;mp-c2003; \
postscriptdriver-ricoh;mp-c2003z; \
postscriptdriver-ricoh;mp-c2503; \
postscriptdriver-ricoh;mp-c2503z; \
postscriptdriver-ricoh;mp-c3003; \
postscriptdriver-ricoh;mp-c3503; \
postscriptdriver-ricoh;mp-c4503; \
postscriptdriver-ricoh;mp-c5503; \
postscriptdriver-ricoh;mp-c6003; \
postscriptdriver-ricoh;mp-c6502; \
postscriptdriver-ricoh;mp-c8002; \
postscriptdriver-ricoh;mp-cw2200; \
postscriptdriver-ricoh;pro-1106ex; \
postscriptdriver-ricoh;pro-1107ex; \
postscriptdriver-ricoh;pro-1356ex; \
postscriptdriver-ricoh;pro-1357ex; \
postscriptdriver-ricoh;pro-8100s; \
postscriptdriver-ricoh;pro-8110s; \
postscriptdriver-ricoh;pro-8120s; \
postscriptdriver-ricoh;pro-906ex; \
postscriptdriver-ricoh;pro-907ex; \
postscriptdriver-ricoh;pro-c5100s; \
postscriptdriver-ricoh;pro-c5110s; \
postscriptdriver-samsung;clp-350-series; \
postscriptdriver-samsung;clp-550; \
postscriptdriver-samsung;m332x-382x-402x-series; \
postscriptdriver-samsung;m337x-387x-407x-series; \
postscriptdriver-samsung;ml-2550-series; \
postscriptdriver-samsung;ml-2570-series; \
postscriptdriver-samsung;ml-4550-series; \
postscriptdriver-samsung;ml-6060; \
postscriptdriver-savin;2404wd; \
postscriptdriver-savin;2404wdp; \
postscriptdriver-savin;2406wd; \
postscriptdriver-savin;2522; \
postscriptdriver-savin;2527; \
postscriptdriver-savin;2532; \
postscriptdriver-savin;2535/2235; \
postscriptdriver-savin;2545/2245; \
postscriptdriver-savin;2560; \
postscriptdriver-savin;2575; \
postscriptdriver-savin;3406wd; \
postscriptdriver-savin;3515; \
postscriptdriver-savin;40105; \
postscriptdriver-savin;4015; \
postscriptdriver-savin;4018; \
postscriptdriver-savin;4018d; \
postscriptdriver-savin;4022; \
postscriptdriver-savin;4027; \
postscriptdriver-savin;4035/4135g; \
postscriptdriver-savin;4035e/4135eg; \
postscriptdriver-savin;4045/4145g; \
postscriptdriver-savin;4045e/4145eg; \
postscriptdriver-savin;4051; \
postscriptdriver-savin;4060; \
postscriptdriver-savin;4075; \
postscriptdriver-savin;4090; \
postscriptdriver-savin;5100wd; \
postscriptdriver-savin;7025; \
postscriptdriver-savin;7140wd; \
postscriptdriver-savin;8016; \
postscriptdriver-savin;8020; \
postscriptdriver-savin;8020d; \
postscriptdriver-savin;8025; \
postscriptdriver-savin;8025e; \
postscriptdriver-savin;8030; \
postscriptdriver-savin;8030e; \
postscriptdriver-savin;8035/8035g; \
postscriptdriver-savin;8035e; \
postscriptdriver-savin;8045/8045g; \
postscriptdriver-savin;8045e; \
postscriptdriver-savin;8055; \
postscriptdriver-savin;8060; \
postscriptdriver-savin;8065; \
postscriptdriver-savin;8070; \
postscriptdriver-savin;8075; \
postscriptdriver-savin;8080; \
postscriptdriver-savin;8090; \
postscriptdriver-savin;8110; \
postscriptdriver-savin;8135; \
postscriptdriver-savin;816; \
postscriptdriver-savin;9016; \
postscriptdriver-savin;9021d; \
postscriptdriver-savin;9025; \
postscriptdriver-savin;9025b; \
postscriptdriver-savin;9033; \
postscriptdriver-savin;9033b; \
postscriptdriver-savin;9040; \
postscriptdriver-savin;9040b; \
postscriptdriver-savin;9050; \
postscriptdriver-savin;9050b; \
postscriptdriver-savin;9060; \
postscriptdriver-savin;9070; \
postscriptdriver-savin;9080; \
postscriptdriver-savin;9090; \
postscriptdriver-savin;917; \
postscriptdriver-savin;920; \
postscriptdriver-savin;9228; \
postscriptdriver-savin;9233; \
postscriptdriver-savin;9240; \
postscriptdriver-savin;9250; \
postscriptdriver-savin;c-230; \
postscriptdriver-savin;c-230sr; \
postscriptdriver-savin;c-240; \
postscriptdriver-savin;c-240sr; \
postscriptdriver-savin;c2408; \
postscriptdriver-savin;c2410; \
postscriptdriver-savin;c2524; \
postscriptdriver-savin;c2525; \
postscriptdriver-savin;c2532; \
postscriptdriver-savin;c2820; \
postscriptdriver-savin;c2824; \
postscriptdriver-savin;c2828; \
postscriptdriver-savin;c3030; \
postscriptdriver-savin;c3210; \
postscriptdriver-savin;c3210e; \
postscriptdriver-savin;c3224; \
postscriptdriver-savin;c3333; \
postscriptdriver-savin;c3528; \
postscriptdriver-savin;c3535; \
postscriptdriver-savin;c3828; \
postscriptdriver-savin;c4040; \
postscriptdriver-savin;c4535; \
postscriptdriver-savin;c4540; \
postscriptdriver-savin;c5050; \
postscriptdriver-savin;c6045; \
postscriptdriver-savin;c6055; \
postscriptdriver-savin;c7570; \
postscriptdriver-savin;c9020; \
postscriptdriver-savin;c9025; \
postscriptdriver-savin;c9065; \
postscriptdriver-savin;c9075; \
postscriptdriver-savin;c9120; \
postscriptdriver-savin;c9125; \
postscriptdriver-savin;c9130; \
postscriptdriver-savin;c9135; \
postscriptdriver-savin;c9145; \
postscriptdriver-savin;c9145a; \
postscriptdriver-savin;c9155; \
postscriptdriver-savin;c9155a; \
postscriptdriver-savin;clp1036; \
postscriptdriver-savin;clp128; \
postscriptdriver-savin;clp131dn; \
postscriptdriver-savin;clp135; \
postscriptdriver-savin;clp1620; \
postscriptdriver-savin;clp17; \
postscriptdriver-savin;clp18; \
postscriptdriver-savin;clp22; \
postscriptdriver-savin;clp240d; \
postscriptdriver-savin;clp26dn; \
postscriptdriver-savin;clp27dn; \
postscriptdriver-savin;clp28; \
postscriptdriver-savin;clp31dn; \
postscriptdriver-savin;clp340d; \
postscriptdriver-savin;clp350d; \
postscriptdriver-savin;clp35; \
postscriptdriver-savin;clp37dn; \
postscriptdriver-savin;clp42dn; \
postscriptdriver-savin;clp831; \
postscriptdriver-savin;fax3799/3799nf; \
postscriptdriver-savin;mlp145; \
postscriptdriver-savin;mlp150dn; \
postscriptdriver-savin;mlp175n; \
postscriptdriver-savin;mlp235n; \
postscriptdriver-savin;mlp25; \
postscriptdriver-savin;mlp25n; \
postscriptdriver-savin;mlp26; \
postscriptdriver-savin;mlp26n; \
postscriptdriver-savin;mlp28; \
postscriptdriver-savin;mlp28n; \
postscriptdriver-savin;mlp31n; \
postscriptdriver-savin;mlp31nl; \
postscriptdriver-savin;mlp32; \
postscriptdriver-savin;mlp35n; \
postscriptdriver-savin;mlp36n; \
postscriptdriver-savin;mlp37n; \
postscriptdriver-savin;mlp45; \
postscriptdriver-savin;mlp75n; \
postscriptdriver-savin;mp-2352; \
postscriptdriver-savin;mp-2501; \
postscriptdriver-savin;mp-2553; \
postscriptdriver-savin;mp-2852; \
postscriptdriver-savin;mp-301; \
postscriptdriver-savin;mp-3053; \
postscriptdriver-savin;mp-3352; \
postscriptdriver-savin;mp-3353; \
postscriptdriver-savin;mp-4002; \
postscriptdriver-savin;mp-5002; \
postscriptdriver-savin;mp-6002; \
postscriptdriver-savin;mp-7502; \
postscriptdriver-savin;mp-9002; \
postscriptdriver-savin;mp-c2003; \
postscriptdriver-savin;mp-c2503; \
postscriptdriver-savin;mp-c3002; \
postscriptdriver-savin;mp-c3003; \
postscriptdriver-savin;mp-c305; \
postscriptdriver-savin;mp-c3502; \
postscriptdriver-savin;mp-c3503; \
postscriptdriver-savin;mp-c4502; \
postscriptdriver-savin;mp-c4502a; \
postscriptdriver-savin;mp-c4503; \
postscriptdriver-savin;mp-c5502; \
postscriptdriver-savin;mp-c5502a; \
postscriptdriver-savin;mp-c5503; \
postscriptdriver-savin;mp-c6003; \
postscriptdriver-savin;mp-c6502; \
postscriptdriver-savin;mp-c8002; \
postscriptdriver-savin;mp-cw2200; \
postscriptdriver-savin;pro-1106ex; \
postscriptdriver-savin;pro-1107ex; \
postscriptdriver-savin;pro-1356ex; \
postscriptdriver-savin;pro-1357ex; \
postscriptdriver-savin;pro-8100s; \
postscriptdriver-savin;pro-8110s; \
postscriptdriver-savin;pro-8120s; \
postscriptdriver-savin;pro-906ex; \
postscriptdriver-savin;pro-907ex; \
postscriptdriver-savin;pro-c5100s; \
postscriptdriver-savin;pro-c5110s; \
postscriptdriver-savin;sdc555; \
postscriptdriver-savin;sgc-1506; \
postscriptdriver-savin;slp26; \
postscriptdriver-savin;slp26n; \
postscriptdriver-savin;slp32; \
postscriptdriver-savin;slp38c; \
postscriptdriver-savin;sp-4310n; \
postscriptdriver-savin;sp-5200dn; \
postscriptdriver-savin;sp-5200s; \
postscriptdriver-savin;sp-5210dn; \
postscriptdriver-savin;sp-5210sf; \
postscriptdriver-savin;sp-5210sr; \
postscriptdriver-savin;sp-8300dn; \
postscriptdriver-savin;sp-c320dn; \
postscriptdriver-savin;sp-c400dn; \
postscriptdriver-savin;sp-c730dn; \
postscriptdriver-savin;sp-c830dn; \
postscriptdriver-savin;sp-c831dn; \
postscriptdriver-sharp;sharp-ar-nb2; \
postscriptdriver-sharp;sharp-ar-p19; \
postscriptdriver-sharp;sharp-ar-p20; \
postscriptdriver-sharp;sharp-ar-pk4; \
postscriptdriver-tektronix;phaser-750dp; \
postscriptdriver-tektronix;phaser-750dx; \
postscriptdriver-tektronix;phaser-750n; \
postscriptdriver-tektronix;phaser-750p; \
postscriptdriver-tektronix;phaser-850dp; \
postscriptdriver-tektronix;phaser-850dx; \
postscriptdriver-tektronix;phaser-850n; \
postscriptdriver-xerox;cups-v1.1; \
postscriptdriver-xerox;docucolor-2006; \
postscriptdriver-xerox;phaser-4400b; \
postscriptdriver-xerox;phaser-4400dt; \
postscriptdriver-xerox;phaser-4400dx; \
postscriptdriver-xerox;phaser-4400n; \
postscriptdriver-xerox;phaser-4500b; \
postscriptdriver-xerox;phaser-4500dt; \
postscriptdriver-xerox;phaser-4500dx; \
postscriptdriver-xerox;phaser-4500n; \
postscriptdriver-xerox;phaser-4510b; \
postscriptdriver-xerox;phaser-4510dt; \
postscriptdriver-xerox;phaser-4510dx; \
postscriptdriver-xerox;phaser-4510n; \
postscriptdriver-xerox;phaser-5500b; \
postscriptdriver-xerox;phaser-5500dn; \
postscriptdriver-xerox;phaser-5500dt; \
postscriptdriver-xerox;phaser-5500dx; \
postscriptdriver-xerox;phaser-5500n; \
postscriptdriver-xerox;phaser-6130n; \
postscriptdriver-xerox;phaser-6180dn; \
postscriptdriver-xerox;phaser-6180mfp-d; \
postscriptdriver-xerox;phaser-6200b; \
postscriptdriver-xerox;phaser-6200dp; \
postscriptdriver-xerox;phaser-6200dx; \
postscriptdriver-xerox;phaser-6200n; \
postscriptdriver-xerox;phaser-6250b; \
postscriptdriver-xerox;phaser-6250dp; \
postscriptdriver-xerox;phaser-6250dt; \
postscriptdriver-xerox;phaser-6250dx; \
postscriptdriver-xerox;phaser-6250n; \
postscriptdriver-xerox;phaser-6300dn; \
postscriptdriver-xerox;phaser-6300n; \
postscriptdriver-xerox;phaser-6350dp; \
postscriptdriver-xerox;phaser-6350dt; \
postscriptdriver-xerox;phaser-6350dx; \
postscriptdriver-xerox;phaser-6360dn; \
postscriptdriver-xerox;phaser-6360dx; \
postscriptdriver-xerox;phaser-7300b; \
postscriptdriver-xerox;phaser-7300dn; \
postscriptdriver-xerox;phaser-7300dt; \
postscriptdriver-xerox;phaser-7300dx; \
postscriptdriver-xerox;phaser-7300n; \
postscriptdriver-xerox;phaser-7400dn; \
postscriptdriver-xerox;phaser-7400dt; \
postscriptdriver-xerox;phaser-7400dx; \
postscriptdriver-xerox;phaser-7400dxf; \
postscriptdriver-xerox;phaser-7400n; \
postscriptdriver-xerox;phaser-7700dn; \
postscriptdriver-xerox;phaser-7700dx; \
postscriptdriver-xerox;phaser-7700gx; \
postscriptdriver-xerox;phaser-7750b; \
postscriptdriver-xerox;phaser-7750dn; \
postscriptdriver-xerox;phaser-7750dxf; \
postscriptdriver-xerox;phaser-7750gx; \
postscriptdriver-xerox;phaser-7760dn; \
postscriptdriver-xerox;phaser-7760dx; \
postscriptdriver-xerox;phaser-7760gx; \
postscriptdriver-xerox;phaser-790; \
postscriptdriver-xerox;phaser-8200b; \
postscriptdriver-xerox;phaser-8200dp; \
postscriptdriver-xerox;phaser-8200dx; \
postscriptdriver-xerox;phaser-8200n; \
postscriptdriver-xerox;phaser-8400b; \
postscriptdriver-xerox;phaser-8400bd; \
postscriptdriver-xerox;phaser-8400dp; \
postscriptdriver-xerox;phaser-8400dx; \
postscriptdriver-xerox;phaser-8400n; \
postscriptdriver-xerox;phaser-8500dn; \
postscriptdriver-xerox;phaser-8500n; \
postscriptdriver-xerox;phaser-8550dp; \
postscriptdriver-xerox;phaser-8550dt; \
postscriptdriver-xerox;phaser-8550dx; \
postscriptdriver-xerox;phaser-8560dn; \
postscriptdriver-xerox;phaser-860b; \
postscriptdriver-xerox;phaser-860dp; \
postscriptdriver-xerox;phaser-860dx; \
postscriptdriver-xerox;phaser-860n; \
postscriptdriver-xerox;phaser-8860; \
postscriptdriver-xerox;workcentre-24; \
postscriptdriver-xerox;workcentre-7228; \
postscriptdriver-xerox;workcentre-c2424; \
postscriptdriver-xerox;workcentre-m118; \
postscriptdriver-xerox;workcentre-pro-128; \
postscriptdriver-xerox;workcentre-pro-133; \
postscriptdriver-xerox;xerox-docuprint-n2125; \
postscriptdriver-xerox;xerox-docuprint-n24; \
postscriptdriver-xerox;xerox-docuprint-n3225; \
postscriptdriver-xerox;xerox-docuprint-n4025; \
postscriptdriver-xerox;xerox-docuprint-n40; \
postscriptdriver-xerox;xerox-docuprint-n4525; \
postscriptdriver-xerox;xerox-faxcentre-2218; \
postscriptdriver-xerox;xerox-phaser-1235; \
postscriptdriver-xerox;xerox-phaser-2135; \
postscriptdriver-xerox;xerox-phaser-3200mfp; \
postscriptdriver-xerox;xerox-phaser-3400; \
postscriptdriver-xerox;xerox-phaser-3450; \
postscriptdriver-xerox;xerox-phaser-3500; \
postscriptdriver-xerox;xerox-wc-4118; \
postscriptdriver-xerox;xerox-wc-m20; \
postscriptdriver-xerox;xerox-wc-pe120;"

RDEPENDS:${PN} += "foomatic-filters"

inherit rpm
