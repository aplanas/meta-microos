SUMMARY = "Printer drivers for HP printers and all-in-one devices"
DESCRIPTION = "This package contains the backend drivers and PPDs for printing \
with HP printers using CUPS. \
 \
HPCUPS is HPLIP's native CUPS printer driver for HP printers. \
HPIJS (deprecated) is HPLIP's Ghostscript printer driver for \
HP printers, and only used for some Fax devices nowadays. \
 \
Install the 'hplip' package if you need the proprietary HP plugin \
required by some devices, or additional functionality besides plain \
printing."
LICENSE = "BSD-3-Clause & GPL-2.0-or-later & MIT"

PV = "3.22.10"

RPM_NAME = "hplip-hpijs-3.22.10-2.1.aarch64.rpm"
RPM_HASH = "814738e344520d43ac1c5c73761f20102c3c828f59e63c86251c1c0afadc09365c6feb718693471ba6f2bf742629007efb3dddfa097b6fbc044d54c582424051"

RPROVIDES:${PN} += "config-hplip-hpijs \
hplip-hpijs \
hplip3-hpijs \
libhpdiscovery.so.0 \
libhpip.so.0 \
libhpipp.so.0 \
libhpmud.so.0 \
postscriptdriver-apollo;apollo-2100; \
postscriptdriver-apollo;apollo-2150; \
postscriptdriver-apollo;apollo-2200; \
postscriptdriver-apollo;apollo-2500; \
postscriptdriver-apollo;apollo-2600; \
postscriptdriver-apollo;apollo-2650; \
postscriptdriver-apollo;apollo-p2000-u; \
postscriptdriver-apollo;apollo-p2250; \
postscriptdriver-hewlett-packard;hp-color-laserjet-2500-series; \
postscriptdriver-hewlett-packard;hp-color-laserjet-2500; \
postscriptdriver-hewlett-packard;hp-color-laserjet-2550; \
postscriptdriver-hewlett-packard;hp-color-laserjet-2605; \
postscriptdriver-hewlett-packard;hp-color-laserjet-2605dn; \
postscriptdriver-hewlett-packard;hp-color-laserjet-2605dtn; \
postscriptdriver-hewlett-packard;hp-color-laserjet-2700; \
postscriptdriver-hewlett-packard;hp-color-laserjet-2700n; \
postscriptdriver-hewlett-packard;hp-color-laserjet-2800; \
postscriptdriver-hewlett-packard;hp-color-laserjet-2820; \
postscriptdriver-hewlett-packard;hp-color-laserjet-2830; \
postscriptdriver-hewlett-packard;hp-color-laserjet-2840; \
postscriptdriver-hewlett-packard;hp-color-laserjet-3000; \
postscriptdriver-hewlett-packard;hp-color-laserjet-3700; \
postscriptdriver-hewlett-packard;hp-color-laserjet-3700n; \
postscriptdriver-hewlett-packard;hp-color-laserjet-3800; \
postscriptdriver-hewlett-packard;hp-color-laserjet-4500; \
postscriptdriver-hewlett-packard;hp-color-laserjet-4550; \
postscriptdriver-hewlett-packard;hp-color-laserjet-4600-series; \
postscriptdriver-hewlett-packard;hp-color-laserjet-4600; \
postscriptdriver-hewlett-packard;hp-color-laserjet-4610; \
postscriptdriver-hewlett-packard;hp-color-laserjet-4650; \
postscriptdriver-hewlett-packard;hp-color-laserjet-4700; \
postscriptdriver-hewlett-packard;hp-color-laserjet-4730mfp; \
postscriptdriver-hewlett-packard;hp-color-laserjet-5500; \
postscriptdriver-hewlett-packard;hp-color-laserjet-5550; \
postscriptdriver-hewlett-packard;hp-color-laserjet-5; \
postscriptdriver-hewlett-packard;hp-color-laserjet-5m; \
postscriptdriver-hewlett-packard;hp-color-laserjet-8500; \
postscriptdriver-hewlett-packard;hp-color-laserjet-8550; \
postscriptdriver-hewlett-packard;hp-color-laserjet-9500; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cm1015; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cm1017; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cm1312-mfp; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cm1312nfi-mfp; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cm2320-mfp; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cm2320fxi-mfp; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cm2320n-mfp; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cm2320nf-mfp; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cm3530-mfp; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cm4540-mfp; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cm4730-mfp; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cm6030-mfp; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cm6040-mfp; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cm6049-mfp; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp1217; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp1514n; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp1515n; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp1518ni; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp2025; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp2025dn; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp2025n; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp2025x; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp3505; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp3525; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp4005; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp4020-series; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp4520-series; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp5225; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp5225dn; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp5225n; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp5520-series; \
postscriptdriver-hewlett-packard;hp-color-laserjet-cp6015; \
postscriptdriver-hewlett-packard;hp-color-laserjet-pro-mfp-m177fw; \
postscriptdriver-hewlett-packard;hp-designjet-4000ps; \
postscriptdriver-hewlett-packard;hp-designjet-4020ps; \
postscriptdriver-hewlett-packard;hp-designjet-4500mfp; \
postscriptdriver-hewlett-packard;hp-designjet-4500ps; \
postscriptdriver-hewlett-packard;hp-designjet-4520mfp; \
postscriptdriver-hewlett-packard;hp-designjet-4520ps; \
postscriptdriver-hewlett-packard;hp-designjet-d5800ps-photo; \
postscriptdriver-hewlett-packard;hp-designjet-t1100ps-24in; \
postscriptdriver-hewlett-packard;hp-designjet-t1100ps-44in; \
postscriptdriver-hewlett-packard;hp-designjet-t1120ps-24in; \
postscriptdriver-hewlett-packard;hp-designjet-t1120ps-44in; \
postscriptdriver-hewlett-packard;hp-designjet-t1200-postscript; \
postscriptdriver-hewlett-packard;hp-designjet-t1300-postscript; \
postscriptdriver-hewlett-packard;hp-designjet-t1500-postscript; \
postscriptdriver-hewlett-packard;hp-designjet-t2300-postscript; \
postscriptdriver-hewlett-packard;hp-designjet-t2500-postscript; \
postscriptdriver-hewlett-packard;hp-designjet-t7100ps-monochrome; \
postscriptdriver-hewlett-packard;hp-designjet-t7100ps; \
postscriptdriver-hewlett-packard;hp-designjet-t7200ps; \
postscriptdriver-hewlett-packard;hp-designjet-t770-postscript; \
postscriptdriver-hewlett-packard;hp-designjet-t770ps-24in; \
postscriptdriver-hewlett-packard;hp-designjet-t790ps-24in; \
postscriptdriver-hewlett-packard;hp-designjet-t790ps-44in; \
postscriptdriver-hewlett-packard;hp-designjet-t795ps-44in; \
postscriptdriver-hewlett-packard;hp-designjet-z2600-postscript; \
postscriptdriver-hewlett-packard;hp-designjet-z5400-postscript; \
postscriptdriver-hewlett-packard;hp-designjet-z5600-postscript; \
postscriptdriver-hewlett-packard;hp-designjet-z6-pro-64in-ps; \
postscriptdriver-hewlett-packard;hp-designjet-z6100ps-42in-photo; \
postscriptdriver-hewlett-packard;hp-designjet-z6100ps-60in-photo; \
postscriptdriver-hewlett-packard;hp-designjet-z6200ps-42in-photo; \
postscriptdriver-hewlett-packard;hp-designjet-z6200ps-60in-photo; \
postscriptdriver-hewlett-packard;hp-designjet-z6600ps; \
postscriptdriver-hewlett-packard;hp-designjet-z6610ps-60in; \
postscriptdriver-hewlett-packard;hp-designjet-z6800ps-photo; \
postscriptdriver-hewlett-packard;hp-designjet-z6810ps-42in; \
postscriptdriver-hewlett-packard;hp-designjet-z6810ps-60in; \
postscriptdriver-hewlett-packard;hp-designjet-z9-24in; \
postscriptdriver-hewlett-packard;hp-designjet-z9-44in; \
postscriptdriver-hewlett-packard;hp-designjet-z9-pro-64in-ps; \
postscriptdriver-hewlett-packard;hp-designjet-z9dr-44in; \
postscriptdriver-hewlett-packard;hp-laserjet-1010; \
postscriptdriver-hewlett-packard;hp-laserjet-1012; \
postscriptdriver-hewlett-packard;hp-laserjet-1015; \
postscriptdriver-hewlett-packard;hp-laserjet-1100; \
postscriptdriver-hewlett-packard;hp-laserjet-1100a; \
postscriptdriver-hewlett-packard;hp-laserjet-1100xi; \
postscriptdriver-hewlett-packard;hp-laserjet-1150; \
postscriptdriver-hewlett-packard;hp-laserjet-1160-series; \
postscriptdriver-hewlett-packard;hp-laserjet-1200; \
postscriptdriver-hewlett-packard;hp-laserjet-1200n; \
postscriptdriver-hewlett-packard;hp-laserjet-1220; \
postscriptdriver-hewlett-packard;hp-laserjet-1220se; \
postscriptdriver-hewlett-packard;hp-laserjet-1300; \
postscriptdriver-hewlett-packard;hp-laserjet-1300n; \
postscriptdriver-hewlett-packard;hp-laserjet-1300xi; \
postscriptdriver-hewlett-packard;hp-laserjet-1320-series; \
postscriptdriver-hewlett-packard;hp-laserjet-1320; \
postscriptdriver-hewlett-packard;hp-laserjet-1320n; \
postscriptdriver-hewlett-packard;hp-laserjet-1320nw; \
postscriptdriver-hewlett-packard;hp-laserjet-1320tn; \
postscriptdriver-hewlett-packard;hp-laserjet-2100-series; \
postscriptdriver-hewlett-packard;hp-laserjet-2100; \
postscriptdriver-hewlett-packard;hp-laserjet-2200-series; \
postscriptdriver-hewlett-packard;hp-laserjet-2200; \
postscriptdriver-hewlett-packard;hp-laserjet-2300-series; \
postscriptdriver-hewlett-packard;hp-laserjet-2300; \
postscriptdriver-hewlett-packard;hp-laserjet-2410; \
postscriptdriver-hewlett-packard;hp-laserjet-2420; \
postscriptdriver-hewlett-packard;hp-laserjet-2430; \
postscriptdriver-hewlett-packard;hp-laserjet-3015; \
postscriptdriver-hewlett-packard;hp-laserjet-3020; \
postscriptdriver-hewlett-packard;hp-laserjet-3030; \
postscriptdriver-hewlett-packard;hp-laserjet-3050; \
postscriptdriver-hewlett-packard;hp-laserjet-3052; \
postscriptdriver-hewlett-packard;hp-laserjet-3055; \
postscriptdriver-hewlett-packard;hp-laserjet-3100; \
postscriptdriver-hewlett-packard;hp-laserjet-3150; \
postscriptdriver-hewlett-packard;hp-laserjet-3200; \
postscriptdriver-hewlett-packard;hp-laserjet-3200m; \
postscriptdriver-hewlett-packard;hp-laserjet-3300-3310-3320; \
postscriptdriver-hewlett-packard;hp-laserjet-3330; \
postscriptdriver-hewlett-packard;hp-laserjet-3380; \
postscriptdriver-hewlett-packard;hp-laserjet-3390; \
postscriptdriver-hewlett-packard;hp-laserjet-3392; \
postscriptdriver-hewlett-packard;hp-laserjet-4-plus; \
postscriptdriver-hewlett-packard;hp-laserjet-4000-series; \
postscriptdriver-hewlett-packard;hp-laserjet-4050-series; \
postscriptdriver-hewlett-packard;hp-laserjet-4100-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-4100-series; \
postscriptdriver-hewlett-packard;hp-laserjet-4150-series; \
postscriptdriver-hewlett-packard;hp-laserjet-4200; \
postscriptdriver-hewlett-packard;hp-laserjet-4240; \
postscriptdriver-hewlett-packard;hp-laserjet-4250; \
postscriptdriver-hewlett-packard;hp-laserjet-4300; \
postscriptdriver-hewlett-packard;hp-laserjet-4345-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-4350; \
postscriptdriver-hewlett-packard;hp-laserjet-4l; \
postscriptdriver-hewlett-packard;hp-laserjet-4ml; \
postscriptdriver-hewlett-packard;hp-laserjet-4mp; \
postscriptdriver-hewlett-packard;hp-laserjet-4si; \
postscriptdriver-hewlett-packard;hp-laserjet-4v; \
postscriptdriver-hewlett-packard;hp-laserjet-5000-series; \
postscriptdriver-hewlett-packard;hp-laserjet-5000; \
postscriptdriver-hewlett-packard;hp-laserjet-5100-series; \
postscriptdriver-hewlett-packard;hp-laserjet-5200; \
postscriptdriver-hewlett-packard;hp-laserjet-5200l; \
postscriptdriver-hewlett-packard;hp-laserjet-5200lx; \
postscriptdriver-hewlett-packard;hp-laserjet-5l; \
postscriptdriver-hewlett-packard;hp-laserjet-5mp; \
postscriptdriver-hewlett-packard;hp-laserjet-5p; \
postscriptdriver-hewlett-packard;hp-laserjet-5si-mopier; \
postscriptdriver-hewlett-packard;hp-laserjet-5si; \
postscriptdriver-hewlett-packard;hp-laserjet-6l; \
postscriptdriver-hewlett-packard;hp-laserjet-6mp; \
postscriptdriver-hewlett-packard;hp-laserjet-6p; \
postscriptdriver-hewlett-packard;hp-laserjet-8000-series; \
postscriptdriver-hewlett-packard;hp-laserjet-8000; \
postscriptdriver-hewlett-packard;hp-laserjet-8100-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-8100-series; \
postscriptdriver-hewlett-packard;hp-laserjet-8150-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-8150-series; \
postscriptdriver-hewlett-packard;hp-laserjet-9000-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-9000-series; \
postscriptdriver-hewlett-packard;hp-laserjet-9040-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-9040; \
postscriptdriver-hewlett-packard;hp-laserjet-9050-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-9050; \
postscriptdriver-hewlett-packard;hp-laserjet-9055mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-9065mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-cm1411fn; \
postscriptdriver-hewlett-packard;hp-laserjet-cm1412fn; \
postscriptdriver-hewlett-packard;hp-laserjet-cm1413fn; \
postscriptdriver-hewlett-packard;hp-laserjet-cm1415fn; \
postscriptdriver-hewlett-packard;hp-laserjet-cm1415fnw; \
postscriptdriver-hewlett-packard;hp-laserjet-cm1416fnw; \
postscriptdriver-hewlett-packard;hp-laserjet-cm1417fnw; \
postscriptdriver-hewlett-packard;hp-laserjet-cm1418fnw; \
postscriptdriver-hewlett-packard;hp-laserjet-cp1025; \
postscriptdriver-hewlett-packard;hp-laserjet-m101-m106; \
postscriptdriver-hewlett-packard;hp-laserjet-m109-m112; \
postscriptdriver-hewlett-packard;hp-laserjet-m14-m17; \
postscriptdriver-hewlett-packard;hp-laserjet-m1522nf-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m1537dnf-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m1538dnf-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m1539dnf-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m207-m212; \
postscriptdriver-hewlett-packard;hp-laserjet-m2727-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m3027-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m3035-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m4345-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m4349-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m5025-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m5035-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m5039-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m9040-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m9050-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-m9059-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-m129-m134; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-m139-m142; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-m232-m237; \
postscriptdriver-hewlett-packard;hp-laserjet-mfp-m28-m31; \
postscriptdriver-hewlett-packard;hp-laserjet-p1009; \
postscriptdriver-hewlett-packard;hp-laserjet-p2015-series; \
postscriptdriver-hewlett-packard;hp-laserjet-p2015d-series; \
postscriptdriver-hewlett-packard;hp-laserjet-p2015dn-series; \
postscriptdriver-hewlett-packard;hp-laserjet-p2015n-series; \
postscriptdriver-hewlett-packard;hp-laserjet-p2015x-series; \
postscriptdriver-hewlett-packard;hp-laserjet-p2055; \
postscriptdriver-hewlett-packard;hp-laserjet-p2055d; \
postscriptdriver-hewlett-packard;hp-laserjet-p2055dn; \
postscriptdriver-hewlett-packard;hp-laserjet-p2055x; \
postscriptdriver-hewlett-packard;hp-laserjet-p3004; \
postscriptdriver-hewlett-packard;hp-laserjet-p3005; \
postscriptdriver-hewlett-packard;hp-laserjet-p3010-series; \
postscriptdriver-hewlett-packard;hp-laserjet-p4014; \
postscriptdriver-hewlett-packard;hp-laserjet-p4014dn; \
postscriptdriver-hewlett-packard;hp-laserjet-p4014n; \
postscriptdriver-hewlett-packard;hp-laserjet-p4015; \
postscriptdriver-hewlett-packard;hp-laserjet-p4015dn; \
postscriptdriver-hewlett-packard;hp-laserjet-p4015n; \
postscriptdriver-hewlett-packard;hp-laserjet-p4015tn; \
postscriptdriver-hewlett-packard;hp-laserjet-p4015x; \
postscriptdriver-hewlett-packard;hp-laserjet-p4515; \
postscriptdriver-hewlett-packard;hp-laserjet-p4515n; \
postscriptdriver-hewlett-packard;hp-laserjet-p4515tn; \
postscriptdriver-hewlett-packard;hp-laserjet-p4515x; \
postscriptdriver-hewlett-packard;hp-laserjet-p4515xm; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-m125a; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-m125nr; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-m125nw; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-m125r; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-m125rnw; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-m125s; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-m126a; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-m126nw; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-m127fn; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-m127fp; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-m127fs; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-m128fn; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-m128fp; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-m128fw; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-m25a; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-m25nw; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-m26a; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-m26nw; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-m27c; \
postscriptdriver-hewlett-packard;hp-laserjet-pro-mfp-m27cnw; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-m1132-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-m1136-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-m1137-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-m1138-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-m1139-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-m1212nf-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-m1213nf-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-m1214nfh-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-m1216nfh-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-m1218nfg-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-m1218nfs-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-m1219nf-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-m1219nfg-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-m1219nfs-mfp; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-p1106; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-p1106w; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-p1107; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-p1107w; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-p1108; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-p1108w; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-p1109; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-p1109w; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-p1567; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-p1568; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-p1569; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-p1606dn; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-p1607dn; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-p1608dn; \
postscriptdriver-hewlett-packard;hp-laserjet-professional-p1609dn; \
postscriptdriver-hewlett-packard;hp-laserjet-tank-1020; \
postscriptdriver-hewlett-packard;hp-laserjet-tank-150x; \
postscriptdriver-hewlett-packard;hp-laserjet-tank-250x; \
postscriptdriver-hewlett-packard;hp-laserjet-tank-mfp-1005; \
postscriptdriver-hewlett-packard;hp-laserjet-tank-mfp-160x; \
postscriptdriver-hewlett-packard;hp-laserjet-tank-mfp-260x; \
postscriptdriver-hp;amp; \
postscriptdriver-hp;business-inkjet-1000; \
postscriptdriver-hp;business-inkjet-1200; \
postscriptdriver-hp;cp1160; \
postscriptdriver-hp;deskjet-1000-j110-series; \
postscriptdriver-hp;deskjet-1010-series; \
postscriptdriver-hp;deskjet-1050-j410-series; \
postscriptdriver-hp;deskjet-1100; \
postscriptdriver-hp;deskjet-1110-series; \
postscriptdriver-hp;deskjet-1120; \
postscriptdriver-hp;deskjet-1125; \
postscriptdriver-hp;deskjet-1200-series; \
postscriptdriver-hp;deskjet-1200c; \
postscriptdriver-hp;deskjet-1220c; \
postscriptdriver-hp;deskjet-1280; \
postscriptdriver-hp;deskjet-1510-series; \
postscriptdriver-hp;deskjet-1600c; \
postscriptdriver-hp;deskjet-1600cm; \
postscriptdriver-hp;deskjet-1600cn; \
postscriptdriver-hp;deskjet-2000-j210-series; \
postscriptdriver-hp;deskjet-2020-series; \
postscriptdriver-hp;deskjet-2050-j510-series; \
postscriptdriver-hp;deskjet-2130-series; \
postscriptdriver-hp;deskjet-2200-series; \
postscriptdriver-hp;deskjet-2300-series; \
postscriptdriver-hp;deskjet-2510-series; \
postscriptdriver-hp;deskjet-2520-series; \
postscriptdriver-hp;deskjet-2540-series; \
postscriptdriver-hp;deskjet-2600-series; \
postscriptdriver-hp;deskjet-2640-series; \
postscriptdriver-hp;deskjet-2700-series; \
postscriptdriver-hp;deskjet-3000-j310-series; \
postscriptdriver-hp;deskjet-3050-j610-series; \
postscriptdriver-hp;deskjet-3050a-j611-series; \
postscriptdriver-hp;deskjet-3070-b611-series; \
postscriptdriver-hp;deskjet-3320; \
postscriptdriver-hp;deskjet-3325; \
postscriptdriver-hp;deskjet-3420; \
postscriptdriver-hp;deskjet-3425; \
postscriptdriver-hp;deskjet-3450; \
postscriptdriver-hp;deskjet-3500; \
postscriptdriver-hp;deskjet-3510-series; \
postscriptdriver-hp;deskjet-3520-series; \
postscriptdriver-hp;deskjet-3540-series; \
postscriptdriver-hp;deskjet-3550; \
postscriptdriver-hp;deskjet-3600; \
postscriptdriver-hp;deskjet-3630-series; \
postscriptdriver-hp;deskjet-3650; \
postscriptdriver-hp;deskjet-3700-series; \
postscriptdriver-hp;deskjet-3740; \
postscriptdriver-hp;deskjet-3810; \
postscriptdriver-hp;deskjet-3816; \
postscriptdriver-hp;deskjet-3819; \
postscriptdriver-hp;deskjet-3820; \
postscriptdriver-hp;deskjet-3822; \
postscriptdriver-hp;deskjet-3830-series; \
postscriptdriver-hp;deskjet-3840; \
postscriptdriver-hp;deskjet-3870; \
postscriptdriver-hp;deskjet-3900; \
postscriptdriver-hp;deskjet-3910; \
postscriptdriver-hp;deskjet-3920; \
postscriptdriver-hp;deskjet-3940; \
postscriptdriver-hp;deskjet-4100-series; \
postscriptdriver-hp;deskjet-4510-series; \
postscriptdriver-hp;deskjet-4530-series; \
postscriptdriver-hp;deskjet-460; \
postscriptdriver-hp;deskjet-4610-series; \
postscriptdriver-hp;deskjet-4620-series; \
postscriptdriver-hp;deskjet-4640-series; \
postscriptdriver-hp;deskjet-4670-series; \
postscriptdriver-hp;deskjet-4720-series; \
postscriptdriver-hp;deskjet-4800-series; \
postscriptdriver-hp;deskjet-5000-series; \
postscriptdriver-hp;deskjet-500; \
postscriptdriver-hp;deskjet-500c; \
postscriptdriver-hp;deskjet-505j; \
postscriptdriver-hp;deskjet-5100; \
postscriptdriver-hp;deskjet-510; \
postscriptdriver-hp;deskjet-5200-series; \
postscriptdriver-hp;deskjet-520; \
postscriptdriver-hp;deskjet-5400-series; \
postscriptdriver-hp;deskjet-540; \
postscriptdriver-hp;deskjet-5520-series; \
postscriptdriver-hp;deskjet-5550; \
postscriptdriver-hp;deskjet-5551; \
postscriptdriver-hp;deskjet-5552; \
postscriptdriver-hp;deskjet-5570-series; \
postscriptdriver-hp;deskjet-5600; \
postscriptdriver-hp;deskjet-5640-series; \
postscriptdriver-hp;deskjet-5650; \
postscriptdriver-hp;deskjet-5652; \
postscriptdriver-hp;deskjet-5700; \
postscriptdriver-hp;deskjet-5730-series; \
postscriptdriver-hp;deskjet-5800; \
postscriptdriver-hp;deskjet-5810-series; \
postscriptdriver-hp;deskjet-5820-series; \
postscriptdriver-hp;deskjet-5850; \
postscriptdriver-hp;deskjet-5900-series; \
postscriptdriver-hp;deskjet-600; \
postscriptdriver-hp;deskjet-610c; \
postscriptdriver-hp;deskjet-610cl; \
postscriptdriver-hp;deskjet-6120; \
postscriptdriver-hp;deskjet-6122; \
postscriptdriver-hp;deskjet-6127; \
postscriptdriver-hp;deskjet-612c; \
postscriptdriver-hp;deskjet-630c; \
postscriptdriver-hp;deskjet-632c; \
postscriptdriver-hp;deskjet-640c; \
postscriptdriver-hp;deskjet-648c; \
postscriptdriver-hp;deskjet-6500; \
postscriptdriver-hp;deskjet-6520-series; \
postscriptdriver-hp;deskjet-656c; \
postscriptdriver-hp;deskjet-6600; \
postscriptdriver-hp;deskjet-660; \
postscriptdriver-hp;deskjet-670; \
postscriptdriver-hp;deskjet-670c; \
postscriptdriver-hp;deskjet-670tv; \
postscriptdriver-hp;deskjet-672c; \
postscriptdriver-hp;deskjet-6800; \
postscriptdriver-hp;deskjet-680; \
postscriptdriver-hp;deskjet-682; \
postscriptdriver-hp;deskjet-690c; \
postscriptdriver-hp;deskjet-692; \
postscriptdriver-hp;deskjet-693; \
postscriptdriver-hp;deskjet-6940-series; \
postscriptdriver-hp;deskjet-694; \
postscriptdriver-hp;deskjet-695; \
postscriptdriver-hp;deskjet-697; \
postscriptdriver-hp;deskjet-6980-series; \
postscriptdriver-hp;deskjet-810c; \
postscriptdriver-hp;deskjet-812c; \
postscriptdriver-hp;deskjet-815c; \
postscriptdriver-hp;deskjet-816c; \
postscriptdriver-hp;deskjet-825c; \
postscriptdriver-hp;deskjet-830c; \
postscriptdriver-hp;deskjet-832c; \
postscriptdriver-hp;deskjet-840c; \
postscriptdriver-hp;deskjet-841c; \
postscriptdriver-hp;deskjet-842c; \
postscriptdriver-hp;deskjet-843c; \
postscriptdriver-hp;deskjet-845c; \
postscriptdriver-hp;deskjet-850c; \
postscriptdriver-hp;deskjet-855c; \
postscriptdriver-hp;deskjet-870c; \
postscriptdriver-hp;deskjet-880c; \
postscriptdriver-hp;deskjet-882c; \
postscriptdriver-hp;deskjet-890c; \
postscriptdriver-hp;deskjet-895c; \
postscriptdriver-hp;deskjet-916c; \
postscriptdriver-hp;deskjet-920c; \
postscriptdriver-hp;deskjet-930c; \
postscriptdriver-hp;deskjet-932c; \
postscriptdriver-hp;deskjet-933c; \
postscriptdriver-hp;deskjet-934c; \
postscriptdriver-hp;deskjet-935c; \
postscriptdriver-hp;deskjet-940c; \
postscriptdriver-hp;deskjet-948c; \
postscriptdriver-hp;deskjet-950c; \
postscriptdriver-hp;deskjet-952c; \
postscriptdriver-hp;deskjet-955c; \
postscriptdriver-hp;deskjet-957c; \
postscriptdriver-hp;deskjet-959c; \
postscriptdriver-hp;deskjet-9600; \
postscriptdriver-hp;deskjet-960c; \
postscriptdriver-hp;deskjet-970c; \
postscriptdriver-hp;deskjet-975c; \
postscriptdriver-hp;deskjet-9800; \
postscriptdriver-hp;deskjet-980c; \
postscriptdriver-hp;deskjet-990c; \
postscriptdriver-hp;deskjet-995c; \
postscriptdriver-hp;deskjet-d1300-series; \
postscriptdriver-hp;deskjet-d1400-series; \
postscriptdriver-hp;deskjet-d1500-series; \
postscriptdriver-hp;deskjet-d1600-series; \
postscriptdriver-hp;deskjet-d2300-series; \
postscriptdriver-hp;deskjet-d2400-series; \
postscriptdriver-hp;deskjet-d2500-series; \
postscriptdriver-hp;deskjet-d2600-series; \
postscriptdriver-hp;deskjet-d4100-series; \
postscriptdriver-hp;deskjet-d4200-series; \
postscriptdriver-hp;deskjet-d4300-series; \
postscriptdriver-hp;deskjet-d5500-series; \
postscriptdriver-hp;deskjet-d730; \
postscriptdriver-hp;deskjet-f2100-series; \
postscriptdriver-hp;deskjet-f2200-series; \
postscriptdriver-hp;deskjet-f2400-series; \
postscriptdriver-hp;deskjet-f300-series; \
postscriptdriver-hp;deskjet-f4100-series; \
postscriptdriver-hp;deskjet-f4200-series; \
postscriptdriver-hp;deskjet-f4400-series; \
postscriptdriver-hp;deskjet-f4500-series; \
postscriptdriver-hp;deskjet-f735; \
postscriptdriver-hp;deskjet-ink-adv-2010-k010; \
postscriptdriver-hp;deskjet-ink-adv-2060-k110; \
postscriptdriver-hp;deskjet-ink-advant-k109a-z; \
postscriptdriver-hp;deskjet-ink-advant-k209a-z; \
postscriptdriver-hp;deskjet-plus-4100-series; \
postscriptdriver-hp;deskjet-plus-6000-series; \
postscriptdriver-hp;deskjet-plus-6400-series; \
postscriptdriver-hp;envy-100-d410-series; \
postscriptdriver-hp;envy-110-series; \
postscriptdriver-hp;envy-120-series; \
postscriptdriver-hp;envy-4500-series; \
postscriptdriver-hp;envy-4510-series; \
postscriptdriver-hp;envy-4520-series; \
postscriptdriver-hp;envy-5000-series; \
postscriptdriver-hp;envy-5530-series; \
postscriptdriver-hp;envy-5540-series; \
postscriptdriver-hp;envy-5640-series; \
postscriptdriver-hp;envy-5660-series; \
postscriptdriver-hp;envy-6000-series; \
postscriptdriver-hp;envy-6400-series; \
postscriptdriver-hp;envy-7640-series; \
postscriptdriver-hp;envy-8000-series; \
postscriptdriver-hp;envy-inspire-7200-series; \
postscriptdriver-hp;envy-inspire-7900-series; \
postscriptdriver-hp;envy-photo-6200-series; \
postscriptdriver-hp;envy-photo-7100-series; \
postscriptdriver-hp;envy-photo-7800-series; \
postscriptdriver-hp;envy-pro-6400-series; \
postscriptdriver-hp;fax-2; \
postscriptdriver-hp;fax-3; \
postscriptdriver-hp;fax-4; \
postscriptdriver-hp;fax; \
postscriptdriver-hp;hp-2000c; \
postscriptdriver-hp;hp-2500c; \
postscriptdriver-hp;hp-910; \
postscriptdriver-hp;hp-915; \
postscriptdriver-hp;hp-business-inkjet-1100; \
postscriptdriver-hp;hp-business-inkjet-2200; \
postscriptdriver-hp;hp-business-inkjet-2230; \
postscriptdriver-hp;hp-business-inkjet-2250; \
postscriptdriver-hp;hp-business-inkjet-2280; \
postscriptdriver-hp;hp-business-inkjet-2300; \
postscriptdriver-hp;hp-business-inkjet-2600; \
postscriptdriver-hp;hp-business-inkjet-2800; \
postscriptdriver-hp;hp-business-inkjet-3000; \
postscriptdriver-hp;hp-color-inkjet-printer-cp1700; \
postscriptdriver-hp;hp-deskjet-350; \
postscriptdriver-hp;hp-deskjet-400; \
postscriptdriver-hp;hp-deskjet-400l; \
postscriptdriver-hp;hp-deskjet-450; \
postscriptdriver-hp;hp-deskjet-550c; \
postscriptdriver-hp;hp-deskjet-9300; \
postscriptdriver-hp;hp-laser-ns-1020; \
postscriptdriver-hp;hp-laser-ns-mfp-1005; \
postscriptdriver-hp;hp-mopier-240; \
postscriptdriver-hp;hp-mopier-320; \
postscriptdriver-hp;hp-neverstop-laser-100x; \
postscriptdriver-hp;hp-neverstop-laser-mfp-120x; \
postscriptdriver-hp;hp-officejet-8010-series; \
postscriptdriver-hp;hp-officejet-8020-series; \
postscriptdriver-hp;hp-officejet-8700; \
postscriptdriver-hp;hp-officejet-9010-series; \
postscriptdriver-hp;hp-officejet-pro-8030-series; \
postscriptdriver-hp;hp-officejet-pro-8610; \
postscriptdriver-hp;hp-officejet-pro-8620; \
postscriptdriver-hp;hp-officejet-pro-8630; \
postscriptdriver-hp;hp-officejet-pro-8640; \
postscriptdriver-hp;hp-officejet-pro-8660; \
postscriptdriver-hp;hp-officejet-pro-8710; \
postscriptdriver-hp;hp-officejet-pro-8720; \
postscriptdriver-hp;hp-officejet-pro-9020-series; \
postscriptdriver-hp;hp-pagewide-xl-4000ps-mfp; \
postscriptdriver-hp;hp-pagewide-xl-4000ps; \
postscriptdriver-hp;hp-pagewide-xl-4500ps-mfp; \
postscriptdriver-hp;hp-pagewide-xl-4500ps; \
postscriptdriver-hp;hp-pagewide-xl-5000ps-mfp; \
postscriptdriver-hp;hp-pagewide-xl-5000ps; \
postscriptdriver-hp;hp-pagewide-xl-5100ps-mfp; \
postscriptdriver-hp;hp-pagewide-xl-5100ps; \
postscriptdriver-hp;hp-pagewide-xl-6000ps-mfp; \
postscriptdriver-hp;hp-pagewide-xl-6000ps; \
postscriptdriver-hp;hp-pagewide-xl-8000ps; \
postscriptdriver-hp;hp-pagewide-xl-pro-5200-ps-mfp-series; \
postscriptdriver-hp;hp-pagewide-xl-pro-8200-ps-mfp-series; \
postscriptdriver-hp;hp2250; \
postscriptdriver-hp;hp2280; \
postscriptdriver-hp;hp2300; \
postscriptdriver-hp;hp2600; \
postscriptdriver-hp;hp3000; \
postscriptdriver-hp;ink-tank-110-series; \
postscriptdriver-hp;ink-tank-310-series; \
postscriptdriver-hp;ink-tank-wireless-410-series; \
postscriptdriver-hp;officejet-100-mobile-l411; \
postscriptdriver-hp;officejet-150-mobile-l511; \
postscriptdriver-hp;officejet-200-mobile-series; \
postscriptdriver-hp;officejet-250-mobile-series; \
postscriptdriver-hp;officejet-2620-series; \
postscriptdriver-hp;officejet-3830-series; \
postscriptdriver-hp;officejet-4000-k210; \
postscriptdriver-hp;officejet-4100-series; \
postscriptdriver-hp;officejet-4105; \
postscriptdriver-hp;officejet-4115-series; \
postscriptdriver-hp;officejet-4200-series; \
postscriptdriver-hp;officejet-4255; \
postscriptdriver-hp;officejet-4300-series; \
postscriptdriver-hp;officejet-4400-k410; \
postscriptdriver-hp;officejet-4500-g510a-f; \
postscriptdriver-hp;officejet-4500-g510g-m; \
postscriptdriver-hp;officejet-4500-g510n-z; \
postscriptdriver-hp;officejet-4500-k710; \
postscriptdriver-hp;officejet-4610-series; \
postscriptdriver-hp;officejet-4620-series; \
postscriptdriver-hp;officejet-4630-series; \
postscriptdriver-hp;officejet-4650-series; \
postscriptdriver-hp;officejet-5100-series; \
postscriptdriver-hp;officejet-5200-series; \
postscriptdriver-hp;officejet-5500-series; \
postscriptdriver-hp;officejet-5600-series; \
postscriptdriver-hp;officejet-5740-series; \
postscriptdriver-hp;officejet-6000-e609a; \
postscriptdriver-hp;officejet-6000-e609n; \
postscriptdriver-hp;officejet-6100-series; \
postscriptdriver-hp;officejet-6100; \
postscriptdriver-hp;officejet-6150-series; \
postscriptdriver-hp;officejet-6200-series; \
postscriptdriver-hp;officejet-6300-series; \
postscriptdriver-hp;officejet-6500-e709a; \
postscriptdriver-hp;officejet-6500-e709n; \
postscriptdriver-hp;officejet-6500-e710a-f; \
postscriptdriver-hp;officejet-6500-e710n-z; \
postscriptdriver-hp;officejet-6600; \
postscriptdriver-hp;officejet-6700; \
postscriptdriver-hp;officejet-6800; \
postscriptdriver-hp;officejet-6950; \
postscriptdriver-hp;officejet-6960; \
postscriptdriver-hp;officejet-7000-e809a-series; \
postscriptdriver-hp;officejet-7100-series; \
postscriptdriver-hp;officejet-7110-series; \
postscriptdriver-hp;officejet-7200-series; \
postscriptdriver-hp;officejet-7300-series; \
postscriptdriver-hp;officejet-7400-series; \
postscriptdriver-hp;officejet-7500-e910; \
postscriptdriver-hp;officejet-7510-series; \
postscriptdriver-hp;officejet-7610-series; \
postscriptdriver-hp;officejet-8040-series; \
postscriptdriver-hp;officejet-9100-series; \
postscriptdriver-hp;officejet-d-series; \
postscriptdriver-hp;officejet-g55; \
postscriptdriver-hp;officejet-g55xi; \
postscriptdriver-hp;officejet-g85; \
postscriptdriver-hp;officejet-g85xi; \
postscriptdriver-hp;officejet-g95; \
postscriptdriver-hp;officejet-h470; \
postscriptdriver-hp;officejet-j3500-series; \
postscriptdriver-hp;officejet-j3600-series; \
postscriptdriver-hp;officejet-j4500-series; \
postscriptdriver-hp;officejet-j4660-series; \
postscriptdriver-hp;officejet-j4680-series; \
postscriptdriver-hp;officejet-j5500-series; \
postscriptdriver-hp;officejet-j5700-series; \
postscriptdriver-hp;officejet-j6400-series; \
postscriptdriver-hp;officejet-k60; \
postscriptdriver-hp;officejet-k60xi; \
postscriptdriver-hp;officejet-k7100; \
postscriptdriver-hp;officejet-k80; \
postscriptdriver-hp;officejet-k80xi; \
postscriptdriver-hp;officejet-lx; \
postscriptdriver-hp;officejet-pro-1150c; \
postscriptdriver-hp;officejet-pro-1170c-series; \
postscriptdriver-hp;officejet-pro-3610; \
postscriptdriver-hp;officejet-pro-3620; \
postscriptdriver-hp;officejet-pro-6230; \
postscriptdriver-hp;officejet-pro-6830; \
postscriptdriver-hp;officejet-pro-6960; \
postscriptdriver-hp;officejet-pro-6970; \
postscriptdriver-hp;officejet-pro-7720-series; \
postscriptdriver-hp;officejet-pro-7730-series; \
postscriptdriver-hp;officejet-pro-7740-series; \
postscriptdriver-hp;officejet-pro-8000-a809; \
postscriptdriver-hp;officejet-pro-8020-series; \
postscriptdriver-hp;officejet-pro-8100; \
postscriptdriver-hp;officejet-pro-8500-a909a; \
postscriptdriver-hp;officejet-pro-8500-a909g; \
postscriptdriver-hp;officejet-pro-8500-a909n; \
postscriptdriver-hp;officejet-pro-8500-a910; \
postscriptdriver-hp;officejet-pro-8600; \
postscriptdriver-hp;officejet-pro-9010-series; \
postscriptdriver-hp;officejet-pro-k5300; \
postscriptdriver-hp;officejet-pro-k5400; \
postscriptdriver-hp;officejet-pro-k550; \
postscriptdriver-hp;officejet-pro-k850; \
postscriptdriver-hp;officejet-pro-k8600; \
postscriptdriver-hp;officejet-pro-l7300; \
postscriptdriver-hp;officejet-pro-l7400; \
postscriptdriver-hp;officejet-pro-l7500; \
postscriptdriver-hp;officejet-pro-l7600; \
postscriptdriver-hp;officejet-pro-l7700; \
postscriptdriver-hp;officejet-r40; \
postscriptdriver-hp;officejet-r40xi; \
postscriptdriver-hp;officejet-r45; \
postscriptdriver-hp;officejet-r60; \
postscriptdriver-hp;officejet-r65; \
postscriptdriver-hp;officejet-r80; \
postscriptdriver-hp;officejet-r80xi; \
postscriptdriver-hp;officejet-series-300; \
postscriptdriver-hp;officejet-series-310; \
postscriptdriver-hp;officejet-series-320; \
postscriptdriver-hp;officejet-series-330; \
postscriptdriver-hp;officejet-series-350; \
postscriptdriver-hp;officejet-series-520; \
postscriptdriver-hp;officejet-series-570; \
postscriptdriver-hp;officejet-series-580; \
postscriptdriver-hp;officejet-series-590; \
postscriptdriver-hp;officejet-series-600; \
postscriptdriver-hp;officejet-series-610; \
postscriptdriver-hp;officejet-series-630; \
postscriptdriver-hp;officejet-series-700; \
postscriptdriver-hp;officejet-series-710; \
postscriptdriver-hp;officejet-series-720; \
postscriptdriver-hp;officejet-series-725; \
postscriptdriver-hp;officejet-t-series; \
postscriptdriver-hp;officejet-v30; \
postscriptdriver-hp;officejet-v40; \
postscriptdriver-hp;officejet-v40xi; \
postscriptdriver-hp;officejet-v45; \
postscriptdriver-hp;officejet; \
postscriptdriver-hp;photosmart-100; \
postscriptdriver-hp;photosmart-1115; \
postscriptdriver-hp;photosmart-1215; \
postscriptdriver-hp;photosmart-1218; \
postscriptdriver-hp;photosmart-130; \
postscriptdriver-hp;photosmart-1315; \
postscriptdriver-hp;photosmart-140-series; \
postscriptdriver-hp;photosmart-230; \
postscriptdriver-hp;photosmart-240-series; \
postscriptdriver-hp;photosmart-2570-series; \
postscriptdriver-hp;photosmart-2600-series; \
postscriptdriver-hp;photosmart-2700-series; \
postscriptdriver-hp;photosmart-3100-series; \
postscriptdriver-hp;photosmart-320-series; \
postscriptdriver-hp;photosmart-3200-series; \
postscriptdriver-hp;photosmart-330-series; \
postscriptdriver-hp;photosmart-3300-series; \
postscriptdriver-hp;photosmart-370-series; \
postscriptdriver-hp;photosmart-380-series; \
postscriptdriver-hp;photosmart-420-series; \
postscriptdriver-hp;photosmart-470-series; \
postscriptdriver-hp;photosmart-5510-series; \
postscriptdriver-hp;photosmart-5510d-series; \
postscriptdriver-hp;photosmart-5520-series; \
postscriptdriver-hp;photosmart-6510-series; \
postscriptdriver-hp;photosmart-6520-series; \
postscriptdriver-hp;photosmart-7200-series; \
postscriptdriver-hp;photosmart-7345; \
postscriptdriver-hp;photosmart-7400-series; \
postscriptdriver-hp;photosmart-7510-series; \
postscriptdriver-hp;photosmart-7520-series; \
postscriptdriver-hp;photosmart-7550; \
postscriptdriver-hp;photosmart-7600-series; \
postscriptdriver-hp;photosmart-7700-series; \
postscriptdriver-hp;photosmart-7800-series; \
postscriptdriver-hp;photosmart-7900-series; \
postscriptdriver-hp;photosmart-8000-series; \
postscriptdriver-hp;photosmart-8100-series; \
postscriptdriver-hp;photosmart-8200-series; \
postscriptdriver-hp;photosmart-8400-series; \
postscriptdriver-hp;photosmart-8700-series; \
postscriptdriver-hp;photosmart-a310-series; \
postscriptdriver-hp;photosmart-a320-series; \
postscriptdriver-hp;photosmart-a430-series; \
postscriptdriver-hp;photosmart-a440-series; \
postscriptdriver-hp;photosmart-a510-series; \
postscriptdriver-hp;photosmart-a520-series; \
postscriptdriver-hp;photosmart-a530-series; \
postscriptdriver-hp;photosmart-a610-series; \
postscriptdriver-hp;photosmart-a620-series; \
postscriptdriver-hp;photosmart-a630-series; \
postscriptdriver-hp;photosmart-a640-series; \
postscriptdriver-hp;photosmart-a710-series; \
postscriptdriver-hp;photosmart-a820-series; \
postscriptdriver-hp;photosmart-b010-series; \
postscriptdriver-hp;photosmart-b109a-series; \
postscriptdriver-hp;photosmart-b110-series; \
postscriptdriver-hp;photosmart-b8500-series; \
postscriptdriver-hp;photosmart-c309a-series; \
postscriptdriver-hp;photosmart-c3100-series; \
postscriptdriver-hp;photosmart-c4100-series; \
postscriptdriver-hp;photosmart-c4200-series; \
postscriptdriver-hp;photosmart-c4340-series; \
postscriptdriver-hp;photosmart-c4380-series; \
postscriptdriver-hp;photosmart-c4400-series; \
postscriptdriver-hp;photosmart-c4500-series; \
postscriptdriver-hp;photosmart-c4600-series; \
postscriptdriver-hp;photosmart-c4700-series; \
postscriptdriver-hp;photosmart-c5100-series; \
postscriptdriver-hp;photosmart-c5200-series; \
postscriptdriver-hp;photosmart-c5300-series; \
postscriptdriver-hp;photosmart-c5500-series; \
postscriptdriver-hp;photosmart-c6100-series; \
postscriptdriver-hp;photosmart-c6200-series; \
postscriptdriver-hp;photosmart-c6300-series; \
postscriptdriver-hp;photosmart-c7100-series; \
postscriptdriver-hp;photosmart-c7200-series; \
postscriptdriver-hp;photosmart-c8100-series; \
postscriptdriver-hp;photosmart-d110-series; \
postscriptdriver-hp;photosmart-d5060-series; \
postscriptdriver-hp;photosmart-d5100-series; \
postscriptdriver-hp;photosmart-d5300-series; \
postscriptdriver-hp;photosmart-d5400-series; \
postscriptdriver-hp;photosmart-d6100-series; \
postscriptdriver-hp;photosmart-d7100-series; \
postscriptdriver-hp;photosmart-d7200-series; \
postscriptdriver-hp;photosmart-d7300-series; \
postscriptdriver-hp;photosmart-d7400-series; \
postscriptdriver-hp;photosmart-d7500-series; \
postscriptdriver-hp;photosmart-estn-c510-series; \
postscriptdriver-hp;photosmart-ink-adv-k510; \
postscriptdriver-hp;photosmart-p1000; \
postscriptdriver-hp;photosmart-p1100; \
postscriptdriver-hp;photosmart-plus-b209a-m; \
postscriptdriver-hp;photosmart-plus-b210-series; \
postscriptdriver-hp;photosmart-prem-c310-series; \
postscriptdriver-hp;photosmart-prem-c410-series; \
postscriptdriver-hp;photosmart-prem-web-c309n-s; \
postscriptdriver-hp;photosmart-premium-c309g-m; \
postscriptdriver-hp;photosmart-pro-b8300-series; \
postscriptdriver-hp;photosmart-pro-b8800-series; \
postscriptdriver-hp;photosmart-wireless-b109n-z; \
postscriptdriver-hp;printer-scanner-copier-300; \
postscriptdriver-hp;psc-1000-series; \
postscriptdriver-hp;psc-1100-series; \
postscriptdriver-hp;psc-1200-series; \
postscriptdriver-hp;psc-1300-series; \
postscriptdriver-hp;psc-1310-series; \
postscriptdriver-hp;psc-1358-series; \
postscriptdriver-hp;psc-1400-series; \
postscriptdriver-hp;psc-1500-series; \
postscriptdriver-hp;psc-1600-series; \
postscriptdriver-hp;psc-2100-series; \
postscriptdriver-hp;psc-2150-series; \
postscriptdriver-hp;psc-2170-series; \
postscriptdriver-hp;psc-2200-series; \
postscriptdriver-hp;psc-2210-series; \
postscriptdriver-hp;psc-2300-series; \
postscriptdriver-hp;psc-2350-series; \
postscriptdriver-hp;psc-2400-series; \
postscriptdriver-hp;psc-2500-series; \
postscriptdriver-hp;psc-500; \
postscriptdriver-hp;psc-720; \
postscriptdriver-hp;psc-750; \
postscriptdriver-hp;psc-750xi; \
postscriptdriver-hp;psc-760; \
postscriptdriver-hp;psc-780; \
postscriptdriver-hp;psc-780xi; \
postscriptdriver-hp;psc-900-series; \
postscriptdriver-hp;psc-920; \
postscriptdriver-hp;psc-950; \
postscriptdriver-hp;psc-950vr; \
postscriptdriver-hp;psc-950xi; \
postscriptdriver-hp;smart-tank-350-series; \
postscriptdriver-hp;smart-tank-500-series; \
postscriptdriver-hp;smart-tank-510-series; \
postscriptdriver-hp;smart-tank-530-series; \
postscriptdriver-hp;smart-tank-6000-series; \
postscriptdriver-hp;smart-tank-610-series; \
postscriptdriver-hp;smart-tank-660-670-series; \
postscriptdriver-hp;smart-tank-7000-series; \
postscriptdriver-hp;smart-tank-710-720-series; \
postscriptdriver-hp;smart-tank-7300-series; \
postscriptdriver-hp;smart-tank-750-series; \
postscriptdriver-hp;smart-tank-7600-series; \
postscriptdriver-hp;smart-tank-790-series; \
postscriptdriver-hp;smart-tank-plus-550-series; \
postscriptdriver-hp;smart-tank-plus-570-series; \
postscriptdriver-hp;smart-tank-plus-650-series; \
postscriptdriver-hp;smart-tank-wireless-450-series; \
postscriptdriver-hp;tango;"

RDEPENDS:${PN} += "/usr/bin/bash \
/usr/bin/python3 \
hplip-udev-rules \
ld-linux-aarch64.so.1 \
libavahi-client.so.3 \
libavahi-common.so.3 \
libc.so.6 \
libcups.so.2 \
libdbus-1.so.3 \
libgcc-s.so.1 \
libjpeg.so.8 \
libm.so.6 \
libnetsnmp.so.40 \
libstdc++.so.6 \
libusb-1.0.so.0 \
libz.so.1"

inherit rpm
