SUMMARY = "LinguisticsPro fonts with LaTeX support"
DESCRIPTION = "The package provides LaTeX, pdfLaTeX, XeLaTeX and LuaLaTeX \
support for the LinguisticsPro family of fonts. This family is \
derived from the Utopia Nova font family, by Andreas Nolda."
LICENSE = "LPPL-1.0"

PV = "2023.209.svn64858"

RPM_NAME = "texlive-linguisticspro-2023.209.svn64858-55.1.noarch.rpm"
RPM_HASH = "0ed9b96b69ac7f13d04f97386118864c629f20ff36ab656414fc98a4cb3dfd8b188fd811b5d6855d276c6bd00db1766874ca4be7ba052bf2be083d352e5cedd5"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-LGRLinguisticsPro-LF.fd \
tex-LGRLinguisticsPro-OsF.fd \
tex-LY1LinguisticsPro-LF.fd \
tex-LY1LinguisticsPro-OsF.fd \
tex-LinguisticsPro-Bold-lf-lgr.tfm \
tex-LinguisticsPro-Bold-lf-ly1.tfm \
tex-LinguisticsPro-Bold-lf-ot1.tfm \
tex-LinguisticsPro-Bold-lf-t1--base.tfm \
tex-LinguisticsPro-Bold-lf-t1.tfm \
tex-LinguisticsPro-Bold-lf-t1.vf \
tex-LinguisticsPro-Bold-lf-t2a.tfm \
tex-LinguisticsPro-Bold-lf-t2b.tfm \
tex-LinguisticsPro-Bold-lf-t2c.tfm \
tex-LinguisticsPro-Bold-lf-t3--base.tfm \
tex-LinguisticsPro-Bold-lf-t3.tfm \
tex-LinguisticsPro-Bold-lf-t3.vf \
tex-LinguisticsPro-Bold-lf-ts1--base.tfm \
tex-LinguisticsPro-Bold-lf-ts1.tfm \
tex-LinguisticsPro-Bold-lf-ts1.vf \
tex-LinguisticsPro-Bold-lf-ts3.tfm \
tex-LinguisticsPro-Bold-osf-lgr.tfm \
tex-LinguisticsPro-Bold-osf-ly1.tfm \
tex-LinguisticsPro-Bold-osf-ot1.tfm \
tex-LinguisticsPro-Bold-osf-t1--base.tfm \
tex-LinguisticsPro-Bold-osf-t1.tfm \
tex-LinguisticsPro-Bold-osf-t1.vf \
tex-LinguisticsPro-Bold-osf-t2a.tfm \
tex-LinguisticsPro-Bold-osf-t2b.tfm \
tex-LinguisticsPro-Bold-osf-t2c.tfm \
tex-LinguisticsPro-Bold-osf-t3--base.tfm \
tex-LinguisticsPro-Bold-osf-t3.tfm \
tex-LinguisticsPro-Bold-osf-t3.vf \
tex-LinguisticsPro-Bold-osf-ts1--base.tfm \
tex-LinguisticsPro-Bold-osf-ts1.tfm \
tex-LinguisticsPro-Bold-osf-ts1.vf \
tex-LinguisticsPro-Bold-osf-ts3.tfm \
tex-LinguisticsPro-BoldItalic-lf-lgr.tfm \
tex-LinguisticsPro-BoldItalic-lf-ly1.tfm \
tex-LinguisticsPro-BoldItalic-lf-ot1.tfm \
tex-LinguisticsPro-BoldItalic-lf-t1--base.tfm \
tex-LinguisticsPro-BoldItalic-lf-t1.tfm \
tex-LinguisticsPro-BoldItalic-lf-t1.vf \
tex-LinguisticsPro-BoldItalic-lf-t2a.tfm \
tex-LinguisticsPro-BoldItalic-lf-t2b.tfm \
tex-LinguisticsPro-BoldItalic-lf-t2c.tfm \
tex-LinguisticsPro-BoldItalic-lf-t3--base.tfm \
tex-LinguisticsPro-BoldItalic-lf-t3.tfm \
tex-LinguisticsPro-BoldItalic-lf-t3.vf \
tex-LinguisticsPro-BoldItalic-lf-ts1--base.tfm \
tex-LinguisticsPro-BoldItalic-lf-ts1.tfm \
tex-LinguisticsPro-BoldItalic-lf-ts1.vf \
tex-LinguisticsPro-BoldItalic-lf-ts3.tfm \
tex-LinguisticsPro-BoldItalic-osf-lgr.tfm \
tex-LinguisticsPro-BoldItalic-osf-ly1.tfm \
tex-LinguisticsPro-BoldItalic-osf-ot1.tfm \
tex-LinguisticsPro-BoldItalic-osf-t1--base.tfm \
tex-LinguisticsPro-BoldItalic-osf-t1.tfm \
tex-LinguisticsPro-BoldItalic-osf-t1.vf \
tex-LinguisticsPro-BoldItalic-osf-t2a.tfm \
tex-LinguisticsPro-BoldItalic-osf-t2b.tfm \
tex-LinguisticsPro-BoldItalic-osf-t2c.tfm \
tex-LinguisticsPro-BoldItalic-osf-t3--base.tfm \
tex-LinguisticsPro-BoldItalic-osf-t3.tfm \
tex-LinguisticsPro-BoldItalic-osf-t3.vf \
tex-LinguisticsPro-BoldItalic-osf-ts1--base.tfm \
tex-LinguisticsPro-BoldItalic-osf-ts1.tfm \
tex-LinguisticsPro-BoldItalic-osf-ts1.vf \
tex-LinguisticsPro-BoldItalic-osf-ts3.tfm \
tex-LinguisticsPro-Italic-lf-lgr.tfm \
tex-LinguisticsPro-Italic-lf-ly1.tfm \
tex-LinguisticsPro-Italic-lf-ot1.tfm \
tex-LinguisticsPro-Italic-lf-t1--base.tfm \
tex-LinguisticsPro-Italic-lf-t1.tfm \
tex-LinguisticsPro-Italic-lf-t1.vf \
tex-LinguisticsPro-Italic-lf-t2a.tfm \
tex-LinguisticsPro-Italic-lf-t2b.tfm \
tex-LinguisticsPro-Italic-lf-t2c.tfm \
tex-LinguisticsPro-Italic-lf-t3--base.tfm \
tex-LinguisticsPro-Italic-lf-t3.tfm \
tex-LinguisticsPro-Italic-lf-t3.vf \
tex-LinguisticsPro-Italic-lf-ts1--base.tfm \
tex-LinguisticsPro-Italic-lf-ts1.tfm \
tex-LinguisticsPro-Italic-lf-ts1.vf \
tex-LinguisticsPro-Italic-lf-ts3.tfm \
tex-LinguisticsPro-Italic-osf-lgr.tfm \
tex-LinguisticsPro-Italic-osf-ly1.tfm \
tex-LinguisticsPro-Italic-osf-ot1.tfm \
tex-LinguisticsPro-Italic-osf-t1--base.tfm \
tex-LinguisticsPro-Italic-osf-t1.tfm \
tex-LinguisticsPro-Italic-osf-t1.vf \
tex-LinguisticsPro-Italic-osf-t2a.tfm \
tex-LinguisticsPro-Italic-osf-t2b.tfm \
tex-LinguisticsPro-Italic-osf-t2c.tfm \
tex-LinguisticsPro-Italic-osf-t3--base.tfm \
tex-LinguisticsPro-Italic-osf-t3.tfm \
tex-LinguisticsPro-Italic-osf-t3.vf \
tex-LinguisticsPro-Italic-osf-ts1--base.tfm \
tex-LinguisticsPro-Italic-osf-ts1.tfm \
tex-LinguisticsPro-Italic-osf-ts1.vf \
tex-LinguisticsPro-Italic-osf-ts3.tfm \
tex-LinguisticsPro-Regular-lf-lgr.tfm \
tex-LinguisticsPro-Regular-lf-ly1.tfm \
tex-LinguisticsPro-Regular-lf-ot1.tfm \
tex-LinguisticsPro-Regular-lf-sc-lgr.tfm \
tex-LinguisticsPro-Regular-lf-sc-ly1--base.tfm \
tex-LinguisticsPro-Regular-lf-sc-ly1.tfm \
tex-LinguisticsPro-Regular-lf-sc-ly1.vf \
tex-LinguisticsPro-Regular-lf-sc-ot1--base.tfm \
tex-LinguisticsPro-Regular-lf-sc-ot1.tfm \
tex-LinguisticsPro-Regular-lf-sc-ot1.vf \
tex-LinguisticsPro-Regular-lf-sc-t1--base.tfm \
tex-LinguisticsPro-Regular-lf-sc-t1.tfm \
tex-LinguisticsPro-Regular-lf-sc-t1.vf \
tex-LinguisticsPro-Regular-lf-sc-t2a.tfm \
tex-LinguisticsPro-Regular-lf-sc-t2b.tfm \
tex-LinguisticsPro-Regular-lf-sc-t2c.tfm \
tex-LinguisticsPro-Regular-lf-sc-t3--base.tfm \
tex-LinguisticsPro-Regular-lf-sc-t3.tfm \
tex-LinguisticsPro-Regular-lf-sc-t3.vf \
tex-LinguisticsPro-Regular-lf-sc-ts3.tfm \
tex-LinguisticsPro-Regular-lf-t1--base.tfm \
tex-LinguisticsPro-Regular-lf-t1.tfm \
tex-LinguisticsPro-Regular-lf-t1.vf \
tex-LinguisticsPro-Regular-lf-t2a.tfm \
tex-LinguisticsPro-Regular-lf-t2b.tfm \
tex-LinguisticsPro-Regular-lf-t2c.tfm \
tex-LinguisticsPro-Regular-lf-t3--base.tfm \
tex-LinguisticsPro-Regular-lf-t3.tfm \
tex-LinguisticsPro-Regular-lf-t3.vf \
tex-LinguisticsPro-Regular-lf-ts1--base.tfm \
tex-LinguisticsPro-Regular-lf-ts1.tfm \
tex-LinguisticsPro-Regular-lf-ts1.vf \
tex-LinguisticsPro-Regular-lf-ts3.tfm \
tex-LinguisticsPro-Regular-osf-lgr.tfm \
tex-LinguisticsPro-Regular-osf-ly1.tfm \
tex-LinguisticsPro-Regular-osf-ot1.tfm \
tex-LinguisticsPro-Regular-osf-sc-lgr.tfm \
tex-LinguisticsPro-Regular-osf-sc-ly1--base.tfm \
tex-LinguisticsPro-Regular-osf-sc-ly1.tfm \
tex-LinguisticsPro-Regular-osf-sc-ly1.vf \
tex-LinguisticsPro-Regular-osf-sc-ot1--base.tfm \
tex-LinguisticsPro-Regular-osf-sc-ot1.tfm \
tex-LinguisticsPro-Regular-osf-sc-ot1.vf \
tex-LinguisticsPro-Regular-osf-sc-t1--base.tfm \
tex-LinguisticsPro-Regular-osf-sc-t1.tfm \
tex-LinguisticsPro-Regular-osf-sc-t1.vf \
tex-LinguisticsPro-Regular-osf-sc-t2a.tfm \
tex-LinguisticsPro-Regular-osf-sc-t2b.tfm \
tex-LinguisticsPro-Regular-osf-sc-t2c.tfm \
tex-LinguisticsPro-Regular-osf-sc-t3--base.tfm \
tex-LinguisticsPro-Regular-osf-sc-t3.tfm \
tex-LinguisticsPro-Regular-osf-sc-t3.vf \
tex-LinguisticsPro-Regular-osf-sc-ts3.tfm \
tex-LinguisticsPro-Regular-osf-t1--base.tfm \
tex-LinguisticsPro-Regular-osf-t1.tfm \
tex-LinguisticsPro-Regular-osf-t1.vf \
tex-LinguisticsPro-Regular-osf-t2a.tfm \
tex-LinguisticsPro-Regular-osf-t2b.tfm \
tex-LinguisticsPro-Regular-osf-t2c.tfm \
tex-LinguisticsPro-Regular-osf-t3--base.tfm \
tex-LinguisticsPro-Regular-osf-t3.tfm \
tex-LinguisticsPro-Regular-osf-t3.vf \
tex-LinguisticsPro-Regular-osf-ts1--base.tfm \
tex-LinguisticsPro-Regular-osf-ts1.tfm \
tex-LinguisticsPro-Regular-osf-ts1.vf \
tex-LinguisticsPro-Regular-osf-ts3.tfm \
tex-LinguisticsPro.map \
tex-OT1LinguisticsPro-LF.fd \
tex-OT1LinguisticsPro-OsF.fd \
tex-T1LinguisticsPro-LF.fd \
tex-T1LinguisticsPro-OsF.fd \
tex-T2ALinguisticsPro-LF.fd \
tex-T2ALinguisticsPro-OsF.fd \
tex-T2BLinguisticsPro-LF.fd \
tex-T2BLinguisticsPro-OsF.fd \
tex-T2CLinguisticsPro-LF.fd \
tex-T2CLinguisticsPro-OsF.fd \
tex-T3LinguisticsPro-LF.fd \
tex-T3LinguisticsPro-OsF.fd \
tex-TS1LinguisticsPro-LF.fd \
tex-TS1LinguisticsPro-OsF.fd \
tex-TS3LinguisticsPro-LF.fd \
tex-TS3LinguisticsPro-OsF.fd \
tex-linguisticspro.sty \
tex-lnpr-2dchsz.enc \
tex-lnpr-2io6ub.enc \
tex-lnpr-2mzpfv.enc \
tex-lnpr-2sam6o.enc \
tex-lnpr-3ifnsw.enc \
tex-lnpr-4slpb2.enc \
tex-lnpr-5g7sdz.enc \
tex-lnpr-6eapwe.enc \
tex-lnpr-6ezgzr.enc \
tex-lnpr-7s35zn.enc \
tex-lnpr-bylpnz.enc \
tex-lnpr-c3wdkv.enc \
tex-lnpr-c5y55d.enc \
tex-lnpr-clyilc.enc \
tex-lnpr-ctp5bu.enc \
tex-lnpr-d5qjpp.enc \
tex-lnpr-ehss4d.enc \
tex-lnpr-elz76p.enc \
tex-lnpr-fxbwbp.enc \
tex-lnpr-i7qe4r.enc \
tex-lnpr-jlizdj.enc \
tex-lnpr-jvdtnb.enc \
tex-lnpr-klqkbd.enc \
tex-lnpr-mptstw.enc \
tex-lnpr-n5uv5s.enc \
tex-lnpr-n7rfoz.enc \
tex-lnpr-niynhd.enc \
tex-lnpr-o6z2fv.enc \
tex-lnpr-olwjlf.enc \
tex-lnpr-p6qnqd.enc \
tex-lnpr-pcxklf.enc \
tex-lnpr-pq5q4e.enc \
tex-lnpr-q4n4m4.enc \
tex-lnpr-qzkx3x.enc \
tex-lnpr-rozyzo.enc \
tex-lnpr-rqjpbq.enc \
tex-lnpr-rr27g2.enc \
tex-lnpr-rwq5kg.enc \
tex-lnpr-syddkj.enc \
tex-lnpr-t2hwm2.enc \
tex-lnpr-tdl523.enc \
tex-lnpr-usrmsl.enc \
tex-lnpr-vfi6fz.enc \
tex-lnpr-vycqam.enc \
tex-lnpr-waxsla.enc \
tex-lnpr-whgjeg.enc \
tex-lnpr-whn5dx.enc \
tex-lnpr-wo5mze.enc \
tex-lnpr-wsrlge.enc \
tex-lnpr-wsw7yh.enc \
tex-lnpr-xexdze.enc \
tex-lnpr-xr332d.enc \
tex-lnpr-xv6zbl.enc \
tex-lnpr-y6ghoo.enc \
tex-lnpr-ydj4q2.enc \
texlive-linguisticspro"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontaxes.sty \
tex-fontenc.sty \
tex-fontspec.sty \
tex-ifluatex.sty \
tex-ifxetex.sty \
tex-mweights.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-linguisticspro-fonts \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
