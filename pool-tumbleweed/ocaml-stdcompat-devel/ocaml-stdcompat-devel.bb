SUMMARY = "Development files for ocaml-stdcompat"
DESCRIPTION = "The ocaml-stdcompat-devel package contains libraries and signature files for \
developing applications that use ocaml-stdcompat."
LICENSE = "BSD-2-Clause"

PV = "19"

RPM_NAME = "ocaml-stdcompat-devel-19-2.4.aarch64.rpm"
RPM_HASH = "bbec8de01ff0cac61ed30a7c0b2d5f6d3c1fdd834b329c4252c5932aa8f799345ffdf833ebd2685bc95a419a91a0f908f1acd819875367849c2e9cc8f122eeba"

RPROVIDES:${PN} += "ocaml-Stdcompat \
ocaml-Stdcompat--arg \
ocaml-Stdcompat--arg-s \
ocaml-Stdcompat--array \
ocaml-Stdcompat--array-s \
ocaml-Stdcompat--arrayLabels \
ocaml-Stdcompat--arrayLabels-s \
ocaml-Stdcompat--atomic \
ocaml-Stdcompat--atomic-s \
ocaml-Stdcompat--bool \
ocaml-Stdcompat--bool-s \
ocaml-Stdcompat--buffer \
ocaml-Stdcompat--buffer-s \
ocaml-Stdcompat--bytes \
ocaml-Stdcompat--bytes-s \
ocaml-Stdcompat--bytesLabels \
ocaml-Stdcompat--bytesLabels-s \
ocaml-Stdcompat--char \
ocaml-Stdcompat--char-s \
ocaml-Stdcompat--digest \
ocaml-Stdcompat--digest-s \
ocaml-Stdcompat--either \
ocaml-Stdcompat--either-s \
ocaml-Stdcompat--ephemeron \
ocaml-Stdcompat--ephemeron-s \
ocaml-Stdcompat--filename \
ocaml-Stdcompat--filename-s \
ocaml-Stdcompat--float \
ocaml-Stdcompat--float-s \
ocaml-Stdcompat--format \
ocaml-Stdcompat--format-s \
ocaml-Stdcompat--fun \
ocaml-Stdcompat--fun-s \
ocaml-Stdcompat--hashtbl \
ocaml-Stdcompat--hashtbl-ext \
ocaml-Stdcompat--hashtbl-s \
ocaml-Stdcompat--in-channel \
ocaml-Stdcompat--in-channel-s \
ocaml-Stdcompat--init \
ocaml-Stdcompat--int \
ocaml-Stdcompat--int-s \
ocaml-Stdcompat--int32 \
ocaml-Stdcompat--int32-s \
ocaml-Stdcompat--int64 \
ocaml-Stdcompat--int64-s \
ocaml-Stdcompat--lazy \
ocaml-Stdcompat--lazy-s \
ocaml-Stdcompat--lexing \
ocaml-Stdcompat--lexing-s \
ocaml-Stdcompat--list \
ocaml-Stdcompat--list-s \
ocaml-Stdcompat--listLabels \
ocaml-Stdcompat--listLabels-s \
ocaml-Stdcompat--map \
ocaml-Stdcompat--map-s \
ocaml-Stdcompat--moreLabels \
ocaml-Stdcompat--moreLabels-s \
ocaml-Stdcompat--native \
ocaml-Stdcompat--nativeint \
ocaml-Stdcompat--nativeint-s \
ocaml-Stdcompat--option \
ocaml-Stdcompat--option-s \
ocaml-Stdcompat--out-channel \
ocaml-Stdcompat--out-channel-s \
ocaml-Stdcompat--pervasives \
ocaml-Stdcompat--pervasives-s \
ocaml-Stdcompat--printexc \
ocaml-Stdcompat--printexc-s \
ocaml-Stdcompat--printf \
ocaml-Stdcompat--printf-s \
ocaml-Stdcompat--queue \
ocaml-Stdcompat--queue-s \
ocaml-Stdcompat--random \
ocaml-Stdcompat--random-s \
ocaml-Stdcompat--result \
ocaml-Stdcompat--result-s \
ocaml-Stdcompat--root \
ocaml-Stdcompat--seq \
ocaml-Stdcompat--seq-s \
ocaml-Stdcompat--set \
ocaml-Stdcompat--set-s \
ocaml-Stdcompat--stack \
ocaml-Stdcompat--stack-s \
ocaml-Stdcompat--stdlib \
ocaml-Stdcompat--stdlib-s \
ocaml-Stdcompat--string \
ocaml-Stdcompat--string-s \
ocaml-Stdcompat--stringLabels \
ocaml-Stdcompat--stringLabels-s \
ocaml-Stdcompat--sys \
ocaml-Stdcompat--sys-s \
ocaml-Stdcompat--tools \
ocaml-Stdcompat--uchar \
ocaml-Stdcompat--uchar-s \
ocaml-Stdcompat--unit \
ocaml-Stdcompat--unit-s \
ocaml-Stdcompat--weak \
ocaml-Stdcompat--weak-s \
ocaml-stdcompat-devel \
ocamlfind-stdcompat \
ocamlx-Stdcompat \
ocamlx-Stdcompat--arg \
ocamlx-Stdcompat--arg-s \
ocamlx-Stdcompat--array \
ocamlx-Stdcompat--array-s \
ocamlx-Stdcompat--arrayLabels \
ocamlx-Stdcompat--arrayLabels-s \
ocamlx-Stdcompat--atomic \
ocamlx-Stdcompat--atomic-s \
ocamlx-Stdcompat--bool \
ocamlx-Stdcompat--bool-s \
ocamlx-Stdcompat--buffer \
ocamlx-Stdcompat--buffer-s \
ocamlx-Stdcompat--bytes \
ocamlx-Stdcompat--bytes-s \
ocamlx-Stdcompat--bytesLabels \
ocamlx-Stdcompat--bytesLabels-s \
ocamlx-Stdcompat--char \
ocamlx-Stdcompat--char-s \
ocamlx-Stdcompat--digest \
ocamlx-Stdcompat--digest-s \
ocamlx-Stdcompat--either \
ocamlx-Stdcompat--either-s \
ocamlx-Stdcompat--ephemeron \
ocamlx-Stdcompat--ephemeron-s \
ocamlx-Stdcompat--filename \
ocamlx-Stdcompat--filename-s \
ocamlx-Stdcompat--float \
ocamlx-Stdcompat--float-s \
ocamlx-Stdcompat--format \
ocamlx-Stdcompat--format-s \
ocamlx-Stdcompat--fun \
ocamlx-Stdcompat--fun-s \
ocamlx-Stdcompat--hashtbl \
ocamlx-Stdcompat--hashtbl-ext \
ocamlx-Stdcompat--hashtbl-s \
ocamlx-Stdcompat--in-channel \
ocamlx-Stdcompat--in-channel-s \
ocamlx-Stdcompat--init \
ocamlx-Stdcompat--int \
ocamlx-Stdcompat--int-s \
ocamlx-Stdcompat--int32 \
ocamlx-Stdcompat--int32-s \
ocamlx-Stdcompat--int64 \
ocamlx-Stdcompat--int64-s \
ocamlx-Stdcompat--lazy \
ocamlx-Stdcompat--lazy-s \
ocamlx-Stdcompat--lexing \
ocamlx-Stdcompat--lexing-s \
ocamlx-Stdcompat--list \
ocamlx-Stdcompat--list-s \
ocamlx-Stdcompat--listLabels \
ocamlx-Stdcompat--listLabels-s \
ocamlx-Stdcompat--map \
ocamlx-Stdcompat--map-s \
ocamlx-Stdcompat--moreLabels \
ocamlx-Stdcompat--moreLabels-s \
ocamlx-Stdcompat--native \
ocamlx-Stdcompat--nativeint \
ocamlx-Stdcompat--nativeint-s \
ocamlx-Stdcompat--option \
ocamlx-Stdcompat--option-s \
ocamlx-Stdcompat--out-channel \
ocamlx-Stdcompat--out-channel-s \
ocamlx-Stdcompat--pervasives \
ocamlx-Stdcompat--pervasives-s \
ocamlx-Stdcompat--printexc \
ocamlx-Stdcompat--printexc-s \
ocamlx-Stdcompat--printf \
ocamlx-Stdcompat--printf-s \
ocamlx-Stdcompat--queue \
ocamlx-Stdcompat--queue-s \
ocamlx-Stdcompat--random \
ocamlx-Stdcompat--random-s \
ocamlx-Stdcompat--result \
ocamlx-Stdcompat--result-s \
ocamlx-Stdcompat--root \
ocamlx-Stdcompat--seq \
ocamlx-Stdcompat--seq-s \
ocamlx-Stdcompat--set \
ocamlx-Stdcompat--set-s \
ocamlx-Stdcompat--stack \
ocamlx-Stdcompat--stack-s \
ocamlx-Stdcompat--stdlib \
ocamlx-Stdcompat--stdlib-s \
ocamlx-Stdcompat--string \
ocamlx-Stdcompat--string-s \
ocamlx-Stdcompat--stringLabels \
ocamlx-Stdcompat--stringLabels-s \
ocamlx-Stdcompat--sys \
ocamlx-Stdcompat--sys-s \
ocamlx-Stdcompat--tools \
ocamlx-Stdcompat--uchar \
ocamlx-Stdcompat--uchar-s \
ocamlx-Stdcompat--unit \
ocamlx-Stdcompat--unit-s \
ocamlx-Stdcompat--weak \
ocamlx-Stdcompat--weak-s"

RDEPENDS:${PN} += "ocaml-CamlinternalFormatBasics \
ocaml-CamlinternalLazy \
ocaml-CamlinternalOO \
ocaml-Stdlib \
ocaml-Stdlib--Arg \
ocaml-Stdlib--Array \
ocaml-Stdlib--ArrayLabels \
ocaml-Stdlib--Atomic \
ocaml-Stdlib--Bool \
ocaml-Stdlib--Buffer \
ocaml-Stdlib--Bytes \
ocaml-Stdlib--Callback \
ocaml-Stdlib--Char \
ocaml-Stdlib--Complex \
ocaml-Stdlib--Digest \
ocaml-Stdlib--Either \
ocaml-Stdlib--Filename \
ocaml-Stdlib--Float \
ocaml-Stdlib--Format \
ocaml-Stdlib--Fun \
ocaml-Stdlib--Gc \
ocaml-Stdlib--Hashtbl \
ocaml-Stdlib--In-channel \
ocaml-Stdlib--Int \
ocaml-Stdlib--Int32 \
ocaml-Stdlib--Int64 \
ocaml-Stdlib--Lazy \
ocaml-Stdlib--Lexing \
ocaml-Stdlib--List \
ocaml-Stdlib--Map \
ocaml-Stdlib--MoreLabels \
ocaml-Stdlib--Nativeint \
ocaml-Stdlib--Obj \
ocaml-Stdlib--Oo \
ocaml-Stdlib--Option \
ocaml-Stdlib--Out-channel \
ocaml-Stdlib--Parsing \
ocaml-Stdlib--Printexc \
ocaml-Stdlib--Printf \
ocaml-Stdlib--Queue \
ocaml-Stdlib--Random \
ocaml-Stdlib--Result \
ocaml-Stdlib--Scanf \
ocaml-Stdlib--Seq \
ocaml-Stdlib--Set \
ocaml-Stdlib--Stack \
ocaml-Stdlib--String \
ocaml-Stdlib--Sys \
ocaml-Stdlib--Uchar \
ocaml-Stdlib--Unit \
ocaml-Stdlib--Weak \
ocaml-stdcompat \
ocamlx-Stdlib \
ocamlx-Stdlib--Arg \
ocamlx-Stdlib--Array \
ocamlx-Stdlib--Atomic \
ocamlx-Stdlib--Bool \
ocamlx-Stdlib--Buffer \
ocamlx-Stdlib--Bytes \
ocamlx-Stdlib--Callback \
ocamlx-Stdlib--Char \
ocamlx-Stdlib--Complex \
ocamlx-Stdlib--Digest \
ocamlx-Stdlib--Either \
ocamlx-Stdlib--Filename \
ocamlx-Stdlib--Float \
ocamlx-Stdlib--Format \
ocamlx-Stdlib--Fun \
ocamlx-Stdlib--Gc \
ocamlx-Stdlib--Hashtbl \
ocamlx-Stdlib--In-channel \
ocamlx-Stdlib--Int \
ocamlx-Stdlib--Int32 \
ocamlx-Stdlib--Int64 \
ocamlx-Stdlib--Lazy \
ocamlx-Stdlib--Lexing \
ocamlx-Stdlib--List \
ocamlx-Stdlib--Nativeint \
ocamlx-Stdlib--Obj \
ocamlx-Stdlib--Oo \
ocamlx-Stdlib--Option \
ocamlx-Stdlib--Out-channel \
ocamlx-Stdlib--Parsing \
ocamlx-Stdlib--Printexc \
ocamlx-Stdlib--Printf \
ocamlx-Stdlib--Queue \
ocamlx-Stdlib--Random \
ocamlx-Stdlib--Result \
ocamlx-Stdlib--Scanf \
ocamlx-Stdlib--Seq \
ocamlx-Stdlib--Stack \
ocamlx-Stdlib--String \
ocamlx-Stdlib--Sys \
ocamlx-Stdlib--Uchar \
ocamlx-Stdlib--Unit \
ocamlx-Stdlib--Weak"

inherit rpm
