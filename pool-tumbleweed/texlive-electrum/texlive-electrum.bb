SUMMARY = "Electrum ADF fonts collection"
DESCRIPTION = "Electrum ADF is a slab-serif font featuring optical and italic \
small-caps; additional ligatures and an alternate Q; lining, \
hanging, inferior and superior digits; and four weights. The \
fonts are provided in Adobe Type 1 format and the support \
material enables use with LaTeX. Licence is mixed: LPPL for \
LaTeX support; GPL with font exception for the fonts."
LICENSE = "LPPL-1.0"

PV = "2023.201.1.005_bsvn19705"

RPM_NAME = "texlive-electrum-2023.201.1.005_bsvn19705-53.1.noarch.rpm"
RPM_HASH = "946b79985263ed44adf8bb745bfa02d98f62810f815b8f7e60d14196dbd7d7a5855a30d6333b8bc2ee5819ffa81511019bf79175b4885da08244d2f7ea949869"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-electrum.sty \
tex-supp-yes.enc \
tex-t1yes.fd \
tex-t1yes0.fd \
tex-t1yes1.fd \
tex-t1yesj.fd \
tex-t1yesjw.fd \
tex-t1yesw.fd \
tex-ts1yes.fd \
tex-ts1yes0.fd \
tex-ts1yes1.fd \
tex-ts1yesj.fd \
tex-ts1yesjw.fd \
tex-ts1yesw.fd \
tex-yes.map \
tex-yesb08c.tfm \
tex-yesb08c.vf \
tex-yesb08t.tfm \
tex-yesb08t.vf \
tex-yesb0o8c.tfm \
tex-yesb0o8c.vf \
tex-yesb0o8t.tfm \
tex-yesb0o8t.vf \
tex-yesb18c.tfm \
tex-yesb18c.vf \
tex-yesb18t.tfm \
tex-yesb18t.vf \
tex-yesb1o8c.tfm \
tex-yesb1o8c.vf \
tex-yesb1o8t.tfm \
tex-yesb1o8t.vf \
tex-yesb8c.tfm \
tex-yesb8c.vf \
tex-yesb8r.tfm \
tex-yesb8s.tfm \
tex-yesb8t.tfm \
tex-yesb8t.vf \
tex-yesbc8t.tfm \
tex-yesbc8t.vf \
tex-yesbcj8t.tfm \
tex-yesbcj8t.vf \
tex-yesbcjo8t.tfm \
tex-yesbcjo8t.vf \
tex-yesbcjow8t.tfm \
tex-yesbcjow8t.vf \
tex-yesbcjw8t.tfm \
tex-yesbcjw8t.vf \
tex-yesbco8t.tfm \
tex-yesbco8t.vf \
tex-yesbcow8t.tfm \
tex-yesbcow8t.vf \
tex-yesbcw8t.tfm \
tex-yesbcw8t.vf \
tex-yesbj8c.tfm \
tex-yesbj8c.vf \
tex-yesbj8t.tfm \
tex-yesbj8t.vf \
tex-yesbjo8c.tfm \
tex-yesbjo8c.vf \
tex-yesbjo8t.tfm \
tex-yesbjo8t.vf \
tex-yesbjow8t.tfm \
tex-yesbjow8t.vf \
tex-yesbjw8t.tfm \
tex-yesbjw8t.vf \
tex-yesbo8c.tfm \
tex-yesbo8c.vf \
tex-yesbo8r.tfm \
tex-yesbo8s.tfm \
tex-yesbo8t.tfm \
tex-yesbo8t.vf \
tex-yesbow8t.tfm \
tex-yesbow8t.vf \
tex-yesbw8t.tfm \
tex-yesbw8t.vf \
tex-yesl08c.tfm \
tex-yesl08c.vf \
tex-yesl08t.tfm \
tex-yesl08t.vf \
tex-yesl0o8c.tfm \
tex-yesl0o8c.vf \
tex-yesl0o8t.tfm \
tex-yesl0o8t.vf \
tex-yesl18c.tfm \
tex-yesl18c.vf \
tex-yesl18t.tfm \
tex-yesl18t.vf \
tex-yesl1o8c.tfm \
tex-yesl1o8c.vf \
tex-yesl1o8t.tfm \
tex-yesl1o8t.vf \
tex-yesl8c.tfm \
tex-yesl8c.vf \
tex-yesl8r.tfm \
tex-yesl8s.tfm \
tex-yesl8t.tfm \
tex-yesl8t.vf \
tex-yeslc8t.tfm \
tex-yeslc8t.vf \
tex-yeslcj8t.tfm \
tex-yeslcj8t.vf \
tex-yeslcjo8t.tfm \
tex-yeslcjo8t.vf \
tex-yeslcjow8t.tfm \
tex-yeslcjow8t.vf \
tex-yeslcjw8t.tfm \
tex-yeslcjw8t.vf \
tex-yeslco8t.tfm \
tex-yeslco8t.vf \
tex-yeslcow8t.tfm \
tex-yeslcow8t.vf \
tex-yeslcw8t.tfm \
tex-yeslcw8t.vf \
tex-yeslj8c.tfm \
tex-yeslj8c.vf \
tex-yeslj8t.tfm \
tex-yeslj8t.vf \
tex-yesljo8c.tfm \
tex-yesljo8c.vf \
tex-yesljo8t.tfm \
tex-yesljo8t.vf \
tex-yesljow8t.tfm \
tex-yesljow8t.vf \
tex-yesljw8t.tfm \
tex-yesljw8t.vf \
tex-yeslo8c.tfm \
tex-yeslo8c.vf \
tex-yeslo8r.tfm \
tex-yeslo8s.tfm \
tex-yeslo8t.tfm \
tex-yeslo8t.vf \
tex-yeslow8t.tfm \
tex-yeslow8t.vf \
tex-yeslw8t.tfm \
tex-yeslw8t.vf \
tex-yesr08c.tfm \
tex-yesr08c.vf \
tex-yesr08t.tfm \
tex-yesr08t.vf \
tex-yesr0o8c.tfm \
tex-yesr0o8c.vf \
tex-yesr0o8t.tfm \
tex-yesr0o8t.vf \
tex-yesr18c.tfm \
tex-yesr18c.vf \
tex-yesr18t.tfm \
tex-yesr18t.vf \
tex-yesr1o8c.tfm \
tex-yesr1o8c.vf \
tex-yesr1o8t.tfm \
tex-yesr1o8t.vf \
tex-yesr8c.tfm \
tex-yesr8c.vf \
tex-yesr8r.tfm \
tex-yesr8s.tfm \
tex-yesr8t.tfm \
tex-yesr8t.vf \
tex-yesrc8t.tfm \
tex-yesrc8t.vf \
tex-yesrcj8t.tfm \
tex-yesrcj8t.vf \
tex-yesrcjo8t.tfm \
tex-yesrcjo8t.vf \
tex-yesrcjow8t.tfm \
tex-yesrcjow8t.vf \
tex-yesrcjw8t.tfm \
tex-yesrcjw8t.vf \
tex-yesrco8t.tfm \
tex-yesrco8t.vf \
tex-yesrcow8t.tfm \
tex-yesrcow8t.vf \
tex-yesrcw8t.tfm \
tex-yesrcw8t.vf \
tex-yesrj8c.tfm \
tex-yesrj8c.vf \
tex-yesrj8t.tfm \
tex-yesrj8t.vf \
tex-yesrjo8c.tfm \
tex-yesrjo8c.vf \
tex-yesrjo8t.tfm \
tex-yesrjo8t.vf \
tex-yesrjow8t.tfm \
tex-yesrjow8t.vf \
tex-yesrjw8t.tfm \
tex-yesrjw8t.vf \
tex-yesro8c.tfm \
tex-yesro8c.vf \
tex-yesro8r.tfm \
tex-yesro8s.tfm \
tex-yesro8t.tfm \
tex-yesro8t.vf \
tex-yesrow8t.tfm \
tex-yesrow8t.vf \
tex-yesrw8t.tfm \
tex-yesrw8t.vf \
tex-yess08c.tfm \
tex-yess08c.vf \
tex-yess08t.tfm \
tex-yess08t.vf \
tex-yess0o8c.tfm \
tex-yess0o8c.vf \
tex-yess0o8t.tfm \
tex-yess0o8t.vf \
tex-yess18c.tfm \
tex-yess18c.vf \
tex-yess18t.tfm \
tex-yess18t.vf \
tex-yess1o8c.tfm \
tex-yess1o8c.vf \
tex-yess1o8t.tfm \
tex-yess1o8t.vf \
tex-yess8c.tfm \
tex-yess8c.vf \
tex-yess8r.tfm \
tex-yess8s.tfm \
tex-yess8t.tfm \
tex-yess8t.vf \
tex-yessc8t.tfm \
tex-yessc8t.vf \
tex-yesscj8t.tfm \
tex-yesscj8t.vf \
tex-yesscjo8t.tfm \
tex-yesscjo8t.vf \
tex-yesscjow8t.tfm \
tex-yesscjow8t.vf \
tex-yesscjw8t.tfm \
tex-yesscjw8t.vf \
tex-yessco8t.tfm \
tex-yessco8t.vf \
tex-yesscow8t.tfm \
tex-yesscow8t.vf \
tex-yesscw8t.tfm \
tex-yesscw8t.vf \
tex-yessj8c.tfm \
tex-yessj8c.vf \
tex-yessj8t.tfm \
tex-yessj8t.vf \
tex-yessjo8c.tfm \
tex-yessjo8c.vf \
tex-yessjo8t.tfm \
tex-yessjo8t.vf \
tex-yessjow8t.tfm \
tex-yessjow8t.vf \
tex-yessjw8t.tfm \
tex-yessjw8t.vf \
tex-yesso8c.tfm \
tex-yesso8c.vf \
tex-yesso8r.tfm \
tex-yesso8s.tfm \
tex-yesso8t.tfm \
tex-yesso8t.vf \
tex-yessow8t.tfm \
tex-yessow8t.vf \
tex-yessw8t.tfm \
tex-yessw8t.vf \
texlive-electrum"

RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontenc.sty \
tex-nfssext-cfr.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-electrum-fonts \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
