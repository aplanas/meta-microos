SUMMARY = "LaTeX support for the Libre-Franklin family of fonts"
DESCRIPTION = "Libre Franklin is an interpretation and expansion based on the \
1912 Morris Fuller Benton's classic, designed by Pablo \
Impallari, Rodrigo Fuenzalida and Nhung Nguyen."
LICENSE = "LPPL-1.0"

PV = "2023.201.svn64441"

RPM_NAME = "texlive-librefranklin-2023.201.svn64441-54.1.noarch.rpm"
RPM_HASH = "cc5e06e4dc7708cfe91101e4ba4904abb2514df5a10ead14bfce3b97629e40e31130fcac39570ea7a237edc76f76f85b7a54e68ad63751a321c3bd5ca8c633a1"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-LGRLibreFranklin-Sup.fd \
tex-LGRLibreFranklin-TLF.fd \
tex-LY1LibreFranklin-Sup.fd \
tex-LY1LibreFranklin-TLF.fd \
tex-LibreFranklin-Black-sup-lgr--base.tfm \
tex-LibreFranklin-Black-sup-lgr.tfm \
tex-LibreFranklin-Black-sup-lgr.vf \
tex-LibreFranklin-Black-sup-ly1--base.tfm \
tex-LibreFranklin-Black-sup-ly1.tfm \
tex-LibreFranklin-Black-sup-ly1.vf \
tex-LibreFranklin-Black-sup-ot1.tfm \
tex-LibreFranklin-Black-sup-t1--base.tfm \
tex-LibreFranklin-Black-sup-t1.tfm \
tex-LibreFranklin-Black-sup-t1.vf \
tex-LibreFranklin-Black-tlf-lgr--base.tfm \
tex-LibreFranklin-Black-tlf-lgr.tfm \
tex-LibreFranklin-Black-tlf-lgr.vf \
tex-LibreFranklin-Black-tlf-ly1--base.tfm \
tex-LibreFranklin-Black-tlf-ly1.tfm \
tex-LibreFranklin-Black-tlf-ly1.vf \
tex-LibreFranklin-Black-tlf-ot1.tfm \
tex-LibreFranklin-Black-tlf-t1--base.tfm \
tex-LibreFranklin-Black-tlf-t1.tfm \
tex-LibreFranklin-Black-tlf-t1.vf \
tex-LibreFranklin-Black-tlf-ts1--base.tfm \
tex-LibreFranklin-Black-tlf-ts1.tfm \
tex-LibreFranklin-Black-tlf-ts1.vf \
tex-LibreFranklin-BlackItalic-sup-lgr--base.tfm \
tex-LibreFranklin-BlackItalic-sup-lgr.tfm \
tex-LibreFranklin-BlackItalic-sup-lgr.vf \
tex-LibreFranklin-BlackItalic-sup-ly1--base.tfm \
tex-LibreFranklin-BlackItalic-sup-ly1.tfm \
tex-LibreFranklin-BlackItalic-sup-ly1.vf \
tex-LibreFranklin-BlackItalic-sup-ot1.tfm \
tex-LibreFranklin-BlackItalic-sup-t1--base.tfm \
tex-LibreFranklin-BlackItalic-sup-t1.tfm \
tex-LibreFranklin-BlackItalic-sup-t1.vf \
tex-LibreFranklin-BlackItalic-tlf-lgr--base.tfm \
tex-LibreFranklin-BlackItalic-tlf-lgr.tfm \
tex-LibreFranklin-BlackItalic-tlf-lgr.vf \
tex-LibreFranklin-BlackItalic-tlf-ly1--base.tfm \
tex-LibreFranklin-BlackItalic-tlf-ly1.tfm \
tex-LibreFranklin-BlackItalic-tlf-ly1.vf \
tex-LibreFranklin-BlackItalic-tlf-ot1.tfm \
tex-LibreFranklin-BlackItalic-tlf-t1--base.tfm \
tex-LibreFranklin-BlackItalic-tlf-t1.tfm \
tex-LibreFranklin-BlackItalic-tlf-t1.vf \
tex-LibreFranklin-BlackItalic-tlf-ts1--base.tfm \
tex-LibreFranklin-BlackItalic-tlf-ts1.tfm \
tex-LibreFranklin-BlackItalic-tlf-ts1.vf \
tex-LibreFranklin-Bold-sup-lgr--base.tfm \
tex-LibreFranklin-Bold-sup-lgr.tfm \
tex-LibreFranklin-Bold-sup-lgr.vf \
tex-LibreFranklin-Bold-sup-ly1--base.tfm \
tex-LibreFranklin-Bold-sup-ly1.tfm \
tex-LibreFranklin-Bold-sup-ly1.vf \
tex-LibreFranklin-Bold-sup-ot1.tfm \
tex-LibreFranklin-Bold-sup-t1--base.tfm \
tex-LibreFranklin-Bold-sup-t1.tfm \
tex-LibreFranklin-Bold-sup-t1.vf \
tex-LibreFranklin-Bold-tlf-lgr--base.tfm \
tex-LibreFranklin-Bold-tlf-lgr.tfm \
tex-LibreFranklin-Bold-tlf-lgr.vf \
tex-LibreFranklin-Bold-tlf-ly1--base.tfm \
tex-LibreFranklin-Bold-tlf-ly1.tfm \
tex-LibreFranklin-Bold-tlf-ly1.vf \
tex-LibreFranklin-Bold-tlf-ot1.tfm \
tex-LibreFranklin-Bold-tlf-t1--base.tfm \
tex-LibreFranklin-Bold-tlf-t1.tfm \
tex-LibreFranklin-Bold-tlf-t1.vf \
tex-LibreFranklin-Bold-tlf-ts1--base.tfm \
tex-LibreFranklin-Bold-tlf-ts1.tfm \
tex-LibreFranklin-Bold-tlf-ts1.vf \
tex-LibreFranklin-BoldItalic-sup-lgr--base.tfm \
tex-LibreFranklin-BoldItalic-sup-lgr.tfm \
tex-LibreFranklin-BoldItalic-sup-lgr.vf \
tex-LibreFranklin-BoldItalic-sup-ly1--base.tfm \
tex-LibreFranklin-BoldItalic-sup-ly1.tfm \
tex-LibreFranklin-BoldItalic-sup-ly1.vf \
tex-LibreFranklin-BoldItalic-sup-ot1.tfm \
tex-LibreFranklin-BoldItalic-sup-t1--base.tfm \
tex-LibreFranklin-BoldItalic-sup-t1.tfm \
tex-LibreFranklin-BoldItalic-sup-t1.vf \
tex-LibreFranklin-BoldItalic-tlf-lgr--base.tfm \
tex-LibreFranklin-BoldItalic-tlf-lgr.tfm \
tex-LibreFranklin-BoldItalic-tlf-lgr.vf \
tex-LibreFranklin-BoldItalic-tlf-ly1--base.tfm \
tex-LibreFranklin-BoldItalic-tlf-ly1.tfm \
tex-LibreFranklin-BoldItalic-tlf-ly1.vf \
tex-LibreFranklin-BoldItalic-tlf-ot1.tfm \
tex-LibreFranklin-BoldItalic-tlf-t1--base.tfm \
tex-LibreFranklin-BoldItalic-tlf-t1.tfm \
tex-LibreFranklin-BoldItalic-tlf-t1.vf \
tex-LibreFranklin-BoldItalic-tlf-ts1--base.tfm \
tex-LibreFranklin-BoldItalic-tlf-ts1.tfm \
tex-LibreFranklin-BoldItalic-tlf-ts1.vf \
tex-LibreFranklin-ExtraBold-sup-lgr--base.tfm \
tex-LibreFranklin-ExtraBold-sup-lgr.tfm \
tex-LibreFranklin-ExtraBold-sup-lgr.vf \
tex-LibreFranklin-ExtraBold-sup-ly1--base.tfm \
tex-LibreFranklin-ExtraBold-sup-ly1.tfm \
tex-LibreFranklin-ExtraBold-sup-ly1.vf \
tex-LibreFranklin-ExtraBold-sup-ot1.tfm \
tex-LibreFranklin-ExtraBold-sup-t1--base.tfm \
tex-LibreFranklin-ExtraBold-sup-t1.tfm \
tex-LibreFranklin-ExtraBold-sup-t1.vf \
tex-LibreFranklin-ExtraBold-tlf-lgr--base.tfm \
tex-LibreFranklin-ExtraBold-tlf-lgr.tfm \
tex-LibreFranklin-ExtraBold-tlf-lgr.vf \
tex-LibreFranklin-ExtraBold-tlf-ly1--base.tfm \
tex-LibreFranklin-ExtraBold-tlf-ly1.tfm \
tex-LibreFranklin-ExtraBold-tlf-ly1.vf \
tex-LibreFranklin-ExtraBold-tlf-ot1.tfm \
tex-LibreFranklin-ExtraBold-tlf-t1--base.tfm \
tex-LibreFranklin-ExtraBold-tlf-t1.tfm \
tex-LibreFranklin-ExtraBold-tlf-t1.vf \
tex-LibreFranklin-ExtraBold-tlf-ts1--base.tfm \
tex-LibreFranklin-ExtraBold-tlf-ts1.tfm \
tex-LibreFranklin-ExtraBold-tlf-ts1.vf \
tex-LibreFranklin-ExtraBoldItalic-sup-lgr--base.tfm \
tex-LibreFranklin-ExtraBoldItalic-sup-lgr.tfm \
tex-LibreFranklin-ExtraBoldItalic-sup-lgr.vf \
tex-LibreFranklin-ExtraBoldItalic-sup-ly1--base.tfm \
tex-LibreFranklin-ExtraBoldItalic-sup-ly1.tfm \
tex-LibreFranklin-ExtraBoldItalic-sup-ly1.vf \
tex-LibreFranklin-ExtraBoldItalic-sup-ot1.tfm \
tex-LibreFranklin-ExtraBoldItalic-sup-t1--base.tfm \
tex-LibreFranklin-ExtraBoldItalic-sup-t1.tfm \
tex-LibreFranklin-ExtraBoldItalic-sup-t1.vf \
tex-LibreFranklin-ExtraBoldItalic-tlf-lgr--base.tfm \
tex-LibreFranklin-ExtraBoldItalic-tlf-lgr.tfm \
tex-LibreFranklin-ExtraBoldItalic-tlf-lgr.vf \
tex-LibreFranklin-ExtraBoldItalic-tlf-ly1--base.tfm \
tex-LibreFranklin-ExtraBoldItalic-tlf-ly1.tfm \
tex-LibreFranklin-ExtraBoldItalic-tlf-ly1.vf \
tex-LibreFranklin-ExtraBoldItalic-tlf-ot1.tfm \
tex-LibreFranklin-ExtraBoldItalic-tlf-t1--base.tfm \
tex-LibreFranklin-ExtraBoldItalic-tlf-t1.tfm \
tex-LibreFranklin-ExtraBoldItalic-tlf-t1.vf \
tex-LibreFranklin-ExtraBoldItalic-tlf-ts1--base.tfm \
tex-LibreFranklin-ExtraBoldItalic-tlf-ts1.tfm \
tex-LibreFranklin-ExtraBoldItalic-tlf-ts1.vf \
tex-LibreFranklin-ExtraLight-sup-lgr--base.tfm \
tex-LibreFranklin-ExtraLight-sup-lgr.tfm \
tex-LibreFranklin-ExtraLight-sup-lgr.vf \
tex-LibreFranklin-ExtraLight-sup-ly1--base.tfm \
tex-LibreFranklin-ExtraLight-sup-ly1.tfm \
tex-LibreFranklin-ExtraLight-sup-ly1.vf \
tex-LibreFranklin-ExtraLight-sup-ot1.tfm \
tex-LibreFranklin-ExtraLight-sup-t1--base.tfm \
tex-LibreFranklin-ExtraLight-sup-t1.tfm \
tex-LibreFranklin-ExtraLight-sup-t1.vf \
tex-LibreFranklin-ExtraLight-tlf-lgr--base.tfm \
tex-LibreFranklin-ExtraLight-tlf-lgr.tfm \
tex-LibreFranklin-ExtraLight-tlf-lgr.vf \
tex-LibreFranklin-ExtraLight-tlf-ly1--base.tfm \
tex-LibreFranklin-ExtraLight-tlf-ly1.tfm \
tex-LibreFranklin-ExtraLight-tlf-ly1.vf \
tex-LibreFranklin-ExtraLight-tlf-ot1.tfm \
tex-LibreFranklin-ExtraLight-tlf-t1--base.tfm \
tex-LibreFranklin-ExtraLight-tlf-t1.tfm \
tex-LibreFranklin-ExtraLight-tlf-t1.vf \
tex-LibreFranklin-ExtraLight-tlf-ts1--base.tfm \
tex-LibreFranklin-ExtraLight-tlf-ts1.tfm \
tex-LibreFranklin-ExtraLight-tlf-ts1.vf \
tex-LibreFranklin-ExtraLightItalic-sup-lgr--base.tfm \
tex-LibreFranklin-ExtraLightItalic-sup-lgr.tfm \
tex-LibreFranklin-ExtraLightItalic-sup-lgr.vf \
tex-LibreFranklin-ExtraLightItalic-sup-ly1--base.tfm \
tex-LibreFranklin-ExtraLightItalic-sup-ly1.tfm \
tex-LibreFranklin-ExtraLightItalic-sup-ly1.vf \
tex-LibreFranklin-ExtraLightItalic-sup-ot1.tfm \
tex-LibreFranklin-ExtraLightItalic-sup-t1--base.tfm \
tex-LibreFranklin-ExtraLightItalic-sup-t1.tfm \
tex-LibreFranklin-ExtraLightItalic-sup-t1.vf \
tex-LibreFranklin-ExtraLightItalic-tlf-lgr--base.tfm \
tex-LibreFranklin-ExtraLightItalic-tlf-lgr.tfm \
tex-LibreFranklin-ExtraLightItalic-tlf-lgr.vf \
tex-LibreFranklin-ExtraLightItalic-tlf-ly1--base.tfm \
tex-LibreFranklin-ExtraLightItalic-tlf-ly1.tfm \
tex-LibreFranklin-ExtraLightItalic-tlf-ly1.vf \
tex-LibreFranklin-ExtraLightItalic-tlf-ot1.tfm \
tex-LibreFranklin-ExtraLightItalic-tlf-t1--base.tfm \
tex-LibreFranklin-ExtraLightItalic-tlf-t1.tfm \
tex-LibreFranklin-ExtraLightItalic-tlf-t1.vf \
tex-LibreFranklin-ExtraLightItalic-tlf-ts1--base.tfm \
tex-LibreFranklin-ExtraLightItalic-tlf-ts1.tfm \
tex-LibreFranklin-ExtraLightItalic-tlf-ts1.vf \
tex-LibreFranklin-Italic-sup-lgr--base.tfm \
tex-LibreFranklin-Italic-sup-lgr.tfm \
tex-LibreFranklin-Italic-sup-lgr.vf \
tex-LibreFranklin-Italic-sup-ly1--base.tfm \
tex-LibreFranklin-Italic-sup-ly1.tfm \
tex-LibreFranklin-Italic-sup-ly1.vf \
tex-LibreFranklin-Italic-sup-ot1.tfm \
tex-LibreFranklin-Italic-sup-t1--base.tfm \
tex-LibreFranklin-Italic-sup-t1.tfm \
tex-LibreFranklin-Italic-sup-t1.vf \
tex-LibreFranklin-Italic-tlf-lgr--base.tfm \
tex-LibreFranklin-Italic-tlf-lgr.tfm \
tex-LibreFranklin-Italic-tlf-lgr.vf \
tex-LibreFranklin-Italic-tlf-ly1--base.tfm \
tex-LibreFranklin-Italic-tlf-ly1.tfm \
tex-LibreFranklin-Italic-tlf-ly1.vf \
tex-LibreFranklin-Italic-tlf-ot1.tfm \
tex-LibreFranklin-Italic-tlf-t1--base.tfm \
tex-LibreFranklin-Italic-tlf-t1.tfm \
tex-LibreFranklin-Italic-tlf-t1.vf \
tex-LibreFranklin-Italic-tlf-ts1--base.tfm \
tex-LibreFranklin-Italic-tlf-ts1.tfm \
tex-LibreFranklin-Italic-tlf-ts1.vf \
tex-LibreFranklin-Light-sup-lgr--base.tfm \
tex-LibreFranklin-Light-sup-lgr.tfm \
tex-LibreFranklin-Light-sup-lgr.vf \
tex-LibreFranklin-Light-sup-ly1--base.tfm \
tex-LibreFranklin-Light-sup-ly1.tfm \
tex-LibreFranklin-Light-sup-ly1.vf \
tex-LibreFranklin-Light-sup-ot1.tfm \
tex-LibreFranklin-Light-sup-t1--base.tfm \
tex-LibreFranklin-Light-sup-t1.tfm \
tex-LibreFranklin-Light-sup-t1.vf \
tex-LibreFranklin-Light-tlf-lgr--base.tfm \
tex-LibreFranklin-Light-tlf-lgr.tfm \
tex-LibreFranklin-Light-tlf-lgr.vf \
tex-LibreFranklin-Light-tlf-ly1--base.tfm \
tex-LibreFranklin-Light-tlf-ly1.tfm \
tex-LibreFranklin-Light-tlf-ly1.vf \
tex-LibreFranklin-Light-tlf-ot1.tfm \
tex-LibreFranklin-Light-tlf-t1--base.tfm \
tex-LibreFranklin-Light-tlf-t1.tfm \
tex-LibreFranklin-Light-tlf-t1.vf \
tex-LibreFranklin-Light-tlf-ts1--base.tfm \
tex-LibreFranklin-Light-tlf-ts1.tfm \
tex-LibreFranklin-Light-tlf-ts1.vf \
tex-LibreFranklin-LightItalic-sup-lgr--base.tfm \
tex-LibreFranklin-LightItalic-sup-lgr.tfm \
tex-LibreFranklin-LightItalic-sup-lgr.vf \
tex-LibreFranklin-LightItalic-sup-ly1--base.tfm \
tex-LibreFranklin-LightItalic-sup-ly1.tfm \
tex-LibreFranklin-LightItalic-sup-ly1.vf \
tex-LibreFranklin-LightItalic-sup-ot1.tfm \
tex-LibreFranklin-LightItalic-sup-t1--base.tfm \
tex-LibreFranklin-LightItalic-sup-t1.tfm \
tex-LibreFranklin-LightItalic-sup-t1.vf \
tex-LibreFranklin-LightItalic-tlf-lgr--base.tfm \
tex-LibreFranklin-LightItalic-tlf-lgr.tfm \
tex-LibreFranklin-LightItalic-tlf-lgr.vf \
tex-LibreFranklin-LightItalic-tlf-ly1--base.tfm \
tex-LibreFranklin-LightItalic-tlf-ly1.tfm \
tex-LibreFranklin-LightItalic-tlf-ly1.vf \
tex-LibreFranklin-LightItalic-tlf-ot1.tfm \
tex-LibreFranklin-LightItalic-tlf-t1--base.tfm \
tex-LibreFranklin-LightItalic-tlf-t1.tfm \
tex-LibreFranklin-LightItalic-tlf-t1.vf \
tex-LibreFranklin-LightItalic-tlf-ts1--base.tfm \
tex-LibreFranklin-LightItalic-tlf-ts1.tfm \
tex-LibreFranklin-LightItalic-tlf-ts1.vf \
tex-LibreFranklin-Medium-sup-lgr--base.tfm \
tex-LibreFranklin-Medium-sup-lgr.tfm \
tex-LibreFranklin-Medium-sup-lgr.vf \
tex-LibreFranklin-Medium-sup-ly1--base.tfm \
tex-LibreFranklin-Medium-sup-ly1.tfm \
tex-LibreFranklin-Medium-sup-ly1.vf \
tex-LibreFranklin-Medium-sup-ot1.tfm \
tex-LibreFranklin-Medium-sup-t1--base.tfm \
tex-LibreFranklin-Medium-sup-t1.tfm \
tex-LibreFranklin-Medium-sup-t1.vf \
tex-LibreFranklin-Medium-tlf-lgr--base.tfm \
tex-LibreFranklin-Medium-tlf-lgr.tfm \
tex-LibreFranklin-Medium-tlf-lgr.vf \
tex-LibreFranklin-Medium-tlf-ly1--base.tfm \
tex-LibreFranklin-Medium-tlf-ly1.tfm \
tex-LibreFranklin-Medium-tlf-ly1.vf \
tex-LibreFranklin-Medium-tlf-ot1.tfm \
tex-LibreFranklin-Medium-tlf-t1--base.tfm \
tex-LibreFranklin-Medium-tlf-t1.tfm \
tex-LibreFranklin-Medium-tlf-t1.vf \
tex-LibreFranklin-Medium-tlf-ts1--base.tfm \
tex-LibreFranklin-Medium-tlf-ts1.tfm \
tex-LibreFranklin-Medium-tlf-ts1.vf \
tex-LibreFranklin-MediumItalic-sup-lgr--base.tfm \
tex-LibreFranklin-MediumItalic-sup-lgr.tfm \
tex-LibreFranklin-MediumItalic-sup-lgr.vf \
tex-LibreFranklin-MediumItalic-sup-ly1--base.tfm \
tex-LibreFranklin-MediumItalic-sup-ly1.tfm \
tex-LibreFranklin-MediumItalic-sup-ly1.vf \
tex-LibreFranklin-MediumItalic-sup-ot1.tfm \
tex-LibreFranklin-MediumItalic-sup-t1--base.tfm \
tex-LibreFranklin-MediumItalic-sup-t1.tfm \
tex-LibreFranklin-MediumItalic-sup-t1.vf \
tex-LibreFranklin-MediumItalic-tlf-lgr--base.tfm \
tex-LibreFranklin-MediumItalic-tlf-lgr.tfm \
tex-LibreFranklin-MediumItalic-tlf-lgr.vf \
tex-LibreFranklin-MediumItalic-tlf-ly1--base.tfm \
tex-LibreFranklin-MediumItalic-tlf-ly1.tfm \
tex-LibreFranklin-MediumItalic-tlf-ly1.vf \
tex-LibreFranklin-MediumItalic-tlf-ot1.tfm \
tex-LibreFranklin-MediumItalic-tlf-t1--base.tfm \
tex-LibreFranklin-MediumItalic-tlf-t1.tfm \
tex-LibreFranklin-MediumItalic-tlf-t1.vf \
tex-LibreFranklin-MediumItalic-tlf-ts1--base.tfm \
tex-LibreFranklin-MediumItalic-tlf-ts1.tfm \
tex-LibreFranklin-MediumItalic-tlf-ts1.vf \
tex-LibreFranklin-Regular-sup-lgr--base.tfm \
tex-LibreFranklin-Regular-sup-lgr.tfm \
tex-LibreFranklin-Regular-sup-lgr.vf \
tex-LibreFranklin-Regular-sup-ly1--base.tfm \
tex-LibreFranklin-Regular-sup-ly1.tfm \
tex-LibreFranklin-Regular-sup-ly1.vf \
tex-LibreFranklin-Regular-sup-ot1.tfm \
tex-LibreFranklin-Regular-sup-t1--base.tfm \
tex-LibreFranklin-Regular-sup-t1.tfm \
tex-LibreFranklin-Regular-sup-t1.vf \
tex-LibreFranklin-Regular-tlf-lgr--base.tfm \
tex-LibreFranklin-Regular-tlf-lgr.tfm \
tex-LibreFranklin-Regular-tlf-lgr.vf \
tex-LibreFranklin-Regular-tlf-ly1--base.tfm \
tex-LibreFranklin-Regular-tlf-ly1.tfm \
tex-LibreFranklin-Regular-tlf-ly1.vf \
tex-LibreFranklin-Regular-tlf-ot1.tfm \
tex-LibreFranklin-Regular-tlf-t1--base.tfm \
tex-LibreFranklin-Regular-tlf-t1.tfm \
tex-LibreFranklin-Regular-tlf-t1.vf \
tex-LibreFranklin-Regular-tlf-ts1--base.tfm \
tex-LibreFranklin-Regular-tlf-ts1.tfm \
tex-LibreFranklin-Regular-tlf-ts1.vf \
tex-LibreFranklin-SemiBold-sup-lgr--base.tfm \
tex-LibreFranklin-SemiBold-sup-lgr.tfm \
tex-LibreFranklin-SemiBold-sup-lgr.vf \
tex-LibreFranklin-SemiBold-sup-ly1--base.tfm \
tex-LibreFranklin-SemiBold-sup-ly1.tfm \
tex-LibreFranklin-SemiBold-sup-ly1.vf \
tex-LibreFranklin-SemiBold-sup-ot1.tfm \
tex-LibreFranklin-SemiBold-sup-t1--base.tfm \
tex-LibreFranklin-SemiBold-sup-t1.tfm \
tex-LibreFranklin-SemiBold-sup-t1.vf \
tex-LibreFranklin-SemiBold-tlf-lgr--base.tfm \
tex-LibreFranklin-SemiBold-tlf-lgr.tfm \
tex-LibreFranklin-SemiBold-tlf-lgr.vf \
tex-LibreFranklin-SemiBold-tlf-ly1--base.tfm \
tex-LibreFranklin-SemiBold-tlf-ly1.tfm \
tex-LibreFranklin-SemiBold-tlf-ly1.vf \
tex-LibreFranklin-SemiBold-tlf-ot1.tfm \
tex-LibreFranklin-SemiBold-tlf-t1--base.tfm \
tex-LibreFranklin-SemiBold-tlf-t1.tfm \
tex-LibreFranklin-SemiBold-tlf-t1.vf \
tex-LibreFranklin-SemiBold-tlf-ts1--base.tfm \
tex-LibreFranklin-SemiBold-tlf-ts1.tfm \
tex-LibreFranklin-SemiBold-tlf-ts1.vf \
tex-LibreFranklin-SemiBoldItalic-sup-lgr--base.tfm \
tex-LibreFranklin-SemiBoldItalic-sup-lgr.tfm \
tex-LibreFranklin-SemiBoldItalic-sup-lgr.vf \
tex-LibreFranklin-SemiBoldItalic-sup-ly1--base.tfm \
tex-LibreFranklin-SemiBoldItalic-sup-ly1.tfm \
tex-LibreFranklin-SemiBoldItalic-sup-ly1.vf \
tex-LibreFranklin-SemiBoldItalic-sup-ot1.tfm \
tex-LibreFranklin-SemiBoldItalic-sup-t1--base.tfm \
tex-LibreFranklin-SemiBoldItalic-sup-t1.tfm \
tex-LibreFranklin-SemiBoldItalic-sup-t1.vf \
tex-LibreFranklin-SemiBoldItalic-tlf-lgr--base.tfm \
tex-LibreFranklin-SemiBoldItalic-tlf-lgr.tfm \
tex-LibreFranklin-SemiBoldItalic-tlf-lgr.vf \
tex-LibreFranklin-SemiBoldItalic-tlf-ly1--base.tfm \
tex-LibreFranklin-SemiBoldItalic-tlf-ly1.tfm \
tex-LibreFranklin-SemiBoldItalic-tlf-ly1.vf \
tex-LibreFranklin-SemiBoldItalic-tlf-ot1.tfm \
tex-LibreFranklin-SemiBoldItalic-tlf-t1--base.tfm \
tex-LibreFranklin-SemiBoldItalic-tlf-t1.tfm \
tex-LibreFranklin-SemiBoldItalic-tlf-t1.vf \
tex-LibreFranklin-SemiBoldItalic-tlf-ts1--base.tfm \
tex-LibreFranklin-SemiBoldItalic-tlf-ts1.tfm \
tex-LibreFranklin-SemiBoldItalic-tlf-ts1.vf \
tex-LibreFranklin-Thin-sup-lgr--base.tfm \
tex-LibreFranklin-Thin-sup-lgr.tfm \
tex-LibreFranklin-Thin-sup-lgr.vf \
tex-LibreFranklin-Thin-sup-ly1--base.tfm \
tex-LibreFranklin-Thin-sup-ly1.tfm \
tex-LibreFranklin-Thin-sup-ly1.vf \
tex-LibreFranklin-Thin-sup-ot1.tfm \
tex-LibreFranklin-Thin-sup-t1--base.tfm \
tex-LibreFranklin-Thin-sup-t1.tfm \
tex-LibreFranklin-Thin-sup-t1.vf \
tex-LibreFranklin-Thin-tlf-lgr--base.tfm \
tex-LibreFranklin-Thin-tlf-lgr.tfm \
tex-LibreFranklin-Thin-tlf-lgr.vf \
tex-LibreFranklin-Thin-tlf-ly1--base.tfm \
tex-LibreFranklin-Thin-tlf-ly1.tfm \
tex-LibreFranklin-Thin-tlf-ly1.vf \
tex-LibreFranklin-Thin-tlf-ot1.tfm \
tex-LibreFranklin-Thin-tlf-t1--base.tfm \
tex-LibreFranklin-Thin-tlf-t1.tfm \
tex-LibreFranklin-Thin-tlf-t1.vf \
tex-LibreFranklin-Thin-tlf-ts1--base.tfm \
tex-LibreFranklin-Thin-tlf-ts1.tfm \
tex-LibreFranklin-Thin-tlf-ts1.vf \
tex-LibreFranklin-ThinItalic-sup-lgr--base.tfm \
tex-LibreFranklin-ThinItalic-sup-lgr.tfm \
tex-LibreFranklin-ThinItalic-sup-lgr.vf \
tex-LibreFranklin-ThinItalic-sup-ly1--base.tfm \
tex-LibreFranklin-ThinItalic-sup-ly1.tfm \
tex-LibreFranklin-ThinItalic-sup-ly1.vf \
tex-LibreFranklin-ThinItalic-sup-ot1.tfm \
tex-LibreFranklin-ThinItalic-sup-t1--base.tfm \
tex-LibreFranklin-ThinItalic-sup-t1.tfm \
tex-LibreFranklin-ThinItalic-sup-t1.vf \
tex-LibreFranklin-ThinItalic-tlf-lgr--base.tfm \
tex-LibreFranklin-ThinItalic-tlf-lgr.tfm \
tex-LibreFranklin-ThinItalic-tlf-lgr.vf \
tex-LibreFranklin-ThinItalic-tlf-ly1--base.tfm \
tex-LibreFranklin-ThinItalic-tlf-ly1.tfm \
tex-LibreFranklin-ThinItalic-tlf-ly1.vf \
tex-LibreFranklin-ThinItalic-tlf-ot1.tfm \
tex-LibreFranklin-ThinItalic-tlf-t1--base.tfm \
tex-LibreFranklin-ThinItalic-tlf-t1.tfm \
tex-LibreFranklin-ThinItalic-tlf-t1.vf \
tex-LibreFranklin-ThinItalic-tlf-ts1--base.tfm \
tex-LibreFranklin-ThinItalic-tlf-ts1.tfm \
tex-LibreFranklin-ThinItalic-tlf-ts1.vf \
tex-LibreFranklin.map \
tex-OT1LibreFranklin-Sup.fd \
tex-OT1LibreFranklin-TLF.fd \
tex-T1LibreFranklin-Sup.fd \
tex-T1LibreFranklin-TLF.fd \
tex-TS1LibreFranklin-TLF.fd \
tex-lbfr-ejn2og.enc \
tex-lbfr-hlvv6p.enc \
tex-lbfr-nb4g6w.enc \
tex-lbfr-spbxfw.enc \
tex-lbfr-tdlrq7.enc \
tex-lbfr-tf5jo5.enc \
tex-lbfr-w4rwtq.enc \
tex-lbfr-wmouhf.enc \
tex-lbfr-xsutkk.enc \
tex-librefranklin.sty \
texlive-librefranklin"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontaxes.sty \
tex-fontenc.sty \
tex-fontspec.sty \
tex-ifluatex.sty \
tex-ifxetex.sty \
tex-mweights.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-librefranklin-fonts \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
