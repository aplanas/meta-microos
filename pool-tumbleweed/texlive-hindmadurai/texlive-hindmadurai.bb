SUMMARY = "The HindMadurai font face with support for LaTeX and pdfLaTeX"
DESCRIPTION = "This package provides the HindMadurai family of fonts designed \
by the Indian Type Foundry, with support for LaTeX and \
pdfLaTeX."
LICENSE = "OFL-1.1"

PV = "2023.209.0.0.0.1svn57360"

RPM_NAME = "texlive-hindmadurai-2023.209.0.0.0.1svn57360-54.2.noarch.rpm"
RPM_HASH = "3f641ce39d4f03f41a01a3cd9f92e7d638d1010767fee4102d51c77b1f25c073353ba4dc86871c5aa7cce478e9a40a81c4c54d4963251a8c89e59c88d4d4bee5"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-HindMadurai-Bold-tlf-ly1--base.tfm \
tex-HindMadurai-Bold-tlf-ly1--lcdfj.tfm \
tex-HindMadurai-Bold-tlf-ly1.tfm \
tex-HindMadurai-Bold-tlf-ly1.vf \
tex-HindMadurai-Bold-tlf-ot1--base.tfm \
tex-HindMadurai-Bold-tlf-ot1--lcdfj.tfm \
tex-HindMadurai-Bold-tlf-ot1.tfm \
tex-HindMadurai-Bold-tlf-ot1.vf \
tex-HindMadurai-Bold-tlf-t1--base.tfm \
tex-HindMadurai-Bold-tlf-t1--lcdfj.tfm \
tex-HindMadurai-Bold-tlf-t1.tfm \
tex-HindMadurai-Bold-tlf-t1.vf \
tex-HindMadurai-Bold-tlf-ts1--base.tfm \
tex-HindMadurai-Bold-tlf-ts1.tfm \
tex-HindMadurai-Bold-tlf-ts1.vf \
tex-HindMadurai-Light-tlf-ly1--base.tfm \
tex-HindMadurai-Light-tlf-ly1--lcdfj.tfm \
tex-HindMadurai-Light-tlf-ly1.tfm \
tex-HindMadurai-Light-tlf-ly1.vf \
tex-HindMadurai-Light-tlf-ot1--base.tfm \
tex-HindMadurai-Light-tlf-ot1--lcdfj.tfm \
tex-HindMadurai-Light-tlf-ot1.tfm \
tex-HindMadurai-Light-tlf-ot1.vf \
tex-HindMadurai-Light-tlf-t1--base.tfm \
tex-HindMadurai-Light-tlf-t1--lcdfj.tfm \
tex-HindMadurai-Light-tlf-t1.tfm \
tex-HindMadurai-Light-tlf-t1.vf \
tex-HindMadurai-Light-tlf-ts1--base.tfm \
tex-HindMadurai-Light-tlf-ts1.tfm \
tex-HindMadurai-Light-tlf-ts1.vf \
tex-HindMadurai-Medium-tlf-ly1--base.tfm \
tex-HindMadurai-Medium-tlf-ly1--lcdfj.tfm \
tex-HindMadurai-Medium-tlf-ly1.tfm \
tex-HindMadurai-Medium-tlf-ly1.vf \
tex-HindMadurai-Medium-tlf-ot1--base.tfm \
tex-HindMadurai-Medium-tlf-ot1--lcdfj.tfm \
tex-HindMadurai-Medium-tlf-ot1.tfm \
tex-HindMadurai-Medium-tlf-ot1.vf \
tex-HindMadurai-Medium-tlf-t1--base.tfm \
tex-HindMadurai-Medium-tlf-t1--lcdfj.tfm \
tex-HindMadurai-Medium-tlf-t1.tfm \
tex-HindMadurai-Medium-tlf-t1.vf \
tex-HindMadurai-Medium-tlf-ts1--base.tfm \
tex-HindMadurai-Medium-tlf-ts1.tfm \
tex-HindMadurai-Medium-tlf-ts1.vf \
tex-HindMadurai-Regular-tlf-ly1--base.tfm \
tex-HindMadurai-Regular-tlf-ly1--lcdfj.tfm \
tex-HindMadurai-Regular-tlf-ly1.tfm \
tex-HindMadurai-Regular-tlf-ly1.vf \
tex-HindMadurai-Regular-tlf-ot1--base.tfm \
tex-HindMadurai-Regular-tlf-ot1--lcdfj.tfm \
tex-HindMadurai-Regular-tlf-ot1.tfm \
tex-HindMadurai-Regular-tlf-ot1.vf \
tex-HindMadurai-Regular-tlf-t1--base.tfm \
tex-HindMadurai-Regular-tlf-t1--lcdfj.tfm \
tex-HindMadurai-Regular-tlf-t1.tfm \
tex-HindMadurai-Regular-tlf-t1.vf \
tex-HindMadurai-Regular-tlf-ts1--base.tfm \
tex-HindMadurai-Regular-tlf-ts1.tfm \
tex-HindMadurai-Regular-tlf-ts1.vf \
tex-HindMadurai-SemiBold-tlf-ly1--base.tfm \
tex-HindMadurai-SemiBold-tlf-ly1--lcdfj.tfm \
tex-HindMadurai-SemiBold-tlf-ly1.tfm \
tex-HindMadurai-SemiBold-tlf-ly1.vf \
tex-HindMadurai-SemiBold-tlf-ot1--base.tfm \
tex-HindMadurai-SemiBold-tlf-ot1--lcdfj.tfm \
tex-HindMadurai-SemiBold-tlf-ot1.tfm \
tex-HindMadurai-SemiBold-tlf-ot1.vf \
tex-HindMadurai-SemiBold-tlf-t1--base.tfm \
tex-HindMadurai-SemiBold-tlf-t1--lcdfj.tfm \
tex-HindMadurai-SemiBold-tlf-t1.tfm \
tex-HindMadurai-SemiBold-tlf-t1.vf \
tex-HindMadurai-SemiBold-tlf-ts1--base.tfm \
tex-HindMadurai-SemiBold-tlf-ts1.tfm \
tex-HindMadurai-SemiBold-tlf-ts1.vf \
tex-HindMadurai.map \
tex-HindMadurai.sty \
tex-LY1HindMadurai-TLF.fd \
tex-OT1HindMadurai-TLF.fd \
tex-T1HindMadurai-TLF.fd \
tex-TS1HindMadurai-TLF.fd \
tex-a-4f5hpf.enc \
tex-a-mlnerp.enc \
tex-a-u5lxld.enc \
tex-a-ym6dij.enc \
texlive-hindmadurai"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontaxes.sty \
tex-fontenc.sty \
tex-ifthen.sty \
tex-mweights.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-filesystem \
texlive-hindmadurai-fonts \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
