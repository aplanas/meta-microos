SUMMARY = "Translations for package four-in-a-row"
DESCRIPTION = "Provides translations for the 'four-in-a-row' package."
LICENSE = "GPL-2.0-or-later & GPL-3.0-or-later"

PV = "3.38.1"

RPM_NAME = "four-in-a-row-lang-3.38.1-1.14.noarch.rpm"
RPM_HASH = "a3367b8fdfb7a899d788a24d47c2354fee957caf033ceedea20afbc1261d81b0735bb5536922976fa155f55aa4bceca1b8ea8e74b9b14e1b45904f97ed283ec7"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "four-in-a-row-lang \
four-in-a-row-lang-all \
locale-four-in-a-row-af \
locale-four-in-a-row-ar \
locale-four-in-a-row-as \
locale-four-in-a-row-ast \
locale-four-in-a-row-az \
locale-four-in-a-row-be \
locale-four-in-a-row-bg \
locale-four-in-a-row-bn \
locale-four-in-a-row-bn-IN \
locale-four-in-a-row-br \
locale-four-in-a-row-bs \
locale-four-in-a-row-ca \
locale-four-in-a-row-ca@valencia \
locale-four-in-a-row-cs \
locale-four-in-a-row-cy \
locale-four-in-a-row-da \
locale-four-in-a-row-de \
locale-four-in-a-row-dz \
locale-four-in-a-row-el \
locale-four-in-a-row-en-CA \
locale-four-in-a-row-en-GB \
locale-four-in-a-row-en@shaw \
locale-four-in-a-row-eo \
locale-four-in-a-row-es \
locale-four-in-a-row-et \
locale-four-in-a-row-eu \
locale-four-in-a-row-fa \
locale-four-in-a-row-fi \
locale-four-in-a-row-fr \
locale-four-in-a-row-fur \
locale-four-in-a-row-ga \
locale-four-in-a-row-gl \
locale-four-in-a-row-gu \
locale-four-in-a-row-he \
locale-four-in-a-row-hi \
locale-four-in-a-row-hr \
locale-four-in-a-row-hu \
locale-four-in-a-row-id \
locale-four-in-a-row-is \
locale-four-in-a-row-it \
locale-four-in-a-row-ja \
locale-four-in-a-row-ka \
locale-four-in-a-row-kk \
locale-four-in-a-row-km \
locale-four-in-a-row-kn \
locale-four-in-a-row-ko \
locale-four-in-a-row-lt \
locale-four-in-a-row-lv \
locale-four-in-a-row-mai \
locale-four-in-a-row-mk \
locale-four-in-a-row-ml \
locale-four-in-a-row-mr \
locale-four-in-a-row-ms \
locale-four-in-a-row-nb \
locale-four-in-a-row-ne \
locale-four-in-a-row-nl \
locale-four-in-a-row-nn \
locale-four-in-a-row-oc \
locale-four-in-a-row-or \
locale-four-in-a-row-pa \
locale-four-in-a-row-pl \
locale-four-in-a-row-pt \
locale-four-in-a-row-pt-BR \
locale-four-in-a-row-ro \
locale-four-in-a-row-ru \
locale-four-in-a-row-si \
locale-four-in-a-row-sk \
locale-four-in-a-row-sl \
locale-four-in-a-row-sq \
locale-four-in-a-row-sr \
locale-four-in-a-row-sr@latin \
locale-four-in-a-row-sv \
locale-four-in-a-row-ta \
locale-four-in-a-row-te \
locale-four-in-a-row-th \
locale-four-in-a-row-tr \
locale-four-in-a-row-ug \
locale-four-in-a-row-uk \
locale-four-in-a-row-vi \
locale-four-in-a-row-wa \
locale-four-in-a-row-zh-CN \
locale-four-in-a-row-zh-HK \
locale-four-in-a-row-zh-TW"

RDEPENDS:${PN} += "four-in-a-row"

inherit rpm
