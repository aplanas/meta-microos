SUMMARY = "The inter font face with support for LaTeX, XeLaTeX, and LuaLaTeX"
DESCRIPTION = "This package provides LaTeX, pdfLaTeX, XeLaTeX and LuaLaTeX \
support for the Inter Sans family of fonts (version 3.015), \
designed by Rasmus Andersson. Inter is a typeface specially \
designed for user interfaces with focus on high legibility of \
small-to-medium sized text on computer screens. The family \
features a tall x-height to aid in readability of mixed-case \
and lower-case text."
LICENSE = "OFL-1.1"

PV = "2023.201.svn58892"

RPM_NAME = "texlive-inter-2023.201.svn58892-52.1.noarch.rpm"
RPM_HASH = "fae5bb82d2b86fb2f22c620f696aa6aeccce0aa62bd733efb2ee0392405288b1cfa874919ce5f415260b8deb614e5328c8de616cb913e754df7149a45cde9b6c"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-Inter-Black-lf-ly1--base.tfm \
tex-Inter-Black-lf-ly1.tfm \
tex-Inter-Black-lf-ly1.vf \
tex-Inter-Black-lf-ot1.tfm \
tex-Inter-Black-lf-swash-ly1--base.tfm \
tex-Inter-Black-lf-swash-ly1.tfm \
tex-Inter-Black-lf-swash-ly1.vf \
tex-Inter-Black-lf-swash-ot1.tfm \
tex-Inter-Black-lf-swash-t1--base.tfm \
tex-Inter-Black-lf-swash-t1.tfm \
tex-Inter-Black-lf-swash-t1.vf \
tex-Inter-Black-lf-t1--base.tfm \
tex-Inter-Black-lf-t1.tfm \
tex-Inter-Black-lf-t1.vf \
tex-Inter-Black-lf-titling-ly1--base.tfm \
tex-Inter-Black-lf-titling-ly1.tfm \
tex-Inter-Black-lf-titling-ly1.vf \
tex-Inter-Black-lf-titling-ot1--base.tfm \
tex-Inter-Black-lf-titling-ot1.tfm \
tex-Inter-Black-lf-titling-ot1.vf \
tex-Inter-Black-lf-titling-t1--base.tfm \
tex-Inter-Black-lf-titling-t1.tfm \
tex-Inter-Black-lf-titling-t1.vf \
tex-Inter-Black-lf-ts1--base.tfm \
tex-Inter-Black-lf-ts1.tfm \
tex-Inter-Black-lf-ts1.vf \
tex-Inter-Black-sup-ly1--base.tfm \
tex-Inter-Black-sup-ly1.tfm \
tex-Inter-Black-sup-ly1.vf \
tex-Inter-Black-sup-ot1.tfm \
tex-Inter-Black-sup-t1--base.tfm \
tex-Inter-Black-sup-t1.tfm \
tex-Inter-Black-sup-t1.vf \
tex-Inter-Black-tlf-ly1--base.tfm \
tex-Inter-Black-tlf-ly1.tfm \
tex-Inter-Black-tlf-ly1.vf \
tex-Inter-Black-tlf-ot1.tfm \
tex-Inter-Black-tlf-swash-ly1--base.tfm \
tex-Inter-Black-tlf-swash-ly1.tfm \
tex-Inter-Black-tlf-swash-ly1.vf \
tex-Inter-Black-tlf-swash-ot1.tfm \
tex-Inter-Black-tlf-swash-t1--base.tfm \
tex-Inter-Black-tlf-swash-t1.tfm \
tex-Inter-Black-tlf-swash-t1.vf \
tex-Inter-Black-tlf-t1--base.tfm \
tex-Inter-Black-tlf-t1.tfm \
tex-Inter-Black-tlf-t1.vf \
tex-Inter-Black-tlf-titling-ly1--base.tfm \
tex-Inter-Black-tlf-titling-ly1.tfm \
tex-Inter-Black-tlf-titling-ly1.vf \
tex-Inter-Black-tlf-titling-ot1--base.tfm \
tex-Inter-Black-tlf-titling-ot1.tfm \
tex-Inter-Black-tlf-titling-ot1.vf \
tex-Inter-Black-tlf-titling-t1--base.tfm \
tex-Inter-Black-tlf-titling-t1.tfm \
tex-Inter-Black-tlf-titling-t1.vf \
tex-Inter-Black-tlf-ts1--base.tfm \
tex-Inter-Black-tlf-ts1.tfm \
tex-Inter-Black-tlf-ts1.vf \
tex-Inter-BlackItalic-lf-ly1--base.tfm \
tex-Inter-BlackItalic-lf-ly1.tfm \
tex-Inter-BlackItalic-lf-ly1.vf \
tex-Inter-BlackItalic-lf-ot1.tfm \
tex-Inter-BlackItalic-lf-swash-ly1--base.tfm \
tex-Inter-BlackItalic-lf-swash-ly1.tfm \
tex-Inter-BlackItalic-lf-swash-ly1.vf \
tex-Inter-BlackItalic-lf-swash-ot1.tfm \
tex-Inter-BlackItalic-lf-swash-t1--base.tfm \
tex-Inter-BlackItalic-lf-swash-t1.tfm \
tex-Inter-BlackItalic-lf-swash-t1.vf \
tex-Inter-BlackItalic-lf-t1--base.tfm \
tex-Inter-BlackItalic-lf-t1.tfm \
tex-Inter-BlackItalic-lf-t1.vf \
tex-Inter-BlackItalic-lf-titling-ly1--base.tfm \
tex-Inter-BlackItalic-lf-titling-ly1.tfm \
tex-Inter-BlackItalic-lf-titling-ly1.vf \
tex-Inter-BlackItalic-lf-titling-ot1--base.tfm \
tex-Inter-BlackItalic-lf-titling-ot1.tfm \
tex-Inter-BlackItalic-lf-titling-ot1.vf \
tex-Inter-BlackItalic-lf-titling-t1--base.tfm \
tex-Inter-BlackItalic-lf-titling-t1.tfm \
tex-Inter-BlackItalic-lf-titling-t1.vf \
tex-Inter-BlackItalic-lf-ts1--base.tfm \
tex-Inter-BlackItalic-lf-ts1.tfm \
tex-Inter-BlackItalic-lf-ts1.vf \
tex-Inter-BlackItalic-sup-ly1--base.tfm \
tex-Inter-BlackItalic-sup-ly1.tfm \
tex-Inter-BlackItalic-sup-ly1.vf \
tex-Inter-BlackItalic-sup-ot1.tfm \
tex-Inter-BlackItalic-sup-t1--base.tfm \
tex-Inter-BlackItalic-sup-t1.tfm \
tex-Inter-BlackItalic-sup-t1.vf \
tex-Inter-BlackItalic-tlf-ly1--base.tfm \
tex-Inter-BlackItalic-tlf-ly1.tfm \
tex-Inter-BlackItalic-tlf-ly1.vf \
tex-Inter-BlackItalic-tlf-ot1.tfm \
tex-Inter-BlackItalic-tlf-swash-ly1--base.tfm \
tex-Inter-BlackItalic-tlf-swash-ly1.tfm \
tex-Inter-BlackItalic-tlf-swash-ly1.vf \
tex-Inter-BlackItalic-tlf-swash-ot1.tfm \
tex-Inter-BlackItalic-tlf-swash-t1--base.tfm \
tex-Inter-BlackItalic-tlf-swash-t1.tfm \
tex-Inter-BlackItalic-tlf-swash-t1.vf \
tex-Inter-BlackItalic-tlf-t1--base.tfm \
tex-Inter-BlackItalic-tlf-t1.tfm \
tex-Inter-BlackItalic-tlf-t1.vf \
tex-Inter-BlackItalic-tlf-titling-ly1--base.tfm \
tex-Inter-BlackItalic-tlf-titling-ly1.tfm \
tex-Inter-BlackItalic-tlf-titling-ly1.vf \
tex-Inter-BlackItalic-tlf-titling-ot1--base.tfm \
tex-Inter-BlackItalic-tlf-titling-ot1.tfm \
tex-Inter-BlackItalic-tlf-titling-ot1.vf \
tex-Inter-BlackItalic-tlf-titling-t1--base.tfm \
tex-Inter-BlackItalic-tlf-titling-t1.tfm \
tex-Inter-BlackItalic-tlf-titling-t1.vf \
tex-Inter-BlackItalic-tlf-ts1--base.tfm \
tex-Inter-BlackItalic-tlf-ts1.tfm \
tex-Inter-BlackItalic-tlf-ts1.vf \
tex-Inter-Bold-lf-ly1--base.tfm \
tex-Inter-Bold-lf-ly1.tfm \
tex-Inter-Bold-lf-ly1.vf \
tex-Inter-Bold-lf-ot1.tfm \
tex-Inter-Bold-lf-swash-ly1--base.tfm \
tex-Inter-Bold-lf-swash-ly1.tfm \
tex-Inter-Bold-lf-swash-ly1.vf \
tex-Inter-Bold-lf-swash-ot1.tfm \
tex-Inter-Bold-lf-swash-t1--base.tfm \
tex-Inter-Bold-lf-swash-t1.tfm \
tex-Inter-Bold-lf-swash-t1.vf \
tex-Inter-Bold-lf-t1--base.tfm \
tex-Inter-Bold-lf-t1.tfm \
tex-Inter-Bold-lf-t1.vf \
tex-Inter-Bold-lf-titling-ly1--base.tfm \
tex-Inter-Bold-lf-titling-ly1.tfm \
tex-Inter-Bold-lf-titling-ly1.vf \
tex-Inter-Bold-lf-titling-ot1--base.tfm \
tex-Inter-Bold-lf-titling-ot1.tfm \
tex-Inter-Bold-lf-titling-ot1.vf \
tex-Inter-Bold-lf-titling-t1--base.tfm \
tex-Inter-Bold-lf-titling-t1.tfm \
tex-Inter-Bold-lf-titling-t1.vf \
tex-Inter-Bold-lf-ts1--base.tfm \
tex-Inter-Bold-lf-ts1.tfm \
tex-Inter-Bold-lf-ts1.vf \
tex-Inter-Bold-sup-ly1--base.tfm \
tex-Inter-Bold-sup-ly1.tfm \
tex-Inter-Bold-sup-ly1.vf \
tex-Inter-Bold-sup-ot1.tfm \
tex-Inter-Bold-sup-t1--base.tfm \
tex-Inter-Bold-sup-t1.tfm \
tex-Inter-Bold-sup-t1.vf \
tex-Inter-Bold-tlf-ly1--base.tfm \
tex-Inter-Bold-tlf-ly1.tfm \
tex-Inter-Bold-tlf-ly1.vf \
tex-Inter-Bold-tlf-ot1.tfm \
tex-Inter-Bold-tlf-swash-ly1--base.tfm \
tex-Inter-Bold-tlf-swash-ly1.tfm \
tex-Inter-Bold-tlf-swash-ly1.vf \
tex-Inter-Bold-tlf-swash-ot1.tfm \
tex-Inter-Bold-tlf-swash-t1--base.tfm \
tex-Inter-Bold-tlf-swash-t1.tfm \
tex-Inter-Bold-tlf-swash-t1.vf \
tex-Inter-Bold-tlf-t1--base.tfm \
tex-Inter-Bold-tlf-t1.tfm \
tex-Inter-Bold-tlf-t1.vf \
tex-Inter-Bold-tlf-titling-ly1--base.tfm \
tex-Inter-Bold-tlf-titling-ly1.tfm \
tex-Inter-Bold-tlf-titling-ly1.vf \
tex-Inter-Bold-tlf-titling-ot1--base.tfm \
tex-Inter-Bold-tlf-titling-ot1.tfm \
tex-Inter-Bold-tlf-titling-ot1.vf \
tex-Inter-Bold-tlf-titling-t1--base.tfm \
tex-Inter-Bold-tlf-titling-t1.tfm \
tex-Inter-Bold-tlf-titling-t1.vf \
tex-Inter-Bold-tlf-ts1--base.tfm \
tex-Inter-Bold-tlf-ts1.tfm \
tex-Inter-Bold-tlf-ts1.vf \
tex-Inter-BoldItalic-lf-ly1--base.tfm \
tex-Inter-BoldItalic-lf-ly1.tfm \
tex-Inter-BoldItalic-lf-ly1.vf \
tex-Inter-BoldItalic-lf-ot1.tfm \
tex-Inter-BoldItalic-lf-swash-ly1--base.tfm \
tex-Inter-BoldItalic-lf-swash-ly1.tfm \
tex-Inter-BoldItalic-lf-swash-ly1.vf \
tex-Inter-BoldItalic-lf-swash-ot1.tfm \
tex-Inter-BoldItalic-lf-swash-t1--base.tfm \
tex-Inter-BoldItalic-lf-swash-t1.tfm \
tex-Inter-BoldItalic-lf-swash-t1.vf \
tex-Inter-BoldItalic-lf-t1--base.tfm \
tex-Inter-BoldItalic-lf-t1.tfm \
tex-Inter-BoldItalic-lf-t1.vf \
tex-Inter-BoldItalic-lf-titling-ly1--base.tfm \
tex-Inter-BoldItalic-lf-titling-ly1.tfm \
tex-Inter-BoldItalic-lf-titling-ly1.vf \
tex-Inter-BoldItalic-lf-titling-ot1--base.tfm \
tex-Inter-BoldItalic-lf-titling-ot1.tfm \
tex-Inter-BoldItalic-lf-titling-ot1.vf \
tex-Inter-BoldItalic-lf-titling-t1--base.tfm \
tex-Inter-BoldItalic-lf-titling-t1.tfm \
tex-Inter-BoldItalic-lf-titling-t1.vf \
tex-Inter-BoldItalic-lf-ts1--base.tfm \
tex-Inter-BoldItalic-lf-ts1.tfm \
tex-Inter-BoldItalic-lf-ts1.vf \
tex-Inter-BoldItalic-sup-ly1--base.tfm \
tex-Inter-BoldItalic-sup-ly1.tfm \
tex-Inter-BoldItalic-sup-ly1.vf \
tex-Inter-BoldItalic-sup-ot1.tfm \
tex-Inter-BoldItalic-sup-t1--base.tfm \
tex-Inter-BoldItalic-sup-t1.tfm \
tex-Inter-BoldItalic-sup-t1.vf \
tex-Inter-BoldItalic-tlf-ly1--base.tfm \
tex-Inter-BoldItalic-tlf-ly1.tfm \
tex-Inter-BoldItalic-tlf-ly1.vf \
tex-Inter-BoldItalic-tlf-ot1.tfm \
tex-Inter-BoldItalic-tlf-swash-ly1--base.tfm \
tex-Inter-BoldItalic-tlf-swash-ly1.tfm \
tex-Inter-BoldItalic-tlf-swash-ly1.vf \
tex-Inter-BoldItalic-tlf-swash-ot1.tfm \
tex-Inter-BoldItalic-tlf-swash-t1--base.tfm \
tex-Inter-BoldItalic-tlf-swash-t1.tfm \
tex-Inter-BoldItalic-tlf-swash-t1.vf \
tex-Inter-BoldItalic-tlf-t1--base.tfm \
tex-Inter-BoldItalic-tlf-t1.tfm \
tex-Inter-BoldItalic-tlf-t1.vf \
tex-Inter-BoldItalic-tlf-titling-ly1--base.tfm \
tex-Inter-BoldItalic-tlf-titling-ly1.tfm \
tex-Inter-BoldItalic-tlf-titling-ly1.vf \
tex-Inter-BoldItalic-tlf-titling-ot1--base.tfm \
tex-Inter-BoldItalic-tlf-titling-ot1.tfm \
tex-Inter-BoldItalic-tlf-titling-ot1.vf \
tex-Inter-BoldItalic-tlf-titling-t1--base.tfm \
tex-Inter-BoldItalic-tlf-titling-t1.tfm \
tex-Inter-BoldItalic-tlf-titling-t1.vf \
tex-Inter-BoldItalic-tlf-ts1--base.tfm \
tex-Inter-BoldItalic-tlf-ts1.tfm \
tex-Inter-BoldItalic-tlf-ts1.vf \
tex-Inter-ExtraBold-lf-ly1--base.tfm \
tex-Inter-ExtraBold-lf-ly1.tfm \
tex-Inter-ExtraBold-lf-ly1.vf \
tex-Inter-ExtraBold-lf-ot1.tfm \
tex-Inter-ExtraBold-lf-swash-ly1--base.tfm \
tex-Inter-ExtraBold-lf-swash-ly1.tfm \
tex-Inter-ExtraBold-lf-swash-ly1.vf \
tex-Inter-ExtraBold-lf-swash-ot1.tfm \
tex-Inter-ExtraBold-lf-swash-t1--base.tfm \
tex-Inter-ExtraBold-lf-swash-t1.tfm \
tex-Inter-ExtraBold-lf-swash-t1.vf \
tex-Inter-ExtraBold-lf-t1--base.tfm \
tex-Inter-ExtraBold-lf-t1.tfm \
tex-Inter-ExtraBold-lf-t1.vf \
tex-Inter-ExtraBold-lf-titling-ly1--base.tfm \
tex-Inter-ExtraBold-lf-titling-ly1.tfm \
tex-Inter-ExtraBold-lf-titling-ly1.vf \
tex-Inter-ExtraBold-lf-titling-ot1--base.tfm \
tex-Inter-ExtraBold-lf-titling-ot1.tfm \
tex-Inter-ExtraBold-lf-titling-ot1.vf \
tex-Inter-ExtraBold-lf-titling-t1--base.tfm \
tex-Inter-ExtraBold-lf-titling-t1.tfm \
tex-Inter-ExtraBold-lf-titling-t1.vf \
tex-Inter-ExtraBold-lf-ts1--base.tfm \
tex-Inter-ExtraBold-lf-ts1.tfm \
tex-Inter-ExtraBold-lf-ts1.vf \
tex-Inter-ExtraBold-sup-ly1--base.tfm \
tex-Inter-ExtraBold-sup-ly1.tfm \
tex-Inter-ExtraBold-sup-ly1.vf \
tex-Inter-ExtraBold-sup-ot1.tfm \
tex-Inter-ExtraBold-sup-t1--base.tfm \
tex-Inter-ExtraBold-sup-t1.tfm \
tex-Inter-ExtraBold-sup-t1.vf \
tex-Inter-ExtraBold-tlf-ly1--base.tfm \
tex-Inter-ExtraBold-tlf-ly1.tfm \
tex-Inter-ExtraBold-tlf-ly1.vf \
tex-Inter-ExtraBold-tlf-ot1.tfm \
tex-Inter-ExtraBold-tlf-swash-ly1--base.tfm \
tex-Inter-ExtraBold-tlf-swash-ly1.tfm \
tex-Inter-ExtraBold-tlf-swash-ly1.vf \
tex-Inter-ExtraBold-tlf-swash-ot1.tfm \
tex-Inter-ExtraBold-tlf-swash-t1--base.tfm \
tex-Inter-ExtraBold-tlf-swash-t1.tfm \
tex-Inter-ExtraBold-tlf-swash-t1.vf \
tex-Inter-ExtraBold-tlf-t1--base.tfm \
tex-Inter-ExtraBold-tlf-t1.tfm \
tex-Inter-ExtraBold-tlf-t1.vf \
tex-Inter-ExtraBold-tlf-titling-ly1--base.tfm \
tex-Inter-ExtraBold-tlf-titling-ly1.tfm \
tex-Inter-ExtraBold-tlf-titling-ly1.vf \
tex-Inter-ExtraBold-tlf-titling-ot1--base.tfm \
tex-Inter-ExtraBold-tlf-titling-ot1.tfm \
tex-Inter-ExtraBold-tlf-titling-ot1.vf \
tex-Inter-ExtraBold-tlf-titling-t1--base.tfm \
tex-Inter-ExtraBold-tlf-titling-t1.tfm \
tex-Inter-ExtraBold-tlf-titling-t1.vf \
tex-Inter-ExtraBold-tlf-ts1--base.tfm \
tex-Inter-ExtraBold-tlf-ts1.tfm \
tex-Inter-ExtraBold-tlf-ts1.vf \
tex-Inter-ExtraBoldItalic-lf-ly1--base.tfm \
tex-Inter-ExtraBoldItalic-lf-ly1.tfm \
tex-Inter-ExtraBoldItalic-lf-ly1.vf \
tex-Inter-ExtraBoldItalic-lf-ot1.tfm \
tex-Inter-ExtraBoldItalic-lf-swash-ly1--base.tfm \
tex-Inter-ExtraBoldItalic-lf-swash-ly1.tfm \
tex-Inter-ExtraBoldItalic-lf-swash-ly1.vf \
tex-Inter-ExtraBoldItalic-lf-swash-ot1.tfm \
tex-Inter-ExtraBoldItalic-lf-swash-t1--base.tfm \
tex-Inter-ExtraBoldItalic-lf-swash-t1.tfm \
tex-Inter-ExtraBoldItalic-lf-swash-t1.vf \
tex-Inter-ExtraBoldItalic-lf-t1--base.tfm \
tex-Inter-ExtraBoldItalic-lf-t1.tfm \
tex-Inter-ExtraBoldItalic-lf-t1.vf \
tex-Inter-ExtraBoldItalic-lf-titling-ly1--base.tfm \
tex-Inter-ExtraBoldItalic-lf-titling-ly1.tfm \
tex-Inter-ExtraBoldItalic-lf-titling-ly1.vf \
tex-Inter-ExtraBoldItalic-lf-titling-ot1--base.tfm \
tex-Inter-ExtraBoldItalic-lf-titling-ot1.tfm \
tex-Inter-ExtraBoldItalic-lf-titling-ot1.vf \
tex-Inter-ExtraBoldItalic-lf-titling-t1--base.tfm \
tex-Inter-ExtraBoldItalic-lf-titling-t1.tfm \
tex-Inter-ExtraBoldItalic-lf-titling-t1.vf \
tex-Inter-ExtraBoldItalic-lf-ts1--base.tfm \
tex-Inter-ExtraBoldItalic-lf-ts1.tfm \
tex-Inter-ExtraBoldItalic-lf-ts1.vf \
tex-Inter-ExtraBoldItalic-sup-ly1--base.tfm \
tex-Inter-ExtraBoldItalic-sup-ly1.tfm \
tex-Inter-ExtraBoldItalic-sup-ly1.vf \
tex-Inter-ExtraBoldItalic-sup-ot1.tfm \
tex-Inter-ExtraBoldItalic-sup-t1--base.tfm \
tex-Inter-ExtraBoldItalic-sup-t1.tfm \
tex-Inter-ExtraBoldItalic-sup-t1.vf \
tex-Inter-ExtraBoldItalic-tlf-ly1--base.tfm \
tex-Inter-ExtraBoldItalic-tlf-ly1.tfm \
tex-Inter-ExtraBoldItalic-tlf-ly1.vf \
tex-Inter-ExtraBoldItalic-tlf-ot1.tfm \
tex-Inter-ExtraBoldItalic-tlf-swash-ly1--base.tfm \
tex-Inter-ExtraBoldItalic-tlf-swash-ly1.tfm \
tex-Inter-ExtraBoldItalic-tlf-swash-ly1.vf \
tex-Inter-ExtraBoldItalic-tlf-swash-ot1.tfm \
tex-Inter-ExtraBoldItalic-tlf-swash-t1--base.tfm \
tex-Inter-ExtraBoldItalic-tlf-swash-t1.tfm \
tex-Inter-ExtraBoldItalic-tlf-swash-t1.vf \
tex-Inter-ExtraBoldItalic-tlf-t1--base.tfm \
tex-Inter-ExtraBoldItalic-tlf-t1.tfm \
tex-Inter-ExtraBoldItalic-tlf-t1.vf \
tex-Inter-ExtraBoldItalic-tlf-titling-ly1--base.tfm \
tex-Inter-ExtraBoldItalic-tlf-titling-ly1.tfm \
tex-Inter-ExtraBoldItalic-tlf-titling-ly1.vf \
tex-Inter-ExtraBoldItalic-tlf-titling-ot1--base.tfm \
tex-Inter-ExtraBoldItalic-tlf-titling-ot1.tfm \
tex-Inter-ExtraBoldItalic-tlf-titling-ot1.vf \
tex-Inter-ExtraBoldItalic-tlf-titling-t1--base.tfm \
tex-Inter-ExtraBoldItalic-tlf-titling-t1.tfm \
tex-Inter-ExtraBoldItalic-tlf-titling-t1.vf \
tex-Inter-ExtraBoldItalic-tlf-ts1--base.tfm \
tex-Inter-ExtraBoldItalic-tlf-ts1.tfm \
tex-Inter-ExtraBoldItalic-tlf-ts1.vf \
tex-Inter-ExtraLight-lf-ly1--base.tfm \
tex-Inter-ExtraLight-lf-ly1.tfm \
tex-Inter-ExtraLight-lf-ly1.vf \
tex-Inter-ExtraLight-lf-ot1.tfm \
tex-Inter-ExtraLight-lf-swash-ly1--base.tfm \
tex-Inter-ExtraLight-lf-swash-ly1.tfm \
tex-Inter-ExtraLight-lf-swash-ly1.vf \
tex-Inter-ExtraLight-lf-swash-ot1.tfm \
tex-Inter-ExtraLight-lf-swash-t1--base.tfm \
tex-Inter-ExtraLight-lf-swash-t1.tfm \
tex-Inter-ExtraLight-lf-swash-t1.vf \
tex-Inter-ExtraLight-lf-t1--base.tfm \
tex-Inter-ExtraLight-lf-t1.tfm \
tex-Inter-ExtraLight-lf-t1.vf \
tex-Inter-ExtraLight-lf-titling-ly1--base.tfm \
tex-Inter-ExtraLight-lf-titling-ly1.tfm \
tex-Inter-ExtraLight-lf-titling-ly1.vf \
tex-Inter-ExtraLight-lf-titling-ot1--base.tfm \
tex-Inter-ExtraLight-lf-titling-ot1.tfm \
tex-Inter-ExtraLight-lf-titling-ot1.vf \
tex-Inter-ExtraLight-lf-titling-t1--base.tfm \
tex-Inter-ExtraLight-lf-titling-t1.tfm \
tex-Inter-ExtraLight-lf-titling-t1.vf \
tex-Inter-ExtraLight-lf-ts1--base.tfm \
tex-Inter-ExtraLight-lf-ts1.tfm \
tex-Inter-ExtraLight-lf-ts1.vf \
tex-Inter-ExtraLight-sup-ly1--base.tfm \
tex-Inter-ExtraLight-sup-ly1.tfm \
tex-Inter-ExtraLight-sup-ly1.vf \
tex-Inter-ExtraLight-sup-ot1.tfm \
tex-Inter-ExtraLight-sup-t1--base.tfm \
tex-Inter-ExtraLight-sup-t1.tfm \
tex-Inter-ExtraLight-sup-t1.vf \
tex-Inter-ExtraLight-tlf-ly1--base.tfm \
tex-Inter-ExtraLight-tlf-ly1.tfm \
tex-Inter-ExtraLight-tlf-ly1.vf \
tex-Inter-ExtraLight-tlf-ot1.tfm \
tex-Inter-ExtraLight-tlf-swash-ly1--base.tfm \
tex-Inter-ExtraLight-tlf-swash-ly1.tfm \
tex-Inter-ExtraLight-tlf-swash-ly1.vf \
tex-Inter-ExtraLight-tlf-swash-ot1.tfm \
tex-Inter-ExtraLight-tlf-swash-t1--base.tfm \
tex-Inter-ExtraLight-tlf-swash-t1.tfm \
tex-Inter-ExtraLight-tlf-swash-t1.vf \
tex-Inter-ExtraLight-tlf-t1--base.tfm \
tex-Inter-ExtraLight-tlf-t1.tfm \
tex-Inter-ExtraLight-tlf-t1.vf \
tex-Inter-ExtraLight-tlf-titling-ly1--base.tfm \
tex-Inter-ExtraLight-tlf-titling-ly1.tfm \
tex-Inter-ExtraLight-tlf-titling-ly1.vf \
tex-Inter-ExtraLight-tlf-titling-ot1--base.tfm \
tex-Inter-ExtraLight-tlf-titling-ot1.tfm \
tex-Inter-ExtraLight-tlf-titling-ot1.vf \
tex-Inter-ExtraLight-tlf-titling-t1--base.tfm \
tex-Inter-ExtraLight-tlf-titling-t1.tfm \
tex-Inter-ExtraLight-tlf-titling-t1.vf \
tex-Inter-ExtraLight-tlf-ts1--base.tfm \
tex-Inter-ExtraLight-tlf-ts1.tfm \
tex-Inter-ExtraLight-tlf-ts1.vf \
tex-Inter-ExtraLightItalic-lf-ly1--base.tfm \
tex-Inter-ExtraLightItalic-lf-ly1.tfm \
tex-Inter-ExtraLightItalic-lf-ly1.vf \
tex-Inter-ExtraLightItalic-lf-ot1.tfm \
tex-Inter-ExtraLightItalic-lf-swash-ly1--base.tfm \
tex-Inter-ExtraLightItalic-lf-swash-ly1.tfm \
tex-Inter-ExtraLightItalic-lf-swash-ly1.vf \
tex-Inter-ExtraLightItalic-lf-swash-ot1.tfm \
tex-Inter-ExtraLightItalic-lf-swash-t1--base.tfm \
tex-Inter-ExtraLightItalic-lf-swash-t1.tfm \
tex-Inter-ExtraLightItalic-lf-swash-t1.vf \
tex-Inter-ExtraLightItalic-lf-t1--base.tfm \
tex-Inter-ExtraLightItalic-lf-t1.tfm \
tex-Inter-ExtraLightItalic-lf-t1.vf \
tex-Inter-ExtraLightItalic-lf-titling-ly1--base.tfm \
tex-Inter-ExtraLightItalic-lf-titling-ly1.tfm \
tex-Inter-ExtraLightItalic-lf-titling-ly1.vf \
tex-Inter-ExtraLightItalic-lf-titling-ot1--base.tfm \
tex-Inter-ExtraLightItalic-lf-titling-ot1.tfm \
tex-Inter-ExtraLightItalic-lf-titling-ot1.vf \
tex-Inter-ExtraLightItalic-lf-titling-t1--base.tfm \
tex-Inter-ExtraLightItalic-lf-titling-t1.tfm \
tex-Inter-ExtraLightItalic-lf-titling-t1.vf \
tex-Inter-ExtraLightItalic-lf-ts1--base.tfm \
tex-Inter-ExtraLightItalic-lf-ts1.tfm \
tex-Inter-ExtraLightItalic-lf-ts1.vf \
tex-Inter-ExtraLightItalic-sup-ly1--base.tfm \
tex-Inter-ExtraLightItalic-sup-ly1.tfm \
tex-Inter-ExtraLightItalic-sup-ly1.vf \
tex-Inter-ExtraLightItalic-sup-ot1.tfm \
tex-Inter-ExtraLightItalic-sup-t1--base.tfm \
tex-Inter-ExtraLightItalic-sup-t1.tfm \
tex-Inter-ExtraLightItalic-sup-t1.vf \
tex-Inter-ExtraLightItalic-tlf-ly1--base.tfm \
tex-Inter-ExtraLightItalic-tlf-ly1.tfm \
tex-Inter-ExtraLightItalic-tlf-ly1.vf \
tex-Inter-ExtraLightItalic-tlf-ot1.tfm \
tex-Inter-ExtraLightItalic-tlf-swash-ly1--base.tfm \
tex-Inter-ExtraLightItalic-tlf-swash-ly1.tfm \
tex-Inter-ExtraLightItalic-tlf-swash-ly1.vf \
tex-Inter-ExtraLightItalic-tlf-swash-ot1.tfm \
tex-Inter-ExtraLightItalic-tlf-swash-t1--base.tfm \
tex-Inter-ExtraLightItalic-tlf-swash-t1.tfm \
tex-Inter-ExtraLightItalic-tlf-swash-t1.vf \
tex-Inter-ExtraLightItalic-tlf-t1--base.tfm \
tex-Inter-ExtraLightItalic-tlf-t1.tfm \
tex-Inter-ExtraLightItalic-tlf-t1.vf \
tex-Inter-ExtraLightItalic-tlf-titling-ly1--base.tfm \
tex-Inter-ExtraLightItalic-tlf-titling-ly1.tfm \
tex-Inter-ExtraLightItalic-tlf-titling-ly1.vf \
tex-Inter-ExtraLightItalic-tlf-titling-ot1--base.tfm \
tex-Inter-ExtraLightItalic-tlf-titling-ot1.tfm \
tex-Inter-ExtraLightItalic-tlf-titling-ot1.vf \
tex-Inter-ExtraLightItalic-tlf-titling-t1--base.tfm \
tex-Inter-ExtraLightItalic-tlf-titling-t1.tfm \
tex-Inter-ExtraLightItalic-tlf-titling-t1.vf \
tex-Inter-ExtraLightItalic-tlf-ts1--base.tfm \
tex-Inter-ExtraLightItalic-tlf-ts1.tfm \
tex-Inter-ExtraLightItalic-tlf-ts1.vf \
tex-Inter-Italic-lf-ly1--base.tfm \
tex-Inter-Italic-lf-ly1.tfm \
tex-Inter-Italic-lf-ly1.vf \
tex-Inter-Italic-lf-ot1.tfm \
tex-Inter-Italic-lf-swash-ly1--base.tfm \
tex-Inter-Italic-lf-swash-ly1.tfm \
tex-Inter-Italic-lf-swash-ly1.vf \
tex-Inter-Italic-lf-swash-ot1.tfm \
tex-Inter-Italic-lf-swash-t1--base.tfm \
tex-Inter-Italic-lf-swash-t1.tfm \
tex-Inter-Italic-lf-swash-t1.vf \
tex-Inter-Italic-lf-t1--base.tfm \
tex-Inter-Italic-lf-t1.tfm \
tex-Inter-Italic-lf-t1.vf \
tex-Inter-Italic-lf-titling-ly1--base.tfm \
tex-Inter-Italic-lf-titling-ly1.tfm \
tex-Inter-Italic-lf-titling-ly1.vf \
tex-Inter-Italic-lf-titling-ot1--base.tfm \
tex-Inter-Italic-lf-titling-ot1.tfm \
tex-Inter-Italic-lf-titling-ot1.vf \
tex-Inter-Italic-lf-titling-t1--base.tfm \
tex-Inter-Italic-lf-titling-t1.tfm \
tex-Inter-Italic-lf-titling-t1.vf \
tex-Inter-Italic-lf-ts1--base.tfm \
tex-Inter-Italic-lf-ts1.tfm \
tex-Inter-Italic-lf-ts1.vf \
tex-Inter-Italic-sup-ly1--base.tfm \
tex-Inter-Italic-sup-ly1.tfm \
tex-Inter-Italic-sup-ly1.vf \
tex-Inter-Italic-sup-ot1.tfm \
tex-Inter-Italic-sup-t1--base.tfm \
tex-Inter-Italic-sup-t1.tfm \
tex-Inter-Italic-sup-t1.vf \
tex-Inter-Italic-tlf-ly1--base.tfm \
tex-Inter-Italic-tlf-ly1.tfm \
tex-Inter-Italic-tlf-ly1.vf \
tex-Inter-Italic-tlf-ot1.tfm \
tex-Inter-Italic-tlf-swash-ly1--base.tfm \
tex-Inter-Italic-tlf-swash-ly1.tfm \
tex-Inter-Italic-tlf-swash-ly1.vf \
tex-Inter-Italic-tlf-swash-ot1.tfm \
tex-Inter-Italic-tlf-swash-t1--base.tfm \
tex-Inter-Italic-tlf-swash-t1.tfm \
tex-Inter-Italic-tlf-swash-t1.vf \
tex-Inter-Italic-tlf-t1--base.tfm \
tex-Inter-Italic-tlf-t1.tfm \
tex-Inter-Italic-tlf-t1.vf \
tex-Inter-Italic-tlf-titling-ly1--base.tfm \
tex-Inter-Italic-tlf-titling-ly1.tfm \
tex-Inter-Italic-tlf-titling-ly1.vf \
tex-Inter-Italic-tlf-titling-ot1--base.tfm \
tex-Inter-Italic-tlf-titling-ot1.tfm \
tex-Inter-Italic-tlf-titling-ot1.vf \
tex-Inter-Italic-tlf-titling-t1--base.tfm \
tex-Inter-Italic-tlf-titling-t1.tfm \
tex-Inter-Italic-tlf-titling-t1.vf \
tex-Inter-Italic-tlf-ts1--base.tfm \
tex-Inter-Italic-tlf-ts1.tfm \
tex-Inter-Italic-tlf-ts1.vf \
tex-Inter-Light-lf-ly1--base.tfm \
tex-Inter-Light-lf-ly1.tfm \
tex-Inter-Light-lf-ly1.vf \
tex-Inter-Light-lf-ot1.tfm \
tex-Inter-Light-lf-swash-ly1--base.tfm \
tex-Inter-Light-lf-swash-ly1.tfm \
tex-Inter-Light-lf-swash-ly1.vf \
tex-Inter-Light-lf-swash-ot1.tfm \
tex-Inter-Light-lf-swash-t1--base.tfm \
tex-Inter-Light-lf-swash-t1.tfm \
tex-Inter-Light-lf-swash-t1.vf \
tex-Inter-Light-lf-t1--base.tfm \
tex-Inter-Light-lf-t1.tfm \
tex-Inter-Light-lf-t1.vf \
tex-Inter-Light-lf-titling-ly1--base.tfm \
tex-Inter-Light-lf-titling-ly1.tfm \
tex-Inter-Light-lf-titling-ly1.vf \
tex-Inter-Light-lf-titling-ot1--base.tfm \
tex-Inter-Light-lf-titling-ot1.tfm \
tex-Inter-Light-lf-titling-ot1.vf \
tex-Inter-Light-lf-titling-t1--base.tfm \
tex-Inter-Light-lf-titling-t1.tfm \
tex-Inter-Light-lf-titling-t1.vf \
tex-Inter-Light-lf-ts1--base.tfm \
tex-Inter-Light-lf-ts1.tfm \
tex-Inter-Light-lf-ts1.vf \
tex-Inter-Light-sup-ly1--base.tfm \
tex-Inter-Light-sup-ly1.tfm \
tex-Inter-Light-sup-ly1.vf \
tex-Inter-Light-sup-ot1.tfm \
tex-Inter-Light-sup-t1--base.tfm \
tex-Inter-Light-sup-t1.tfm \
tex-Inter-Light-sup-t1.vf \
tex-Inter-Light-tlf-ly1--base.tfm \
tex-Inter-Light-tlf-ly1.tfm \
tex-Inter-Light-tlf-ly1.vf \
tex-Inter-Light-tlf-ot1.tfm \
tex-Inter-Light-tlf-swash-ly1--base.tfm \
tex-Inter-Light-tlf-swash-ly1.tfm \
tex-Inter-Light-tlf-swash-ly1.vf \
tex-Inter-Light-tlf-swash-ot1.tfm \
tex-Inter-Light-tlf-swash-t1--base.tfm \
tex-Inter-Light-tlf-swash-t1.tfm \
tex-Inter-Light-tlf-swash-t1.vf \
tex-Inter-Light-tlf-t1--base.tfm \
tex-Inter-Light-tlf-t1.tfm \
tex-Inter-Light-tlf-t1.vf \
tex-Inter-Light-tlf-titling-ly1--base.tfm \
tex-Inter-Light-tlf-titling-ly1.tfm \
tex-Inter-Light-tlf-titling-ly1.vf \
tex-Inter-Light-tlf-titling-ot1--base.tfm \
tex-Inter-Light-tlf-titling-ot1.tfm \
tex-Inter-Light-tlf-titling-ot1.vf \
tex-Inter-Light-tlf-titling-t1--base.tfm \
tex-Inter-Light-tlf-titling-t1.tfm \
tex-Inter-Light-tlf-titling-t1.vf \
tex-Inter-Light-tlf-ts1--base.tfm \
tex-Inter-Light-tlf-ts1.tfm \
tex-Inter-Light-tlf-ts1.vf \
tex-Inter-LightItalic-lf-ly1--base.tfm \
tex-Inter-LightItalic-lf-ly1.tfm \
tex-Inter-LightItalic-lf-ly1.vf \
tex-Inter-LightItalic-lf-ot1.tfm \
tex-Inter-LightItalic-lf-swash-ly1--base.tfm \
tex-Inter-LightItalic-lf-swash-ly1.tfm \
tex-Inter-LightItalic-lf-swash-ly1.vf \
tex-Inter-LightItalic-lf-swash-ot1.tfm \
tex-Inter-LightItalic-lf-swash-t1--base.tfm \
tex-Inter-LightItalic-lf-swash-t1.tfm \
tex-Inter-LightItalic-lf-swash-t1.vf \
tex-Inter-LightItalic-lf-t1--base.tfm \
tex-Inter-LightItalic-lf-t1.tfm \
tex-Inter-LightItalic-lf-t1.vf \
tex-Inter-LightItalic-lf-titling-ly1--base.tfm \
tex-Inter-LightItalic-lf-titling-ly1.tfm \
tex-Inter-LightItalic-lf-titling-ly1.vf \
tex-Inter-LightItalic-lf-titling-ot1--base.tfm \
tex-Inter-LightItalic-lf-titling-ot1.tfm \
tex-Inter-LightItalic-lf-titling-ot1.vf \
tex-Inter-LightItalic-lf-titling-t1--base.tfm \
tex-Inter-LightItalic-lf-titling-t1.tfm \
tex-Inter-LightItalic-lf-titling-t1.vf \
tex-Inter-LightItalic-lf-ts1--base.tfm \
tex-Inter-LightItalic-lf-ts1.tfm \
tex-Inter-LightItalic-lf-ts1.vf \
tex-Inter-LightItalic-sup-ly1--base.tfm \
tex-Inter-LightItalic-sup-ly1.tfm \
tex-Inter-LightItalic-sup-ly1.vf \
tex-Inter-LightItalic-sup-ot1.tfm \
tex-Inter-LightItalic-sup-t1--base.tfm \
tex-Inter-LightItalic-sup-t1.tfm \
tex-Inter-LightItalic-sup-t1.vf \
tex-Inter-LightItalic-tlf-ly1--base.tfm \
tex-Inter-LightItalic-tlf-ly1.tfm \
tex-Inter-LightItalic-tlf-ly1.vf \
tex-Inter-LightItalic-tlf-ot1.tfm \
tex-Inter-LightItalic-tlf-swash-ly1--base.tfm \
tex-Inter-LightItalic-tlf-swash-ly1.tfm \
tex-Inter-LightItalic-tlf-swash-ly1.vf \
tex-Inter-LightItalic-tlf-swash-ot1.tfm \
tex-Inter-LightItalic-tlf-swash-t1--base.tfm \
tex-Inter-LightItalic-tlf-swash-t1.tfm \
tex-Inter-LightItalic-tlf-swash-t1.vf \
tex-Inter-LightItalic-tlf-t1--base.tfm \
tex-Inter-LightItalic-tlf-t1.tfm \
tex-Inter-LightItalic-tlf-t1.vf \
tex-Inter-LightItalic-tlf-titling-ly1--base.tfm \
tex-Inter-LightItalic-tlf-titling-ly1.tfm \
tex-Inter-LightItalic-tlf-titling-ly1.vf \
tex-Inter-LightItalic-tlf-titling-ot1--base.tfm \
tex-Inter-LightItalic-tlf-titling-ot1.tfm \
tex-Inter-LightItalic-tlf-titling-ot1.vf \
tex-Inter-LightItalic-tlf-titling-t1--base.tfm \
tex-Inter-LightItalic-tlf-titling-t1.tfm \
tex-Inter-LightItalic-tlf-titling-t1.vf \
tex-Inter-LightItalic-tlf-ts1--base.tfm \
tex-Inter-LightItalic-tlf-ts1.tfm \
tex-Inter-LightItalic-tlf-ts1.vf \
tex-Inter-Medium-lf-ly1--base.tfm \
tex-Inter-Medium-lf-ly1.tfm \
tex-Inter-Medium-lf-ly1.vf \
tex-Inter-Medium-lf-ot1.tfm \
tex-Inter-Medium-lf-swash-ly1--base.tfm \
tex-Inter-Medium-lf-swash-ly1.tfm \
tex-Inter-Medium-lf-swash-ly1.vf \
tex-Inter-Medium-lf-swash-ot1.tfm \
tex-Inter-Medium-lf-swash-t1--base.tfm \
tex-Inter-Medium-lf-swash-t1.tfm \
tex-Inter-Medium-lf-swash-t1.vf \
tex-Inter-Medium-lf-t1--base.tfm \
tex-Inter-Medium-lf-t1.tfm \
tex-Inter-Medium-lf-t1.vf \
tex-Inter-Medium-lf-titling-ly1--base.tfm \
tex-Inter-Medium-lf-titling-ly1.tfm \
tex-Inter-Medium-lf-titling-ly1.vf \
tex-Inter-Medium-lf-titling-ot1--base.tfm \
tex-Inter-Medium-lf-titling-ot1.tfm \
tex-Inter-Medium-lf-titling-ot1.vf \
tex-Inter-Medium-lf-titling-t1--base.tfm \
tex-Inter-Medium-lf-titling-t1.tfm \
tex-Inter-Medium-lf-titling-t1.vf \
tex-Inter-Medium-lf-ts1--base.tfm \
tex-Inter-Medium-lf-ts1.tfm \
tex-Inter-Medium-lf-ts1.vf \
tex-Inter-Medium-sup-ly1--base.tfm \
tex-Inter-Medium-sup-ly1.tfm \
tex-Inter-Medium-sup-ly1.vf \
tex-Inter-Medium-sup-ot1.tfm \
tex-Inter-Medium-sup-t1--base.tfm \
tex-Inter-Medium-sup-t1.tfm \
tex-Inter-Medium-sup-t1.vf \
tex-Inter-Medium-tlf-ly1--base.tfm \
tex-Inter-Medium-tlf-ly1.tfm \
tex-Inter-Medium-tlf-ly1.vf \
tex-Inter-Medium-tlf-ot1.tfm \
tex-Inter-Medium-tlf-swash-ly1--base.tfm \
tex-Inter-Medium-tlf-swash-ly1.tfm \
tex-Inter-Medium-tlf-swash-ly1.vf \
tex-Inter-Medium-tlf-swash-ot1.tfm \
tex-Inter-Medium-tlf-swash-t1--base.tfm \
tex-Inter-Medium-tlf-swash-t1.tfm \
tex-Inter-Medium-tlf-swash-t1.vf \
tex-Inter-Medium-tlf-t1--base.tfm \
tex-Inter-Medium-tlf-t1.tfm \
tex-Inter-Medium-tlf-t1.vf \
tex-Inter-Medium-tlf-titling-ly1--base.tfm \
tex-Inter-Medium-tlf-titling-ly1.tfm \
tex-Inter-Medium-tlf-titling-ly1.vf \
tex-Inter-Medium-tlf-titling-ot1--base.tfm \
tex-Inter-Medium-tlf-titling-ot1.tfm \
tex-Inter-Medium-tlf-titling-ot1.vf \
tex-Inter-Medium-tlf-titling-t1--base.tfm \
tex-Inter-Medium-tlf-titling-t1.tfm \
tex-Inter-Medium-tlf-titling-t1.vf \
tex-Inter-Medium-tlf-ts1--base.tfm \
tex-Inter-Medium-tlf-ts1.tfm \
tex-Inter-Medium-tlf-ts1.vf \
tex-Inter-MediumItalic-lf-ly1--base.tfm \
tex-Inter-MediumItalic-lf-ly1.tfm \
tex-Inter-MediumItalic-lf-ly1.vf \
tex-Inter-MediumItalic-lf-ot1.tfm \
tex-Inter-MediumItalic-lf-swash-ly1--base.tfm \
tex-Inter-MediumItalic-lf-swash-ly1.tfm \
tex-Inter-MediumItalic-lf-swash-ly1.vf \
tex-Inter-MediumItalic-lf-swash-ot1.tfm \
tex-Inter-MediumItalic-lf-swash-t1--base.tfm \
tex-Inter-MediumItalic-lf-swash-t1.tfm \
tex-Inter-MediumItalic-lf-swash-t1.vf \
tex-Inter-MediumItalic-lf-t1--base.tfm \
tex-Inter-MediumItalic-lf-t1.tfm \
tex-Inter-MediumItalic-lf-t1.vf \
tex-Inter-MediumItalic-lf-titling-ly1--base.tfm \
tex-Inter-MediumItalic-lf-titling-ly1.tfm \
tex-Inter-MediumItalic-lf-titling-ly1.vf \
tex-Inter-MediumItalic-lf-titling-ot1--base.tfm \
tex-Inter-MediumItalic-lf-titling-ot1.tfm \
tex-Inter-MediumItalic-lf-titling-ot1.vf \
tex-Inter-MediumItalic-lf-titling-t1--base.tfm \
tex-Inter-MediumItalic-lf-titling-t1.tfm \
tex-Inter-MediumItalic-lf-titling-t1.vf \
tex-Inter-MediumItalic-lf-ts1--base.tfm \
tex-Inter-MediumItalic-lf-ts1.tfm \
tex-Inter-MediumItalic-lf-ts1.vf \
tex-Inter-MediumItalic-sup-ly1--base.tfm \
tex-Inter-MediumItalic-sup-ly1.tfm \
tex-Inter-MediumItalic-sup-ly1.vf \
tex-Inter-MediumItalic-sup-ot1.tfm \
tex-Inter-MediumItalic-sup-t1--base.tfm \
tex-Inter-MediumItalic-sup-t1.tfm \
tex-Inter-MediumItalic-sup-t1.vf \
tex-Inter-MediumItalic-tlf-ly1--base.tfm \
tex-Inter-MediumItalic-tlf-ly1.tfm \
tex-Inter-MediumItalic-tlf-ly1.vf \
tex-Inter-MediumItalic-tlf-ot1.tfm \
tex-Inter-MediumItalic-tlf-swash-ly1--base.tfm \
tex-Inter-MediumItalic-tlf-swash-ly1.tfm \
tex-Inter-MediumItalic-tlf-swash-ly1.vf \
tex-Inter-MediumItalic-tlf-swash-ot1.tfm \
tex-Inter-MediumItalic-tlf-swash-t1--base.tfm \
tex-Inter-MediumItalic-tlf-swash-t1.tfm \
tex-Inter-MediumItalic-tlf-swash-t1.vf \
tex-Inter-MediumItalic-tlf-t1--base.tfm \
tex-Inter-MediumItalic-tlf-t1.tfm \
tex-Inter-MediumItalic-tlf-t1.vf \
tex-Inter-MediumItalic-tlf-titling-ly1--base.tfm \
tex-Inter-MediumItalic-tlf-titling-ly1.tfm \
tex-Inter-MediumItalic-tlf-titling-ly1.vf \
tex-Inter-MediumItalic-tlf-titling-ot1--base.tfm \
tex-Inter-MediumItalic-tlf-titling-ot1.tfm \
tex-Inter-MediumItalic-tlf-titling-ot1.vf \
tex-Inter-MediumItalic-tlf-titling-t1--base.tfm \
tex-Inter-MediumItalic-tlf-titling-t1.tfm \
tex-Inter-MediumItalic-tlf-titling-t1.vf \
tex-Inter-MediumItalic-tlf-ts1--base.tfm \
tex-Inter-MediumItalic-tlf-ts1.tfm \
tex-Inter-MediumItalic-tlf-ts1.vf \
tex-Inter-Regular-lf-ly1--base.tfm \
tex-Inter-Regular-lf-ly1.tfm \
tex-Inter-Regular-lf-ly1.vf \
tex-Inter-Regular-lf-ot1.tfm \
tex-Inter-Regular-lf-swash-ly1--base.tfm \
tex-Inter-Regular-lf-swash-ly1.tfm \
tex-Inter-Regular-lf-swash-ly1.vf \
tex-Inter-Regular-lf-swash-ot1.tfm \
tex-Inter-Regular-lf-swash-t1--base.tfm \
tex-Inter-Regular-lf-swash-t1.tfm \
tex-Inter-Regular-lf-swash-t1.vf \
tex-Inter-Regular-lf-t1--base.tfm \
tex-Inter-Regular-lf-t1.tfm \
tex-Inter-Regular-lf-t1.vf \
tex-Inter-Regular-lf-titling-ly1--base.tfm \
tex-Inter-Regular-lf-titling-ly1.tfm \
tex-Inter-Regular-lf-titling-ly1.vf \
tex-Inter-Regular-lf-titling-ot1--base.tfm \
tex-Inter-Regular-lf-titling-ot1.tfm \
tex-Inter-Regular-lf-titling-ot1.vf \
tex-Inter-Regular-lf-titling-t1--base.tfm \
tex-Inter-Regular-lf-titling-t1.tfm \
tex-Inter-Regular-lf-titling-t1.vf \
tex-Inter-Regular-lf-ts1--base.tfm \
tex-Inter-Regular-lf-ts1.tfm \
tex-Inter-Regular-lf-ts1.vf \
tex-Inter-Regular-sup-ly1--base.tfm \
tex-Inter-Regular-sup-ly1.tfm \
tex-Inter-Regular-sup-ly1.vf \
tex-Inter-Regular-sup-ot1.tfm \
tex-Inter-Regular-sup-t1--base.tfm \
tex-Inter-Regular-sup-t1.tfm \
tex-Inter-Regular-sup-t1.vf \
tex-Inter-Regular-tlf-ly1--base.tfm \
tex-Inter-Regular-tlf-ly1.tfm \
tex-Inter-Regular-tlf-ly1.vf \
tex-Inter-Regular-tlf-ot1.tfm \
tex-Inter-Regular-tlf-swash-ly1--base.tfm \
tex-Inter-Regular-tlf-swash-ly1.tfm \
tex-Inter-Regular-tlf-swash-ly1.vf \
tex-Inter-Regular-tlf-swash-ot1.tfm \
tex-Inter-Regular-tlf-swash-t1--base.tfm \
tex-Inter-Regular-tlf-swash-t1.tfm \
tex-Inter-Regular-tlf-swash-t1.vf \
tex-Inter-Regular-tlf-t1--base.tfm \
tex-Inter-Regular-tlf-t1.tfm \
tex-Inter-Regular-tlf-t1.vf \
tex-Inter-Regular-tlf-titling-ly1--base.tfm \
tex-Inter-Regular-tlf-titling-ly1.tfm \
tex-Inter-Regular-tlf-titling-ly1.vf \
tex-Inter-Regular-tlf-titling-ot1--base.tfm \
tex-Inter-Regular-tlf-titling-ot1.tfm \
tex-Inter-Regular-tlf-titling-ot1.vf \
tex-Inter-Regular-tlf-titling-t1--base.tfm \
tex-Inter-Regular-tlf-titling-t1.tfm \
tex-Inter-Regular-tlf-titling-t1.vf \
tex-Inter-Regular-tlf-ts1--base.tfm \
tex-Inter-Regular-tlf-ts1.tfm \
tex-Inter-Regular-tlf-ts1.vf \
tex-Inter-SemiBold-lf-ly1--base.tfm \
tex-Inter-SemiBold-lf-ly1.tfm \
tex-Inter-SemiBold-lf-ly1.vf \
tex-Inter-SemiBold-lf-ot1.tfm \
tex-Inter-SemiBold-lf-swash-ly1--base.tfm \
tex-Inter-SemiBold-lf-swash-ly1.tfm \
tex-Inter-SemiBold-lf-swash-ly1.vf \
tex-Inter-SemiBold-lf-swash-ot1.tfm \
tex-Inter-SemiBold-lf-swash-t1--base.tfm \
tex-Inter-SemiBold-lf-swash-t1.tfm \
tex-Inter-SemiBold-lf-swash-t1.vf \
tex-Inter-SemiBold-lf-t1--base.tfm \
tex-Inter-SemiBold-lf-t1.tfm \
tex-Inter-SemiBold-lf-t1.vf \
tex-Inter-SemiBold-lf-titling-ly1--base.tfm \
tex-Inter-SemiBold-lf-titling-ly1.tfm \
tex-Inter-SemiBold-lf-titling-ly1.vf \
tex-Inter-SemiBold-lf-titling-ot1--base.tfm \
tex-Inter-SemiBold-lf-titling-ot1.tfm \
tex-Inter-SemiBold-lf-titling-ot1.vf \
tex-Inter-SemiBold-lf-titling-t1--base.tfm \
tex-Inter-SemiBold-lf-titling-t1.tfm \
tex-Inter-SemiBold-lf-titling-t1.vf \
tex-Inter-SemiBold-lf-ts1--base.tfm \
tex-Inter-SemiBold-lf-ts1.tfm \
tex-Inter-SemiBold-lf-ts1.vf \
tex-Inter-SemiBold-sup-ly1--base.tfm \
tex-Inter-SemiBold-sup-ly1.tfm \
tex-Inter-SemiBold-sup-ly1.vf \
tex-Inter-SemiBold-sup-ot1.tfm \
tex-Inter-SemiBold-sup-t1--base.tfm \
tex-Inter-SemiBold-sup-t1.tfm \
tex-Inter-SemiBold-sup-t1.vf \
tex-Inter-SemiBold-tlf-ly1--base.tfm \
tex-Inter-SemiBold-tlf-ly1.tfm \
tex-Inter-SemiBold-tlf-ly1.vf \
tex-Inter-SemiBold-tlf-ot1.tfm \
tex-Inter-SemiBold-tlf-swash-ly1--base.tfm \
tex-Inter-SemiBold-tlf-swash-ly1.tfm \
tex-Inter-SemiBold-tlf-swash-ly1.vf \
tex-Inter-SemiBold-tlf-swash-ot1.tfm \
tex-Inter-SemiBold-tlf-swash-t1--base.tfm \
tex-Inter-SemiBold-tlf-swash-t1.tfm \
tex-Inter-SemiBold-tlf-swash-t1.vf \
tex-Inter-SemiBold-tlf-t1--base.tfm \
tex-Inter-SemiBold-tlf-t1.tfm \
tex-Inter-SemiBold-tlf-t1.vf \
tex-Inter-SemiBold-tlf-titling-ly1--base.tfm \
tex-Inter-SemiBold-tlf-titling-ly1.tfm \
tex-Inter-SemiBold-tlf-titling-ly1.vf \
tex-Inter-SemiBold-tlf-titling-ot1--base.tfm \
tex-Inter-SemiBold-tlf-titling-ot1.tfm \
tex-Inter-SemiBold-tlf-titling-ot1.vf \
tex-Inter-SemiBold-tlf-titling-t1--base.tfm \
tex-Inter-SemiBold-tlf-titling-t1.tfm \
tex-Inter-SemiBold-tlf-titling-t1.vf \
tex-Inter-SemiBold-tlf-ts1--base.tfm \
tex-Inter-SemiBold-tlf-ts1.tfm \
tex-Inter-SemiBold-tlf-ts1.vf \
tex-Inter-SemiBoldItalic-lf-ly1--base.tfm \
tex-Inter-SemiBoldItalic-lf-ly1.tfm \
tex-Inter-SemiBoldItalic-lf-ly1.vf \
tex-Inter-SemiBoldItalic-lf-ot1.tfm \
tex-Inter-SemiBoldItalic-lf-swash-ly1--base.tfm \
tex-Inter-SemiBoldItalic-lf-swash-ly1.tfm \
tex-Inter-SemiBoldItalic-lf-swash-ly1.vf \
tex-Inter-SemiBoldItalic-lf-swash-ot1.tfm \
tex-Inter-SemiBoldItalic-lf-swash-t1--base.tfm \
tex-Inter-SemiBoldItalic-lf-swash-t1.tfm \
tex-Inter-SemiBoldItalic-lf-swash-t1.vf \
tex-Inter-SemiBoldItalic-lf-t1--base.tfm \
tex-Inter-SemiBoldItalic-lf-t1.tfm \
tex-Inter-SemiBoldItalic-lf-t1.vf \
tex-Inter-SemiBoldItalic-lf-titling-ly1--base.tfm \
tex-Inter-SemiBoldItalic-lf-titling-ly1.tfm \
tex-Inter-SemiBoldItalic-lf-titling-ly1.vf \
tex-Inter-SemiBoldItalic-lf-titling-ot1--base.tfm \
tex-Inter-SemiBoldItalic-lf-titling-ot1.tfm \
tex-Inter-SemiBoldItalic-lf-titling-ot1.vf \
tex-Inter-SemiBoldItalic-lf-titling-t1--base.tfm \
tex-Inter-SemiBoldItalic-lf-titling-t1.tfm \
tex-Inter-SemiBoldItalic-lf-titling-t1.vf \
tex-Inter-SemiBoldItalic-lf-ts1--base.tfm \
tex-Inter-SemiBoldItalic-lf-ts1.tfm \
tex-Inter-SemiBoldItalic-lf-ts1.vf \
tex-Inter-SemiBoldItalic-sup-ly1--base.tfm \
tex-Inter-SemiBoldItalic-sup-ly1.tfm \
tex-Inter-SemiBoldItalic-sup-ly1.vf \
tex-Inter-SemiBoldItalic-sup-ot1.tfm \
tex-Inter-SemiBoldItalic-sup-t1--base.tfm \
tex-Inter-SemiBoldItalic-sup-t1.tfm \
tex-Inter-SemiBoldItalic-sup-t1.vf \
tex-Inter-SemiBoldItalic-tlf-ly1--base.tfm \
tex-Inter-SemiBoldItalic-tlf-ly1.tfm \
tex-Inter-SemiBoldItalic-tlf-ly1.vf \
tex-Inter-SemiBoldItalic-tlf-ot1.tfm \
tex-Inter-SemiBoldItalic-tlf-swash-ly1--base.tfm \
tex-Inter-SemiBoldItalic-tlf-swash-ly1.tfm \
tex-Inter-SemiBoldItalic-tlf-swash-ly1.vf \
tex-Inter-SemiBoldItalic-tlf-swash-ot1.tfm \
tex-Inter-SemiBoldItalic-tlf-swash-t1--base.tfm \
tex-Inter-SemiBoldItalic-tlf-swash-t1.tfm \
tex-Inter-SemiBoldItalic-tlf-swash-t1.vf \
tex-Inter-SemiBoldItalic-tlf-t1--base.tfm \
tex-Inter-SemiBoldItalic-tlf-t1.tfm \
tex-Inter-SemiBoldItalic-tlf-t1.vf \
tex-Inter-SemiBoldItalic-tlf-titling-ly1--base.tfm \
tex-Inter-SemiBoldItalic-tlf-titling-ly1.tfm \
tex-Inter-SemiBoldItalic-tlf-titling-ly1.vf \
tex-Inter-SemiBoldItalic-tlf-titling-ot1--base.tfm \
tex-Inter-SemiBoldItalic-tlf-titling-ot1.tfm \
tex-Inter-SemiBoldItalic-tlf-titling-ot1.vf \
tex-Inter-SemiBoldItalic-tlf-titling-t1--base.tfm \
tex-Inter-SemiBoldItalic-tlf-titling-t1.tfm \
tex-Inter-SemiBoldItalic-tlf-titling-t1.vf \
tex-Inter-SemiBoldItalic-tlf-ts1--base.tfm \
tex-Inter-SemiBoldItalic-tlf-ts1.tfm \
tex-Inter-SemiBoldItalic-tlf-ts1.vf \
tex-Inter-Thin-lf-ly1--base.tfm \
tex-Inter-Thin-lf-ly1.tfm \
tex-Inter-Thin-lf-ly1.vf \
tex-Inter-Thin-lf-ot1.tfm \
tex-Inter-Thin-lf-swash-ly1--base.tfm \
tex-Inter-Thin-lf-swash-ly1.tfm \
tex-Inter-Thin-lf-swash-ly1.vf \
tex-Inter-Thin-lf-swash-ot1.tfm \
tex-Inter-Thin-lf-swash-t1--base.tfm \
tex-Inter-Thin-lf-swash-t1.tfm \
tex-Inter-Thin-lf-swash-t1.vf \
tex-Inter-Thin-lf-t1--base.tfm \
tex-Inter-Thin-lf-t1.tfm \
tex-Inter-Thin-lf-t1.vf \
tex-Inter-Thin-lf-titling-ly1--base.tfm \
tex-Inter-Thin-lf-titling-ly1.tfm \
tex-Inter-Thin-lf-titling-ly1.vf \
tex-Inter-Thin-lf-titling-ot1--base.tfm \
tex-Inter-Thin-lf-titling-ot1.tfm \
tex-Inter-Thin-lf-titling-ot1.vf \
tex-Inter-Thin-lf-titling-t1--base.tfm \
tex-Inter-Thin-lf-titling-t1.tfm \
tex-Inter-Thin-lf-titling-t1.vf \
tex-Inter-Thin-lf-ts1--base.tfm \
tex-Inter-Thin-lf-ts1.tfm \
tex-Inter-Thin-lf-ts1.vf \
tex-Inter-Thin-sup-ly1--base.tfm \
tex-Inter-Thin-sup-ly1.tfm \
tex-Inter-Thin-sup-ly1.vf \
tex-Inter-Thin-sup-ot1.tfm \
tex-Inter-Thin-sup-t1--base.tfm \
tex-Inter-Thin-sup-t1.tfm \
tex-Inter-Thin-sup-t1.vf \
tex-Inter-Thin-tlf-ly1--base.tfm \
tex-Inter-Thin-tlf-ly1.tfm \
tex-Inter-Thin-tlf-ly1.vf \
tex-Inter-Thin-tlf-ot1.tfm \
tex-Inter-Thin-tlf-swash-ly1--base.tfm \
tex-Inter-Thin-tlf-swash-ly1.tfm \
tex-Inter-Thin-tlf-swash-ly1.vf \
tex-Inter-Thin-tlf-swash-ot1.tfm \
tex-Inter-Thin-tlf-swash-t1--base.tfm \
tex-Inter-Thin-tlf-swash-t1.tfm \
tex-Inter-Thin-tlf-swash-t1.vf \
tex-Inter-Thin-tlf-t1--base.tfm \
tex-Inter-Thin-tlf-t1.tfm \
tex-Inter-Thin-tlf-t1.vf \
tex-Inter-Thin-tlf-titling-ly1--base.tfm \
tex-Inter-Thin-tlf-titling-ly1.tfm \
tex-Inter-Thin-tlf-titling-ly1.vf \
tex-Inter-Thin-tlf-titling-ot1--base.tfm \
tex-Inter-Thin-tlf-titling-ot1.tfm \
tex-Inter-Thin-tlf-titling-ot1.vf \
tex-Inter-Thin-tlf-titling-t1--base.tfm \
tex-Inter-Thin-tlf-titling-t1.tfm \
tex-Inter-Thin-tlf-titling-t1.vf \
tex-Inter-Thin-tlf-ts1--base.tfm \
tex-Inter-Thin-tlf-ts1.tfm \
tex-Inter-Thin-tlf-ts1.vf \
tex-Inter-ThinItalic-lf-ly1--base.tfm \
tex-Inter-ThinItalic-lf-ly1.tfm \
tex-Inter-ThinItalic-lf-ly1.vf \
tex-Inter-ThinItalic-lf-ot1.tfm \
tex-Inter-ThinItalic-lf-swash-ly1--base.tfm \
tex-Inter-ThinItalic-lf-swash-ly1.tfm \
tex-Inter-ThinItalic-lf-swash-ly1.vf \
tex-Inter-ThinItalic-lf-swash-ot1.tfm \
tex-Inter-ThinItalic-lf-swash-t1--base.tfm \
tex-Inter-ThinItalic-lf-swash-t1.tfm \
tex-Inter-ThinItalic-lf-swash-t1.vf \
tex-Inter-ThinItalic-lf-t1--base.tfm \
tex-Inter-ThinItalic-lf-t1.tfm \
tex-Inter-ThinItalic-lf-t1.vf \
tex-Inter-ThinItalic-lf-titling-ly1--base.tfm \
tex-Inter-ThinItalic-lf-titling-ly1.tfm \
tex-Inter-ThinItalic-lf-titling-ly1.vf \
tex-Inter-ThinItalic-lf-titling-ot1--base.tfm \
tex-Inter-ThinItalic-lf-titling-ot1.tfm \
tex-Inter-ThinItalic-lf-titling-ot1.vf \
tex-Inter-ThinItalic-lf-titling-t1--base.tfm \
tex-Inter-ThinItalic-lf-titling-t1.tfm \
tex-Inter-ThinItalic-lf-titling-t1.vf \
tex-Inter-ThinItalic-lf-ts1--base.tfm \
tex-Inter-ThinItalic-lf-ts1.tfm \
tex-Inter-ThinItalic-lf-ts1.vf \
tex-Inter-ThinItalic-sup-ly1--base.tfm \
tex-Inter-ThinItalic-sup-ly1.tfm \
tex-Inter-ThinItalic-sup-ly1.vf \
tex-Inter-ThinItalic-sup-ot1.tfm \
tex-Inter-ThinItalic-sup-t1--base.tfm \
tex-Inter-ThinItalic-sup-t1.tfm \
tex-Inter-ThinItalic-sup-t1.vf \
tex-Inter-ThinItalic-tlf-ly1--base.tfm \
tex-Inter-ThinItalic-tlf-ly1.tfm \
tex-Inter-ThinItalic-tlf-ly1.vf \
tex-Inter-ThinItalic-tlf-ot1.tfm \
tex-Inter-ThinItalic-tlf-swash-ly1--base.tfm \
tex-Inter-ThinItalic-tlf-swash-ly1.tfm \
tex-Inter-ThinItalic-tlf-swash-ly1.vf \
tex-Inter-ThinItalic-tlf-swash-ot1.tfm \
tex-Inter-ThinItalic-tlf-swash-t1--base.tfm \
tex-Inter-ThinItalic-tlf-swash-t1.tfm \
tex-Inter-ThinItalic-tlf-swash-t1.vf \
tex-Inter-ThinItalic-tlf-t1--base.tfm \
tex-Inter-ThinItalic-tlf-t1.tfm \
tex-Inter-ThinItalic-tlf-t1.vf \
tex-Inter-ThinItalic-tlf-titling-ly1--base.tfm \
tex-Inter-ThinItalic-tlf-titling-ly1.tfm \
tex-Inter-ThinItalic-tlf-titling-ly1.vf \
tex-Inter-ThinItalic-tlf-titling-ot1--base.tfm \
tex-Inter-ThinItalic-tlf-titling-ot1.tfm \
tex-Inter-ThinItalic-tlf-titling-ot1.vf \
tex-Inter-ThinItalic-tlf-titling-t1--base.tfm \
tex-Inter-ThinItalic-tlf-titling-t1.tfm \
tex-Inter-ThinItalic-tlf-titling-t1.vf \
tex-Inter-ThinItalic-tlf-ts1--base.tfm \
tex-Inter-ThinItalic-tlf-ts1.tfm \
tex-Inter-ThinItalic-tlf-ts1.vf \
tex-Inter.map \
tex-LY1Inter-LF.fd \
tex-LY1Inter-Sup.fd \
tex-LY1Inter-TLF.fd \
tex-OT1Inter-LF.fd \
tex-OT1Inter-Sup.fd \
tex-OT1Inter-TLF.fd \
tex-T1Inter-LF.fd \
tex-T1Inter-Sup.fd \
tex-T1Inter-TLF.fd \
tex-TS1Inter-LF.fd \
tex-TS1Inter-TLF.fd \
tex-a-2p3rhn.enc \
tex-a-3kvptd.enc \
tex-a-6drkwd.enc \
tex-a-6juwg2.enc \
tex-a-bal5qf.enc \
tex-a-cwhrm5.enc \
tex-a-cyrdxo.enc \
tex-a-doz5y6.enc \
tex-a-dxdtrq.enc \
tex-a-g6if7q.enc \
tex-a-ggbt67.enc \
tex-a-hx3dc4.enc \
tex-a-jvxmtv.enc \
tex-a-n63sgl.enc \
tex-a-nkgz7y.enc \
tex-a-pj3fbv.enc \
tex-a-pn4hzq.enc \
tex-a-rjznlt.enc \
tex-a-v3wpkc.enc \
tex-a-wgqtfc.enc \
tex-a-y2idd3.enc \
tex-a-y6622h.enc \
tex-a-yzlvkb.enc \
tex-a-zasxrl.enc \
tex-a-zxuxr2.enc \
tex-inter.sty \
texlive-inter"

RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontaxes.sty \
tex-fontspec.sty \
tex-ifluatex.sty \
tex-ifxetex.sty \
tex-mweights.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-filesystem \
texlive-inter-fonts \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
