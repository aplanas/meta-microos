SUMMARY = "URW 'Base 35' font pack for LaTeX"
DESCRIPTION = "A set of fonts for use as 'drop-in' replacements for Adobe's \
basic set, comprising: Century Schoolbook (substituting for \
Adobe's New Century Schoolbook); Dingbats (substituting for \
Adobe's Zapf Dingbats); Nimbus Mono L (substituting for Abobe's \
Courier); Nimbus Roman No9 L (substituting for Adobe's Times); \
Nimbus Sans L (substituting for Adobe's Helvetica); Standard \
Symbols L (substituting for Adobe's Symbol); URW Bookman; URW \
Chancery L Medium Italic (substituting for Adobe's Zapf \
Chancery); URW Gothic L Book (substituting for Adobe's Avant \
Garde); and URW Palladio L (substituting for Adobe's Palatino)."
LICENSE = "GPL-2.0-or-later"

PV = "2023.201.svn61719"

RPM_NAME = "texlive-helvetic-2023.201.svn61719-53.1.noarch.rpm"
RPM_HASH = "8b5329c5a1306e2ca61fe7fe64d13176e55074aa4ead7c483a2a440bfcf10ce194120181bff4a29dad267d08d9b97acafe3e9f16be8e339bba38d6205ca63491"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex(8ruhv.fd) \
tex(arb10u.tfm) \
tex(arb2n.tfm) \
tex(arb7j.tfm) \
tex(arb8u.tfm) \
tex(arb9t.tfm) \
tex(ari10u.tfm) \
tex(ari2n.tfm) \
tex(ari7j.tfm) \
tex(ari8u.tfm) \
tex(ari9t.tfm) \
tex(arj10u.tfm) \
tex(arj2n.tfm) \
tex(arj7j.tfm) \
tex(arj8u.tfm) \
tex(arj9t.tfm) \
tex(arr10u.tfm) \
tex(arr2n.tfm) \
tex(arr7j.tfm) \
tex(arr8u.tfm) \
tex(arr9t.tfm) \
tex(mhvb.tfm) \
tex(mhvb.vf) \
tex(mhvb8t.tfm) \
tex(mhvb8t.vf) \
tex(mhvbi.tfm) \
tex(mhvbi.vf) \
tex(mhvbi8t.tfm) \
tex(mhvbi8t.vf) \
tex(mhvr.tfm) \
tex(mhvr.vf) \
tex(mhvr8t.tfm) \
tex(mhvr8t.vf) \
tex(mhvri.tfm) \
tex(mhvri.vf) \
tex(mhvri8t.tfm) \
tex(mhvri8t.vf) \
tex(omluhv.fd) \
tex(omsuhv.fd) \
tex(ot1uhv.fd) \
tex(phvb.tfm) \
tex(phvb.vf) \
tex(phvb7t.tfm) \
tex(phvb7t.vf) \
tex(phvb7tn.tfm) \
tex(phvb7tn.vf) \
tex(phvb8c.tfm) \
tex(phvb8c.vf) \
tex(phvb8cn.tfm) \
tex(phvb8cn.vf) \
tex(phvb8r.tfm) \
tex(phvb8rn.tfm) \
tex(phvb8t.tfm) \
tex(phvb8t.vf) \
tex(phvb8tn.tfm) \
tex(phvb8tn.vf) \
tex(phvbc.tfm) \
tex(phvbc.vf) \
tex(phvbc7t.tfm) \
tex(phvbc7t.vf) \
tex(phvbc7tn.tfm) \
tex(phvbc7tn.vf) \
tex(phvbc8t.tfm) \
tex(phvbc8t.vf) \
tex(phvbc8tn.tfm) \
tex(phvbc8tn.vf) \
tex(phvbo.tfm) \
tex(phvbo.vf) \
tex(phvbo7t.tfm) \
tex(phvbo7t.vf) \
tex(phvbo7tn.tfm) \
tex(phvbo7tn.vf) \
tex(phvbo8c.tfm) \
tex(phvbo8c.vf) \
tex(phvbo8cn.tfm) \
tex(phvbo8cn.vf) \
tex(phvbo8r.tfm) \
tex(phvbo8rn.tfm) \
tex(phvbo8t.tfm) \
tex(phvbo8t.vf) \
tex(phvbo8tn.tfm) \
tex(phvbo8tn.vf) \
tex(phvbon.tfm) \
tex(phvbon.vf) \
tex(phvbrn.tfm) \
tex(phvbrn.vf) \
tex(phvr.tfm) \
tex(phvr.vf) \
tex(phvr7t.tfm) \
tex(phvr7t.vf) \
tex(phvr7tn.tfm) \
tex(phvr7tn.vf) \
tex(phvr8c.tfm) \
tex(phvr8c.vf) \
tex(phvr8cn.tfm) \
tex(phvr8cn.vf) \
tex(phvr8r.tfm) \
tex(phvr8rn.tfm) \
tex(phvr8t.tfm) \
tex(phvr8t.vf) \
tex(phvr8tn.tfm) \
tex(phvr8tn.vf) \
tex(phvrc.tfm) \
tex(phvrc.vf) \
tex(phvrc7t.tfm) \
tex(phvrc7t.vf) \
tex(phvrc7tn.tfm) \
tex(phvrc7tn.vf) \
tex(phvrc8t.tfm) \
tex(phvrc8t.vf) \
tex(phvrc8tn.tfm) \
tex(phvrc8tn.vf) \
tex(phvro.tfm) \
tex(phvro.vf) \
tex(phvro7t.tfm) \
tex(phvro7t.vf) \
tex(phvro7tn.tfm) \
tex(phvro7tn.vf) \
tex(phvro8c.tfm) \
tex(phvro8c.vf) \
tex(phvro8cn.tfm) \
tex(phvro8cn.vf) \
tex(phvro8r.tfm) \
tex(phvro8rn.tfm) \
tex(phvro8t.tfm) \
tex(phvro8t.vf) \
tex(phvro8tn.tfm) \
tex(phvro8tn.vf) \
tex(phvron.tfm) \
tex(phvron.vf) \
tex(phvrrn.tfm) \
tex(phvrrn.vf) \
tex(t1uhv.fd) \
tex(ts1uhv.fd) \
tex(uhv.map) \
tex(uhvb7t.tfm) \
tex(uhvb7t.vf) \
tex(uhvb7tn.tfm) \
tex(uhvb7tn.vf) \
tex(uhvb8c.tfm) \
tex(uhvb8c.vf) \
tex(uhvb8cn.tfm) \
tex(uhvb8cn.vf) \
tex(uhvb8r.tfm) \
tex(uhvb8rn.tfm) \
tex(uhvb8t.tfm) \
tex(uhvb8t.vf) \
tex(uhvb8tn.tfm) \
tex(uhvb8tn.vf) \
tex(uhvbc7t.tfm) \
tex(uhvbc7t.vf) \
tex(uhvbc7tn.tfm) \
tex(uhvbc7tn.vf) \
tex(uhvbc8t.tfm) \
tex(uhvbc8t.vf) \
tex(uhvbc8tn.tfm) \
tex(uhvbc8tn.vf) \
tex(uhvbi7t.tfm) \
tex(uhvbi7t.vf) \
tex(uhvbi8c.tfm) \
tex(uhvbi8c.vf) \
tex(uhvbi8r.tfm) \
tex(uhvbi8t.tfm) \
tex(uhvbi8t.vf) \
tex(uhvbo7t.tfm) \
tex(uhvbo7t.vf) \
tex(uhvbo7tn.tfm) \
tex(uhvbo7tn.vf) \
tex(uhvbo8c.tfm) \
tex(uhvbo8c.vf) \
tex(uhvbo8cn.tfm) \
tex(uhvbo8cn.vf) \
tex(uhvbo8r.tfm) \
tex(uhvbo8rn.tfm) \
tex(uhvbo8t.tfm) \
tex(uhvbo8t.vf) \
tex(uhvbo8tn.tfm) \
tex(uhvbo8tn.vf) \
tex(uhvr7t.tfm) \
tex(uhvr7t.vf) \
tex(uhvr7tn.tfm) \
tex(uhvr7tn.vf) \
tex(uhvr8c.tfm) \
tex(uhvr8c.vf) \
tex(uhvr8cn.tfm) \
tex(uhvr8cn.vf) \
tex(uhvr8r.tfm) \
tex(uhvr8rn.tfm) \
tex(uhvr8t.tfm) \
tex(uhvr8t.vf) \
tex(uhvr8tn.tfm) \
tex(uhvr8tn.vf) \
tex(uhvrc7t.tfm) \
tex(uhvrc7t.vf) \
tex(uhvrc7tn.tfm) \
tex(uhvrc7tn.vf) \
tex(uhvrc8t.tfm) \
tex(uhvrc8t.vf) \
tex(uhvrc8tn.tfm) \
tex(uhvrc8tn.vf) \
tex(uhvri7t.tfm) \
tex(uhvri7t.vf) \
tex(uhvri7tn.tfm) \
tex(uhvri7tn.vf) \
tex(uhvri8c.tfm) \
tex(uhvri8c.vf) \
tex(uhvri8cn.tfm) \
tex(uhvri8cn.vf) \
tex(uhvri8r.tfm) \
tex(uhvri8rn.tfm) \
tex(uhvri8t.tfm) \
tex(uhvri8t.vf) \
tex(uhvri8tn.tfm) \
tex(uhvri8tn.vf) \
tex(uhvro7t.tfm) \
tex(uhvro7t.vf) \
tex(uhvro7tn.tfm) \
tex(uhvro7tn.vf) \
tex(uhvro8c.tfm) \
tex(uhvro8c.vf) \
tex(uhvro8cn.tfm) \
tex(uhvro8cn.vf) \
tex(uhvro8r.tfm) \
tex(uhvro8rn.tfm) \
tex(uhvro8t.tfm) \
tex(uhvro8t.vf) \
tex(uhvro8tn.tfm) \
tex(uhvro8tn.vf) \
texlive-helvetic"

RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex(updmap.cfg) \
texlive \
texlive-filesystem \
texlive-helvetic-fonts \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
