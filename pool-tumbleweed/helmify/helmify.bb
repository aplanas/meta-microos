SUMMARY = "Creates Helm chart from Kubernetes yaml"
DESCRIPTION = "CLI that creates Helm charts from kubernetes yamls. \
 \
Helmify reads a list of supported k8s objects from stdin and converts it to a helm chart. Designed to generate charts for k8s operators but not limited to. See examples of charts generated by helmify. \
 \
Supports Helm >=v3.6.0"
LICENSE = "MIT"

PV = "0.4.5"

RPM_NAME = "helmify-0.4.5-1.1.aarch64.rpm"
RPM_HASH = "eedddc9785deb201559d6f8344cb14ab7f72859a98a01ab3d6e422503d70af3ebd912b66b9e09a624fcbcd4ef2adaee96a11afa79eaf4a9fe81ea14c30cd939e"

RPROVIDES:${PN} += "helmify"

RDEPENDS:${PN} += "libc.so.6"

inherit rpm
