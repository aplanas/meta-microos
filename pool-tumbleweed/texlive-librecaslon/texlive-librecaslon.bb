SUMMARY = "Libre Caslon fonts, with LaTeX support"
DESCRIPTION = "The Libre Caslon fonts are designed by Pablo Impallari. \
Although they have been designed for use as web fonts, they \
work well as conventional text fonts. An artificially generated \
BoldItalic variant has been added."
LICENSE = "OFL-1.1"

PV = "2023.201.svn64432"

RPM_NAME = "texlive-librecaslon-2023.201.svn64432-54.1.noarch.rpm"
RPM_HASH = "a513a2ad7d0df4cda41ce9f7659000e7c923030ab15202da982b7fba6fb03046f624c8207a6950984fbd7ebfb8be243aa5cc0999408f55d67f80afe9c1cd3908"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex(LY1LibreCsln-Inf.fd) \
tex(LY1LibreCsln-LF.fd) \
tex(LY1LibreCsln-OsF.fd) \
tex(LY1LibreCsln-Sup.fd) \
tex(LY1LibreCsln-TLF.fd) \
tex(LY1LibreCsln-TOsF.fd) \
tex(LibreCaslon.map) \
tex(LibreCsln-Bold-inf-ly1--base.tfm) \
tex(LibreCsln-Bold-inf-ly1.tfm) \
tex(LibreCsln-Bold-inf-ly1.vf) \
tex(LibreCsln-Bold-inf-ot1.tfm) \
tex(LibreCsln-Bold-inf-t1--base.tfm) \
tex(LibreCsln-Bold-inf-t1.tfm) \
tex(LibreCsln-Bold-inf-t1.vf) \
tex(LibreCsln-Bold-lf-ly1--base.tfm) \
tex(LibreCsln-Bold-lf-ly1.tfm) \
tex(LibreCsln-Bold-lf-ly1.vf) \
tex(LibreCsln-Bold-lf-ot1.tfm) \
tex(LibreCsln-Bold-lf-t1--base.tfm) \
tex(LibreCsln-Bold-lf-t1.tfm) \
tex(LibreCsln-Bold-lf-t1.vf) \
tex(LibreCsln-Bold-lf-ts1--base.tfm) \
tex(LibreCsln-Bold-lf-ts1.tfm) \
tex(LibreCsln-Bold-lf-ts1.vf) \
tex(LibreCsln-Bold-osf-ly1--base.tfm) \
tex(LibreCsln-Bold-osf-ly1.tfm) \
tex(LibreCsln-Bold-osf-ly1.vf) \
tex(LibreCsln-Bold-osf-ot1.tfm) \
tex(LibreCsln-Bold-osf-t1--base.tfm) \
tex(LibreCsln-Bold-osf-t1.tfm) \
tex(LibreCsln-Bold-osf-t1.vf) \
tex(LibreCsln-Bold-osf-ts1--base.tfm) \
tex(LibreCsln-Bold-osf-ts1.tfm) \
tex(LibreCsln-Bold-osf-ts1.vf) \
tex(LibreCsln-Bold-sup-ly1--base.tfm) \
tex(LibreCsln-Bold-sup-ly1.tfm) \
tex(LibreCsln-Bold-sup-ly1.vf) \
tex(LibreCsln-Bold-sup-ot1.tfm) \
tex(LibreCsln-Bold-sup-t1--base.tfm) \
tex(LibreCsln-Bold-sup-t1.tfm) \
tex(LibreCsln-Bold-sup-t1.vf) \
tex(LibreCsln-Bold-tlf-ly1--base.tfm) \
tex(LibreCsln-Bold-tlf-ly1.tfm) \
tex(LibreCsln-Bold-tlf-ly1.vf) \
tex(LibreCsln-Bold-tlf-ot1.tfm) \
tex(LibreCsln-Bold-tlf-t1--base.tfm) \
tex(LibreCsln-Bold-tlf-t1.tfm) \
tex(LibreCsln-Bold-tlf-t1.vf) \
tex(LibreCsln-Bold-tlf-ts1--base.tfm) \
tex(LibreCsln-Bold-tlf-ts1.tfm) \
tex(LibreCsln-Bold-tlf-ts1.vf) \
tex(LibreCsln-Bold-tosf-ly1--base.tfm) \
tex(LibreCsln-Bold-tosf-ly1.tfm) \
tex(LibreCsln-Bold-tosf-ly1.vf) \
tex(LibreCsln-Bold-tosf-ot1.tfm) \
tex(LibreCsln-Bold-tosf-t1--base.tfm) \
tex(LibreCsln-Bold-tosf-t1.tfm) \
tex(LibreCsln-Bold-tosf-t1.vf) \
tex(LibreCsln-Bold-tosf-ts1--base.tfm) \
tex(LibreCsln-Bold-tosf-ts1.tfm) \
tex(LibreCsln-Bold-tosf-ts1.vf) \
tex(LibreCsln-BoldItalic-inf-ly1--base.tfm) \
tex(LibreCsln-BoldItalic-inf-ly1.tfm) \
tex(LibreCsln-BoldItalic-inf-ly1.vf) \
tex(LibreCsln-BoldItalic-inf-ot1.tfm) \
tex(LibreCsln-BoldItalic-inf-t1--base.tfm) \
tex(LibreCsln-BoldItalic-inf-t1.tfm) \
tex(LibreCsln-BoldItalic-inf-t1.vf) \
tex(LibreCsln-BoldItalic-lf-ly1--base.tfm) \
tex(LibreCsln-BoldItalic-lf-ly1.tfm) \
tex(LibreCsln-BoldItalic-lf-ly1.vf) \
tex(LibreCsln-BoldItalic-lf-ot1.tfm) \
tex(LibreCsln-BoldItalic-lf-t1--base.tfm) \
tex(LibreCsln-BoldItalic-lf-t1.tfm) \
tex(LibreCsln-BoldItalic-lf-t1.vf) \
tex(LibreCsln-BoldItalic-lf-ts1--base.tfm) \
tex(LibreCsln-BoldItalic-lf-ts1.tfm) \
tex(LibreCsln-BoldItalic-lf-ts1.vf) \
tex(LibreCsln-BoldItalic-osf-ly1--base.tfm) \
tex(LibreCsln-BoldItalic-osf-ly1.tfm) \
tex(LibreCsln-BoldItalic-osf-ly1.vf) \
tex(LibreCsln-BoldItalic-osf-ot1.tfm) \
tex(LibreCsln-BoldItalic-osf-t1--base.tfm) \
tex(LibreCsln-BoldItalic-osf-t1.tfm) \
tex(LibreCsln-BoldItalic-osf-t1.vf) \
tex(LibreCsln-BoldItalic-osf-ts1--base.tfm) \
tex(LibreCsln-BoldItalic-osf-ts1.tfm) \
tex(LibreCsln-BoldItalic-osf-ts1.vf) \
tex(LibreCsln-BoldItalic-sup-ly1--base.tfm) \
tex(LibreCsln-BoldItalic-sup-ly1.tfm) \
tex(LibreCsln-BoldItalic-sup-ly1.vf) \
tex(LibreCsln-BoldItalic-sup-ot1.tfm) \
tex(LibreCsln-BoldItalic-sup-t1--base.tfm) \
tex(LibreCsln-BoldItalic-sup-t1.tfm) \
tex(LibreCsln-BoldItalic-sup-t1.vf) \
tex(LibreCsln-BoldItalic-tlf-ly1--base.tfm) \
tex(LibreCsln-BoldItalic-tlf-ly1.tfm) \
tex(LibreCsln-BoldItalic-tlf-ly1.vf) \
tex(LibreCsln-BoldItalic-tlf-ot1.tfm) \
tex(LibreCsln-BoldItalic-tlf-t1--base.tfm) \
tex(LibreCsln-BoldItalic-tlf-t1.tfm) \
tex(LibreCsln-BoldItalic-tlf-t1.vf) \
tex(LibreCsln-BoldItalic-tlf-ts1--base.tfm) \
tex(LibreCsln-BoldItalic-tlf-ts1.tfm) \
tex(LibreCsln-BoldItalic-tlf-ts1.vf) \
tex(LibreCsln-BoldItalic-tosf-ly1--base.tfm) \
tex(LibreCsln-BoldItalic-tosf-ly1.tfm) \
tex(LibreCsln-BoldItalic-tosf-ly1.vf) \
tex(LibreCsln-BoldItalic-tosf-ot1.tfm) \
tex(LibreCsln-BoldItalic-tosf-t1--base.tfm) \
tex(LibreCsln-BoldItalic-tosf-t1.tfm) \
tex(LibreCsln-BoldItalic-tosf-t1.vf) \
tex(LibreCsln-BoldItalic-tosf-ts1--base.tfm) \
tex(LibreCsln-BoldItalic-tosf-ts1.tfm) \
tex(LibreCsln-BoldItalic-tosf-ts1.vf) \
tex(LibreCsln-Italic-inf-ly1--base.tfm) \
tex(LibreCsln-Italic-inf-ly1.tfm) \
tex(LibreCsln-Italic-inf-ly1.vf) \
tex(LibreCsln-Italic-inf-ot1.tfm) \
tex(LibreCsln-Italic-inf-t1--base.tfm) \
tex(LibreCsln-Italic-inf-t1.tfm) \
tex(LibreCsln-Italic-inf-t1.vf) \
tex(LibreCsln-Italic-lf-ly1--base.tfm) \
tex(LibreCsln-Italic-lf-ly1.tfm) \
tex(LibreCsln-Italic-lf-ly1.vf) \
tex(LibreCsln-Italic-lf-ot1.tfm) \
tex(LibreCsln-Italic-lf-t1--base.tfm) \
tex(LibreCsln-Italic-lf-t1.tfm) \
tex(LibreCsln-Italic-lf-t1.vf) \
tex(LibreCsln-Italic-lf-ts1--base.tfm) \
tex(LibreCsln-Italic-lf-ts1.tfm) \
tex(LibreCsln-Italic-lf-ts1.vf) \
tex(LibreCsln-Italic-osf-ly1--base.tfm) \
tex(LibreCsln-Italic-osf-ly1.tfm) \
tex(LibreCsln-Italic-osf-ly1.vf) \
tex(LibreCsln-Italic-osf-ot1.tfm) \
tex(LibreCsln-Italic-osf-t1--base.tfm) \
tex(LibreCsln-Italic-osf-t1.tfm) \
tex(LibreCsln-Italic-osf-t1.vf) \
tex(LibreCsln-Italic-osf-ts1--base.tfm) \
tex(LibreCsln-Italic-osf-ts1.tfm) \
tex(LibreCsln-Italic-osf-ts1.vf) \
tex(LibreCsln-Italic-sup-ly1--base.tfm) \
tex(LibreCsln-Italic-sup-ly1.tfm) \
tex(LibreCsln-Italic-sup-ly1.vf) \
tex(LibreCsln-Italic-sup-ot1.tfm) \
tex(LibreCsln-Italic-sup-t1--base.tfm) \
tex(LibreCsln-Italic-sup-t1.tfm) \
tex(LibreCsln-Italic-sup-t1.vf) \
tex(LibreCsln-Italic-tlf-ly1--base.tfm) \
tex(LibreCsln-Italic-tlf-ly1.tfm) \
tex(LibreCsln-Italic-tlf-ly1.vf) \
tex(LibreCsln-Italic-tlf-ot1.tfm) \
tex(LibreCsln-Italic-tlf-t1--base.tfm) \
tex(LibreCsln-Italic-tlf-t1.tfm) \
tex(LibreCsln-Italic-tlf-t1.vf) \
tex(LibreCsln-Italic-tlf-ts1--base.tfm) \
tex(LibreCsln-Italic-tlf-ts1.tfm) \
tex(LibreCsln-Italic-tlf-ts1.vf) \
tex(LibreCsln-Italic-tosf-ly1--base.tfm) \
tex(LibreCsln-Italic-tosf-ly1.tfm) \
tex(LibreCsln-Italic-tosf-ly1.vf) \
tex(LibreCsln-Italic-tosf-ot1.tfm) \
tex(LibreCsln-Italic-tosf-t1--base.tfm) \
tex(LibreCsln-Italic-tosf-t1.tfm) \
tex(LibreCsln-Italic-tosf-t1.vf) \
tex(LibreCsln-Italic-tosf-ts1--base.tfm) \
tex(LibreCsln-Italic-tosf-ts1.tfm) \
tex(LibreCsln-Italic-tosf-ts1.vf) \
tex(LibreCsln-Regular-inf-ly1--base.tfm) \
tex(LibreCsln-Regular-inf-ly1.tfm) \
tex(LibreCsln-Regular-inf-ly1.vf) \
tex(LibreCsln-Regular-inf-ot1.tfm) \
tex(LibreCsln-Regular-inf-t1--base.tfm) \
tex(LibreCsln-Regular-inf-t1.tfm) \
tex(LibreCsln-Regular-inf-t1.vf) \
tex(LibreCsln-Regular-lf-ly1--base.tfm) \
tex(LibreCsln-Regular-lf-ly1.tfm) \
tex(LibreCsln-Regular-lf-ly1.vf) \
tex(LibreCsln-Regular-lf-ot1.tfm) \
tex(LibreCsln-Regular-lf-t1--base.tfm) \
tex(LibreCsln-Regular-lf-t1.tfm) \
tex(LibreCsln-Regular-lf-t1.vf) \
tex(LibreCsln-Regular-lf-ts1--base.tfm) \
tex(LibreCsln-Regular-lf-ts1.tfm) \
tex(LibreCsln-Regular-lf-ts1.vf) \
tex(LibreCsln-Regular-osf-ly1--base.tfm) \
tex(LibreCsln-Regular-osf-ly1.tfm) \
tex(LibreCsln-Regular-osf-ly1.vf) \
tex(LibreCsln-Regular-osf-ot1.tfm) \
tex(LibreCsln-Regular-osf-t1--base.tfm) \
tex(LibreCsln-Regular-osf-t1.tfm) \
tex(LibreCsln-Regular-osf-t1.vf) \
tex(LibreCsln-Regular-osf-ts1--base.tfm) \
tex(LibreCsln-Regular-osf-ts1.tfm) \
tex(LibreCsln-Regular-osf-ts1.vf) \
tex(LibreCsln-Regular-sup-ly1--base.tfm) \
tex(LibreCsln-Regular-sup-ly1.tfm) \
tex(LibreCsln-Regular-sup-ly1.vf) \
tex(LibreCsln-Regular-sup-ot1.tfm) \
tex(LibreCsln-Regular-sup-t1--base.tfm) \
tex(LibreCsln-Regular-sup-t1.tfm) \
tex(LibreCsln-Regular-sup-t1.vf) \
tex(LibreCsln-Regular-tlf-ly1--base.tfm) \
tex(LibreCsln-Regular-tlf-ly1.tfm) \
tex(LibreCsln-Regular-tlf-ly1.vf) \
tex(LibreCsln-Regular-tlf-ot1.tfm) \
tex(LibreCsln-Regular-tlf-t1--base.tfm) \
tex(LibreCsln-Regular-tlf-t1.tfm) \
tex(LibreCsln-Regular-tlf-t1.vf) \
tex(LibreCsln-Regular-tlf-ts1--base.tfm) \
tex(LibreCsln-Regular-tlf-ts1.tfm) \
tex(LibreCsln-Regular-tlf-ts1.vf) \
tex(LibreCsln-Regular-tosf-ly1--base.tfm) \
tex(LibreCsln-Regular-tosf-ly1.tfm) \
tex(LibreCsln-Regular-tosf-ly1.vf) \
tex(LibreCsln-Regular-tosf-ot1.tfm) \
tex(LibreCsln-Regular-tosf-t1--base.tfm) \
tex(LibreCsln-Regular-tosf-t1.tfm) \
tex(LibreCsln-Regular-tosf-t1.vf) \
tex(LibreCsln-Regular-tosf-ts1--base.tfm) \
tex(LibreCsln-Regular-tosf-ts1.tfm) \
tex(LibreCsln-Regular-tosf-ts1.vf) \
tex(OT1LibreCsln-Inf.fd) \
tex(OT1LibreCsln-LF.fd) \
tex(OT1LibreCsln-OsF.fd) \
tex(OT1LibreCsln-Sup.fd) \
tex(OT1LibreCsln-TLF.fd) \
tex(OT1LibreCsln-TOsF.fd) \
tex(T1LibreCsln-Inf.fd) \
tex(T1LibreCsln-LF.fd) \
tex(T1LibreCsln-OsF.fd) \
tex(T1LibreCsln-Sup.fd) \
tex(T1LibreCsln-TLF.fd) \
tex(T1LibreCsln-TOsF.fd) \
tex(TS1LibreCsln-LF.fd) \
tex(TS1LibreCsln-OsF.fd) \
tex(TS1LibreCsln-TLF.fd) \
tex(TS1LibreCsln-TOsF.fd) \
tex(lcsln_4uz6a2.enc) \
tex(lcsln_4yc6wb.enc) \
tex(lcsln_6hj2ra.enc) \
tex(lcsln_cfomvu.enc) \
tex(lcsln_dwvqiv.enc) \
tex(lcsln_dybe4i.enc) \
tex(lcsln_etzx2k.enc) \
tex(lcsln_fx4jx2.enc) \
tex(lcsln_igmdqj.enc) \
tex(lcsln_n56tqa.enc) \
tex(lcsln_p6yehx.enc) \
tex(lcsln_uf5aa7.enc) \
tex(lcsln_ufnake.enc) \
tex(lcsln_vwciie.enc) \
tex(lcsln_yeotsr.enc) \
tex(lcsln_yiohbm.enc) \
tex(lcsln_zdmgtj.enc) \
tex(librecaslon.sty) \
texlive-librecaslon"

RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex(fontaxes.sty) \
tex(fontenc.sty) \
tex(fontspec.sty) \
tex(ifluatex.sty) \
tex(ifxetex.sty) \
tex(textcomp.sty) \
tex(updmap.cfg) \
tex(xkeyval.sty) \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-librecaslon-fonts \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
