SUMMARY = "Linux kernel firmware files"
DESCRIPTION = "This package contains the raw uncompressed firmware files for Linux kernel \
drivers.  This package is provided only for compatibility with older kernels \
that do not support the compressed format."
LICENSE = "GPL-2.0-only & SUSE-Firmware & GPL-2.0-or-later & MIT"

PV = "20230724"

RPM_NAME = "kernel-firmware-20230724-1.1.noarch.rpm"
RPM_HASH = "672eba312994b9cd49f93445abe6c381a4f32e56611a52b4e8134c68a1e79d8087e905ba8471833651770e7782499c89d197df6438ac7e5d7aa8addc6cba3794"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "3-model-a-plus.txt) \
3-model-b-plus.txt) \
3-model-b.txt) \
4 \
4-model-b.txt) \
4.txt) \
B.txt) \
C0 \
COMPUTER \
Compute \
Corp.-VALLEYVIEW \
Corporation-CHERRYVIEW \
D1 \
Foundation-Raspberry \
INC.-TF103CE.txt) \
Inc-Mipad2.txt) \
Model \
Module \
PLATFORM.txt) \
PLUS.txt) \
Pi \
Z83-4.txt) \
am5729-beagleboneai.txt) \
ath3k-firmware \
aura.txt) \
bananapro.txt) \
bcm43xx-firmware-/lib/firmware/brcm/brcmfmac43430-sdio.bin \
beaglev-starlight-jh7100-a1.txt) \
beaglev-starlight-jh7100-r0.txt) \
bpi-m2-plus.txt) \
bpi-m2-ultra.txt) \
bpi-m2-zero.txt) \
bpi-m3.txt) \
compat-wireless-firmware \
cubietruck.txt) \
cxgb3-firmware \
firefly-rk3399.txt) \
firmware(brcm/brcmfmac43241b4-sdio.Intel \
firmware(brcm/brcmfmac43340-sdio.ASUSTeK \
firmware(brcm/brcmfmac43362-sdio.cubietech \
firmware(brcm/brcmfmac43362-sdio.kobo \
firmware(brcm/brcmfmac43362-sdio.lemaker \
firmware(brcm/brcmfmac43430-sdio.beagle \
firmware(brcm/brcmfmac43430-sdio.friendlyarm \
firmware(brcm/brcmfmac43430-sdio.raspberrypi \
firmware(brcm/brcmfmac43430-sdio.sinovoip \
firmware(brcm/brcmfmac43430-sdio.starfive \
firmware(brcm/brcmfmac43430a0-sdio.ONDA-V80 \
firmware(brcm/brcmfmac43455-sdio.MINIX-NEO \
firmware(brcm/brcmfmac43455-sdio.Raspberry \
firmware(brcm/brcmfmac43455-sdio.beagle \
firmware(brcm/brcmfmac43455-sdio.pine64 \
firmware(brcm/brcmfmac43455-sdio.raspberrypi \
firmware(brcm/brcmfmac4356-pcie.Intel \
firmware(brcm/brcmfmac4356-pcie.Xiaomi \
firmware(brcm/brcmfmac4356-sdio.firefly \
firmware(brcm/brcmfmac4356-sdio.khadas \
firmware(brcm/brcmfmac4356-sdio.vamrs \
firmware-3com/typhoon.bin \
firmware-RTL8192E/boot.img \
firmware-RTL8192E/data.img \
firmware-RTL8192E/main.img \
firmware-a300-pfp.fw \
firmware-a300-pm4.fw \
firmware-acenic/tg1.bin \
firmware-acenic/tg2.bin \
firmware-adaptec/starfire-rx.bin \
firmware-adaptec/starfire-tx.bin \
firmware-advansys/3550.bin \
firmware-advansys/38C0800.bin \
firmware-advansys/38C1600.bin \
firmware-advansys/mcode.bin \
firmware-agere-ap-fw.bin \
firmware-agere-sta-fw.bin \
firmware-amd/amd-sev-fam17h-model0xh.sbin \
firmware-amd/amd-sev-fam17h-model3xh.sbin \
firmware-amd/amd-sev-fam19h-model0xh.sbin \
firmware-amdgpu/aldebaran-mec.bin \
firmware-amdgpu/aldebaran-mec2.bin \
firmware-amdgpu/aldebaran-rlc.bin \
firmware-amdgpu/aldebaran-sdma.bin \
firmware-amdgpu/aldebaran-sjt-mec.bin \
firmware-amdgpu/aldebaran-sjt-mec2.bin \
firmware-amdgpu/aldebaran-smc.bin \
firmware-amdgpu/aldebaran-sos.bin \
firmware-amdgpu/aldebaran-ta.bin \
firmware-amdgpu/aldebaran-vcn.bin \
firmware-amdgpu/arcturus-asd.bin \
firmware-amdgpu/arcturus-gpu-info.bin \
firmware-amdgpu/arcturus-mec.bin \
firmware-amdgpu/arcturus-mec2.bin \
firmware-amdgpu/arcturus-rlc.bin \
firmware-amdgpu/arcturus-sdma.bin \
firmware-amdgpu/arcturus-smc.bin \
firmware-amdgpu/arcturus-sos.bin \
firmware-amdgpu/arcturus-ta.bin \
firmware-amdgpu/arcturus-vcn.bin \
firmware-amdgpu/banks-k-2-smc.bin \
firmware-amdgpu/beige-goby-ce.bin \
firmware-amdgpu/beige-goby-dmcub.bin \
firmware-amdgpu/beige-goby-me.bin \
firmware-amdgpu/beige-goby-mec.bin \
firmware-amdgpu/beige-goby-mec2.bin \
firmware-amdgpu/beige-goby-pfp.bin \
firmware-amdgpu/beige-goby-rlc.bin \
firmware-amdgpu/beige-goby-sdma.bin \
firmware-amdgpu/beige-goby-smc.bin \
firmware-amdgpu/beige-goby-sos.bin \
firmware-amdgpu/beige-goby-ta.bin \
firmware-amdgpu/beige-goby-vcn.bin \
firmware-amdgpu/bonaire-ce.bin \
firmware-amdgpu/bonaire-k-smc.bin \
firmware-amdgpu/bonaire-mc.bin \
firmware-amdgpu/bonaire-me.bin \
firmware-amdgpu/bonaire-mec.bin \
firmware-amdgpu/bonaire-pfp.bin \
firmware-amdgpu/bonaire-rlc.bin \
firmware-amdgpu/bonaire-sdma.bin \
firmware-amdgpu/bonaire-sdma1.bin \
firmware-amdgpu/bonaire-smc.bin \
firmware-amdgpu/bonaire-uvd.bin \
firmware-amdgpu/bonaire-vce.bin \
firmware-amdgpu/carrizo-ce.bin \
firmware-amdgpu/carrizo-me.bin \
firmware-amdgpu/carrizo-mec.bin \
firmware-amdgpu/carrizo-mec2.bin \
firmware-amdgpu/carrizo-pfp.bin \
firmware-amdgpu/carrizo-rlc.bin \
firmware-amdgpu/carrizo-sdma.bin \
firmware-amdgpu/carrizo-sdma1.bin \
firmware-amdgpu/carrizo-uvd.bin \
firmware-amdgpu/carrizo-vce.bin \
firmware-amdgpu/cyan-skillfish2-ce.bin \
firmware-amdgpu/cyan-skillfish2-me.bin \
firmware-amdgpu/cyan-skillfish2-mec.bin \
firmware-amdgpu/cyan-skillfish2-mec2.bin \
firmware-amdgpu/cyan-skillfish2-pfp.bin \
firmware-amdgpu/cyan-skillfish2-rlc.bin \
firmware-amdgpu/cyan-skillfish2-sdma.bin \
firmware-amdgpu/cyan-skillfish2-sdma1.bin \
firmware-amdgpu/dcn-3-1-4-dmcub.bin \
firmware-amdgpu/dcn-3-1-5-dmcub.bin \
firmware-amdgpu/dcn-3-1-6-dmcub.bin \
firmware-amdgpu/dcn-3-2-0-dmcub.bin \
firmware-amdgpu/dcn-3-2-1-dmcub.bin \
firmware-amdgpu/dimgrey-cavefish-ce.bin \
firmware-amdgpu/dimgrey-cavefish-dmcub.bin \
firmware-amdgpu/dimgrey-cavefish-me.bin \
firmware-amdgpu/dimgrey-cavefish-mec.bin \
firmware-amdgpu/dimgrey-cavefish-mec2.bin \
firmware-amdgpu/dimgrey-cavefish-pfp.bin \
firmware-amdgpu/dimgrey-cavefish-rlc.bin \
firmware-amdgpu/dimgrey-cavefish-sdma.bin \
firmware-amdgpu/dimgrey-cavefish-smc.bin \
firmware-amdgpu/dimgrey-cavefish-sos.bin \
firmware-amdgpu/dimgrey-cavefish-ta.bin \
firmware-amdgpu/dimgrey-cavefish-vcn.bin \
firmware-amdgpu/fiji-ce.bin \
firmware-amdgpu/fiji-mc.bin \
firmware-amdgpu/fiji-me.bin \
firmware-amdgpu/fiji-mec.bin \
firmware-amdgpu/fiji-mec2.bin \
firmware-amdgpu/fiji-pfp.bin \
firmware-amdgpu/fiji-rlc.bin \
firmware-amdgpu/fiji-sdma.bin \
firmware-amdgpu/fiji-sdma1.bin \
firmware-amdgpu/fiji-smc.bin \
firmware-amdgpu/fiji-uvd.bin \
firmware-amdgpu/fiji-vce.bin \
firmware-amdgpu/gc-10-3-6-ce.bin \
firmware-amdgpu/gc-10-3-6-me.bin \
firmware-amdgpu/gc-10-3-6-mec.bin \
firmware-amdgpu/gc-10-3-6-mec2.bin \
firmware-amdgpu/gc-10-3-6-pfp.bin \
firmware-amdgpu/gc-10-3-6-rlc.bin \
firmware-amdgpu/gc-10-3-7-ce.bin \
firmware-amdgpu/gc-10-3-7-me.bin \
firmware-amdgpu/gc-10-3-7-mec.bin \
firmware-amdgpu/gc-10-3-7-mec2.bin \
firmware-amdgpu/gc-10-3-7-pfp.bin \
firmware-amdgpu/gc-10-3-7-rlc.bin \
firmware-amdgpu/gc-11-0-0-imu.bin \
firmware-amdgpu/gc-11-0-0-me.bin \
firmware-amdgpu/gc-11-0-0-mec.bin \
firmware-amdgpu/gc-11-0-0-mes-2.bin \
firmware-amdgpu/gc-11-0-0-mes.bin \
firmware-amdgpu/gc-11-0-0-mes1.bin \
firmware-amdgpu/gc-11-0-0-pfp.bin \
firmware-amdgpu/gc-11-0-0-rlc.bin \
firmware-amdgpu/gc-11-0-1-imu.bin \
firmware-amdgpu/gc-11-0-1-me.bin \
firmware-amdgpu/gc-11-0-1-mec.bin \
firmware-amdgpu/gc-11-0-1-mes-2.bin \
firmware-amdgpu/gc-11-0-1-mes.bin \
firmware-amdgpu/gc-11-0-1-mes1.bin \
firmware-amdgpu/gc-11-0-1-pfp.bin \
firmware-amdgpu/gc-11-0-1-rlc.bin \
firmware-amdgpu/gc-11-0-2-imu.bin \
firmware-amdgpu/gc-11-0-2-me.bin \
firmware-amdgpu/gc-11-0-2-mec.bin \
firmware-amdgpu/gc-11-0-2-mes-2.bin \
firmware-amdgpu/gc-11-0-2-mes.bin \
firmware-amdgpu/gc-11-0-2-mes1.bin \
firmware-amdgpu/gc-11-0-2-pfp.bin \
firmware-amdgpu/gc-11-0-2-rlc.bin \
firmware-amdgpu/gc-11-0-3-imu.bin \
firmware-amdgpu/gc-11-0-3-me.bin \
firmware-amdgpu/gc-11-0-3-mec.bin \
firmware-amdgpu/gc-11-0-3-mes-2.bin \
firmware-amdgpu/gc-11-0-3-mes1.bin \
firmware-amdgpu/gc-11-0-3-pfp.bin \
firmware-amdgpu/gc-11-0-3-rlc.bin \
firmware-amdgpu/gc-11-0-4-imu.bin \
firmware-amdgpu/gc-11-0-4-me.bin \
firmware-amdgpu/gc-11-0-4-mec.bin \
firmware-amdgpu/gc-11-0-4-mes-2.bin \
firmware-amdgpu/gc-11-0-4-mes.bin \
firmware-amdgpu/gc-11-0-4-mes1.bin \
firmware-amdgpu/gc-11-0-4-pfp.bin \
firmware-amdgpu/gc-11-0-4-rlc.bin \
firmware-amdgpu/green-sardine-asd.bin \
firmware-amdgpu/green-sardine-ce.bin \
firmware-amdgpu/green-sardine-dmcub.bin \
firmware-amdgpu/green-sardine-me.bin \
firmware-amdgpu/green-sardine-mec.bin \
firmware-amdgpu/green-sardine-mec2.bin \
firmware-amdgpu/green-sardine-pfp.bin \
firmware-amdgpu/green-sardine-rlc.bin \
firmware-amdgpu/green-sardine-sdma.bin \
firmware-amdgpu/green-sardine-ta.bin \
firmware-amdgpu/green-sardine-vcn.bin \
firmware-amdgpu/hainan-ce.bin \
firmware-amdgpu/hainan-k-smc.bin \
firmware-amdgpu/hainan-mc.bin \
firmware-amdgpu/hainan-me.bin \
firmware-amdgpu/hainan-pfp.bin \
firmware-amdgpu/hainan-rlc.bin \
firmware-amdgpu/hainan-smc.bin \
firmware-amdgpu/hawaii-ce.bin \
firmware-amdgpu/hawaii-k-smc.bin \
firmware-amdgpu/hawaii-mc.bin \
firmware-amdgpu/hawaii-me.bin \
firmware-amdgpu/hawaii-mec.bin \
firmware-amdgpu/hawaii-pfp.bin \
firmware-amdgpu/hawaii-rlc.bin \
firmware-amdgpu/hawaii-sdma.bin \
firmware-amdgpu/hawaii-sdma1.bin \
firmware-amdgpu/hawaii-smc.bin \
firmware-amdgpu/hawaii-uvd.bin \
firmware-amdgpu/hawaii-vce.bin \
firmware-amdgpu/kabini-ce.bin \
firmware-amdgpu/kabini-me.bin \
firmware-amdgpu/kabini-mec.bin \
firmware-amdgpu/kabini-pfp.bin \
firmware-amdgpu/kabini-rlc.bin \
firmware-amdgpu/kabini-sdma.bin \
firmware-amdgpu/kabini-sdma1.bin \
firmware-amdgpu/kabini-uvd.bin \
firmware-amdgpu/kabini-vce.bin \
firmware-amdgpu/kaveri-ce.bin \
firmware-amdgpu/kaveri-me.bin \
firmware-amdgpu/kaveri-mec.bin \
firmware-amdgpu/kaveri-mec2.bin \
firmware-amdgpu/kaveri-pfp.bin \
firmware-amdgpu/kaveri-rlc.bin \
firmware-amdgpu/kaveri-sdma.bin \
firmware-amdgpu/kaveri-sdma1.bin \
firmware-amdgpu/kaveri-uvd.bin \
firmware-amdgpu/kaveri-vce.bin \
firmware-amdgpu/mullins-ce.bin \
firmware-amdgpu/mullins-me.bin \
firmware-amdgpu/mullins-mec.bin \
firmware-amdgpu/mullins-pfp.bin \
firmware-amdgpu/mullins-rlc.bin \
firmware-amdgpu/mullins-sdma.bin \
firmware-amdgpu/mullins-sdma1.bin \
firmware-amdgpu/mullins-uvd.bin \
firmware-amdgpu/mullins-vce.bin \
firmware-amdgpu/navi10-asd.bin \
firmware-amdgpu/navi10-ce.bin \
firmware-amdgpu/navi10-gpu-info.bin \
firmware-amdgpu/navi10-me.bin \
firmware-amdgpu/navi10-mec.bin \
firmware-amdgpu/navi10-mec2.bin \
firmware-amdgpu/navi10-pfp.bin \
firmware-amdgpu/navi10-rlc.bin \
firmware-amdgpu/navi10-sdma.bin \
firmware-amdgpu/navi10-sdma1.bin \
firmware-amdgpu/navi10-smc.bin \
firmware-amdgpu/navi10-sos.bin \
firmware-amdgpu/navi10-ta.bin \
firmware-amdgpu/navi10-vcn.bin \
firmware-amdgpu/navi12-asd.bin \
firmware-amdgpu/navi12-ce.bin \
firmware-amdgpu/navi12-dmcu.bin \
firmware-amdgpu/navi12-gpu-info.bin \
firmware-amdgpu/navi12-me.bin \
firmware-amdgpu/navi12-mec.bin \
firmware-amdgpu/navi12-mec2.bin \
firmware-amdgpu/navi12-pfp.bin \
firmware-amdgpu/navi12-rlc.bin \
firmware-amdgpu/navi12-sdma.bin \
firmware-amdgpu/navi12-sdma1.bin \
firmware-amdgpu/navi12-smc.bin \
firmware-amdgpu/navi12-sos.bin \
firmware-amdgpu/navi12-ta.bin \
firmware-amdgpu/navi12-vcn.bin \
firmware-amdgpu/navi14-asd.bin \
firmware-amdgpu/navi14-ce-wks.bin \
firmware-amdgpu/navi14-ce.bin \
firmware-amdgpu/navi14-gpu-info.bin \
firmware-amdgpu/navi14-me-wks.bin \
firmware-amdgpu/navi14-me.bin \
firmware-amdgpu/navi14-mec-wks.bin \
firmware-amdgpu/navi14-mec.bin \
firmware-amdgpu/navi14-mec2-wks.bin \
firmware-amdgpu/navi14-mec2.bin \
firmware-amdgpu/navi14-pfp-wks.bin \
firmware-amdgpu/navi14-pfp.bin \
firmware-amdgpu/navi14-rlc.bin \
firmware-amdgpu/navi14-sdma.bin \
firmware-amdgpu/navi14-sdma1.bin \
firmware-amdgpu/navi14-smc.bin \
firmware-amdgpu/navi14-sos.bin \
firmware-amdgpu/navi14-ta.bin \
firmware-amdgpu/navi14-vcn.bin \
firmware-amdgpu/navy-flounder-ce.bin \
firmware-amdgpu/navy-flounder-dmcub.bin \
firmware-amdgpu/navy-flounder-me.bin \
firmware-amdgpu/navy-flounder-mec.bin \
firmware-amdgpu/navy-flounder-mec2.bin \
firmware-amdgpu/navy-flounder-pfp.bin \
firmware-amdgpu/navy-flounder-rlc.bin \
firmware-amdgpu/navy-flounder-sdma.bin \
firmware-amdgpu/navy-flounder-smc.bin \
firmware-amdgpu/navy-flounder-sos.bin \
firmware-amdgpu/navy-flounder-ta.bin \
firmware-amdgpu/navy-flounder-vcn.bin \
firmware-amdgpu/oland-ce.bin \
firmware-amdgpu/oland-k-smc.bin \
firmware-amdgpu/oland-mc.bin \
firmware-amdgpu/oland-me.bin \
firmware-amdgpu/oland-pfp.bin \
firmware-amdgpu/oland-rlc.bin \
firmware-amdgpu/oland-smc.bin \
firmware-amdgpu/oland-uvd.bin \
firmware-amdgpu/picasso-asd.bin \
firmware-amdgpu/picasso-ce.bin \
firmware-amdgpu/picasso-gpu-info.bin \
firmware-amdgpu/picasso-me.bin \
firmware-amdgpu/picasso-mec.bin \
firmware-amdgpu/picasso-mec2.bin \
firmware-amdgpu/picasso-pfp.bin \
firmware-amdgpu/picasso-rlc-am4.bin \
firmware-amdgpu/picasso-rlc.bin \
firmware-amdgpu/picasso-sdma.bin \
firmware-amdgpu/picasso-ta.bin \
firmware-amdgpu/picasso-vcn.bin \
firmware-amdgpu/pitcairn-ce.bin \
firmware-amdgpu/pitcairn-k-smc.bin \
firmware-amdgpu/pitcairn-mc.bin \
firmware-amdgpu/pitcairn-me.bin \
firmware-amdgpu/pitcairn-pfp.bin \
firmware-amdgpu/pitcairn-rlc.bin \
firmware-amdgpu/pitcairn-smc.bin \
firmware-amdgpu/pitcairn-uvd.bin \
firmware-amdgpu/polaris10-ce-2.bin \
firmware-amdgpu/polaris10-ce.bin \
firmware-amdgpu/polaris10-k-mc.bin \
firmware-amdgpu/polaris10-k-smc.bin \
firmware-amdgpu/polaris10-k2-smc.bin \
firmware-amdgpu/polaris10-mc.bin \
firmware-amdgpu/polaris10-me-2.bin \
firmware-amdgpu/polaris10-me.bin \
firmware-amdgpu/polaris10-mec-2.bin \
firmware-amdgpu/polaris10-mec.bin \
firmware-amdgpu/polaris10-mec2-2.bin \
firmware-amdgpu/polaris10-mec2.bin \
firmware-amdgpu/polaris10-pfp-2.bin \
firmware-amdgpu/polaris10-pfp.bin \
firmware-amdgpu/polaris10-rlc.bin \
firmware-amdgpu/polaris10-sdma.bin \
firmware-amdgpu/polaris10-sdma1.bin \
firmware-amdgpu/polaris10-smc-sk.bin \
firmware-amdgpu/polaris10-smc.bin \
firmware-amdgpu/polaris10-uvd.bin \
firmware-amdgpu/polaris10-vce.bin \
firmware-amdgpu/polaris11-ce-2.bin \
firmware-amdgpu/polaris11-ce.bin \
firmware-amdgpu/polaris11-k-mc.bin \
firmware-amdgpu/polaris11-k-smc.bin \
firmware-amdgpu/polaris11-k2-smc.bin \
firmware-amdgpu/polaris11-mc.bin \
firmware-amdgpu/polaris11-me-2.bin \
firmware-amdgpu/polaris11-me.bin \
firmware-amdgpu/polaris11-mec-2.bin \
firmware-amdgpu/polaris11-mec.bin \
firmware-amdgpu/polaris11-mec2-2.bin \
firmware-amdgpu/polaris11-mec2.bin \
firmware-amdgpu/polaris11-pfp-2.bin \
firmware-amdgpu/polaris11-pfp.bin \
firmware-amdgpu/polaris11-rlc.bin \
firmware-amdgpu/polaris11-sdma.bin \
firmware-amdgpu/polaris11-sdma1.bin \
firmware-amdgpu/polaris11-smc-sk.bin \
firmware-amdgpu/polaris11-smc.bin \
firmware-amdgpu/polaris11-uvd.bin \
firmware-amdgpu/polaris11-vce.bin \
firmware-amdgpu/polaris12-32-mc.bin \
firmware-amdgpu/polaris12-ce-2.bin \
firmware-amdgpu/polaris12-ce.bin \
firmware-amdgpu/polaris12-k-mc.bin \
firmware-amdgpu/polaris12-k-smc.bin \
firmware-amdgpu/polaris12-mc.bin \
firmware-amdgpu/polaris12-me-2.bin \
firmware-amdgpu/polaris12-me.bin \
firmware-amdgpu/polaris12-mec-2.bin \
firmware-amdgpu/polaris12-mec.bin \
firmware-amdgpu/polaris12-mec2-2.bin \
firmware-amdgpu/polaris12-mec2.bin \
firmware-amdgpu/polaris12-pfp-2.bin \
firmware-amdgpu/polaris12-pfp.bin \
firmware-amdgpu/polaris12-rlc.bin \
firmware-amdgpu/polaris12-sdma.bin \
firmware-amdgpu/polaris12-sdma1.bin \
firmware-amdgpu/polaris12-smc.bin \
firmware-amdgpu/polaris12-uvd.bin \
firmware-amdgpu/polaris12-vce.bin \
firmware-amdgpu/psp-13-0-0-sos.bin \
firmware-amdgpu/psp-13-0-0-ta.bin \
firmware-amdgpu/psp-13-0-10-sos.bin \
firmware-amdgpu/psp-13-0-10-ta.bin \
firmware-amdgpu/psp-13-0-11-ta.bin \
firmware-amdgpu/psp-13-0-11-toc.bin \
firmware-amdgpu/psp-13-0-4-ta.bin \
firmware-amdgpu/psp-13-0-4-toc.bin \
firmware-amdgpu/psp-13-0-5-asd.bin \
firmware-amdgpu/psp-13-0-5-ta.bin \
firmware-amdgpu/psp-13-0-5-toc.bin \
firmware-amdgpu/psp-13-0-7-sos.bin \
firmware-amdgpu/psp-13-0-7-ta.bin \
firmware-amdgpu/psp-13-0-8-asd.bin \
firmware-amdgpu/psp-13-0-8-ta.bin \
firmware-amdgpu/psp-13-0-8-toc.bin \
firmware-amdgpu/raven-asd.bin \
firmware-amdgpu/raven-ce.bin \
firmware-amdgpu/raven-dmcu.bin \
firmware-amdgpu/raven-gpu-info.bin \
firmware-amdgpu/raven-kicker-rlc.bin \
firmware-amdgpu/raven-me.bin \
firmware-amdgpu/raven-mec.bin \
firmware-amdgpu/raven-mec2.bin \
firmware-amdgpu/raven-pfp.bin \
firmware-amdgpu/raven-rlc.bin \
firmware-amdgpu/raven-sdma.bin \
firmware-amdgpu/raven-ta.bin \
firmware-amdgpu/raven-vcn.bin \
firmware-amdgpu/raven2-asd.bin \
firmware-amdgpu/raven2-ce.bin \
firmware-amdgpu/raven2-gpu-info.bin \
firmware-amdgpu/raven2-me.bin \
firmware-amdgpu/raven2-mec.bin \
firmware-amdgpu/raven2-mec2.bin \
firmware-amdgpu/raven2-pfp.bin \
firmware-amdgpu/raven2-rlc.bin \
firmware-amdgpu/raven2-sdma.bin \
firmware-amdgpu/raven2-ta.bin \
firmware-amdgpu/raven2-vcn.bin \
firmware-amdgpu/renoir-asd.bin \
firmware-amdgpu/renoir-ce.bin \
firmware-amdgpu/renoir-dmcub.bin \
firmware-amdgpu/renoir-gpu-info.bin \
firmware-amdgpu/renoir-me.bin \
firmware-amdgpu/renoir-mec.bin \
firmware-amdgpu/renoir-mec2.bin \
firmware-amdgpu/renoir-pfp.bin \
firmware-amdgpu/renoir-rlc.bin \
firmware-amdgpu/renoir-sdma.bin \
firmware-amdgpu/renoir-ta.bin \
firmware-amdgpu/renoir-vcn.bin \
firmware-amdgpu/sdma-5-2-6.bin \
firmware-amdgpu/sdma-5-2-7.bin \
firmware-amdgpu/sdma-6-0-0.bin \
firmware-amdgpu/sdma-6-0-1.bin \
firmware-amdgpu/sdma-6-0-2.bin \
firmware-amdgpu/sdma-6-0-3.bin \
firmware-amdgpu/si58-mc.bin \
firmware-amdgpu/sienna-cichlid-ce.bin \
firmware-amdgpu/sienna-cichlid-dmcub.bin \
firmware-amdgpu/sienna-cichlid-me.bin \
firmware-amdgpu/sienna-cichlid-mec.bin \
firmware-amdgpu/sienna-cichlid-mec2.bin \
firmware-amdgpu/sienna-cichlid-pfp.bin \
firmware-amdgpu/sienna-cichlid-rlc.bin \
firmware-amdgpu/sienna-cichlid-sdma.bin \
firmware-amdgpu/sienna-cichlid-smc.bin \
firmware-amdgpu/sienna-cichlid-sos.bin \
firmware-amdgpu/sienna-cichlid-ta.bin \
firmware-amdgpu/sienna-cichlid-vcn.bin \
firmware-amdgpu/smu-13-0-0.bin \
firmware-amdgpu/smu-13-0-10.bin \
firmware-amdgpu/smu-13-0-7.bin \
firmware-amdgpu/stoney-ce.bin \
firmware-amdgpu/stoney-me.bin \
firmware-amdgpu/stoney-mec.bin \
firmware-amdgpu/stoney-pfp.bin \
firmware-amdgpu/stoney-rlc.bin \
firmware-amdgpu/stoney-sdma.bin \
firmware-amdgpu/stoney-uvd.bin \
firmware-amdgpu/stoney-vce.bin \
firmware-amdgpu/tahiti-ce.bin \
firmware-amdgpu/tahiti-k-smc.bin \
firmware-amdgpu/tahiti-mc.bin \
firmware-amdgpu/tahiti-me.bin \
firmware-amdgpu/tahiti-pfp.bin \
firmware-amdgpu/tahiti-rlc.bin \
firmware-amdgpu/tahiti-smc.bin \
firmware-amdgpu/tahiti-uvd.bin \
firmware-amdgpu/tonga-ce.bin \
firmware-amdgpu/tonga-k-smc.bin \
firmware-amdgpu/tonga-mc.bin \
firmware-amdgpu/tonga-me.bin \
firmware-amdgpu/tonga-mec.bin \
firmware-amdgpu/tonga-mec2.bin \
firmware-amdgpu/tonga-pfp.bin \
firmware-amdgpu/tonga-rlc.bin \
firmware-amdgpu/tonga-sdma.bin \
firmware-amdgpu/tonga-sdma1.bin \
firmware-amdgpu/tonga-smc.bin \
firmware-amdgpu/tonga-uvd.bin \
firmware-amdgpu/tonga-vce.bin \
firmware-amdgpu/topaz-ce.bin \
firmware-amdgpu/topaz-k-smc.bin \
firmware-amdgpu/topaz-mc.bin \
firmware-amdgpu/topaz-me.bin \
firmware-amdgpu/topaz-mec.bin \
firmware-amdgpu/topaz-mec2.bin \
firmware-amdgpu/topaz-pfp.bin \
firmware-amdgpu/topaz-rlc.bin \
firmware-amdgpu/topaz-sdma.bin \
firmware-amdgpu/topaz-sdma1.bin \
firmware-amdgpu/topaz-smc.bin \
firmware-amdgpu/vangogh-asd.bin \
firmware-amdgpu/vangogh-ce.bin \
firmware-amdgpu/vangogh-dmcub.bin \
firmware-amdgpu/vangogh-me.bin \
firmware-amdgpu/vangogh-mec.bin \
firmware-amdgpu/vangogh-mec2.bin \
firmware-amdgpu/vangogh-pfp.bin \
firmware-amdgpu/vangogh-rlc.bin \
firmware-amdgpu/vangogh-sdma.bin \
firmware-amdgpu/vangogh-toc.bin \
firmware-amdgpu/vangogh-vcn.bin \
firmware-amdgpu/vcn-3-1-2.bin \
firmware-amdgpu/vcn-4-0-0.bin \
firmware-amdgpu/vcn-4-0-2.bin \
firmware-amdgpu/vcn-4-0-4.bin \
firmware-amdgpu/vega10-acg-smc.bin \
firmware-amdgpu/vega10-asd.bin \
firmware-amdgpu/vega10-ce.bin \
firmware-amdgpu/vega10-gpu-info.bin \
firmware-amdgpu/vega10-me.bin \
firmware-amdgpu/vega10-mec.bin \
firmware-amdgpu/vega10-mec2.bin \
firmware-amdgpu/vega10-pfp.bin \
firmware-amdgpu/vega10-rlc.bin \
firmware-amdgpu/vega10-sdma.bin \
firmware-amdgpu/vega10-sdma1.bin \
firmware-amdgpu/vega10-smc.bin \
firmware-amdgpu/vega10-sos.bin \
firmware-amdgpu/vega10-uvd.bin \
firmware-amdgpu/vega10-vce.bin \
firmware-amdgpu/vega12-asd.bin \
firmware-amdgpu/vega12-ce.bin \
firmware-amdgpu/vega12-gpu-info.bin \
firmware-amdgpu/vega12-me.bin \
firmware-amdgpu/vega12-mec.bin \
firmware-amdgpu/vega12-mec2.bin \
firmware-amdgpu/vega12-pfp.bin \
firmware-amdgpu/vega12-rlc.bin \
firmware-amdgpu/vega12-sdma.bin \
firmware-amdgpu/vega12-sdma1.bin \
firmware-amdgpu/vega12-smc.bin \
firmware-amdgpu/vega12-sos.bin \
firmware-amdgpu/vega12-uvd.bin \
firmware-amdgpu/vega12-vce.bin \
firmware-amdgpu/vega20-asd.bin \
firmware-amdgpu/vega20-ce.bin \
firmware-amdgpu/vega20-me.bin \
firmware-amdgpu/vega20-mec.bin \
firmware-amdgpu/vega20-mec2.bin \
firmware-amdgpu/vega20-pfp.bin \
firmware-amdgpu/vega20-rlc.bin \
firmware-amdgpu/vega20-sdma.bin \
firmware-amdgpu/vega20-sdma1.bin \
firmware-amdgpu/vega20-smc.bin \
firmware-amdgpu/vega20-sos.bin \
firmware-amdgpu/vega20-ta.bin \
firmware-amdgpu/vega20-uvd.bin \
firmware-amdgpu/vega20-vce.bin \
firmware-amdgpu/vegam-ce.bin \
firmware-amdgpu/vegam-me.bin \
firmware-amdgpu/vegam-mec.bin \
firmware-amdgpu/vegam-mec2.bin \
firmware-amdgpu/vegam-pfp.bin \
firmware-amdgpu/vegam-rlc.bin \
firmware-amdgpu/vegam-sdma.bin \
firmware-amdgpu/vegam-sdma1.bin \
firmware-amdgpu/vegam-smc.bin \
firmware-amdgpu/vegam-uvd.bin \
firmware-amdgpu/vegam-vce.bin \
firmware-amdgpu/verde-ce.bin \
firmware-amdgpu/verde-k-smc.bin \
firmware-amdgpu/verde-mc.bin \
firmware-amdgpu/verde-me.bin \
firmware-amdgpu/verde-pfp.bin \
firmware-amdgpu/verde-rlc.bin \
firmware-amdgpu/verde-smc.bin \
firmware-amdgpu/verde-uvd.bin \
firmware-amdgpu/yellow-carp-asd.bin \
firmware-amdgpu/yellow-carp-ce.bin \
firmware-amdgpu/yellow-carp-dmcub.bin \
firmware-amdgpu/yellow-carp-me.bin \
firmware-amdgpu/yellow-carp-mec.bin \
firmware-amdgpu/yellow-carp-mec2.bin \
firmware-amdgpu/yellow-carp-pfp.bin \
firmware-amdgpu/yellow-carp-rlc.bin \
firmware-amdgpu/yellow-carp-sdma.bin \
firmware-amdgpu/yellow-carp-ta.bin \
firmware-amdgpu/yellow-carp-toc.bin \
firmware-amdgpu/yellow-carp-vcn.bin \
firmware-amphion/vpu/vpu-fw-imx8-dec.bin \
firmware-amphion/vpu/vpu-fw-imx8-enc.bin \
firmware-ar3k/1020200/PS-ASIC.pst \
firmware-ar3k/1020200/RamPatch.txt \
firmware-ar3k/1020200/ar3kbdaddr.pst \
firmware-ar3k/1020201/PS-ASIC.pst \
firmware-ar3k/1020201/RamPatch.txt \
firmware-ar3k/1020201coex/ramps-0x01020201-26-HighPriority.dfu \
firmware-ar3k/30000/PS-ASIC.pst \
firmware-ar3k/30000/RamPatch.txt \
firmware-ar3k/30000/ar3kbdaddr.pst \
firmware-ar3k/30101/PS-ASIC.pst \
firmware-ar3k/30101/RamPatch.txt \
firmware-ar3k/30101/ar3kbdaddr.pst \
firmware-ar3k/30101coex/PS-ASIC-aclHighPri.pst \
firmware-ar3k/30101coex/PS-ASIC-aclLowPri.pst \
firmware-ar3k/30101coex/PS-ASIC.pst \
firmware-ar3k/30101coex/RamPatch.txt \
firmware-ar3k/30101coex/ar3kbdaddr.pst \
firmware-ar3k/AthrBT-0x01020001.dfu \
firmware-ar3k/AthrBT-0x01020200.dfu \
firmware-ar3k/AthrBT-0x01020201.dfu \
firmware-ar3k/AthrBT-0x11020000.dfu \
firmware-ar3k/AthrBT-0x11020100.dfu \
firmware-ar3k/AthrBT-0x31010000.dfu \
firmware-ar3k/AthrBT-0x31010100.dfu \
firmware-ar3k/AthrBT-0x41020000.dfu \
firmware-ar3k/ramps-0x01020001-26.dfu \
firmware-ar3k/ramps-0x01020200-26.dfu \
firmware-ar3k/ramps-0x01020200-40.dfu \
firmware-ar3k/ramps-0x01020201-26.dfu \
firmware-ar3k/ramps-0x01020201-40.dfu \
firmware-ar3k/ramps-0x11020000-40.dfu \
firmware-ar3k/ramps-0x11020100-40.dfu \
firmware-ar3k/ramps-0x31010000-40.dfu \
firmware-ar3k/ramps-0x31010100-40.dfu \
firmware-ar3k/ramps-0x41020000-40.dfu \
firmware-ar5523.bin \
firmware-ar7010-1-1.fw \
firmware-ar7010.fw \
firmware-ar9170-1.fw \
firmware-ar9170-2.fw \
firmware-ar9271.fw \
firmware-as102-data1-st.hex \
firmware-as102-data2-st.hex \
firmware-ast-dp501-fw.bin \
firmware-ath10k/QCA4019/hw1.0/board-2.bin \
firmware-ath10k/QCA4019/hw1.0/firmware-5.bin \
firmware-ath10k/QCA4019/hw1.0/notice-ath10k-firmware-5.txt \
firmware-ath10k/QCA6174/hw2.1/board-2.bin \
firmware-ath10k/QCA6174/hw2.1/board.bin \
firmware-ath10k/QCA6174/hw2.1/firmware-5.bin \
firmware-ath10k/QCA6174/hw2.1/notice-ath10k-firmware-5.txt \
firmware-ath10k/QCA6174/hw3.0/board-2.bin \
firmware-ath10k/QCA6174/hw3.0/board.bin \
firmware-ath10k/QCA6174/hw3.0/firmware-4.bin \
firmware-ath10k/QCA6174/hw3.0/firmware-6.bin \
firmware-ath10k/QCA6174/hw3.0/firmware-sdio-6.bin \
firmware-ath10k/QCA6174/hw3.0/notice-ath10k-firmware-4.txt \
firmware-ath10k/QCA6174/hw3.0/notice-ath10k-firmware-6.txt \
firmware-ath10k/QCA6174/hw3.0/notice-ath10k-firmware-sdio-6.txt \
firmware-ath10k/QCA9377/hw1.0/board-2.bin \
firmware-ath10k/QCA9377/hw1.0/board.bin \
firmware-ath10k/QCA9377/hw1.0/firmware-5.bin \
firmware-ath10k/QCA9377/hw1.0/firmware-6.bin \
firmware-ath10k/QCA9377/hw1.0/firmware-sdio-5.bin \
firmware-ath10k/QCA9377/hw1.0/notice-ath10k-firmware-5.txt \
firmware-ath10k/QCA9377/hw1.0/notice-ath10k-firmware-6.txt \
firmware-ath10k/QCA9377/hw1.0/notice-ath10k-firmware-sdio-5.txt \
firmware-ath10k/QCA9887/hw1.0/board.bin \
firmware-ath10k/QCA9887/hw1.0/firmware-5.bin \
firmware-ath10k/QCA9887/hw1.0/notice-ath10k-firmware-5.txt \
firmware-ath10k/QCA9888/hw2.0/board-2.bin \
firmware-ath10k/QCA9888/hw2.0/firmware-5.bin \
firmware-ath10k/QCA9888/hw2.0/notice-ath10k-firmware-5.txt \
firmware-ath10k/QCA988X/hw2.0/board.bin \
firmware-ath10k/QCA988X/hw2.0/firmware-4.bin \
firmware-ath10k/QCA988X/hw2.0/firmware-5.bin \
firmware-ath10k/QCA988X/hw2.0/notice-ath10k-firmware-4.txt \
firmware-ath10k/QCA988X/hw2.0/notice-ath10k-firmware-5.txt \
firmware-ath10k/QCA9984/hw1.0/board-2.bin \
firmware-ath10k/QCA9984/hw1.0/firmware-5.bin \
firmware-ath10k/QCA9984/hw1.0/notice-ath10k-firmware-5.txt \
firmware-ath10k/QCA99X0/hw2.0/board-2.bin \
firmware-ath10k/QCA99X0/hw2.0/firmware-5.bin \
firmware-ath10k/QCA99X0/hw2.0/notice-ath10k-firmware-5.txt \
firmware-ath10k/WCN3990/hw1.0/board-2.bin \
firmware-ath10k/WCN3990/hw1.0/firmware-5.bin \
firmware-ath10k/WCN3990/hw1.0/notice.txt-wlanmdsp \
firmware-ath10k/WCN3990/hw1.0/wlanmdsp.mbn \
firmware-ath11k/IPQ5018/hw1.0/Notice.txt \
firmware-ath11k/IPQ5018/hw1.0/board-2.bin \
firmware-ath11k/IPQ5018/hw1.0/m3-fw.b00 \
firmware-ath11k/IPQ5018/hw1.0/m3-fw.b01 \
firmware-ath11k/IPQ5018/hw1.0/m3-fw.b02 \
firmware-ath11k/IPQ5018/hw1.0/m3-fw.flist \
firmware-ath11k/IPQ5018/hw1.0/m3-fw.mdt \
firmware-ath11k/IPQ5018/hw1.0/q6-fw.b00 \
firmware-ath11k/IPQ5018/hw1.0/q6-fw.b01 \
firmware-ath11k/IPQ5018/hw1.0/q6-fw.b02 \
firmware-ath11k/IPQ5018/hw1.0/q6-fw.b03 \
firmware-ath11k/IPQ5018/hw1.0/q6-fw.b04 \
firmware-ath11k/IPQ5018/hw1.0/q6-fw.b05 \
firmware-ath11k/IPQ5018/hw1.0/q6-fw.b07 \
firmware-ath11k/IPQ5018/hw1.0/q6-fw.b08 \
firmware-ath11k/IPQ5018/hw1.0/q6-fw.b09 \
firmware-ath11k/IPQ5018/hw1.0/q6-fw.b10 \
firmware-ath11k/IPQ5018/hw1.0/q6-fw.b11 \
firmware-ath11k/IPQ5018/hw1.0/q6-fw.b13 \
firmware-ath11k/IPQ5018/hw1.0/q6-fw.b14 \
firmware-ath11k/IPQ5018/hw1.0/q6-fw.flist \
firmware-ath11k/IPQ5018/hw1.0/q6-fw.mdt \
firmware-ath11k/IPQ6018/hw1.0/Notice.txt \
firmware-ath11k/IPQ6018/hw1.0/board-2.bin \
firmware-ath11k/IPQ6018/hw1.0/m3-fw.b00 \
firmware-ath11k/IPQ6018/hw1.0/m3-fw.b01 \
firmware-ath11k/IPQ6018/hw1.0/m3-fw.b02 \
firmware-ath11k/IPQ6018/hw1.0/m3-fw.flist \
firmware-ath11k/IPQ6018/hw1.0/m3-fw.mdt \
firmware-ath11k/IPQ6018/hw1.0/q6-fw.b00 \
firmware-ath11k/IPQ6018/hw1.0/q6-fw.b01 \
firmware-ath11k/IPQ6018/hw1.0/q6-fw.b02 \
firmware-ath11k/IPQ6018/hw1.0/q6-fw.b03 \
firmware-ath11k/IPQ6018/hw1.0/q6-fw.b04 \
firmware-ath11k/IPQ6018/hw1.0/q6-fw.b05 \
firmware-ath11k/IPQ6018/hw1.0/q6-fw.b07 \
firmware-ath11k/IPQ6018/hw1.0/q6-fw.b08 \
firmware-ath11k/IPQ6018/hw1.0/q6-fw.flist \
firmware-ath11k/IPQ6018/hw1.0/q6-fw.mdt \
firmware-ath11k/IPQ8074/hw2.0/Notice.txt \
firmware-ath11k/IPQ8074/hw2.0/board-2.bin \
firmware-ath11k/IPQ8074/hw2.0/m3-fw.b00 \
firmware-ath11k/IPQ8074/hw2.0/m3-fw.b01 \
firmware-ath11k/IPQ8074/hw2.0/m3-fw.b02 \
firmware-ath11k/IPQ8074/hw2.0/m3-fw.flist \
firmware-ath11k/IPQ8074/hw2.0/m3-fw.mdt \
firmware-ath11k/IPQ8074/hw2.0/q6-fw.b00 \
firmware-ath11k/IPQ8074/hw2.0/q6-fw.b01 \
firmware-ath11k/IPQ8074/hw2.0/q6-fw.b02 \
firmware-ath11k/IPQ8074/hw2.0/q6-fw.b03 \
firmware-ath11k/IPQ8074/hw2.0/q6-fw.b04 \
firmware-ath11k/IPQ8074/hw2.0/q6-fw.b05 \
firmware-ath11k/IPQ8074/hw2.0/q6-fw.b07 \
firmware-ath11k/IPQ8074/hw2.0/q6-fw.b08 \
firmware-ath11k/IPQ8074/hw2.0/q6-fw.flist \
firmware-ath11k/IPQ8074/hw2.0/q6-fw.mdt \
firmware-ath11k/QCA6390/hw2.0/Notice.txt \
firmware-ath11k/QCA6390/hw2.0/amss.bin \
firmware-ath11k/QCA6390/hw2.0/board-2.bin \
firmware-ath11k/QCA6390/hw2.0/m3.bin \
firmware-ath11k/QCN9074/hw1.0/Notice.txt \
firmware-ath11k/QCN9074/hw1.0/amss.bin \
firmware-ath11k/QCN9074/hw1.0/board-2.bin \
firmware-ath11k/QCN9074/hw1.0/m3.bin \
firmware-ath11k/WCN6750/hw1.0/Notice.txt \
firmware-ath11k/WCN6750/hw1.0/board-2.bin \
firmware-ath11k/WCN6750/hw1.0/wpss.b00 \
firmware-ath11k/WCN6750/hw1.0/wpss.b01 \
firmware-ath11k/WCN6750/hw1.0/wpss.b02 \
firmware-ath11k/WCN6750/hw1.0/wpss.b03 \
firmware-ath11k/WCN6750/hw1.0/wpss.b04 \
firmware-ath11k/WCN6750/hw1.0/wpss.b05 \
firmware-ath11k/WCN6750/hw1.0/wpss.b06 \
firmware-ath11k/WCN6750/hw1.0/wpss.b07 \
firmware-ath11k/WCN6750/hw1.0/wpss.b08 \
firmware-ath11k/WCN6750/hw1.0/wpss.mdt \
firmware-ath11k/WCN6855/hw2.0/Notice.txt \
firmware-ath11k/WCN6855/hw2.0/amss.bin \
firmware-ath11k/WCN6855/hw2.0/board-2.bin \
firmware-ath11k/WCN6855/hw2.0/m3.bin \
firmware-ath11k/WCN6855/hw2.0/regdb.bin \
firmware-ath11k/WCN6855/hw2.1/amss.bin \
firmware-ath11k/WCN6855/hw2.1/board-2.bin \
firmware-ath11k/WCN6855/hw2.1/m3.bin \
firmware-ath11k/WCN6855/hw2.1/regdb.bin \
firmware-ath3k-1.fw \
firmware-ath6k/AR6002/athwlan.bin.z77 \
firmware-ath6k/AR6002/data.patch.hw2-0.bin \
firmware-ath6k/AR6002/eeprom.bin \
firmware-ath6k/AR6002/eeprom.data \
firmware-ath6k/AR6003.1/hw2.1.1/athwlan.bin \
firmware-ath6k/AR6003.1/hw2.1.1/bdata.SD31.bin \
firmware-ath6k/AR6003.1/hw2.1.1/bdata.SD32.bin \
firmware-ath6k/AR6003.1/hw2.1.1/bdata.WB31.bin \
firmware-ath6k/AR6003.1/hw2.1.1/data.patch.bin \
firmware-ath6k/AR6003.1/hw2.1.1/endpointping.bin \
firmware-ath6k/AR6003.1/hw2.1.1/otp.bin \
firmware-ath6k/AR6003/hw1.0/athwlan.bin.z77 \
firmware-ath6k/AR6003/hw1.0/bdata.SD31.bin \
firmware-ath6k/AR6003/hw1.0/bdata.SD32.bin \
firmware-ath6k/AR6003/hw1.0/bdata.WB31.bin \
firmware-ath6k/AR6003/hw1.0/data.patch.bin \
firmware-ath6k/AR6003/hw1.0/otp.bin.z77 \
firmware-ath6k/AR6003/hw2.0/athwlan.bin.z77 \
firmware-ath6k/AR6003/hw2.0/bdata.SD31.bin \
firmware-ath6k/AR6003/hw2.0/bdata.SD32.bin \
firmware-ath6k/AR6003/hw2.0/bdata.WB31.bin \
firmware-ath6k/AR6003/hw2.0/data.patch.bin \
firmware-ath6k/AR6003/hw2.0/otp.bin.z77 \
firmware-ath6k/AR6003/hw2.1.1/athwlan.bin \
firmware-ath6k/AR6003/hw2.1.1/bdata.SD31.bin \
firmware-ath6k/AR6003/hw2.1.1/bdata.SD32.bin \
firmware-ath6k/AR6003/hw2.1.1/bdata.WB31.bin \
firmware-ath6k/AR6003/hw2.1.1/data.patch.bin \
firmware-ath6k/AR6003/hw2.1.1/endpointping.bin \
firmware-ath6k/AR6003/hw2.1.1/fw-2.bin \
firmware-ath6k/AR6003/hw2.1.1/fw-3.bin \
firmware-ath6k/AR6003/hw2.1.1/otp.bin \
firmware-ath6k/AR6004/hw1.2/bdata.bin \
firmware-ath6k/AR6004/hw1.2/fw-2.bin \
firmware-ath6k/AR6004/hw1.3/bdata.bin \
firmware-ath6k/AR6004/hw1.3/fw-3.bin \
firmware-ath9k-htc/htc-7010-1.4.0.fw \
firmware-ath9k-htc/htc-9271-1.4.0.fw \
firmware-atmel/wilc1000-ap-fw.bin \
firmware-atmel/wilc1000-fw.bin \
firmware-atmel/wilc1000-p2p-fw.bin \
firmware-atmel/wilc1000-wifi-firmware-1.bin \
firmware-atmel/wilc1000-wifi-firmware.bin \
firmware-atusb/atusb-0.2.dfu \
firmware-atusb/atusb-0.3.dfu \
firmware-atusb/rzusb-0.3.bin \
firmware-av7110/bootcode.bin \
firmware-bnx2/bnx2-mips-06-6.2.3.fw \
firmware-bnx2/bnx2-mips-09-6.2.1b.fw \
firmware-bnx2/bnx2-rv2p-06-6.0.15.fw \
firmware-bnx2/bnx2-rv2p-09-6.0.17.fw \
firmware-bnx2/bnx2-rv2p-09ax-6.0.17.fw \
firmware-bnx2x/bnx2x-e1-7.13.1.0.fw \
firmware-bnx2x/bnx2x-e1-7.13.11.0.fw \
firmware-bnx2x/bnx2x-e1-7.13.15.0.fw \
firmware-bnx2x/bnx2x-e1-7.13.21.0.fw \
firmware-bnx2x/bnx2x-e1h-7.13.1.0.fw \
firmware-bnx2x/bnx2x-e1h-7.13.11.0.fw \
firmware-bnx2x/bnx2x-e1h-7.13.15.0.fw \
firmware-bnx2x/bnx2x-e1h-7.13.21.0.fw \
firmware-bnx2x/bnx2x-e2-7.13.1.0.fw \
firmware-bnx2x/bnx2x-e2-7.13.11.0.fw \
firmware-bnx2x/bnx2x-e2-7.13.15.0.fw \
firmware-bnx2x/bnx2x-e2-7.13.21.0.fw \
firmware-brcm/BCM-0a5c-6410.hcd \
firmware-brcm/BCM-0bb4-0306.hcd \
firmware-brcm/bcm4329-fullmac-4.bin \
firmware-brcm/bcm43xx-0.fw \
firmware-brcm/bcm43xx-hdr-0.fw \
firmware-brcm/brcmfmac43012-sdio.bin \
firmware-brcm/brcmfmac43012-sdio.clm-blob \
firmware-brcm/brcmfmac43143-sdio.bin \
firmware-brcm/brcmfmac43143.bin \
firmware-brcm/brcmfmac43236b.bin \
firmware-brcm/brcmfmac43241b0-sdio.bin \
firmware-brcm/brcmfmac43241b4-sdio.Advantech-MICA-071.txt \
firmware-brcm/brcmfmac43241b4-sdio.bin \
firmware-brcm/brcmfmac43241b5-sdio.bin \
firmware-brcm/brcmfmac43242a.bin \
firmware-brcm/brcmfmac4329-sdio.bin \
firmware-brcm/brcmfmac4330-sdio.Prowise-PT301.txt \
firmware-brcm/brcmfmac4330-sdio.bin \
firmware-brcm/brcmfmac4334-sdio.bin \
firmware-brcm/brcmfmac43340-sdio.bin \
firmware-brcm/brcmfmac43340-sdio.meegopad-t08.txt \
firmware-brcm/brcmfmac43340-sdio.pov-tab-p1006w-data.txt \
firmware-brcm/brcmfmac43340-sdio.predia-basic.txt \
firmware-brcm/brcmfmac4335-sdio.bin \
firmware-brcm/brcmfmac43362-sdio.WC121.txt \
firmware-brcm/brcmfmac43362-sdio.bin \
firmware-brcm/brcmfmac4339-sdio.bin \
firmware-brcm/brcmfmac43430-sdio.AP6212.txt \
firmware-brcm/brcmfmac43430-sdio.Hampoo-D2D3-Vi8A1.txt \
firmware-brcm/brcmfmac43430-sdio.MUR1DX.txt \
firmware-brcm/brcmfmac43430-sdio.bin \
firmware-brcm/brcmfmac43430-sdio.clm-blob \
firmware-brcm/brcmfmac43430a0-sdio.bin \
firmware-brcm/brcmfmac43430a0-sdio.ilife-S806.txt \
firmware-brcm/brcmfmac43430a0-sdio.jumper-ezpad-mini3.txt \
firmware-brcm/brcmfmac43455-sdio.AW-CM256SM.txt \
firmware-brcm/brcmfmac43455-sdio.acepc-t8.txt \
firmware-brcm/brcmfmac43455-sdio.bin \
firmware-brcm/brcmfmac43455-sdio.clm-blob \
firmware-brcm/brcmfmac4350-pcie.bin \
firmware-brcm/brcmfmac4350c2-pcie.bin \
firmware-brcm/brcmfmac4354-sdio.bin \
firmware-brcm/brcmfmac4354-sdio.clm-blob \
firmware-brcm/brcmfmac4356-pcie.bin \
firmware-brcm/brcmfmac4356-pcie.clm-blob \
firmware-brcm/brcmfmac4356-pcie.gpd-win-pocket.txt \
firmware-brcm/brcmfmac4356-sdio.AP6356S.txt \
firmware-brcm/brcmfmac4356-sdio.bin \
firmware-brcm/brcmfmac4356-sdio.clm-blob \
firmware-brcm/brcmfmac43569.bin \
firmware-brcm/brcmfmac43570-pcie.bin \
firmware-brcm/brcmfmac43570-pcie.clm-blob \
firmware-brcm/brcmfmac4358-pcie.bin \
firmware-brcm/brcmfmac43602-pcie.ap.bin \
firmware-brcm/brcmfmac43602-pcie.bin \
firmware-brcm/brcmfmac4366b-pcie.bin \
firmware-brcm/brcmfmac4366c-pcie.bin \
firmware-brcm/brcmfmac4371-pcie.bin \
firmware-brcm/brcmfmac4373-sdio.bin \
firmware-brcm/brcmfmac4373-sdio.clm-blob \
firmware-brcm/brcmfmac4373.bin \
firmware-brcm/brcmfmac54591-pcie.bin \
firmware-brcm/brcmfmac54591-pcie.clm-blob \
firmware-cadence/mhdp8546.bin \
firmware-carl9170-1.fw \
firmware-cavium/cnn55xx-ae.fw \
firmware-cavium/cnn55xx-se.fw \
firmware-cbfw-3.2.5.1.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c896e-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c896e-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c896e.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8971.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8971.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8972.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8972.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8973.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8973.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8974.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8974.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8975-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8975-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8975.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8981-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8981-l1.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8981-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8981-r1.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8981.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c898e.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c898e.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c898f.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c898f.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8991.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8991.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8992.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8992.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8994.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8994.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8995.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8995.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c89c3-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c89c3-l1.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c89c3-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c89c3-r1.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c89c3.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c89c6-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c89c6-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c89c6.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b42.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b42.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b43.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b43.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b44.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b44.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b45.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b45.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b46.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b46.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b47.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b47.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b63-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b63-l1.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b63-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b63-r1.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b63.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b70.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b70.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b72.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b72.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b74.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b74.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b77.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b77.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b8f-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b8f-l1.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b8f-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b8f-r1.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8b92.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8c26.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-103c8c26.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-104312af-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-104312af-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-104312af-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-104312af-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-104312af.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431433-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431433-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431433-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431433-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431433.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431463-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431463-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431463-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431463-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431463.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431473-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431473-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431473.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431483-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431483-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431483.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431493-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431493-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431493-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431493-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431493.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-104314d3-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-104314d3-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-104314d3-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-104314d3-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-104314d3.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-104314e3-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-104314e3-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-104314e3-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-104314e3-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-104314e3.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431503-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431503-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431503-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431503-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431503.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431533-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431533-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431533-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431533-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431533.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431573-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431573-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431573-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431573-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431573.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431663-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431663-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431663.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-104317f3-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-104317f3-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-104317f3-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-104317f3-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-104317f3.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431a20.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431a30.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431a40.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431a50.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431a60.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431a8f-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431a8f-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431a8f-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431a8f-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431a8f.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431b93-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431b93-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431b93-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431b93-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431b93.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431c9f-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431c9f-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431c9f-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431c9f-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431c9f.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431caf-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431caf-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431caf-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431caf-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431caf.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431ccf-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431ccf-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431ccf-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431ccf-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431ccf.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431cdf-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431cdf-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431cdf-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431cdf-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431cdf.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431cef-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431cef-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431cef-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431cef-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431cef.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431d1f-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431d1f-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431d1f-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431d1f-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431d1f.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431e02-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431e02-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431e02-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431e02-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431e02.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431e12-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431e12-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431e12-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431e12-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431e12.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431f12-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431f12-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431f12-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431f12-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10431f12.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-10433a20-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10433a20-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10433a20-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10433a20-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10433a30-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10433a30-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10433a30-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10433a30-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10433a40-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10433a40-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10433a40-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10433a40-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10433a50-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10433a50-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10433a50-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10433a50-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10433a60-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10433a60-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10433a60-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-10433a60-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa22f1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa22f1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa22f1.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa22f2-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa22f2-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa22f2.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa22f3-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa22f3-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa22f3.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa2316-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa2316-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa2316-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa2316-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa2316.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa2317-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa2317-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa2317-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa2317-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa2317.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa2318-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa2318-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa2318.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa2319-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa2319-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa2319.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa231a-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa231a-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa231a.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa3847-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa3847-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa3847.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa3855-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa3855-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-cali-17aa3855.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c896e-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c896e-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c896e.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8971.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8971.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8972.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8972.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8973.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8973.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8974.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8974.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8975-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8975-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8975.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8981-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8981-l1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8981-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8981-r1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8981.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c898e.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c898e.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c898f.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c898f.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8991.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8991.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8992.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8992.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8994.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8994.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8995.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8995.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c89c3-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c89c3-l1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c89c3-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c89c3-r1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c89c3.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c89c6-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c89c6-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c89c6.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b42.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b42.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b43.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b43.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b44.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b44.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b45.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b45.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b46.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b46.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b47.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b47.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b63-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b63-l1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b63-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b63-r1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b63.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b70.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b70.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b72.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b72.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b74.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b74.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b77.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b77.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b8f-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b8f-l1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b8f-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b8f-r1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b8f.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b92.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b92.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c26.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c26.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-104312af-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104312af-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104312af-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104312af-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104312af.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431433-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431433-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431433-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431433-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431433.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431463-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431463-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431463-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431463-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431463.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431473-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431473-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431473.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431483-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431483-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431483.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431493-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431493-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431493-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431493-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431493.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-104314d3-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104314d3-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104314d3-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104314d3-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104314d3.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-104314e3-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104314e3-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104314e3-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104314e3-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104314e3.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431503-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431503-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431503-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431503-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431503.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431533-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431533-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431533-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431533-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431533.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431573-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431573-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431573-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431573-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431573.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431663-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431663-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431663.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-104317f3-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104317f3-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104317f3-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104317f3-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104317f3.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a20.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a30.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a40.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a50.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a60.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a8f-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a8f-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a8f-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a8f-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a8f.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431b93-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431b93-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431b93-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431b93-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431b93.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c9f-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c9f-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c9f-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c9f-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c9f.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431caf-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431caf-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431caf-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431caf-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431caf.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431ccf-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431ccf-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431ccf-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431ccf-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431ccf.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431cdf-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431cdf-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431cdf-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431cdf-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431cdf.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431cef-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431cef-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431cef-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431cef-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431cef.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431d1f-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431d1f-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431d1f-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431d1f-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431d1f.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431e02-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431e02-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431e02-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431e02-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431e02.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431e12-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431e12-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431e12-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431e12-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431e12.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431f12-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431f12-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431f12-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431f12-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431f12.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a20-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a20-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a20-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a20-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a30-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a30-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a30-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a30-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a40-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a40-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a40-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a40-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a50-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a50-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a50-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a50-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a60-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a60-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a60-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a60-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa22f1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa22f1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa22f1.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa22f2-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa22f2-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa22f2.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa22f3-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa22f3-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa22f3.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2316-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2316-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2316-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2316-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2316.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2317-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2317-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2317-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2317-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2317.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2318-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2318-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2318.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2319-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2319-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2319.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa231a-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa231a-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa231a.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3847-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3847-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3847-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3847-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3847.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3855-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3855-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3855-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3855-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3855.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot.wmfw \
firmware-cirrus/cs35l41/v6.39.0/halo-cspl-RAM-revB2-29.41.0.wmfw \
firmware-cirrus/cs35l41/v6.47.0/halo-cspl-RAM-revB2-29.49.0.wmfw \
firmware-cirrus/cs35l41/v6.61.1/halo-cspl-RAM-revB2-29.63.1.wmfw \
firmware-cirrus/cs35l41/v6.63.0/halo-cspl-RAM-revB2-29.65.0.wmfw \
firmware-cirrus/cs35l41/v6.78.0/halo-cspl-RAM-revB2-29.80.0.wmfw \
firmware-cis/3CCFEM556.cis \
firmware-cis/3CXEM556.cis \
firmware-cis/COMpad2.cis \
firmware-cis/COMpad4.cis \
firmware-cis/DP83903.cis \
firmware-cis/LA-PCM.cis \
firmware-cis/MT5634ZLX.cis \
firmware-cis/NE2K.cis \
firmware-cis/PCMLM28.cis \
firmware-cis/PE-200.cis \
firmware-cis/PE520.cis \
firmware-cis/RS-COM-2P.cis \
firmware-cis/SW-555-SER.cis \
firmware-cis/SW-7xx-SER.cis \
firmware-cis/SW-8xx-SER.cis \
firmware-cis/tamarack.cis \
firmware-cmmb-vega-12mhz.inp \
firmware-cmmb-venice-12mhz.inp \
firmware-cnm/wave521c-k3-codec-fw.bin \
firmware-cpia2/stv0672-vp4.bin \
firmware-ct2fw-3.2.5.1.bin \
firmware-ctefx.bin \
firmware-ctfw-3.2.5.1.bin \
firmware-ctspeq.bin \
firmware-cxgb3/ael2005-opt-edc.bin \
firmware-cxgb3/ael2005-twx-edc.bin \
firmware-cxgb3/ael2020-twx-edc.bin \
firmware-cxgb3/t3b-psram-1.1.0.bin \
firmware-cxgb3/t3c-psram-1.1.0.bin \
firmware-cxgb3/t3fw-7.0.0.bin \
firmware-cxgb3/t3fw-7.1.0.bin \
firmware-cxgb3/t3fw-7.10.0.bin \
firmware-cxgb3/t3fw-7.12.0.bin \
firmware-cxgb3/t3fw-7.4.0.bin \
firmware-cxgb4/aq1202-fw.cld \
firmware-cxgb4/bcm8483.bin \
firmware-cxgb4/configs/t4-config-default.txt \
firmware-cxgb4/configs/t5-config-default.txt \
firmware-cxgb4/configs/t5-config-hashfilter.txt \
firmware-cxgb4/configs/t6-config-default.txt \
firmware-cxgb4/configs/t6-config-hashfilter.txt \
firmware-cxgb4/t4-config.txt \
firmware-cxgb4/t4fw-1.14.4.0.bin \
firmware-cxgb4/t4fw-1.15.37.0.bin \
firmware-cxgb4/t4fw-1.27.3.0.bin \
firmware-cxgb4/t4fw.bin \
firmware-cxgb4/t5-config.txt \
firmware-cxgb4/t5fw-1.14.4.0.bin \
firmware-cxgb4/t5fw-1.15.37.0.bin \
firmware-cxgb4/t5fw-1.27.3.0.bin \
firmware-cxgb4/t5fw.bin \
firmware-cxgb4/t6-config.txt \
firmware-cxgb4/t6fw-1.27.3.0.bin \
firmware-cxgb4/t6fw.bin \
firmware-cypress/cyfmac43012-sdio.bin \
firmware-cypress/cyfmac43012-sdio.clm-blob \
firmware-cypress/cyfmac43340-sdio.bin \
firmware-cypress/cyfmac43362-sdio.bin \
firmware-cypress/cyfmac4339-sdio.bin \
firmware-cypress/cyfmac43430-sdio.bin \
firmware-cypress/cyfmac43430-sdio.clm-blob \
firmware-cypress/cyfmac43455-sdio.bin \
firmware-cypress/cyfmac43455-sdio.clm-blob \
firmware-cypress/cyfmac4354-sdio.bin \
firmware-cypress/cyfmac4354-sdio.clm-blob \
firmware-cypress/cyfmac4356-pcie.bin \
firmware-cypress/cyfmac4356-pcie.clm-blob \
firmware-cypress/cyfmac4356-sdio.bin \
firmware-cypress/cyfmac4356-sdio.clm-blob \
firmware-cypress/cyfmac43570-pcie.bin \
firmware-cypress/cyfmac43570-pcie.clm-blob \
firmware-cypress/cyfmac4373-sdio.bin \
firmware-cypress/cyfmac4373-sdio.clm-blob \
firmware-cypress/cyfmac54591-pcie.bin \
firmware-cypress/cyfmac54591-pcie.clm-blob \
firmware-dabusb/bitstream.bin \
firmware-dabusb/firmware.fw \
firmware-dpaa2/mc/mc-10.10.0-ls1088a.itb \
firmware-dpaa2/mc/mc-10.10.0-ls2088a.itb \
firmware-dpaa2/mc/mc-10.10.0-lx2160a.itb \
firmware-dpaa2/mc/mc-10.14.3-ls1088a.itb \
firmware-dpaa2/mc/mc-10.14.3-ls2088a.itb \
firmware-dpaa2/mc/mc-10.14.3-lx2160a.itb \
firmware-dpaa2/mc/mc-10.16.2-ls1088a.itb \
firmware-dpaa2/mc/mc-10.16.2-ls2088a.itb \
firmware-dpaa2/mc/mc-10.16.2-lx2160a.itb \
firmware-dpaa2/mc/mc-10.18.0-ls1088a.itb \
firmware-dpaa2/mc/mc-10.18.0-ls2088a.itb \
firmware-dpaa2/mc/mc-10.18.0-lx2160a.itb \
firmware-dpaa2/mc/mc-10.28.1-ls1088a.itb \
firmware-dpaa2/mc/mc-10.28.1-ls2088a.itb \
firmware-dpaa2/mc/mc-10.28.1-lx2160a.itb \
firmware-dsp56k/bootstrap.bin \
firmware-dvb-fe-xc4000-1.4.1.fw \
firmware-dvb-fe-xc5000-1.6.114.fw \
firmware-dvb-fe-xc5000c-4.1.30.7.fw \
firmware-dvb-nova-12mhz-b0.inp \
firmware-dvb-nova-12mhz.inp \
firmware-dvb-usb-dib0700-1.20.fw \
firmware-dvb-usb-it9135-01.fw \
firmware-dvb-usb-it9135-02.fw \
firmware-dvb-usb-terratec-h5-drxk.fw \
firmware-e100/d101m-ucode.bin \
firmware-e100/d101s-ucode.bin \
firmware-e100/d102e-ucode.bin \
firmware-edgeport/boot.fw \
firmware-edgeport/boot2.fw \
firmware-edgeport/down.fw \
firmware-edgeport/down2.fw \
firmware-edgeport/down3.bin \
firmware-emi26/bitstream.fw \
firmware-emi26/firmware.fw \
firmware-emi26/loader.fw \
firmware-emi62/bitstream.fw \
firmware-emi62/loader.fw \
firmware-emi62/midi.fw \
firmware-emi62/spdif.fw \
firmware-ene-ub6250/ms-init.bin \
firmware-ene-ub6250/ms-rdwr.bin \
firmware-ene-ub6250/msp-rdwr.bin \
firmware-ene-ub6250/sd-init1.bin \
firmware-ene-ub6250/sd-init2.bin \
firmware-ene-ub6250/sd-rdwr.bin \
firmware-ess/maestro3-assp-kernel.fw \
firmware-ess/maestro3-assp-minisrc.fw \
firmware-f2255usb.bin \
firmware-go7007/go7007fw.bin \
firmware-go7007/go7007tv.bin \
firmware-go7007/lr192.fw \
firmware-go7007/px-m402u.fw \
firmware-go7007/px-tv402u.fw \
firmware-go7007/s2250-1.fw \
firmware-go7007/s2250-2.fw \
firmware-go7007/wis-startrek.fw \
firmware-hfi1-dc8051.fw \
firmware-hfi1-fabric.fw \
firmware-hfi1-pcie.fw \
firmware-hfi1-sbus.fw \
firmware-htc-7010.fw \
firmware-htc-9271.fw \
firmware-i915/adlp-dmc-ver2-09.bin \
firmware-i915/adlp-dmc-ver2-10.bin \
firmware-i915/adlp-dmc-ver2-12.bin \
firmware-i915/adlp-dmc-ver2-14.bin \
firmware-i915/adlp-dmc-ver2-16.bin \
firmware-i915/adlp-dmc.bin \
firmware-i915/adlp-guc-62.0.3.bin \
firmware-i915/adlp-guc-69.0.3.bin \
firmware-i915/adlp-guc-70.1.1.bin \
firmware-i915/adlp-guc-70.bin \
firmware-i915/adls-dmc-ver2-01.bin \
firmware-i915/bxt-dmc-ver1-07.bin \
firmware-i915/bxt-dmc-ver1.bin \
firmware-i915/bxt-guc-32.0.3.bin \
firmware-i915/bxt-guc-33.0.0.bin \
firmware-i915/bxt-guc-49.0.1.bin \
firmware-i915/bxt-guc-62.0.0.bin \
firmware-i915/bxt-guc-69.0.3.bin \
firmware-i915/bxt-guc-70.1.1.bin \
firmware-i915/bxt-guc-ver8-7.bin \
firmware-i915/bxt-guc-ver9-29.bin \
firmware-i915/bxt-huc-2.0.0.bin \
firmware-i915/bxt-huc-ver01-07-1398.bin \
firmware-i915/bxt-huc-ver01-8-2893.bin \
firmware-i915/cml-guc-33.0.0.bin \
firmware-i915/cml-guc-49.0.1.bin \
firmware-i915/cml-guc-62.0.0.bin \
firmware-i915/cml-guc-69.0.3.bin \
firmware-i915/cml-guc-70.1.1.bin \
firmware-i915/cml-huc-4.0.0.bin \
firmware-i915/cnl-dmc-ver1-06.bin \
firmware-i915/cnl-dmc-ver1-07.bin \
firmware-i915/dg1-dmc-ver2-02.bin \
firmware-i915/dg1-guc-49.0.1.bin \
firmware-i915/dg1-guc-62.0.0.bin \
firmware-i915/dg1-guc-69.0.3.bin \
firmware-i915/dg1-guc-70.1.1.bin \
firmware-i915/dg1-guc-70.bin \
firmware-i915/dg1-huc-7.7.1.bin \
firmware-i915/dg1-huc-7.9.3.bin \
firmware-i915/dg1-huc.bin \
firmware-i915/dg2-dmc-ver2-06.bin \
firmware-i915/dg2-dmc-ver2-07.bin \
firmware-i915/dg2-dmc-ver2-08.bin \
firmware-i915/dg2-guc-70.1.2.bin \
firmware-i915/dg2-guc-70.4.1.bin \
firmware-i915/dg2-guc-70.bin \
firmware-i915/dg2-huc-gsc.bin \
firmware-i915/ehl-guc-33.0.4.bin \
firmware-i915/ehl-guc-49.0.1.bin \
firmware-i915/ehl-guc-62.0.0.bin \
firmware-i915/ehl-guc-69.0.3.bin \
firmware-i915/ehl-guc-70.1.1.bin \
firmware-i915/ehl-huc-9.0.0.bin \
firmware-i915/glk-dmc-ver1-04.bin \
firmware-i915/glk-guc-32.0.3.bin \
firmware-i915/glk-guc-33.0.0.bin \
firmware-i915/glk-guc-49.0.1.bin \
firmware-i915/glk-guc-62.0.0.bin \
firmware-i915/glk-guc-69.0.3.bin \
firmware-i915/glk-guc-70.1.1.bin \
firmware-i915/glk-huc-4.0.0.bin \
firmware-i915/glk-huc-ver03-01-2893.bin \
firmware-i915/icl-dmc-ver1-07.bin \
firmware-i915/icl-dmc-ver1-09.bin \
firmware-i915/icl-guc-32.0.3.bin \
firmware-i915/icl-guc-33.0.0.bin \
firmware-i915/icl-guc-49.0.1.bin \
firmware-i915/icl-guc-62.0.0.bin \
firmware-i915/icl-guc-69.0.3.bin \
firmware-i915/icl-guc-70.1.1.bin \
firmware-i915/icl-huc-9.0.0.bin \
firmware-i915/icl-huc-ver8-4-3238.bin \
firmware-i915/kbl-dmc-ver1-01.bin \
firmware-i915/kbl-dmc-ver1-04.bin \
firmware-i915/kbl-dmc-ver1.bin \
firmware-i915/kbl-guc-32.0.3.bin \
firmware-i915/kbl-guc-33.0.0.bin \
firmware-i915/kbl-guc-49.0.1.bin \
firmware-i915/kbl-guc-62.0.0.bin \
firmware-i915/kbl-guc-69.0.3.bin \
firmware-i915/kbl-guc-70.1.1.bin \
firmware-i915/kbl-guc-ver9-14.bin \
firmware-i915/kbl-guc-ver9-39.bin \
firmware-i915/kbl-huc-4.0.0.bin \
firmware-i915/kbl-huc-ver02-00-1810.bin \
firmware-i915/mtl-dmc-ver2-10.bin \
firmware-i915/mtl-dmc.bin \
firmware-i915/mtl-guc-70.bin \
firmware-i915/mtl-huc-gsc.bin \
firmware-i915/rkl-dmc-ver2-02.bin \
firmware-i915/rkl-dmc-ver2-03.bin \
firmware-i915/skl-dmc-ver1-23.bin \
firmware-i915/skl-dmc-ver1-26.bin \
firmware-i915/skl-dmc-ver1-27.bin \
firmware-i915/skl-dmc-ver1.bin \
firmware-i915/skl-guc-32.0.3.bin \
firmware-i915/skl-guc-33.0.0.bin \
firmware-i915/skl-guc-49.0.1.bin \
firmware-i915/skl-guc-62.0.0.bin \
firmware-i915/skl-guc-69.0.3.bin \
firmware-i915/skl-guc-70.1.1.bin \
firmware-i915/skl-guc-ver1.bin \
firmware-i915/skl-guc-ver4.bin \
firmware-i915/skl-guc-ver6-1.bin \
firmware-i915/skl-guc-ver6.bin \
firmware-i915/skl-guc-ver9-33.bin \
firmware-i915/skl-huc-2.0.0.bin \
firmware-i915/skl-huc-ver01-07-1398.bin \
firmware-i915/tgl-dmc-ver2-04.bin \
firmware-i915/tgl-dmc-ver2-06.bin \
firmware-i915/tgl-dmc-ver2-08.bin \
firmware-i915/tgl-dmc-ver2-12.bin \
firmware-i915/tgl-guc-35.2.0.bin \
firmware-i915/tgl-guc-49.0.1.bin \
firmware-i915/tgl-guc-62.0.0.bin \
firmware-i915/tgl-guc-69.0.3.bin \
firmware-i915/tgl-guc-70.1.1.bin \
firmware-i915/tgl-guc-70.bin \
firmware-i915/tgl-huc-7.0.12.bin \
firmware-i915/tgl-huc-7.0.3.bin \
firmware-i915/tgl-huc-7.5.0.bin \
firmware-i915/tgl-huc-7.9.3.bin \
firmware-i915/tgl-huc.bin \
firmware-imx/sdma/sdma-imx6q.bin \
firmware-imx/sdma/sdma-imx7d.bin \
firmware-inside-secure/eip197-minifw/ifpp.bin \
firmware-inside-secure/eip197-minifw/ipue.bin \
firmware-intel/IntcSST2.bin \
firmware-intel/avs/apl/dsp-basefw.bin \
firmware-intel/avs/cnl/dsp-basefw.bin \
firmware-intel/avs/skl/dsp-basefw.bin \
firmware-intel/avs/skl/dsp-mod-7CAD0808-AB10-CD23-EF45-12AB34CD56EF.bin \
firmware-intel/catpt/bdw/dsp-basefw.bin \
firmware-intel/dsp-fw-bxtn-v2219.bin \
firmware-intel/dsp-fw-bxtn-v3366.bin \
firmware-intel/dsp-fw-bxtn.bin \
firmware-intel/dsp-fw-cnl-v1191.bin \
firmware-intel/dsp-fw-cnl-v1858.bin \
firmware-intel/dsp-fw-cnl.bin \
firmware-intel/dsp-fw-glk-v1814.bin \
firmware-intel/dsp-fw-glk-v2768.bin \
firmware-intel/dsp-fw-glk-v2880.bin \
firmware-intel/dsp-fw-glk-v3366.bin \
firmware-intel/dsp-fw-glk.bin \
firmware-intel/dsp-fw-kbl-v1037.bin \
firmware-intel/dsp-fw-kbl-v2042.bin \
firmware-intel/dsp-fw-kbl-v2630.bin \
firmware-intel/dsp-fw-kbl-v3266.bin \
firmware-intel/dsp-fw-kbl-v3402.bin \
firmware-intel/dsp-fw-kbl-v3420.bin \
firmware-intel/dsp-fw-kbl-v701.bin \
firmware-intel/dsp-fw-kbl.bin \
firmware-intel/dsp-fw-release-v3402.bin \
firmware-intel/dsp-fw-release-v969.bin \
firmware-intel/dsp-fw-release.bin \
firmware-intel/fw-sst-0f28-ssp0.bin \
firmware-intel/fw-sst-0f28.bin \
firmware-intel/fw-sst-0f28.bin-48kHz-i2s-master \
firmware-intel/fw-sst-22a8.bin \
firmware-intel/ibt-0040-0041.ddc \
firmware-intel/ibt-0040-0041.sfi \
firmware-intel/ibt-0040-1020.ddc \
firmware-intel/ibt-0040-1020.sfi \
firmware-intel/ibt-0040-2120.ddc \
firmware-intel/ibt-0040-2120.sfi \
firmware-intel/ibt-0040-4150.ddc \
firmware-intel/ibt-0040-4150.sfi \
firmware-intel/ibt-0041-0041.ddc \
firmware-intel/ibt-0041-0041.sfi \
firmware-intel/ibt-1040-0041.ddc \
firmware-intel/ibt-1040-0041.sfi \
firmware-intel/ibt-1040-1020.ddc \
firmware-intel/ibt-1040-1020.sfi \
firmware-intel/ibt-1040-2120.ddc \
firmware-intel/ibt-1040-2120.sfi \
firmware-intel/ibt-1040-4150.ddc \
firmware-intel/ibt-1040-4150.sfi \
firmware-intel/ibt-11-5.ddc \
firmware-intel/ibt-11-5.sfi \
firmware-intel/ibt-12-16.ddc \
firmware-intel/ibt-12-16.sfi \
firmware-intel/ibt-17-0-1.ddc \
firmware-intel/ibt-17-0-1.sfi \
firmware-intel/ibt-17-1.ddc \
firmware-intel/ibt-17-1.sfi \
firmware-intel/ibt-17-16-1.ddc \
firmware-intel/ibt-17-16-1.sfi \
firmware-intel/ibt-17-2.ddc \
firmware-intel/ibt-17-2.sfi \
firmware-intel/ibt-18-0-1.ddc \
firmware-intel/ibt-18-0-1.sfi \
firmware-intel/ibt-18-1.ddc \
firmware-intel/ibt-18-1.sfi \
firmware-intel/ibt-18-16-1.ddc \
firmware-intel/ibt-18-16-1.sfi \
firmware-intel/ibt-18-2.ddc \
firmware-intel/ibt-18-2.sfi \
firmware-intel/ibt-19-0-0.ddc \
firmware-intel/ibt-19-0-0.sfi \
firmware-intel/ibt-19-0-1.ddc \
firmware-intel/ibt-19-0-1.sfi \
firmware-intel/ibt-19-0-3.ddc \
firmware-intel/ibt-19-0-3.sfi \
firmware-intel/ibt-19-0-4.ddc \
firmware-intel/ibt-19-0-4.sfi \
firmware-intel/ibt-19-16-4.ddc \
firmware-intel/ibt-19-16-4.sfi \
firmware-intel/ibt-19-240-1.ddc \
firmware-intel/ibt-19-240-1.sfi \
firmware-intel/ibt-19-240-4.ddc \
firmware-intel/ibt-19-240-4.sfi \
firmware-intel/ibt-19-32-0.ddc \
firmware-intel/ibt-19-32-0.sfi \
firmware-intel/ibt-19-32-1.ddc \
firmware-intel/ibt-19-32-1.sfi \
firmware-intel/ibt-19-32-4.ddc \
firmware-intel/ibt-19-32-4.sfi \
firmware-intel/ibt-20-0-3.ddc \
firmware-intel/ibt-20-0-3.sfi \
firmware-intel/ibt-20-1-3.ddc \
firmware-intel/ibt-20-1-3.sfi \
firmware-intel/ibt-20-1-4.ddc \
firmware-intel/ibt-20-1-4.sfi \
firmware-intel/ibt-hw-37.7.10-fw-1.0.1.2d.d.bseq \
firmware-intel/ibt-hw-37.7.10-fw-1.0.2.3.d.bseq \
firmware-intel/ibt-hw-37.7.10-fw-1.80.1.2d.d.bseq \
firmware-intel/ibt-hw-37.7.10-fw-1.80.2.3.d.bseq \
firmware-intel/ibt-hw-37.7.bseq \
firmware-intel/ibt-hw-37.8.10-fw-1.10.2.27.d.bseq \
firmware-intel/ibt-hw-37.8.10-fw-1.10.3.11.e.bseq \
firmware-intel/ibt-hw-37.8.10-fw-22.50.19.14.f.bseq \
firmware-intel/ibt-hw-37.8.bseq \
firmware-intel/ice/ddp-comms/ice-comms-1.3.40.0.pkg \
firmware-intel/ice/ddp-wireless-edge/ice-wireless-edge-1.3.10.0.pkg \
firmware-intel/ice/ddp/ice-1.3.30.0.pkg \
firmware-intel/ice/ddp/ice.pkg \
firmware-intel/ipu3-fw.bin \
firmware-intel/irci-irci-ecr-master-20161208-0213-20170112-1500.bin \
firmware-isci/isci-firmware.bin \
firmware-isdbt-nova-12mhz-b0.inp \
firmware-isdbt-nova-12mhz.inp \
firmware-isdbt-rio.inp \
firmware-iwlwifi-100-5.ucode \
firmware-iwlwifi-1000-5.ucode \
firmware-iwlwifi-105-6.ucode \
firmware-iwlwifi-135-6.ucode \
firmware-iwlwifi-2000-6.ucode \
firmware-iwlwifi-2030-6.ucode \
firmware-iwlwifi-3160-17.ucode \
firmware-iwlwifi-3168-29.ucode \
firmware-iwlwifi-3945-2.ucode \
firmware-iwlwifi-4965-2.ucode \
firmware-iwlwifi-5000-5.ucode \
firmware-iwlwifi-5150-2.ucode \
firmware-iwlwifi-6000-4.ucode \
firmware-iwlwifi-6000g2a-6.ucode \
firmware-iwlwifi-6000g2b-6.ucode \
firmware-iwlwifi-6050-5.ucode \
firmware-iwlwifi-7260-17.ucode \
firmware-iwlwifi-7265-17.ucode \
firmware-iwlwifi-7265D-29.ucode \
firmware-iwlwifi-8000C-34.ucode \
firmware-iwlwifi-8000C-36.ucode \
firmware-iwlwifi-8265-34.ucode \
firmware-iwlwifi-8265-36.ucode \
firmware-iwlwifi-9000-pu-b0-jf-b0-34.ucode \
firmware-iwlwifi-9000-pu-b0-jf-b0-38.ucode \
firmware-iwlwifi-9000-pu-b0-jf-b0-46.ucode \
firmware-iwlwifi-9260-th-b0-jf-b0-34.ucode \
firmware-iwlwifi-9260-th-b0-jf-b0-38.ucode \
firmware-iwlwifi-9260-th-b0-jf-b0-46.ucode \
firmware-iwlwifi-Qu-b0-hr-b0-50.ucode \
firmware-iwlwifi-Qu-b0-hr-b0-59.ucode \
firmware-iwlwifi-Qu-b0-hr-b0-66.ucode \
firmware-iwlwifi-Qu-b0-hr-b0-72.ucode \
firmware-iwlwifi-Qu-b0-hr-b0-73.ucode \
firmware-iwlwifi-Qu-b0-hr-b0-74.ucode \
firmware-iwlwifi-Qu-b0-hr-b0-77.ucode \
firmware-iwlwifi-Qu-b0-jf-b0-50.ucode \
firmware-iwlwifi-Qu-b0-jf-b0-59.ucode \
firmware-iwlwifi-Qu-b0-jf-b0-66.ucode \
firmware-iwlwifi-Qu-b0-jf-b0-72.ucode \
firmware-iwlwifi-Qu-b0-jf-b0-73.ucode \
firmware-iwlwifi-Qu-b0-jf-b0-74.ucode \
firmware-iwlwifi-Qu-b0-jf-b0-77.ucode \
firmware-iwlwifi-Qu-c0-hr-b0-50.ucode \
firmware-iwlwifi-Qu-c0-hr-b0-59.ucode \
firmware-iwlwifi-Qu-c0-hr-b0-66.ucode \
firmware-iwlwifi-Qu-c0-hr-b0-72.ucode \
firmware-iwlwifi-Qu-c0-hr-b0-73.ucode \
firmware-iwlwifi-Qu-c0-hr-b0-74.ucode \
firmware-iwlwifi-Qu-c0-hr-b0-77.ucode \
firmware-iwlwifi-Qu-c0-jf-b0-50.ucode \
firmware-iwlwifi-Qu-c0-jf-b0-59.ucode \
firmware-iwlwifi-Qu-c0-jf-b0-66.ucode \
firmware-iwlwifi-Qu-c0-jf-b0-72.ucode \
firmware-iwlwifi-Qu-c0-jf-b0-73.ucode \
firmware-iwlwifi-Qu-c0-jf-b0-74.ucode \
firmware-iwlwifi-Qu-c0-jf-b0-77.ucode \
firmware-iwlwifi-QuZ-a0-hr-b0-50.ucode \
firmware-iwlwifi-QuZ-a0-hr-b0-59.ucode \
firmware-iwlwifi-QuZ-a0-hr-b0-66.ucode \
firmware-iwlwifi-QuZ-a0-hr-b0-72.ucode \
firmware-iwlwifi-QuZ-a0-hr-b0-73.ucode \
firmware-iwlwifi-QuZ-a0-hr-b0-74.ucode \
firmware-iwlwifi-QuZ-a0-hr-b0-77.ucode \
firmware-iwlwifi-QuZ-a0-jf-b0-50.ucode \
firmware-iwlwifi-QuZ-a0-jf-b0-59.ucode \
firmware-iwlwifi-QuZ-a0-jf-b0-66.ucode \
firmware-iwlwifi-QuZ-a0-jf-b0-72.ucode \
firmware-iwlwifi-QuZ-a0-jf-b0-73.ucode \
firmware-iwlwifi-QuZ-a0-jf-b0-74.ucode \
firmware-iwlwifi-QuZ-a0-jf-b0-77.ucode \
firmware-iwlwifi-cc-a0-50.ucode \
firmware-iwlwifi-cc-a0-59.ucode \
firmware-iwlwifi-cc-a0-66.ucode \
firmware-iwlwifi-cc-a0-72.ucode \
firmware-iwlwifi-cc-a0-73.ucode \
firmware-iwlwifi-cc-a0-74.ucode \
firmware-iwlwifi-cc-a0-77.ucode \
firmware-iwlwifi-so-a0-gf-a0-72.ucode \
firmware-iwlwifi-so-a0-gf-a0-73.ucode \
firmware-iwlwifi-so-a0-gf-a0-74.ucode \
firmware-iwlwifi-so-a0-gf-a0-77.ucode \
firmware-iwlwifi-so-a0-gf-a0-78.ucode \
firmware-iwlwifi-so-a0-gf-a0-79.ucode \
firmware-iwlwifi-so-a0-gf-a0-81.ucode \
firmware-iwlwifi-so-a0-gf-a0-83.ucode \
firmware-iwlwifi-so-a0-gf-a0.pnvm \
firmware-iwlwifi-so-a0-gf4-a0-72.ucode \
firmware-iwlwifi-so-a0-gf4-a0-73.ucode \
firmware-iwlwifi-so-a0-gf4-a0-74.ucode \
firmware-iwlwifi-so-a0-gf4-a0-77.ucode \
firmware-iwlwifi-so-a0-gf4-a0-78.ucode \
firmware-iwlwifi-so-a0-gf4-a0-79.ucode \
firmware-iwlwifi-so-a0-gf4-a0-81.ucode \
firmware-iwlwifi-so-a0-gf4-a0-83.ucode \
firmware-iwlwifi-so-a0-gf4-a0.pnvm \
firmware-iwlwifi-so-a0-hr-b0-72.ucode \
firmware-iwlwifi-so-a0-hr-b0-73.ucode \
firmware-iwlwifi-so-a0-hr-b0-74.ucode \
firmware-iwlwifi-so-a0-hr-b0-77.ucode \
firmware-iwlwifi-so-a0-hr-b0-79.ucode \
firmware-iwlwifi-so-a0-hr-b0-81.ucode \
firmware-iwlwifi-so-a0-jf-b0-72.ucode \
firmware-iwlwifi-so-a0-jf-b0-73.ucode \
firmware-iwlwifi-so-a0-jf-b0-74.ucode \
firmware-iwlwifi-so-a0-jf-b0-77.ucode \
firmware-iwlwifi-ty-a0-gf-a0-59.ucode \
firmware-iwlwifi-ty-a0-gf-a0-66.ucode \
firmware-iwlwifi-ty-a0-gf-a0-72.ucode \
firmware-iwlwifi-ty-a0-gf-a0-73.ucode \
firmware-iwlwifi-ty-a0-gf-a0-74.ucode \
firmware-iwlwifi-ty-a0-gf-a0-77.ucode \
firmware-iwlwifi-ty-a0-gf-a0-78.ucode \
firmware-iwlwifi-ty-a0-gf-a0-79.ucode \
firmware-iwlwifi-ty-a0-gf-a0-81.ucode \
firmware-iwlwifi-ty-a0-gf-a0-83.ucode \
firmware-iwlwifi-ty-a0-gf-a0.pnvm \
firmware-kaweth/new-code-fix.bin \
firmware-kaweth/new-code.bin \
firmware-kaweth/trigger-code-fix.bin \
firmware-kaweth/trigger-code.bin \
firmware-keyspan-pda/keyspan-pda.fw \
firmware-keyspan-pda/xircom-pgs.fw \
firmware-keyspan/mpr.fw \
firmware-keyspan/usa18x.fw \
firmware-keyspan/usa19.fw \
firmware-keyspan/usa19qi.fw \
firmware-keyspan/usa19qw.fw \
firmware-keyspan/usa19w.fw \
firmware-keyspan/usa28.fw \
firmware-keyspan/usa28x.fw \
firmware-keyspan/usa28xa.fw \
firmware-keyspan/usa28xb.fw \
firmware-keyspan/usa49w.fw \
firmware-keyspan/usa49wlc.fw \
firmware-korg/k1212.dsp \
firmware-lbtf-usb.bin \
firmware-lgs8g75.fw \
firmware-libertas/cf8381-helper.bin \
firmware-libertas/cf8381.bin \
firmware-libertas/cf8385-helper.bin \
firmware-libertas/cf8385.bin \
firmware-libertas/gspi8682-helper.bin \
firmware-libertas/gspi8682.bin \
firmware-libertas/gspi8686-v9-helper.bin \
firmware-libertas/gspi8686-v9.bin \
firmware-libertas/gspi8688-helper.bin \
firmware-libertas/gspi8688.bin \
firmware-libertas/lbtf-sdio.bin \
firmware-libertas/sd8385-helper.bin \
firmware-libertas/sd8385.bin \
firmware-libertas/sd8682-helper.bin \
firmware-libertas/sd8682.bin \
firmware-libertas/sd8686-v8-helper.bin \
firmware-libertas/sd8686-v8.bin \
firmware-libertas/sd8686-v9-helper.bin \
firmware-libertas/sd8686-v9.bin \
firmware-libertas/sd8688-helper.bin \
firmware-libertas/sd8688.bin \
firmware-libertas/usb8388-olpc.bin \
firmware-libertas/usb8388-v5.bin \
firmware-libertas/usb8388-v9.bin \
firmware-libertas/usb8682.bin \
firmware-liquidio/lio-210nv-nic.bin \
firmware-liquidio/lio-210sv-nic.bin \
firmware-liquidio/lio-23xx-nic.bin \
firmware-liquidio/lio-410nv-nic.bin \
firmware-lt9611uxc-fw.bin \
firmware-matrox/g200-warp.fw \
firmware-matrox/g400-warp.fw \
firmware-mediatek/BT-RAM-CODE-MT7922-1-1-hdr.bin \
firmware-mediatek/BT-RAM-CODE-MT7961-1-2-hdr.bin \
firmware-mediatek/WIFI-MT7922-patch-mcu-1-1-hdr.bin \
firmware-mediatek/WIFI-MT7961-patch-mcu-1-2-hdr.bin \
firmware-mediatek/WIFI-RAM-CODE-MT7922-1.bin \
firmware-mediatek/WIFI-RAM-CODE-MT7961-1.bin \
firmware-mediatek/mt7601u.bin \
firmware-mediatek/mt7610e.bin \
firmware-mediatek/mt7610u.bin \
firmware-mediatek/mt7615-cr4.bin \
firmware-mediatek/mt7615-n9.bin \
firmware-mediatek/mt7615-rom-patch.bin \
firmware-mediatek/mt7622-n9.bin \
firmware-mediatek/mt7622-rom-patch.bin \
firmware-mediatek/mt7622pr2h.bin \
firmware-mediatek/mt7650.bin \
firmware-mediatek/mt7650e.bin \
firmware-mediatek/mt7662-rom-patch.bin \
firmware-mediatek/mt7662.bin \
firmware-mediatek/mt7662u-rom-patch.bin \
firmware-mediatek/mt7662u.bin \
firmware-mediatek/mt7663-n9-rebb.bin \
firmware-mediatek/mt7663-n9-v3.bin \
firmware-mediatek/mt7663pr2h-rebb.bin \
firmware-mediatek/mt7663pr2h.bin \
firmware-mediatek/mt7668pr2h.bin \
firmware-mediatek/mt7915-eeprom-dbdc.bin \
firmware-mediatek/mt7915-eeprom.bin \
firmware-mediatek/mt7915-rom-patch.bin \
firmware-mediatek/mt7915-wa.bin \
firmware-mediatek/mt7915-wm.bin \
firmware-mediatek/mt7916-eeprom.bin \
firmware-mediatek/mt7916-rom-patch.bin \
firmware-mediatek/mt7916-wa.bin \
firmware-mediatek/mt7916-wm.bin \
firmware-mediatek/mt7981-rom-patch.bin \
firmware-mediatek/mt7981-wa.bin \
firmware-mediatek/mt7981-wm.bin \
firmware-mediatek/mt7981-wo.bin \
firmware-mediatek/mt7986-eeprom-mt7975-dual.bin \
firmware-mediatek/mt7986-eeprom-mt7976-dbdc.bin \
firmware-mediatek/mt7986-eeprom-mt7976-dual.bin \
firmware-mediatek/mt7986-eeprom-mt7976.bin \
firmware-mediatek/mt7986-rom-patch-mt7975.bin \
firmware-mediatek/mt7986-rom-patch.bin \
firmware-mediatek/mt7986-wa.bin \
firmware-mediatek/mt7986-wm-mt7975.bin \
firmware-mediatek/mt7986-wm.bin \
firmware-mediatek/mt7986-wo-0.bin \
firmware-mediatek/mt7986-wo-1.bin \
firmware-mediatek/mt8173/vpu-d.bin \
firmware-mediatek/mt8173/vpu-p.bin \
firmware-mediatek/mt8183/scp.img \
firmware-mediatek/mt8186/scp.img \
firmware-mediatek/mt8192/scp.img \
firmware-mediatek/mt8195/scp.img \
firmware-mediatek/sof-tplg/sof-mt8186.tplg \
firmware-mediatek/sof-tplg/sof-mt8195-mt6359-rt1019-rt5682-dts.tplg \
firmware-mediatek/sof-tplg/sof-mt8195-mt6359-rt1019-rt5682.tplg \
firmware-mediatek/sof/sof-mt8186.ldc \
firmware-mediatek/sof/sof-mt8186.ri \
firmware-mediatek/sof/sof-mt8195.ldc \
firmware-mediatek/sof/sof-mt8195.ri \
firmware-mellanox/lc-ini-bundle-2010-1006.bin \
firmware-mellanox/lc-ini-bundle-2010-1502.bin \
firmware-mellanox/lc-ini-bundle-2010-3020.bin \
firmware-mellanox/lc-ini-bundle-2010-3146.bin \
firmware-mellanox/mlxsw-spectrum-13.1420.122.mfa2 \
firmware-mellanox/mlxsw-spectrum-13.1530.152.mfa2 \
firmware-mellanox/mlxsw-spectrum-13.1620.192.mfa2 \
firmware-mellanox/mlxsw-spectrum-13.1702.6.mfa2 \
firmware-mellanox/mlxsw-spectrum-13.1703.4.mfa2 \
firmware-mellanox/mlxsw-spectrum-13.1910.622.mfa2 \
firmware-mellanox/mlxsw-spectrum-13.2000.1122.mfa2 \
firmware-mellanox/mlxsw-spectrum-13.2000.1886.mfa2 \
firmware-mellanox/mlxsw-spectrum-13.2000.2308.mfa2 \
firmware-mellanox/mlxsw-spectrum-13.2000.2714.mfa2 \
firmware-mellanox/mlxsw-spectrum-13.2007.1168.mfa2 \
firmware-mellanox/mlxsw-spectrum-13.2008.1036.mfa2 \
firmware-mellanox/mlxsw-spectrum-13.2008.1310.mfa2 \
firmware-mellanox/mlxsw-spectrum-13.2008.1312.mfa2 \
firmware-mellanox/mlxsw-spectrum-13.2008.2018.mfa2 \
firmware-mellanox/mlxsw-spectrum-13.2008.2304.mfa2 \
firmware-mellanox/mlxsw-spectrum-13.2008.2406.mfa2 \
firmware-mellanox/mlxsw-spectrum-13.2008.2438.mfa2 \
firmware-mellanox/mlxsw-spectrum-13.2008.2946.mfa2 \
firmware-mellanox/mlxsw-spectrum-13.2008.3326.mfa2 \
firmware-mellanox/mlxsw-spectrum-13.2010.1006.mfa2 \
firmware-mellanox/mlxsw-spectrum-13.2010.1232.mfa2 \
firmware-mellanox/mlxsw-spectrum-13.2010.1406.mfa2 \
firmware-mellanox/mlxsw-spectrum-13.2010.1502.mfa2 \
firmware-mellanox/mlxsw-spectrum-13.2010.3020.mfa2 \
firmware-mellanox/mlxsw-spectrum-13.2010.3146.mfa2 \
firmware-mellanox/mlxsw-spectrum2-29.2000.2308.mfa2 \
firmware-mellanox/mlxsw-spectrum2-29.2000.2714.mfa2 \
firmware-mellanox/mlxsw-spectrum2-29.2007.1168.mfa2 \
firmware-mellanox/mlxsw-spectrum2-29.2008.1036.mfa2 \
firmware-mellanox/mlxsw-spectrum2-29.2008.1310.mfa2 \
firmware-mellanox/mlxsw-spectrum2-29.2008.1312.mfa2 \
firmware-mellanox/mlxsw-spectrum2-29.2008.2018.mfa2 \
firmware-mellanox/mlxsw-spectrum2-29.2008.2304.mfa2 \
firmware-mellanox/mlxsw-spectrum2-29.2008.2406.mfa2 \
firmware-mellanox/mlxsw-spectrum2-29.2008.2438.mfa2 \
firmware-mellanox/mlxsw-spectrum2-29.2008.2946.mfa2 \
firmware-mellanox/mlxsw-spectrum2-29.2008.3326.mfa2 \
firmware-mellanox/mlxsw-spectrum2-29.2010.1006.mfa2 \
firmware-mellanox/mlxsw-spectrum2-29.2010.1232.mfa2 \
firmware-mellanox/mlxsw-spectrum2-29.2010.1406.mfa2 \
firmware-mellanox/mlxsw-spectrum2-29.2010.1502.mfa2 \
firmware-mellanox/mlxsw-spectrum2-29.2010.3020.mfa2 \
firmware-mellanox/mlxsw-spectrum2-29.2010.3146.mfa2 \
firmware-mellanox/mlxsw-spectrum3-30.2007.1168.mfa2 \
firmware-mellanox/mlxsw-spectrum3-30.2008.1036.mfa2 \
firmware-mellanox/mlxsw-spectrum3-30.2008.1310.mfa2 \
firmware-mellanox/mlxsw-spectrum3-30.2008.1312.mfa2 \
firmware-mellanox/mlxsw-spectrum3-30.2008.2018.mfa2 \
firmware-mellanox/mlxsw-spectrum3-30.2008.2304.mfa2 \
firmware-mellanox/mlxsw-spectrum3-30.2008.2406.mfa2 \
firmware-mellanox/mlxsw-spectrum3-30.2008.2438.mfa2 \
firmware-mellanox/mlxsw-spectrum3-30.2008.2946.mfa2 \
firmware-mellanox/mlxsw-spectrum3-30.2008.3326.mfa2 \
firmware-mellanox/mlxsw-spectrum3-30.2010.1006.mfa2 \
firmware-mellanox/mlxsw-spectrum3-30.2010.1232.mfa2 \
firmware-mellanox/mlxsw-spectrum3-30.2010.1406.mfa2 \
firmware-mellanox/mlxsw-spectrum3-30.2010.1502.mfa2 \
firmware-mellanox/mlxsw-spectrum3-30.2010.3020.mfa2 \
firmware-mellanox/mlxsw-spectrum3-30.2010.3146.mfa2 \
firmware-meson/vdec/g12a-h264.bin \
firmware-meson/vdec/g12a-hevc-mmu.bin \
firmware-meson/vdec/g12a-vp9.bin \
firmware-meson/vdec/gxbb-h264.bin \
firmware-meson/vdec/gxl-h263.bin \
firmware-meson/vdec/gxl-h264.bin \
firmware-meson/vdec/gxl-hevc-mmu.bin \
firmware-meson/vdec/gxl-hevc.bin \
firmware-meson/vdec/gxl-mjpeg.bin \
firmware-meson/vdec/gxl-mpeg12.bin \
firmware-meson/vdec/gxl-mpeg4-5.bin \
firmware-meson/vdec/gxl-vp9.bin \
firmware-meson/vdec/gxm-h264.bin \
firmware-meson/vdec/sm1-hevc-mmu.bin \
firmware-meson/vdec/sm1-vp9-mmu.bin \
firmware-microchip/mscc-vsc8574-revb-int8051-29e8.bin \
firmware-microchip/mscc-vsc8584-revb-int8051-fb48.bin \
firmware-moxa/moxa-1110.fw \
firmware-moxa/moxa-1130.fw \
firmware-moxa/moxa-1131.fw \
firmware-moxa/moxa-1150.fw \
firmware-moxa/moxa-1151.fw \
firmware-moxa/moxa-1250.fw \
firmware-moxa/moxa-1251.fw \
firmware-moxa/moxa-1410.fw \
firmware-moxa/moxa-1450.fw \
firmware-moxa/moxa-1451.fw \
firmware-moxa/moxa-1613.fw \
firmware-moxa/moxa-1618.fw \
firmware-moxa/moxa-1653.fw \
firmware-moxa/moxa-1658.fw \
firmware-mrvl/cpt01/ae.out \
firmware-mrvl/cpt01/ie.out \
firmware-mrvl/cpt01/se.out \
firmware-mrvl/cpt02/ae.out \
firmware-mrvl/cpt02/ie.out \
firmware-mrvl/cpt02/se.out \
firmware-mrvl/cpt03/ae.out \
firmware-mrvl/cpt03/ie.out \
firmware-mrvl/cpt03/se.out \
firmware-mrvl/cpt04/ae.out \
firmware-mrvl/cpt04/ie.out \
firmware-mrvl/cpt04/se.out \
firmware-mrvl/pcie8897-uapsta.bin \
firmware-mrvl/pcie8997-wlan-v4.bin \
firmware-mrvl/pcieuart8997-combo-v4.bin \
firmware-mrvl/pcieusb8997-combo-v4.bin \
firmware-mrvl/prestera/mvsw-prestera-fw-arm64-v4.1.img \
firmware-mrvl/prestera/mvsw-prestera-fw-v2.0.img \
firmware-mrvl/prestera/mvsw-prestera-fw-v3.0.img \
firmware-mrvl/prestera/mvsw-prestera-fw-v4.0.img \
firmware-mrvl/prestera/mvsw-prestera-fw-v4.1.img \
firmware-mrvl/sd8688-helper.bin \
firmware-mrvl/sd8688.bin \
firmware-mrvl/sd8787-uapsta.bin \
firmware-mrvl/sd8797-uapsta.bin \
firmware-mrvl/sd8801-uapsta.bin \
firmware-mrvl/sd8887-uapsta.bin \
firmware-mrvl/sd8897-uapsta.bin \
firmware-mrvl/sdsd8977-combo-v2.bin \
firmware-mrvl/sdsd8997-combo-v4.bin \
firmware-mrvl/usb8766-uapsta.bin \
firmware-mrvl/usb8797-uapsta.bin \
firmware-mrvl/usb8801-uapsta.bin \
firmware-mrvl/usb8897-uapsta.bin \
firmware-mrvl/usbusb8997-combo-v4.bin \
firmware-mt7601u.bin \
firmware-mt7650.bin \
firmware-mt7662-rom-patch.bin \
firmware-mt7662.bin \
firmware-mts-cdma.fw \
firmware-mts-edge.fw \
firmware-mts-gsm.fw \
firmware-mts-mt9234mu.fw \
firmware-mts-mt9234zba.fw \
firmware-mwl8k/fmimage-8366-ap-1.fw \
firmware-mwl8k/fmimage-8366-ap-2.fw \
firmware-mwl8k/fmimage-8366-ap-3.fw \
firmware-mwl8k/fmimage-8366.fw \
firmware-mwl8k/fmimage-8687.fw \
firmware-mwl8k/fmimage-8764-ap-1.fw \
firmware-mwl8k/helper-8366.fw \
firmware-mwl8k/helper-8687.fw \
firmware-mwlwifi/88W8864.bin \
firmware-mwlwifi/88W8897.bin \
firmware-myri10ge-eth-big-z8e.dat \
firmware-myri10ge-eth-z8e.dat \
firmware-myri10ge-ethp-big-z8e.dat \
firmware-myri10ge-ethp-z8e.dat \
firmware-myri10ge-rss-eth-big-z8e.dat \
firmware-myri10ge-rss-eth-z8e.dat \
firmware-myri10ge-rss-ethp-big-z8e.dat \
firmware-myri10ge-rss-ethp-z8e.dat \
firmware-myricom/lanai.bin \
firmware-netronome/bpf/nic-AMDA0058-0011-2x40.nffw \
firmware-netronome/bpf/nic-AMDA0058-0012-2x40.nffw \
firmware-netronome/bpf/nic-AMDA0078-0011-1x100.nffw \
firmware-netronome/bpf/nic-AMDA0081-0001-1x40.nffw \
firmware-netronome/bpf/nic-AMDA0081-0001-4x10.nffw \
firmware-netronome/bpf/nic-AMDA0096-0001-2x10.nffw \
firmware-netronome/bpf/nic-AMDA0097-0001-2x40.nffw \
firmware-netronome/bpf/nic-AMDA0097-0001-4x10-1x40.nffw \
firmware-netronome/bpf/nic-AMDA0097-0001-8x10.nffw \
firmware-netronome/bpf/nic-AMDA0099-0001-1x10-1x25.nffw \
firmware-netronome/bpf/nic-AMDA0099-0001-2x10.nffw \
firmware-netronome/bpf/nic-AMDA0099-0001-2x25.nffw \
firmware-netronome/flower/nic-AMDA0058-0011-1x100.nffw \
firmware-netronome/flower/nic-AMDA0058-0011-2x40.nffw \
firmware-netronome/flower/nic-AMDA0058-0011-4x10-1x40.nffw \
firmware-netronome/flower/nic-AMDA0058-0011-8x10.nffw \
firmware-netronome/flower/nic-AMDA0058-0012-1x100.nffw \
firmware-netronome/flower/nic-AMDA0058-0012-2x40.nffw \
firmware-netronome/flower/nic-AMDA0058-0012-4x10-1x40.nffw \
firmware-netronome/flower/nic-AMDA0058-0012-8x10.nffw \
firmware-netronome/flower/nic-AMDA0058.nffw \
firmware-netronome/flower/nic-AMDA0078-0011-1x100.nffw \
firmware-netronome/flower/nic-AMDA0078-0011-2x40.nffw \
firmware-netronome/flower/nic-AMDA0078-0011-4x10-1x40.nffw \
firmware-netronome/flower/nic-AMDA0078-0011-8x10.nffw \
firmware-netronome/flower/nic-AMDA0078-0012-1x100.nffw \
firmware-netronome/flower/nic-AMDA0078-0012-2x40.nffw \
firmware-netronome/flower/nic-AMDA0078-0012-4x10-1x40.nffw \
firmware-netronome/flower/nic-AMDA0078-0012-8x10.nffw \
firmware-netronome/flower/nic-AMDA0081-0001-1x40.nffw \
firmware-netronome/flower/nic-AMDA0081-0001-4x10.nffw \
firmware-netronome/flower/nic-AMDA0081.nffw \
firmware-netronome/flower/nic-AMDA0096-0001-2x10.nffw \
firmware-netronome/flower/nic-AMDA0096.nffw \
firmware-netronome/flower/nic-AMDA0097-0001-2x40.nffw \
firmware-netronome/flower/nic-AMDA0097-0001-4x10-1x40.nffw \
firmware-netronome/flower/nic-AMDA0097-0001-8x10.nffw \
firmware-netronome/flower/nic-AMDA0097.nffw \
firmware-netronome/flower/nic-AMDA0099-0001-1x10-1x25.nffw \
firmware-netronome/flower/nic-AMDA0099-0001-2x10.nffw \
firmware-netronome/flower/nic-AMDA0099-0001-2x25.nffw \
firmware-netronome/flower/nic-AMDA0099.nffw \
firmware-netronome/nic-AMDA0058-0011-2x40.nffw \
firmware-netronome/nic-AMDA0058-0012-2x40.nffw \
firmware-netronome/nic-AMDA0078-0011-1x100.nffw \
firmware-netronome/nic-AMDA0081-0001-1x40.nffw \
firmware-netronome/nic-AMDA0081-0001-4x10.nffw \
firmware-netronome/nic-AMDA0096-0001-2x10.nffw \
firmware-netronome/nic-AMDA0097-0001-2x40.nffw \
firmware-netronome/nic-AMDA0097-0001-4x10-1x40.nffw \
firmware-netronome/nic-AMDA0097-0001-8x10.nffw \
firmware-netronome/nic-AMDA0099-0001-1x10-1x25.nffw \
firmware-netronome/nic-AMDA0099-0001-2x10.nffw \
firmware-netronome/nic-AMDA0099-0001-2x25.nffw \
firmware-netronome/nic-sriov/nic-AMDA0058-0011-2x40.nffw \
firmware-netronome/nic-sriov/nic-AMDA0058-0012-2x40.nffw \
firmware-netronome/nic-sriov/nic-AMDA0078-0011-1x100.nffw \
firmware-netronome/nic-sriov/nic-AMDA0081-0001-1x40.nffw \
firmware-netronome/nic-sriov/nic-AMDA0081-0001-4x10.nffw \
firmware-netronome/nic-sriov/nic-AMDA0096-0001-2x10.nffw \
firmware-netronome/nic-sriov/nic-AMDA0097-0001-2x40.nffw \
firmware-netronome/nic-sriov/nic-AMDA0097-0001-4x10-1x40.nffw \
firmware-netronome/nic-sriov/nic-AMDA0097-0001-8x10.nffw \
firmware-netronome/nic-sriov/nic-AMDA0099-0001-1x10-1x25.nffw \
firmware-netronome/nic-sriov/nic-AMDA0099-0001-2x10.nffw \
firmware-netronome/nic-sriov/nic-AMDA0099-0001-2x25.nffw \
firmware-netronome/nic/nic-AMDA0058-0011-2x40.nffw \
firmware-netronome/nic/nic-AMDA0058-0012-2x40.nffw \
firmware-netronome/nic/nic-AMDA0078-0011-1x100.nffw \
firmware-netronome/nic/nic-AMDA0081-0001-1x40.nffw \
firmware-netronome/nic/nic-AMDA0081-0001-4x10.nffw \
firmware-netronome/nic/nic-AMDA0096-0001-2x10.nffw \
firmware-netronome/nic/nic-AMDA0097-0001-2x40.nffw \
firmware-netronome/nic/nic-AMDA0097-0001-4x10-1x40.nffw \
firmware-netronome/nic/nic-AMDA0097-0001-8x10.nffw \
firmware-netronome/nic/nic-AMDA0099-0001-1x10-1x25.nffw \
firmware-netronome/nic/nic-AMDA0099-0001-2x10.nffw \
firmware-netronome/nic/nic-AMDA0099-0001-2x25.nffw \
firmware-nvidia/ga102/acr/ucode-ahesasc.bin \
firmware-nvidia/ga102/acr/ucode-asb.bin \
firmware-nvidia/ga102/acr/ucode-unload.bin \
firmware-nvidia/ga102/gr/NET-img.bin \
firmware-nvidia/ga102/gr/fecs-bl.bin \
firmware-nvidia/ga102/gr/fecs-sig.bin \
firmware-nvidia/ga102/gr/gpccs-bl.bin \
firmware-nvidia/ga102/gr/gpccs-sig.bin \
firmware-nvidia/ga102/nvdec/scrubber.bin \
firmware-nvidia/ga102/sec2/desc.bin \
firmware-nvidia/ga102/sec2/hs-bl-sig.bin \
firmware-nvidia/ga102/sec2/image.bin \
firmware-nvidia/ga102/sec2/sig.bin \
firmware-nvidia/ga103/acr/ucode-ahesasc.bin \
firmware-nvidia/ga103/acr/ucode-asb.bin \
firmware-nvidia/ga103/acr/ucode-unload.bin \
firmware-nvidia/ga103/gr/NET-img.bin \
firmware-nvidia/ga103/gr/fecs-bl.bin \
firmware-nvidia/ga103/gr/fecs-sig.bin \
firmware-nvidia/ga103/gr/gpccs-bl.bin \
firmware-nvidia/ga103/gr/gpccs-sig.bin \
firmware-nvidia/ga103/nvdec/scrubber.bin \
firmware-nvidia/ga103/sec2/desc.bin \
firmware-nvidia/ga103/sec2/hs-bl-sig.bin \
firmware-nvidia/ga103/sec2/image.bin \
firmware-nvidia/ga103/sec2/sig.bin \
firmware-nvidia/ga104/acr/ucode-ahesasc.bin \
firmware-nvidia/ga104/acr/ucode-asb.bin \
firmware-nvidia/ga104/acr/ucode-unload.bin \
firmware-nvidia/ga104/gr/NET-img.bin \
firmware-nvidia/ga104/gr/fecs-bl.bin \
firmware-nvidia/ga104/gr/fecs-sig.bin \
firmware-nvidia/ga104/gr/gpccs-bl.bin \
firmware-nvidia/ga104/gr/gpccs-sig.bin \
firmware-nvidia/ga104/nvdec/scrubber.bin \
firmware-nvidia/ga104/sec2/desc.bin \
firmware-nvidia/ga104/sec2/hs-bl-sig.bin \
firmware-nvidia/ga104/sec2/image.bin \
firmware-nvidia/ga104/sec2/sig.bin \
firmware-nvidia/ga106/acr/ucode-ahesasc.bin \
firmware-nvidia/ga106/acr/ucode-asb.bin \
firmware-nvidia/ga106/acr/ucode-unload.bin \
firmware-nvidia/ga106/gr/NET-img.bin \
firmware-nvidia/ga106/gr/fecs-bl.bin \
firmware-nvidia/ga106/gr/fecs-sig.bin \
firmware-nvidia/ga106/gr/gpccs-bl.bin \
firmware-nvidia/ga106/gr/gpccs-sig.bin \
firmware-nvidia/ga106/nvdec/scrubber.bin \
firmware-nvidia/ga106/sec2/desc.bin \
firmware-nvidia/ga106/sec2/hs-bl-sig.bin \
firmware-nvidia/ga106/sec2/image.bin \
firmware-nvidia/ga106/sec2/sig.bin \
firmware-nvidia/ga107/acr/ucode-ahesasc.bin \
firmware-nvidia/ga107/acr/ucode-asb.bin \
firmware-nvidia/ga107/acr/ucode-unload.bin \
firmware-nvidia/ga107/gr/NET-img.bin \
firmware-nvidia/ga107/gr/fecs-bl.bin \
firmware-nvidia/ga107/gr/fecs-sig.bin \
firmware-nvidia/ga107/gr/gpccs-bl.bin \
firmware-nvidia/ga107/gr/gpccs-sig.bin \
firmware-nvidia/ga107/nvdec/scrubber.bin \
firmware-nvidia/ga107/sec2/desc.bin \
firmware-nvidia/ga107/sec2/hs-bl-sig.bin \
firmware-nvidia/ga107/sec2/image.bin \
firmware-nvidia/ga107/sec2/sig.bin \
firmware-nvidia/gk20a/fecs-data.bin \
firmware-nvidia/gk20a/fecs-inst.bin \
firmware-nvidia/gk20a/gpccs-data.bin \
firmware-nvidia/gk20a/gpccs-inst.bin \
firmware-nvidia/gk20a/sw-bundle-init.bin \
firmware-nvidia/gk20a/sw-ctx.bin \
firmware-nvidia/gk20a/sw-method-init.bin \
firmware-nvidia/gk20a/sw-nonctx.bin \
firmware-nvidia/gm200/acr/bl.bin \
firmware-nvidia/gm200/acr/ucode-load.bin \
firmware-nvidia/gm200/acr/ucode-unload.bin \
firmware-nvidia/gm200/gr/fecs-bl.bin \
firmware-nvidia/gm200/gr/fecs-data.bin \
firmware-nvidia/gm200/gr/fecs-inst.bin \
firmware-nvidia/gm200/gr/fecs-sig.bin \
firmware-nvidia/gm200/gr/gpccs-bl.bin \
firmware-nvidia/gm200/gr/gpccs-data.bin \
firmware-nvidia/gm200/gr/gpccs-inst.bin \
firmware-nvidia/gm200/gr/gpccs-sig.bin \
firmware-nvidia/gm200/gr/sw-bundle-init.bin \
firmware-nvidia/gm200/gr/sw-ctx.bin \
firmware-nvidia/gm200/gr/sw-method-init.bin \
firmware-nvidia/gm200/gr/sw-nonctx.bin \
firmware-nvidia/gm204/acr/bl.bin \
firmware-nvidia/gm204/acr/ucode-load.bin \
firmware-nvidia/gm204/acr/ucode-unload.bin \
firmware-nvidia/gm204/gr/fecs-bl.bin \
firmware-nvidia/gm204/gr/fecs-data.bin \
firmware-nvidia/gm204/gr/fecs-inst.bin \
firmware-nvidia/gm204/gr/fecs-sig.bin \
firmware-nvidia/gm204/gr/gpccs-bl.bin \
firmware-nvidia/gm204/gr/gpccs-data.bin \
firmware-nvidia/gm204/gr/gpccs-inst.bin \
firmware-nvidia/gm204/gr/gpccs-sig.bin \
firmware-nvidia/gm204/gr/sw-bundle-init.bin \
firmware-nvidia/gm204/gr/sw-ctx.bin \
firmware-nvidia/gm204/gr/sw-method-init.bin \
firmware-nvidia/gm204/gr/sw-nonctx.bin \
firmware-nvidia/gm206/acr/bl.bin \
firmware-nvidia/gm206/acr/ucode-load.bin \
firmware-nvidia/gm206/acr/ucode-unload.bin \
firmware-nvidia/gm206/gr/fecs-bl.bin \
firmware-nvidia/gm206/gr/fecs-data.bin \
firmware-nvidia/gm206/gr/fecs-inst.bin \
firmware-nvidia/gm206/gr/fecs-sig.bin \
firmware-nvidia/gm206/gr/gpccs-bl.bin \
firmware-nvidia/gm206/gr/gpccs-data.bin \
firmware-nvidia/gm206/gr/gpccs-inst.bin \
firmware-nvidia/gm206/gr/gpccs-sig.bin \
firmware-nvidia/gm206/gr/sw-bundle-init.bin \
firmware-nvidia/gm206/gr/sw-ctx.bin \
firmware-nvidia/gm206/gr/sw-method-init.bin \
firmware-nvidia/gm206/gr/sw-nonctx.bin \
firmware-nvidia/gm20b/acr/bl.bin \
firmware-nvidia/gm20b/acr/ucode-load.bin \
firmware-nvidia/gm20b/gr/fecs-bl.bin \
firmware-nvidia/gm20b/gr/fecs-data.bin \
firmware-nvidia/gm20b/gr/fecs-inst.bin \
firmware-nvidia/gm20b/gr/fecs-sig.bin \
firmware-nvidia/gm20b/gr/gpccs-data.bin \
firmware-nvidia/gm20b/gr/gpccs-inst.bin \
firmware-nvidia/gm20b/gr/sw-bundle-init.bin \
firmware-nvidia/gm20b/gr/sw-ctx.bin \
firmware-nvidia/gm20b/gr/sw-method-init.bin \
firmware-nvidia/gm20b/gr/sw-nonctx.bin \
firmware-nvidia/gm20b/pmu/desc.bin \
firmware-nvidia/gm20b/pmu/image.bin \
firmware-nvidia/gm20b/pmu/sig.bin \
firmware-nvidia/gp100/acr/bl.bin \
firmware-nvidia/gp100/acr/ucode-load.bin \
firmware-nvidia/gp100/acr/ucode-unload.bin \
firmware-nvidia/gp100/gr/fecs-bl.bin \
firmware-nvidia/gp100/gr/fecs-data.bin \
firmware-nvidia/gp100/gr/fecs-inst.bin \
firmware-nvidia/gp100/gr/fecs-sig.bin \
firmware-nvidia/gp100/gr/gpccs-bl.bin \
firmware-nvidia/gp100/gr/gpccs-data.bin \
firmware-nvidia/gp100/gr/gpccs-inst.bin \
firmware-nvidia/gp100/gr/gpccs-sig.bin \
firmware-nvidia/gp100/gr/sw-bundle-init.bin \
firmware-nvidia/gp100/gr/sw-ctx.bin \
firmware-nvidia/gp100/gr/sw-method-init.bin \
firmware-nvidia/gp100/gr/sw-nonctx.bin \
firmware-nvidia/gp102/acr/bl.bin \
firmware-nvidia/gp102/acr/ucode-load.bin \
firmware-nvidia/gp102/acr/ucode-unload.bin \
firmware-nvidia/gp102/acr/unload-bl.bin \
firmware-nvidia/gp102/gr/fecs-bl.bin \
firmware-nvidia/gp102/gr/fecs-data.bin \
firmware-nvidia/gp102/gr/fecs-inst.bin \
firmware-nvidia/gp102/gr/fecs-sig.bin \
firmware-nvidia/gp102/gr/gpccs-bl.bin \
firmware-nvidia/gp102/gr/gpccs-data.bin \
firmware-nvidia/gp102/gr/gpccs-inst.bin \
firmware-nvidia/gp102/gr/gpccs-sig.bin \
firmware-nvidia/gp102/gr/sw-bundle-init.bin \
firmware-nvidia/gp102/gr/sw-ctx.bin \
firmware-nvidia/gp102/gr/sw-method-init.bin \
firmware-nvidia/gp102/gr/sw-nonctx.bin \
firmware-nvidia/gp102/nvdec/scrubber.bin \
firmware-nvidia/gp102/sec2/desc-1.bin \
firmware-nvidia/gp102/sec2/desc.bin \
firmware-nvidia/gp102/sec2/image-1.bin \
firmware-nvidia/gp102/sec2/image.bin \
firmware-nvidia/gp102/sec2/sig-1.bin \
firmware-nvidia/gp102/sec2/sig.bin \
firmware-nvidia/gp104/acr/bl.bin \
firmware-nvidia/gp104/acr/ucode-load.bin \
firmware-nvidia/gp104/acr/ucode-unload.bin \
firmware-nvidia/gp104/acr/unload-bl.bin \
firmware-nvidia/gp104/gr/fecs-bl.bin \
firmware-nvidia/gp104/gr/fecs-data.bin \
firmware-nvidia/gp104/gr/fecs-inst.bin \
firmware-nvidia/gp104/gr/fecs-sig.bin \
firmware-nvidia/gp104/gr/gpccs-bl.bin \
firmware-nvidia/gp104/gr/gpccs-data.bin \
firmware-nvidia/gp104/gr/gpccs-inst.bin \
firmware-nvidia/gp104/gr/gpccs-sig.bin \
firmware-nvidia/gp104/gr/sw-bundle-init.bin \
firmware-nvidia/gp104/gr/sw-ctx.bin \
firmware-nvidia/gp104/gr/sw-method-init.bin \
firmware-nvidia/gp104/gr/sw-nonctx.bin \
firmware-nvidia/gp104/nvdec/scrubber.bin \
firmware-nvidia/gp104/sec2/desc-1.bin \
firmware-nvidia/gp104/sec2/desc.bin \
firmware-nvidia/gp104/sec2/image-1.bin \
firmware-nvidia/gp104/sec2/image.bin \
firmware-nvidia/gp104/sec2/sig-1.bin \
firmware-nvidia/gp104/sec2/sig.bin \
firmware-nvidia/gp106/acr/bl.bin \
firmware-nvidia/gp106/acr/ucode-load.bin \
firmware-nvidia/gp106/acr/ucode-unload.bin \
firmware-nvidia/gp106/acr/unload-bl.bin \
firmware-nvidia/gp106/gr/fecs-bl.bin \
firmware-nvidia/gp106/gr/fecs-data.bin \
firmware-nvidia/gp106/gr/fecs-inst.bin \
firmware-nvidia/gp106/gr/fecs-sig.bin \
firmware-nvidia/gp106/gr/gpccs-bl.bin \
firmware-nvidia/gp106/gr/gpccs-data.bin \
firmware-nvidia/gp106/gr/gpccs-inst.bin \
firmware-nvidia/gp106/gr/gpccs-sig.bin \
firmware-nvidia/gp106/gr/sw-bundle-init.bin \
firmware-nvidia/gp106/gr/sw-ctx.bin \
firmware-nvidia/gp106/gr/sw-method-init.bin \
firmware-nvidia/gp106/gr/sw-nonctx.bin \
firmware-nvidia/gp106/nvdec/scrubber.bin \
firmware-nvidia/gp106/sec2/desc-1.bin \
firmware-nvidia/gp106/sec2/desc.bin \
firmware-nvidia/gp106/sec2/image-1.bin \
firmware-nvidia/gp106/sec2/image.bin \
firmware-nvidia/gp106/sec2/sig-1.bin \
firmware-nvidia/gp106/sec2/sig.bin \
firmware-nvidia/gp107/acr/bl.bin \
firmware-nvidia/gp107/acr/ucode-load.bin \
firmware-nvidia/gp107/acr/ucode-unload.bin \
firmware-nvidia/gp107/acr/unload-bl.bin \
firmware-nvidia/gp107/gr/fecs-bl.bin \
firmware-nvidia/gp107/gr/fecs-data.bin \
firmware-nvidia/gp107/gr/fecs-inst.bin \
firmware-nvidia/gp107/gr/fecs-sig.bin \
firmware-nvidia/gp107/gr/gpccs-bl.bin \
firmware-nvidia/gp107/gr/gpccs-data.bin \
firmware-nvidia/gp107/gr/gpccs-inst.bin \
firmware-nvidia/gp107/gr/gpccs-sig.bin \
firmware-nvidia/gp107/gr/sw-bundle-init.bin \
firmware-nvidia/gp107/gr/sw-ctx.bin \
firmware-nvidia/gp107/gr/sw-method-init.bin \
firmware-nvidia/gp107/gr/sw-nonctx.bin \
firmware-nvidia/gp107/nvdec/scrubber.bin \
firmware-nvidia/gp107/sec2/desc-1.bin \
firmware-nvidia/gp107/sec2/desc.bin \
firmware-nvidia/gp107/sec2/image-1.bin \
firmware-nvidia/gp107/sec2/image.bin \
firmware-nvidia/gp107/sec2/sig-1.bin \
firmware-nvidia/gp107/sec2/sig.bin \
firmware-nvidia/gp108/acr/bl.bin \
firmware-nvidia/gp108/acr/ucode-load.bin \
firmware-nvidia/gp108/acr/ucode-unload.bin \
firmware-nvidia/gp108/acr/unload-bl.bin \
firmware-nvidia/gp108/gr/fecs-bl.bin \
firmware-nvidia/gp108/gr/fecs-data.bin \
firmware-nvidia/gp108/gr/fecs-inst.bin \
firmware-nvidia/gp108/gr/fecs-sig.bin \
firmware-nvidia/gp108/gr/gpccs-bl.bin \
firmware-nvidia/gp108/gr/gpccs-data.bin \
firmware-nvidia/gp108/gr/gpccs-inst.bin \
firmware-nvidia/gp108/gr/gpccs-sig.bin \
firmware-nvidia/gp108/gr/sw-bundle-init.bin \
firmware-nvidia/gp108/gr/sw-ctx.bin \
firmware-nvidia/gp108/gr/sw-method-init.bin \
firmware-nvidia/gp108/gr/sw-nonctx.bin \
firmware-nvidia/gp108/nvdec/scrubber.bin \
firmware-nvidia/gp108/sec2/desc.bin \
firmware-nvidia/gp108/sec2/image.bin \
firmware-nvidia/gp108/sec2/sig.bin \
firmware-nvidia/gp10b/acr/bl.bin \
firmware-nvidia/gp10b/acr/ucode-load.bin \
firmware-nvidia/gp10b/gr/fecs-bl.bin \
firmware-nvidia/gp10b/gr/fecs-data.bin \
firmware-nvidia/gp10b/gr/fecs-inst.bin \
firmware-nvidia/gp10b/gr/fecs-sig.bin \
firmware-nvidia/gp10b/gr/gpccs-bl.bin \
firmware-nvidia/gp10b/gr/gpccs-data.bin \
firmware-nvidia/gp10b/gr/gpccs-inst.bin \
firmware-nvidia/gp10b/gr/gpccs-sig.bin \
firmware-nvidia/gp10b/gr/sw-bundle-init.bin \
firmware-nvidia/gp10b/gr/sw-ctx.bin \
firmware-nvidia/gp10b/gr/sw-method-init.bin \
firmware-nvidia/gp10b/gr/sw-nonctx.bin \
firmware-nvidia/gp10b/pmu/desc.bin \
firmware-nvidia/gp10b/pmu/image.bin \
firmware-nvidia/gp10b/pmu/sig.bin \
firmware-nvidia/gv100/acr/bl.bin \
firmware-nvidia/gv100/acr/ucode-load.bin \
firmware-nvidia/gv100/acr/ucode-unload.bin \
firmware-nvidia/gv100/acr/unload-bl.bin \
firmware-nvidia/gv100/gr/fecs-bl.bin \
firmware-nvidia/gv100/gr/fecs-data.bin \
firmware-nvidia/gv100/gr/fecs-inst.bin \
firmware-nvidia/gv100/gr/fecs-sig.bin \
firmware-nvidia/gv100/gr/gpccs-bl.bin \
firmware-nvidia/gv100/gr/gpccs-data.bin \
firmware-nvidia/gv100/gr/gpccs-inst.bin \
firmware-nvidia/gv100/gr/gpccs-sig.bin \
firmware-nvidia/gv100/gr/sw-bundle-init.bin \
firmware-nvidia/gv100/gr/sw-ctx.bin \
firmware-nvidia/gv100/gr/sw-method-init.bin \
firmware-nvidia/gv100/gr/sw-nonctx.bin \
firmware-nvidia/gv100/nvdec/scrubber.bin \
firmware-nvidia/gv100/sec2/desc.bin \
firmware-nvidia/gv100/sec2/image.bin \
firmware-nvidia/gv100/sec2/sig.bin \
firmware-nvidia/tegra124/vic.bin \
firmware-nvidia/tegra124/vic03-ucode.bin \
firmware-nvidia/tegra124/xusb.bin \
firmware-nvidia/tegra186/vic.bin \
firmware-nvidia/tegra186/vic04-ucode.bin \
firmware-nvidia/tegra186/xusb.bin \
firmware-nvidia/tegra194/vic.bin \
firmware-nvidia/tegra194/xusb.bin \
firmware-nvidia/tegra210/vic.bin \
firmware-nvidia/tegra210/vic04-ucode.bin \
firmware-nvidia/tegra210/xusb.bin \
firmware-nvidia/tu102/acr/bl.bin \
firmware-nvidia/tu102/acr/ucode-ahesasc.bin \
firmware-nvidia/tu102/acr/ucode-asb.bin \
firmware-nvidia/tu102/acr/ucode-unload.bin \
firmware-nvidia/tu102/acr/unload-bl.bin \
firmware-nvidia/tu102/gr/fecs-bl.bin \
firmware-nvidia/tu102/gr/fecs-data.bin \
firmware-nvidia/tu102/gr/fecs-inst.bin \
firmware-nvidia/tu102/gr/fecs-sig.bin \
firmware-nvidia/tu102/gr/gpccs-bl.bin \
firmware-nvidia/tu102/gr/gpccs-data.bin \
firmware-nvidia/tu102/gr/gpccs-inst.bin \
firmware-nvidia/tu102/gr/gpccs-sig.bin \
firmware-nvidia/tu102/gr/sw-bundle-init.bin \
firmware-nvidia/tu102/gr/sw-ctx.bin \
firmware-nvidia/tu102/gr/sw-method-init.bin \
firmware-nvidia/tu102/gr/sw-nonctx.bin \
firmware-nvidia/tu102/gr/sw-veid-bundle-init.bin \
firmware-nvidia/tu102/nvdec/scrubber.bin \
firmware-nvidia/tu102/sec2/desc.bin \
firmware-nvidia/tu102/sec2/image.bin \
firmware-nvidia/tu102/sec2/sig.bin \
firmware-nvidia/tu104/acr/bl.bin \
firmware-nvidia/tu104/acr/ucode-ahesasc.bin \
firmware-nvidia/tu104/acr/ucode-asb.bin \
firmware-nvidia/tu104/acr/ucode-unload.bin \
firmware-nvidia/tu104/acr/unload-bl.bin \
firmware-nvidia/tu104/gr/fecs-bl.bin \
firmware-nvidia/tu104/gr/fecs-data.bin \
firmware-nvidia/tu104/gr/fecs-inst.bin \
firmware-nvidia/tu104/gr/fecs-sig.bin \
firmware-nvidia/tu104/gr/gpccs-bl.bin \
firmware-nvidia/tu104/gr/gpccs-data.bin \
firmware-nvidia/tu104/gr/gpccs-inst.bin \
firmware-nvidia/tu104/gr/gpccs-sig.bin \
firmware-nvidia/tu104/gr/sw-bundle-init.bin \
firmware-nvidia/tu104/gr/sw-ctx.bin \
firmware-nvidia/tu104/gr/sw-method-init.bin \
firmware-nvidia/tu104/gr/sw-nonctx.bin \
firmware-nvidia/tu104/gr/sw-veid-bundle-init.bin \
firmware-nvidia/tu104/nvdec/scrubber.bin \
firmware-nvidia/tu104/sec2/desc.bin \
firmware-nvidia/tu104/sec2/image.bin \
firmware-nvidia/tu104/sec2/sig.bin \
firmware-nvidia/tu106/acr/bl.bin \
firmware-nvidia/tu106/acr/ucode-ahesasc.bin \
firmware-nvidia/tu106/acr/ucode-asb.bin \
firmware-nvidia/tu106/acr/ucode-unload.bin \
firmware-nvidia/tu106/acr/unload-bl.bin \
firmware-nvidia/tu106/gr/fecs-bl.bin \
firmware-nvidia/tu106/gr/fecs-data.bin \
firmware-nvidia/tu106/gr/fecs-inst.bin \
firmware-nvidia/tu106/gr/fecs-sig.bin \
firmware-nvidia/tu106/gr/gpccs-bl.bin \
firmware-nvidia/tu106/gr/gpccs-data.bin \
firmware-nvidia/tu106/gr/gpccs-inst.bin \
firmware-nvidia/tu106/gr/gpccs-sig.bin \
firmware-nvidia/tu106/gr/sw-bundle-init.bin \
firmware-nvidia/tu106/gr/sw-ctx.bin \
firmware-nvidia/tu106/gr/sw-method-init.bin \
firmware-nvidia/tu106/gr/sw-nonctx.bin \
firmware-nvidia/tu106/gr/sw-veid-bundle-init.bin \
firmware-nvidia/tu106/nvdec/scrubber.bin \
firmware-nvidia/tu106/sec2/desc.bin \
firmware-nvidia/tu106/sec2/image.bin \
firmware-nvidia/tu106/sec2/sig.bin \
firmware-nvidia/tu10x/typec/ccg-boot.cyacd \
firmware-nvidia/tu10x/typec/ccg-primary.cyacd \
firmware-nvidia/tu10x/typec/ccg-secondary.cyacd \
firmware-nvidia/tu116/acr/bl.bin \
firmware-nvidia/tu116/acr/ucode-ahesasc.bin \
firmware-nvidia/tu116/acr/ucode-asb.bin \
firmware-nvidia/tu116/acr/ucode-unload.bin \
firmware-nvidia/tu116/acr/unload-bl.bin \
firmware-nvidia/tu116/gr/fecs-bl.bin \
firmware-nvidia/tu116/gr/fecs-data.bin \
firmware-nvidia/tu116/gr/fecs-inst.bin \
firmware-nvidia/tu116/gr/fecs-sig.bin \
firmware-nvidia/tu116/gr/gpccs-bl.bin \
firmware-nvidia/tu116/gr/gpccs-data.bin \
firmware-nvidia/tu116/gr/gpccs-inst.bin \
firmware-nvidia/tu116/gr/gpccs-sig.bin \
firmware-nvidia/tu116/gr/sw-bundle-init.bin \
firmware-nvidia/tu116/gr/sw-ctx.bin \
firmware-nvidia/tu116/gr/sw-method-init.bin \
firmware-nvidia/tu116/gr/sw-nonctx.bin \
firmware-nvidia/tu116/gr/sw-veid-bundle-init.bin \
firmware-nvidia/tu116/nvdec/scrubber.bin \
firmware-nvidia/tu116/sec2/desc.bin \
firmware-nvidia/tu116/sec2/image.bin \
firmware-nvidia/tu116/sec2/sig.bin \
firmware-nvidia/tu117/acr/bl.bin \
firmware-nvidia/tu117/acr/ucode-ahesasc.bin \
firmware-nvidia/tu117/acr/ucode-asb.bin \
firmware-nvidia/tu117/acr/ucode-unload.bin \
firmware-nvidia/tu117/acr/unload-bl.bin \
firmware-nvidia/tu117/gr/fecs-bl.bin \
firmware-nvidia/tu117/gr/fecs-data.bin \
firmware-nvidia/tu117/gr/fecs-inst.bin \
firmware-nvidia/tu117/gr/fecs-sig.bin \
firmware-nvidia/tu117/gr/gpccs-bl.bin \
firmware-nvidia/tu117/gr/gpccs-data.bin \
firmware-nvidia/tu117/gr/gpccs-inst.bin \
firmware-nvidia/tu117/gr/gpccs-sig.bin \
firmware-nvidia/tu117/gr/sw-bundle-init.bin \
firmware-nvidia/tu117/gr/sw-ctx.bin \
firmware-nvidia/tu117/gr/sw-method-init.bin \
firmware-nvidia/tu117/gr/sw-nonctx.bin \
firmware-nvidia/tu117/gr/sw-veid-bundle-init.bin \
firmware-nvidia/tu117/nvdec/scrubber.bin \
firmware-nvidia/tu117/sec2/desc.bin \
firmware-nvidia/tu117/sec2/image.bin \
firmware-nvidia/tu117/sec2/sig.bin \
firmware-nxp/helper-uart-3000000.bin \
firmware-nxp/sr150-fw.bin \
firmware-nxp/uartiw416-bt-v0.bin \
firmware-nxp/uartspi-n61x-v1.bin.se \
firmware-nxp/uartuart8987-bt.bin \
firmware-nxp/uartuart8997-bt-v4.bin \
firmware-nxp/uartuart9098-bt-v1.bin \
firmware-ositech/Xilinx7OD.bin \
firmware-phanfw.bin \
firmware-qat-4xxx-mmp.bin \
firmware-qat-4xxx.bin \
firmware-qat-895xcc-mmp.bin \
firmware-qat-895xcc.bin \
firmware-qat-c3xxx-mmp.bin \
firmware-qat-c3xxx.bin \
firmware-qat-c62x-mmp.bin \
firmware-qat-c62x.bin \
firmware-qat-mmp.bin \
firmware-qca/crbtfw21.tlv \
firmware-qca/crbtfw32.tlv \
firmware-qca/crnv21.bin \
firmware-qca/crnv32.bin \
firmware-qca/crnv32u.bin \
firmware-qca/hpbtfw21.tlv \
firmware-qca/hpnv21.301 \
firmware-qca/hpnv21.302 \
firmware-qca/hpnv21.bin \
firmware-qca/hpnv21g.301 \
firmware-qca/hpnv21g.302 \
firmware-qca/hpnv21g.bin \
firmware-qca/htbtfw20.tlv \
firmware-qca/htnv20.bin \
firmware-qca/msbtfw11.mbn \
firmware-qca/msbtfw11.tlv \
firmware-qca/msnv11.b09 \
firmware-qca/msnv11.b0a \
firmware-qca/msnv11.bin \
firmware-qca/nvm-00130300.bin \
firmware-qca/nvm-00130302.bin \
firmware-qca/nvm-00230302.bin \
firmware-qca/nvm-00440302-eu.bin \
firmware-qca/nvm-00440302-i2s-eu.bin \
firmware-qca/nvm-00440302.bin \
firmware-qca/nvm-usb-00000200.bin \
firmware-qca/nvm-usb-00000201.bin \
firmware-qca/nvm-usb-00000300.bin \
firmware-qca/nvm-usb-00000302-eu.bin \
firmware-qca/nvm-usb-00000302.bin \
firmware-qca/nvm-usb-00130200-0104.bin \
firmware-qca/nvm-usb-00130200-0105.bin \
firmware-qca/nvm-usb-00130200-0106.bin \
firmware-qca/nvm-usb-00130200-0107.bin \
firmware-qca/nvm-usb-00130200-0109.bin \
firmware-qca/nvm-usb-00130200-0110.bin \
firmware-qca/nvm-usb-00130200.bin \
firmware-qca/nvm-usb-00130201-010a.bin \
firmware-qca/nvm-usb-00130201-010b.bin \
firmware-qca/nvm-usb-00130201-0303.bin \
firmware-qca/nvm-usb-00130201-gf-010a.bin \
firmware-qca/nvm-usb-00130201-gf-010b.bin \
firmware-qca/nvm-usb-00130201-gf-0303.bin \
firmware-qca/nvm-usb-00130201-gf.bin \
firmware-qca/nvm-usb-00130201.bin \
firmware-qca/nvm-usb-00190200.bin \
firmware-qca/rampatch-00130300.bin \
firmware-qca/rampatch-00130302.bin \
firmware-qca/rampatch-00230302.bin \
firmware-qca/rampatch-00440302.bin \
firmware-qca/rampatch-usb-00000200.bin \
firmware-qca/rampatch-usb-00000201.bin \
firmware-qca/rampatch-usb-00000300.bin \
firmware-qca/rampatch-usb-00000302.bin \
firmware-qca/rampatch-usb-00130200.bin \
firmware-qca/rampatch-usb-00130201.bin \
firmware-qca/rampatch-usb-00190200.bin \
firmware-qcom/a300-pfp.fw \
firmware-qcom/a300-pm4.fw \
firmware-qcom/a330-pfp.fw \
firmware-qcom/a330-pm4.fw \
firmware-qcom/a420-pfp.fw \
firmware-qcom/a420-pm4.fw \
firmware-qcom/a530-pfp.fw \
firmware-qcom/a530-pm4.fw \
firmware-qcom/a530-zap.mdt \
firmware-qcom/a530v3-gpmu.fw2 \
firmware-qcom/a630-gmu.bin \
firmware-qcom/a630-sqe.fw \
firmware-qcom/a650-gmu.bin \
firmware-qcom/a650-sqe.fw \
firmware-qcom/a660-gmu.bin \
firmware-qcom/a660-sqe.fw \
firmware-qcom/apq8016/WCNSS-qcom-wlan-nv-sbc.bin \
firmware-qcom/apq8016/mba.mbn \
firmware-qcom/apq8016/modem.mbn \
firmware-qcom/apq8016/wcnss.mbn \
firmware-qcom/apq8096/a530-zap.mbn \
firmware-qcom/apq8096/adsp.mbn \
firmware-qcom/apq8096/adspr.jsn \
firmware-qcom/apq8096/adspua.jsn \
firmware-qcom/apq8096/mba.mbn \
firmware-qcom/apq8096/modem.mbn \
firmware-qcom/apq8096/modemr.jsn \
firmware-qcom/leia-pfp-470.fw \
firmware-qcom/leia-pm4-470.fw \
firmware-qcom/sc8280xp/LENOVO/21BX/adspr.jsn \
firmware-qcom/sc8280xp/LENOVO/21BX/adspua.jsn \
firmware-qcom/sc8280xp/LENOVO/21BX/audioreach-tplg.bin \
firmware-qcom/sc8280xp/LENOVO/21BX/battmgr.jsn \
firmware-qcom/sc8280xp/LENOVO/21BX/cdspr.jsn \
firmware-qcom/sc8280xp/LENOVO/21BX/qcadsp8280.mbn \
firmware-qcom/sc8280xp/LENOVO/21BX/qccdsp8280.mbn \
firmware-qcom/sc8280xp/LENOVO/21BX/qcdxkmsuc8280.mbn \
firmware-qcom/sc8280xp/LENOVO/21BX/qcslpi8280.mbn \
firmware-qcom/sdm845/a630-zap.mbn \
firmware-qcom/sdm845/adsp.mbn \
firmware-qcom/sdm845/adspr.jsn \
firmware-qcom/sdm845/adspua.jsn \
firmware-qcom/sdm845/cdsp.mbn \
firmware-qcom/sdm845/cdspr.jsn \
firmware-qcom/sdm845/mba.mbn \
firmware-qcom/sdm845/modem-nm.mbn \
firmware-qcom/sdm845/modem.mbn \
firmware-qcom/sdm845/modemuw.jsn \
firmware-qcom/sdm845/wlanmdsp.mbn \
firmware-qcom/sm8250/a650-zap.mbn \
firmware-qcom/sm8250/adsp.mbn \
firmware-qcom/sm8250/adspr.jsn \
firmware-qcom/sm8250/adspua.jsn \
firmware-qcom/sm8250/cdsp.mbn \
firmware-qcom/sm8250/cdspr.jsn \
firmware-qcom/venus-1.8/venus.mbn \
firmware-qcom/venus-1.8/venus.mdt \
firmware-qcom/venus-4.2/venus.mbn \
firmware-qcom/venus-4.2/venus.mdt \
firmware-qcom/venus-5.2/venus.mbn \
firmware-qcom/venus-5.2/venus.mdt \
firmware-qcom/venus-5.4/venus.mbn \
firmware-qcom/venus-5.4/venus.mdt \
firmware-qcom/vpu-1.0/venus.mbn \
firmware-qcom/vpu-1.0/venus.mdt \
firmware-qcom/vpu-2.0/venus.mbn \
firmware-qcom/yamato-pfp.fw \
firmware-qcom/yamato-pm4.fw \
firmware-qed/qed-init-values-8.10.9.0.bin \
firmware-qed/qed-init-values-8.14.6.0.bin \
firmware-qed/qed-init-values-8.18.9.0.bin \
firmware-qed/qed-init-values-8.20.0.0.bin \
firmware-qed/qed-init-values-8.30.12.0.bin \
firmware-qed/qed-init-values-8.33.12.0.bin \
firmware-qed/qed-init-values-8.37.7.0.bin \
firmware-qed/qed-init-values-8.40.33.0.bin \
firmware-qed/qed-init-values-zipped-8.10.10.0.bin \
firmware-qed/qed-init-values-zipped-8.10.5.0.bin \
firmware-qed/qed-init-values-zipped-8.15.3.0.bin \
firmware-qed/qed-init-values-zipped-8.20.0.0.bin \
firmware-qed/qed-init-values-zipped-8.33.1.0.bin \
firmware-qed/qed-init-values-zipped-8.33.11.0.bin \
firmware-qed/qed-init-values-zipped-8.37.2.0.bin \
firmware-qed/qed-init-values-zipped-8.37.7.0.bin \
firmware-qed/qed-init-values-zipped-8.4.2.0.bin \
firmware-qed/qed-init-values-zipped-8.42.2.0.bin \
firmware-qed/qed-init-values-zipped-8.59.1.0.bin \
firmware-qed/qed-init-values-zipped-8.7.3.0.bin \
firmware-ql2100-fw.bin \
firmware-ql2200-fw.bin \
firmware-ql2300-fw.bin \
firmware-ql2322-fw.bin \
firmware-ql2400-fw.bin \
firmware-ql2500-fw.bin \
firmware-ql2600-fw.bin \
firmware-ql2700-fw.bin \
firmware-ql8300-fw.bin \
firmware-qlogic/1040.bin \
firmware-qlogic/12160.bin \
firmware-qlogic/1280.bin \
firmware-qlogic/isp1000.bin \
firmware-qlogic/sd7220.fw \
firmware-r128/r128-cce.bin \
firmware-r8a779x-usb3-v1.dlmem \
firmware-r8a779x-usb3-v2.dlmem \
firmware-r8a779x-usb3-v3.dlmem \
firmware-radeon/ARUBA-me.bin \
firmware-radeon/ARUBA-pfp.bin \
firmware-radeon/ARUBA-rlc.bin \
firmware-radeon/BARTS-mc.bin \
firmware-radeon/BARTS-me.bin \
firmware-radeon/BARTS-pfp.bin \
firmware-radeon/BARTS-smc.bin \
firmware-radeon/BONAIRE-ce.bin \
firmware-radeon/BONAIRE-mc.bin \
firmware-radeon/BONAIRE-mc2.bin \
firmware-radeon/BONAIRE-me.bin \
firmware-radeon/BONAIRE-mec.bin \
firmware-radeon/BONAIRE-pfp.bin \
firmware-radeon/BONAIRE-rlc.bin \
firmware-radeon/BONAIRE-sdma.bin \
firmware-radeon/BONAIRE-smc.bin \
firmware-radeon/BONAIRE-uvd.bin \
firmware-radeon/BONAIRE-vce.bin \
firmware-radeon/BTC-rlc.bin \
firmware-radeon/CAICOS-mc.bin \
firmware-radeon/CAICOS-me.bin \
firmware-radeon/CAICOS-pfp.bin \
firmware-radeon/CAICOS-smc.bin \
firmware-radeon/CAYMAN-mc.bin \
firmware-radeon/CAYMAN-me.bin \
firmware-radeon/CAYMAN-pfp.bin \
firmware-radeon/CAYMAN-rlc.bin \
firmware-radeon/CAYMAN-smc.bin \
firmware-radeon/CEDAR-me.bin \
firmware-radeon/CEDAR-pfp.bin \
firmware-radeon/CEDAR-rlc.bin \
firmware-radeon/CEDAR-smc.bin \
firmware-radeon/CYPRESS-me.bin \
firmware-radeon/CYPRESS-pfp.bin \
firmware-radeon/CYPRESS-rlc.bin \
firmware-radeon/CYPRESS-smc.bin \
firmware-radeon/CYPRESS-uvd.bin \
firmware-radeon/HAINAN-ce.bin \
firmware-radeon/HAINAN-mc.bin \
firmware-radeon/HAINAN-mc2.bin \
firmware-radeon/HAINAN-me.bin \
firmware-radeon/HAINAN-pfp.bin \
firmware-radeon/HAINAN-rlc.bin \
firmware-radeon/HAINAN-smc.bin \
firmware-radeon/HAWAII-ce.bin \
firmware-radeon/HAWAII-mc.bin \
firmware-radeon/HAWAII-mc2.bin \
firmware-radeon/HAWAII-me.bin \
firmware-radeon/HAWAII-mec.bin \
firmware-radeon/HAWAII-pfp.bin \
firmware-radeon/HAWAII-rlc.bin \
firmware-radeon/HAWAII-sdma.bin \
firmware-radeon/HAWAII-smc.bin \
firmware-radeon/JUNIPER-me.bin \
firmware-radeon/JUNIPER-pfp.bin \
firmware-radeon/JUNIPER-rlc.bin \
firmware-radeon/JUNIPER-smc.bin \
firmware-radeon/KABINI-ce.bin \
firmware-radeon/KABINI-me.bin \
firmware-radeon/KABINI-mec.bin \
firmware-radeon/KABINI-pfp.bin \
firmware-radeon/KABINI-rlc.bin \
firmware-radeon/KABINI-sdma.bin \
firmware-radeon/KAVERI-ce.bin \
firmware-radeon/KAVERI-me.bin \
firmware-radeon/KAVERI-mec.bin \
firmware-radeon/KAVERI-pfp.bin \
firmware-radeon/KAVERI-rlc.bin \
firmware-radeon/KAVERI-sdma.bin \
firmware-radeon/MULLINS-ce.bin \
firmware-radeon/MULLINS-me.bin \
firmware-radeon/MULLINS-mec.bin \
firmware-radeon/MULLINS-pfp.bin \
firmware-radeon/MULLINS-rlc.bin \
firmware-radeon/MULLINS-sdma.bin \
firmware-radeon/OLAND-ce.bin \
firmware-radeon/OLAND-mc.bin \
firmware-radeon/OLAND-mc2.bin \
firmware-radeon/OLAND-me.bin \
firmware-radeon/OLAND-pfp.bin \
firmware-radeon/OLAND-rlc.bin \
firmware-radeon/OLAND-smc.bin \
firmware-radeon/PALM-me.bin \
firmware-radeon/PALM-pfp.bin \
firmware-radeon/PITCAIRN-ce.bin \
firmware-radeon/PITCAIRN-mc.bin \
firmware-radeon/PITCAIRN-mc2.bin \
firmware-radeon/PITCAIRN-me.bin \
firmware-radeon/PITCAIRN-pfp.bin \
firmware-radeon/PITCAIRN-rlc.bin \
firmware-radeon/PITCAIRN-smc.bin \
firmware-radeon/R100-cp.bin \
firmware-radeon/R200-cp.bin \
firmware-radeon/R300-cp.bin \
firmware-radeon/R420-cp.bin \
firmware-radeon/R520-cp.bin \
firmware-radeon/R600-me.bin \
firmware-radeon/R600-pfp.bin \
firmware-radeon/R600-rlc.bin \
firmware-radeon/R600-uvd.bin \
firmware-radeon/R700-rlc.bin \
firmware-radeon/REDWOOD-me.bin \
firmware-radeon/REDWOOD-pfp.bin \
firmware-radeon/REDWOOD-rlc.bin \
firmware-radeon/REDWOOD-smc.bin \
firmware-radeon/RS600-cp.bin \
firmware-radeon/RS690-cp.bin \
firmware-radeon/RS780-me.bin \
firmware-radeon/RS780-pfp.bin \
firmware-radeon/RS780-uvd.bin \
firmware-radeon/RV610-me.bin \
firmware-radeon/RV610-pfp.bin \
firmware-radeon/RV620-me.bin \
firmware-radeon/RV620-pfp.bin \
firmware-radeon/RV630-me.bin \
firmware-radeon/RV630-pfp.bin \
firmware-radeon/RV635-me.bin \
firmware-radeon/RV635-pfp.bin \
firmware-radeon/RV670-me.bin \
firmware-radeon/RV670-pfp.bin \
firmware-radeon/RV710-me.bin \
firmware-radeon/RV710-pfp.bin \
firmware-radeon/RV710-smc.bin \
firmware-radeon/RV710-uvd.bin \
firmware-radeon/RV730-me.bin \
firmware-radeon/RV730-pfp.bin \
firmware-radeon/RV730-smc.bin \
firmware-radeon/RV740-smc.bin \
firmware-radeon/RV770-me.bin \
firmware-radeon/RV770-pfp.bin \
firmware-radeon/RV770-smc.bin \
firmware-radeon/RV770-uvd.bin \
firmware-radeon/SUMO-me.bin \
firmware-radeon/SUMO-pfp.bin \
firmware-radeon/SUMO-rlc.bin \
firmware-radeon/SUMO-uvd.bin \
firmware-radeon/SUMO2-me.bin \
firmware-radeon/SUMO2-pfp.bin \
firmware-radeon/TAHITI-ce.bin \
firmware-radeon/TAHITI-mc.bin \
firmware-radeon/TAHITI-mc2.bin \
firmware-radeon/TAHITI-me.bin \
firmware-radeon/TAHITI-pfp.bin \
firmware-radeon/TAHITI-rlc.bin \
firmware-radeon/TAHITI-smc.bin \
firmware-radeon/TAHITI-uvd.bin \
firmware-radeon/TAHITI-vce.bin \
firmware-radeon/TURKS-mc.bin \
firmware-radeon/TURKS-me.bin \
firmware-radeon/TURKS-pfp.bin \
firmware-radeon/TURKS-smc.bin \
firmware-radeon/VERDE-ce.bin \
firmware-radeon/VERDE-mc.bin \
firmware-radeon/VERDE-mc2.bin \
firmware-radeon/VERDE-me.bin \
firmware-radeon/VERDE-pfp.bin \
firmware-radeon/VERDE-rlc.bin \
firmware-radeon/VERDE-smc.bin \
firmware-radeon/banks-k-2-smc.bin \
firmware-radeon/bonaire-ce.bin \
firmware-radeon/bonaire-k-smc.bin \
firmware-radeon/bonaire-mc.bin \
firmware-radeon/bonaire-me.bin \
firmware-radeon/bonaire-mec.bin \
firmware-radeon/bonaire-pfp.bin \
firmware-radeon/bonaire-rlc.bin \
firmware-radeon/bonaire-sdma.bin \
firmware-radeon/bonaire-sdma1.bin \
firmware-radeon/bonaire-smc.bin \
firmware-radeon/bonaire-uvd.bin \
firmware-radeon/bonaire-vce.bin \
firmware-radeon/hainan-ce.bin \
firmware-radeon/hainan-k-smc.bin \
firmware-radeon/hainan-mc.bin \
firmware-radeon/hainan-me.bin \
firmware-radeon/hainan-pfp.bin \
firmware-radeon/hainan-rlc.bin \
firmware-radeon/hainan-smc.bin \
firmware-radeon/hawaii-ce.bin \
firmware-radeon/hawaii-k-smc.bin \
firmware-radeon/hawaii-mc.bin \
firmware-radeon/hawaii-me.bin \
firmware-radeon/hawaii-mec.bin \
firmware-radeon/hawaii-pfp.bin \
firmware-radeon/hawaii-rlc.bin \
firmware-radeon/hawaii-sdma.bin \
firmware-radeon/hawaii-sdma1.bin \
firmware-radeon/hawaii-smc.bin \
firmware-radeon/hawaii-uvd.bin \
firmware-radeon/hawaii-vce.bin \
firmware-radeon/kabini-ce.bin \
firmware-radeon/kabini-me.bin \
firmware-radeon/kabini-mec.bin \
firmware-radeon/kabini-pfp.bin \
firmware-radeon/kabini-rlc.bin \
firmware-radeon/kabini-sdma.bin \
firmware-radeon/kabini-sdma1.bin \
firmware-radeon/kabini-uvd.bin \
firmware-radeon/kabini-vce.bin \
firmware-radeon/kaveri-ce.bin \
firmware-radeon/kaveri-me.bin \
firmware-radeon/kaveri-mec.bin \
firmware-radeon/kaveri-mec2.bin \
firmware-radeon/kaveri-pfp.bin \
firmware-radeon/kaveri-rlc.bin \
firmware-radeon/kaveri-sdma.bin \
firmware-radeon/kaveri-sdma1.bin \
firmware-radeon/kaveri-uvd.bin \
firmware-radeon/kaveri-vce.bin \
firmware-radeon/mullins-ce.bin \
firmware-radeon/mullins-me.bin \
firmware-radeon/mullins-mec.bin \
firmware-radeon/mullins-pfp.bin \
firmware-radeon/mullins-rlc.bin \
firmware-radeon/mullins-sdma.bin \
firmware-radeon/mullins-sdma1.bin \
firmware-radeon/mullins-uvd.bin \
firmware-radeon/mullins-vce.bin \
firmware-radeon/oland-ce.bin \
firmware-radeon/oland-k-smc.bin \
firmware-radeon/oland-mc.bin \
firmware-radeon/oland-me.bin \
firmware-radeon/oland-pfp.bin \
firmware-radeon/oland-rlc.bin \
firmware-radeon/oland-smc.bin \
firmware-radeon/pitcairn-ce.bin \
firmware-radeon/pitcairn-k-smc.bin \
firmware-radeon/pitcairn-mc.bin \
firmware-radeon/pitcairn-me.bin \
firmware-radeon/pitcairn-pfp.bin \
firmware-radeon/pitcairn-rlc.bin \
firmware-radeon/pitcairn-smc.bin \
firmware-radeon/si58-mc.bin \
firmware-radeon/tahiti-ce.bin \
firmware-radeon/tahiti-k-smc.bin \
firmware-radeon/tahiti-mc.bin \
firmware-radeon/tahiti-me.bin \
firmware-radeon/tahiti-pfp.bin \
firmware-radeon/tahiti-rlc.bin \
firmware-radeon/tahiti-smc.bin \
firmware-radeon/verde-ce.bin \
firmware-radeon/verde-k-smc.bin \
firmware-radeon/verde-mc.bin \
firmware-radeon/verde-me.bin \
firmware-radeon/verde-pfp.bin \
firmware-radeon/verde-rlc.bin \
firmware-radeon/verde-smc.bin \
firmware-rockchip/dptx.bin \
firmware-rp2.fw \
firmware-rsi-91x.fw \
firmware-rsi/rs9113-ap-bt-dual-mode.rps \
firmware-rsi/rs9113-wlan-bt-dual-mode.rps \
firmware-rsi/rs9113-wlan-qspi.rps \
firmware-rsi/rs9116-wlan-bt-classic.rps \
firmware-rsi/rs9116-wlan.rps \
firmware-rt2561.bin \
firmware-rt2561s.bin \
firmware-rt2661.bin \
firmware-rt2860.bin \
firmware-rt2870.bin \
firmware-rt3070.bin \
firmware-rt3071.bin \
firmware-rt3090.bin \
firmware-rt3290.bin \
firmware-rt73.bin \
firmware-rtl-bt/rtl8192ee-fw.bin \
firmware-rtl-bt/rtl8192eu-fw.bin \
firmware-rtl-bt/rtl8723a-fw.bin \
firmware-rtl-bt/rtl8723b-fw.bin \
firmware-rtl-bt/rtl8723bs-config-OBDA0623.bin \
firmware-rtl-bt/rtl8723bs-config-OBDA8723.bin \
firmware-rtl-bt/rtl8723bs-fw.bin \
firmware-rtl-bt/rtl8723d-config.bin \
firmware-rtl-bt/rtl8723d-fw.bin \
firmware-rtl-bt/rtl8761a-fw.bin \
firmware-rtl-bt/rtl8761b-config.bin \
firmware-rtl-bt/rtl8761b-fw.bin \
firmware-rtl-bt/rtl8761bu-config.bin \
firmware-rtl-bt/rtl8761bu-fw.bin \
firmware-rtl-bt/rtl8812ae-fw.bin \
firmware-rtl-bt/rtl8821a-config.bin \
firmware-rtl-bt/rtl8821a-fw.bin \
firmware-rtl-bt/rtl8821c-config.bin \
firmware-rtl-bt/rtl8821c-fw.bin \
firmware-rtl-bt/rtl8821cs-config.bin \
firmware-rtl-bt/rtl8821cs-fw.bin \
firmware-rtl-bt/rtl8822b-config.bin \
firmware-rtl-bt/rtl8822b-fw.bin \
firmware-rtl-bt/rtl8822cs-config.bin \
firmware-rtl-bt/rtl8822cs-fw.bin \
firmware-rtl-bt/rtl8822cu-config.bin \
firmware-rtl-bt/rtl8822cu-fw.bin \
firmware-rtl-bt/rtl8851bu-config.bin \
firmware-rtl-bt/rtl8851bu-fw.bin \
firmware-rtl-bt/rtl8852au-config.bin \
firmware-rtl-bt/rtl8852au-fw.bin \
firmware-rtl-bt/rtl8852bu-config.bin \
firmware-rtl-bt/rtl8852bu-fw.bin \
firmware-rtl-bt/rtl8852cu-config.bin \
firmware-rtl-bt/rtl8852cu-fw.bin \
firmware-rtl-nic/rtl8105e-1.fw \
firmware-rtl-nic/rtl8106e-1.fw \
firmware-rtl-nic/rtl8106e-2.fw \
firmware-rtl-nic/rtl8107e-1.fw \
firmware-rtl-nic/rtl8107e-2.fw \
firmware-rtl-nic/rtl8125a-3.fw \
firmware-rtl-nic/rtl8125b-1.fw \
firmware-rtl-nic/rtl8125b-2.fw \
firmware-rtl-nic/rtl8153a-2.fw \
firmware-rtl-nic/rtl8153a-3.fw \
firmware-rtl-nic/rtl8153a-4.fw \
firmware-rtl-nic/rtl8153b-2.fw \
firmware-rtl-nic/rtl8153c-1.fw \
firmware-rtl-nic/rtl8156a-2.fw \
firmware-rtl-nic/rtl8156b-2.fw \
firmware-rtl-nic/rtl8168d-1.fw \
firmware-rtl-nic/rtl8168d-2.fw \
firmware-rtl-nic/rtl8168e-1.fw \
firmware-rtl-nic/rtl8168e-2.fw \
firmware-rtl-nic/rtl8168e-3.fw \
firmware-rtl-nic/rtl8168f-1.fw \
firmware-rtl-nic/rtl8168f-2.fw \
firmware-rtl-nic/rtl8168fp-3.fw \
firmware-rtl-nic/rtl8168g-1.fw \
firmware-rtl-nic/rtl8168g-2.fw \
firmware-rtl-nic/rtl8168g-3.fw \
firmware-rtl-nic/rtl8168h-1.fw \
firmware-rtl-nic/rtl8168h-2.fw \
firmware-rtl-nic/rtl8402-1.fw \
firmware-rtl-nic/rtl8411-1.fw \
firmware-rtl-nic/rtl8411-2.fw \
firmware-rtlwifi/rtl8188efw.bin \
firmware-rtlwifi/rtl8188eufw.bin \
firmware-rtlwifi/rtl8188fufw.bin \
firmware-rtlwifi/rtl8192cfw.bin \
firmware-rtlwifi/rtl8192cfwU-B.bin \
firmware-rtlwifi/rtl8192cfwU.bin \
firmware-rtlwifi/rtl8192cufw-A.bin \
firmware-rtlwifi/rtl8192cufw-B.bin \
firmware-rtlwifi/rtl8192cufw-TMSC.bin \
firmware-rtlwifi/rtl8192cufw.bin \
firmware-rtlwifi/rtl8192defw.bin \
firmware-rtlwifi/rtl8192eefw.bin \
firmware-rtlwifi/rtl8192eu-ap-wowlan.bin \
firmware-rtlwifi/rtl8192eu-nic.bin \
firmware-rtlwifi/rtl8192eu-wowlan.bin \
firmware-rtlwifi/rtl8192fufw.bin \
firmware-rtlwifi/rtl8192sefw.bin \
firmware-rtlwifi/rtl8710bufw-SMIC.bin \
firmware-rtlwifi/rtl8710bufw-UMC.bin \
firmware-rtlwifi/rtl8712u.bin \
firmware-rtlwifi/rtl8723aufw-A.bin \
firmware-rtlwifi/rtl8723aufw-B-NoBT.bin \
firmware-rtlwifi/rtl8723aufw-B.bin \
firmware-rtlwifi/rtl8723befw-36.bin \
firmware-rtlwifi/rtl8723befw.bin \
firmware-rtlwifi/rtl8723bs-ap-wowlan.bin \
firmware-rtlwifi/rtl8723bs-bt.bin \
firmware-rtlwifi/rtl8723bs-nic.bin \
firmware-rtlwifi/rtl8723bs-wowlan.bin \
firmware-rtlwifi/rtl8723bu-ap-wowlan.bin \
firmware-rtlwifi/rtl8723bu-nic.bin \
firmware-rtlwifi/rtl8723bu-wowlan.bin \
firmware-rtlwifi/rtl8723defw.bin \
firmware-rtlwifi/rtl8723fw-B.bin \
firmware-rtlwifi/rtl8723fw.bin \
firmware-rtlwifi/rtl8812aefw-wowlan.bin \
firmware-rtlwifi/rtl8812aefw.bin \
firmware-rtlwifi/rtl8821aefw-29.bin \
firmware-rtlwifi/rtl8821aefw-wowlan.bin \
firmware-rtlwifi/rtl8821aefw.bin \
firmware-rtlwifi/rtl8822befw.bin \
firmware-rtw88/README \
firmware-rtw88/rtw8723d-fw.bin \
firmware-rtw88/rtw8821c-fw.bin \
firmware-rtw88/rtw8822b-fw.bin \
firmware-rtw88/rtw8822c-fw.bin \
firmware-rtw88/rtw8822c-wow-fw.bin \
firmware-rtw89/rtw8851b-fw.bin \
firmware-rtw89/rtw8852a-fw.bin \
firmware-rtw89/rtw8852b-fw-1.bin \
firmware-rtw89/rtw8852b-fw.bin \
firmware-rtw89/rtw8852c-fw.bin \
firmware-s2250-loader.fw \
firmware-s2250.fw \
firmware-s5p-mfc-v6-v2.fw \
firmware-s5p-mfc-v6.fw \
firmware-s5p-mfc-v7.fw \
firmware-s5p-mfc-v8.fw \
firmware-s5p-mfc.fw \
firmware-sb16/alaw-main.csp \
firmware-sb16/ima-adpcm-capture.csp \
firmware-sb16/ima-adpcm-init.csp \
firmware-sb16/ima-adpcm-playback.csp \
firmware-sb16/mulaw-main.csp \
firmware-sdd-sagrad-1091-1098.bin \
firmware-slicoss/gbdownload.sys \
firmware-slicoss/gbrcvucode.sys \
firmware-slicoss/oasisdbgdownload.sys \
firmware-slicoss/oasisdownload.sys \
firmware-slicoss/oasisrcvucode.sys \
firmware-sms1xxx-hcw-55xxx-dvbt-02.fw \
firmware-sms1xxx-hcw-55xxx-isdbt-02.fw \
firmware-sms1xxx-nova-a-dvbt-01.fw \
firmware-sms1xxx-nova-b-dvbt-01.fw \
firmware-sms1xxx-stellar-dvbt-01.fw \
firmware-sun/cassini.bin \
firmware-sxg/saharadbgdownloadB.sys \
firmware-sxg/saharadownloadB.sys \
firmware-tdmb-nova-12mhz.inp \
firmware-tehuti/bdx.bin \
firmware-ti-3410.fw \
firmware-ti-5052.fw \
firmware-ti-connectivity/TIInit-6.2.31.bts \
firmware-ti-connectivity/TIInit-6.6.15.bts \
firmware-ti-connectivity/TIInit-7.2.31.bts \
firmware-ti-connectivity/wl1251-fw.bin \
firmware-ti-connectivity/wl1251-nvs.bin \
firmware-ti-connectivity/wl1271-fw-2.bin \
firmware-ti-connectivity/wl1271-fw-ap.bin \
firmware-ti-connectivity/wl1271-fw.bin \
firmware-ti-connectivity/wl1271-nvs.bin \
firmware-ti-connectivity/wl127x-fw-3.bin \
firmware-ti-connectivity/wl127x-fw-4-mr.bin \
firmware-ti-connectivity/wl127x-fw-4-plt.bin \
firmware-ti-connectivity/wl127x-fw-4-sr.bin \
firmware-ti-connectivity/wl127x-fw-5-mr.bin \
firmware-ti-connectivity/wl127x-fw-5-plt.bin \
firmware-ti-connectivity/wl127x-fw-5-sr.bin \
firmware-ti-connectivity/wl127x-fw-plt-3.bin \
firmware-ti-connectivity/wl127x-nvs.bin \
firmware-ti-connectivity/wl128x-fw-3.bin \
firmware-ti-connectivity/wl128x-fw-4-mr.bin \
firmware-ti-connectivity/wl128x-fw-4-plt.bin \
firmware-ti-connectivity/wl128x-fw-4-sr.bin \
firmware-ti-connectivity/wl128x-fw-5-mr.bin \
firmware-ti-connectivity/wl128x-fw-5-plt.bin \
firmware-ti-connectivity/wl128x-fw-5-sr.bin \
firmware-ti-connectivity/wl128x-fw-ap.bin \
firmware-ti-connectivity/wl128x-fw-plt-3.bin \
firmware-ti-connectivity/wl128x-fw.bin \
firmware-ti-connectivity/wl128x-nvs.bin \
firmware-ti-connectivity/wl12xx-nvs.bin \
firmware-ti-connectivity/wl18xx-fw-2.bin \
firmware-ti-connectivity/wl18xx-fw-3.bin \
firmware-ti-connectivity/wl18xx-fw-4.bin \
firmware-ti-connectivity/wl18xx-fw.bin \
firmware-ti-keystone/ks2-qmss-pdsp-acc48-k2-le-1-0-0-9.bin \
firmware-ti/vpdma-1b8.bin \
firmware-tigon/tg3-tso.bin \
firmware-tigon/tg3-tso5.bin \
firmware-tigon/tg3.bin \
firmware-tigon/tg357766.bin \
firmware-tlg2300-firmware.bin \
firmware-ttusb-budget/dspbootcode.bin \
firmware-ueagle-atm/930-fpga.bin \
firmware-ueagle-atm/CMV4p.bin.v2 \
firmware-ueagle-atm/CMV9i.bin \
firmware-ueagle-atm/CMV9p.bin \
firmware-ueagle-atm/CMVei.bin \
firmware-ueagle-atm/CMVeiWO.bin \
firmware-ueagle-atm/CMVep.bin \
firmware-ueagle-atm/CMVepES.bin \
firmware-ueagle-atm/CMVepES03.bin \
firmware-ueagle-atm/CMVepFR.bin \
firmware-ueagle-atm/CMVepFR04.bin \
firmware-ueagle-atm/CMVepFR10.bin \
firmware-ueagle-atm/CMVepIT.bin \
firmware-ueagle-atm/CMVepWO.bin \
firmware-ueagle-atm/DSP4p.bin \
firmware-ueagle-atm/DSP9i.bin \
firmware-ueagle-atm/DSP9p.bin \
firmware-ueagle-atm/DSPei.bin \
firmware-ueagle-atm/DSPep.bin \
firmware-ueagle-atm/adi930.fw \
firmware-ueagle-atm/eagleI.fw \
firmware-ueagle-atm/eagleII.fw \
firmware-ueagle-atm/eagleIII.fw \
firmware-ueagle-atm/eagleIV.fw \
firmware-usbdux-firmware.bin \
firmware-usbduxfast-firmware.bin \
firmware-usbduxsigma-firmware.bin \
firmware-v4l-cx231xx-avcore-01.fw \
firmware-v4l-cx23418-apu.fw \
firmware-v4l-cx23418-cpu.fw \
firmware-v4l-cx23418-dig.fw \
firmware-v4l-cx23885-avcore-01.fw \
firmware-v4l-cx25840.fw \
firmware-vicam/firmware.fw \
firmware-vntwusb.fw \
firmware-vpu-d.bin \
firmware-vpu-p.bin \
firmware-vxge/X3fw-pxe.ncf \
firmware-vxge/X3fw.ncf \
firmware-wfx/brd4001a.pds \
firmware-wfx/brd8022a.pds \
firmware-wfx/brd8023a.pds \
firmware-wfx/wfm-wf200-C0.sec \
firmware-whiteheat-loader.fw \
firmware-whiteheat.fw \
firmware-wil6210.brd \
firmware-wil6210.fw \
firmware-wsm-22.bin \
firmware-yam/1200.bin \
firmware-yam/9600.bin \
firmware-yamaha/ds1-ctrl.fw \
firmware-yamaha/ds1-dsp.fw \
firmware-yamaha/ds1e-ctrl.fw \
firmware-yamaha/yss225-registers.bin \
iwl100-ucode \
iwl1000-ucode \
iwl3945-ucode \
iwl4965-ucode \
iwl5000-ucode \
iwl5150-ucode \
iwl6000-ucode \
iwl6000g2-ucode \
iwl6050-ucode \
kernel-firmware \
model-zero-2-w.txt) \
model-zero-w.txt) \
nanopi-r1.txt) \
pinebook-pro.txt) \
pinenote-v1.1.txt) \
pinenote-v1.2.txt) \
pinephone-pro.txt) \
qlogic-firmware \
quartz64-a.txt) \
quartz64-b.txt) \
ralink-firmware \
rock960.txt) \
rockpro64-v2.0.txt) \
rockpro64-v2.1.txt) \
soquartz-blade.txt) \
soquartz-cm4io.txt) \
soquartz-model-a.txt) \
tolino-shine2hd.txt) \
vim2.txt) \
visionfive-v1.txt)"

RDEPENDS:${PN} += "/usr/bin/mkdir \
/usr/bin/sh \
/usr/bin/touch"

inherit rpm
