SUMMARY = "Translations for package libKF5Bookmarks5"
DESCRIPTION = "Provides translations for the 'libKF5Bookmarks5' package."
LICENSE = "LGPL-2.1-or-later"

PV = "5.108.0"

RPM_NAME = "libKF5Bookmarks5-lang-5.108.0-1.1.noarch.rpm"
RPM_HASH = "b7ee6bc6263765868ca492e2a3a4d27ed30e74ae006736776029efc7f668627516a580c115cfa91349dc0129ab4d645570e1fb21b6f60149cb81fffd43bb4d0b"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKF5Bookmarks5-lang \
libKF5Bookmarks5-lang-all \
locale-libKF5Bookmarks5-af \
locale-libKF5Bookmarks5-ar \
locale-libKF5Bookmarks5-az \
locale-libKF5Bookmarks5-be \
locale-libKF5Bookmarks5-be@latin \
locale-libKF5Bookmarks5-bg \
locale-libKF5Bookmarks5-bn \
locale-libKF5Bookmarks5-br \
locale-libKF5Bookmarks5-bs \
locale-libKF5Bookmarks5-ca \
locale-libKF5Bookmarks5-ca@valencia \
locale-libKF5Bookmarks5-cs \
locale-libKF5Bookmarks5-cy \
locale-libKF5Bookmarks5-da \
locale-libKF5Bookmarks5-de \
locale-libKF5Bookmarks5-el \
locale-libKF5Bookmarks5-en-GB \
locale-libKF5Bookmarks5-eo \
locale-libKF5Bookmarks5-es \
locale-libKF5Bookmarks5-et \
locale-libKF5Bookmarks5-eu \
locale-libKF5Bookmarks5-fa \
locale-libKF5Bookmarks5-fi \
locale-libKF5Bookmarks5-fr \
locale-libKF5Bookmarks5-ga \
locale-libKF5Bookmarks5-gd \
locale-libKF5Bookmarks5-gl \
locale-libKF5Bookmarks5-gu \
locale-libKF5Bookmarks5-he \
locale-libKF5Bookmarks5-hi \
locale-libKF5Bookmarks5-hr \
locale-libKF5Bookmarks5-hu \
locale-libKF5Bookmarks5-ia \
locale-libKF5Bookmarks5-id \
locale-libKF5Bookmarks5-is \
locale-libKF5Bookmarks5-it \
locale-libKF5Bookmarks5-ja \
locale-libKF5Bookmarks5-ka \
locale-libKF5Bookmarks5-kk \
locale-libKF5Bookmarks5-km \
locale-libKF5Bookmarks5-ko \
locale-libKF5Bookmarks5-lt \
locale-libKF5Bookmarks5-lv \
locale-libKF5Bookmarks5-mai \
locale-libKF5Bookmarks5-mk \
locale-libKF5Bookmarks5-ml \
locale-libKF5Bookmarks5-mr \
locale-libKF5Bookmarks5-ms \
locale-libKF5Bookmarks5-nb \
locale-libKF5Bookmarks5-nds \
locale-libKF5Bookmarks5-ne \
locale-libKF5Bookmarks5-nl \
locale-libKF5Bookmarks5-nn \
locale-libKF5Bookmarks5-oc \
locale-libKF5Bookmarks5-pa \
locale-libKF5Bookmarks5-pl \
locale-libKF5Bookmarks5-pt \
locale-libKF5Bookmarks5-pt-BR \
locale-libKF5Bookmarks5-ro \
locale-libKF5Bookmarks5-ru \
locale-libKF5Bookmarks5-sk \
locale-libKF5Bookmarks5-sl \
locale-libKF5Bookmarks5-sq \
locale-libKF5Bookmarks5-sr \
locale-libKF5Bookmarks5-sr@ijekavian \
locale-libKF5Bookmarks5-sr@ijekavianlatin \
locale-libKF5Bookmarks5-sr@latin \
locale-libKF5Bookmarks5-sv \
locale-libKF5Bookmarks5-ta \
locale-libKF5Bookmarks5-th \
locale-libKF5Bookmarks5-tr \
locale-libKF5Bookmarks5-ug \
locale-libKF5Bookmarks5-uk \
locale-libKF5Bookmarks5-vi \
locale-libKF5Bookmarks5-wa \
locale-libKF5Bookmarks5-zh-CN \
locale-libKF5Bookmarks5-zh-TW"

RDEPENDS:${PN} += "libKF5Bookmarks5"

inherit rpm
