SUMMARY = "Microsoft Azure CLI 2.0"
DESCRIPTION = "Microsoft Azure CLI 2.0 Command Line Utilities"
LICENSE = "MIT"

PV = "2.51.0"

RPM_NAME = "azure-cli-2.51.0-1.1.noarch.rpm"
RPM_HASH = "eff9f9ea64919b4bfceadfc0ba42cc8e8a062ff4517883648a183a7f1dbb9121a25d06383373bc1cc30861208f41b7ad42bae24212d68c1accb253093b4cea32"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "azure-cli \
azure-cli-acr \
azure-cli-acs \
azure-cli-advisor \
azure-cli-ams \
azure-cli-appservice \
azure-cli-backup \
azure-cli-batch \
azure-cli-batchai \
azure-cli-billing \
azure-cli-botservice \
azure-cli-cdn \
azure-cli-cloud \
azure-cli-cognitiveservices \
azure-cli-component \
azure-cli-configure \
azure-cli-consumption \
azure-cli-container \
azure-cli-cosmosdb \
azure-cli-deploymentmanager \
azure-cli-dla \
azure-cli-dls \
azure-cli-dms \
azure-cli-eventgrid \
azure-cli-eventhubs \
azure-cli-extension \
azure-cli-feedback \
azure-cli-find \
azure-cli-hdinsight \
azure-cli-interactive \
azure-cli-iot \
azure-cli-iotcentral \
azure-cli-keyvault \
azure-cli-kusto \
azure-cli-lab \
azure-cli-maps \
azure-cli-monitor \
azure-cli-natgateway \
azure-cli-network \
azure-cli-policyinsights \
azure-cli-privatedns \
azure-cli-profile \
azure-cli-rdbms \
azure-cli-redis \
azure-cli-relay \
azure-cli-reservations \
azure-cli-resource \
azure-cli-role \
azure-cli-search \
azure-cli-security \
azure-cli-servicebus \
azure-cli-servicefabric \
azure-cli-signalr \
azure-cli-sql \
azure-cli-sqlvm \
azure-cli-storage \
azure-cli-vm \
python3.11dist-azure-cli \
python3dist-azure-cli"

RDEPENDS:${PN} += "/usr/bin/python3 \
azure-cli-command-modules-nspkg \
azure-cli-core \
azure-cli-nspkg \
python-abi \
python3-Fabric \
python3-PyGithub \
python3-PyNaCl \
python3-PyYAML \
python3-antlr4-python3-runtime \
python3-azure-appconfiguration \
python3-azure-batch \
python3-azure-cosmos \
python3-azure-data-tables \
python3-azure-datalake-store \
python3-azure-graphrbac \
python3-azure-keyvault \
python3-azure-keyvault-administration \
python3-azure-keyvault-certificates \
python3-azure-keyvault-keys \
python3-azure-keyvault-secrets \
python3-azure-loganalytics \
python3-azure-mgmt-advisor \
python3-azure-mgmt-apimanagement \
python3-azure-mgmt-appconfiguration \
python3-azure-mgmt-appcontainers \
python3-azure-mgmt-applicationinsights \
python3-azure-mgmt-authorization \
python3-azure-mgmt-batch \
python3-azure-mgmt-batchai \
python3-azure-mgmt-billing \
python3-azure-mgmt-botservice \
python3-azure-mgmt-cdn \
python3-azure-mgmt-cognitiveservices \
python3-azure-mgmt-compute \
python3-azure-mgmt-consumption \
python3-azure-mgmt-containerinstance \
python3-azure-mgmt-containerregistry \
python3-azure-mgmt-containerservice \
python3-azure-mgmt-cosmosdb \
python3-azure-mgmt-databoxedge \
python3-azure-mgmt-datalake-analytics \
python3-azure-mgmt-datalake-store \
python3-azure-mgmt-datamigration \
python3-azure-mgmt-devtestlabs \
python3-azure-mgmt-dns \
python3-azure-mgmt-eventgrid \
python3-azure-mgmt-eventhub \
python3-azure-mgmt-extendedlocation \
python3-azure-mgmt-hdinsight \
python3-azure-mgmt-imagebuilder \
python3-azure-mgmt-iotcentral \
python3-azure-mgmt-iothub \
python3-azure-mgmt-iothubprovisioningservices \
python3-azure-mgmt-keyvault \
python3-azure-mgmt-kusto \
python3-azure-mgmt-loganalytics \
python3-azure-mgmt-managedservices \
python3-azure-mgmt-managementgroups \
python3-azure-mgmt-maps \
python3-azure-mgmt-marketplaceordering \
python3-azure-mgmt-media \
python3-azure-mgmt-monitor \
python3-azure-mgmt-msi \
python3-azure-mgmt-netapp \
python3-azure-mgmt-policyinsights \
python3-azure-mgmt-privatedns \
python3-azure-mgmt-rdbms \
python3-azure-mgmt-recoveryservices \
python3-azure-mgmt-recoveryservicesbackup \
python3-azure-mgmt-redhatopenshift \
python3-azure-mgmt-redis \
python3-azure-mgmt-relay \
python3-azure-mgmt-reservations \
python3-azure-mgmt-resource \
python3-azure-mgmt-search \
python3-azure-mgmt-security \
python3-azure-mgmt-servicebus \
python3-azure-mgmt-servicefabric \
python3-azure-mgmt-servicefabricmanagedclusters \
python3-azure-mgmt-servicelinker \
python3-azure-mgmt-signalr \
python3-azure-mgmt-sql \
python3-azure-mgmt-sqlvirtualmachine \
python3-azure-mgmt-storage \
python3-azure-mgmt-synapse \
python3-azure-mgmt-trafficmanager \
python3-azure-mgmt-web \
python3-azure-multiapi-storage \
python3-azure-storage-common \
python3-azure-synapse-accesscontrol \
python3-azure-synapse-artifacts \
python3-azure-synapse-managedprivateendpoints \
python3-azure-synapse-spark \
python3-chardet \
python3-colorama \
python3-distro \
python3-javaproperties \
python3-jsondiff \
python3-packaging \
python3-pydocumentdb \
python3-pygments \
python3-scp \
python3-semver \
python3-six \
python3-sshtunnel \
python3-urllib3 \
python3-websocket-client \
python3-xmltodict"

inherit rpm
