SUMMARY = "Development files for ocaml-luv"
DESCRIPTION = "The ocaml-luv-devel package contains libraries and signature files for \
developing applications that use ocaml-luv."
LICENSE = "MIT"

PV = "0.5.12"

RPM_NAME = "ocaml-luv-devel-0.5.12-1.3.aarch64.rpm"
RPM_HASH = "d1eec001a54aa11fda8379807179c872dc6218f15c77f7e8601fb1af1c61f31e60f8086d4f3f7a5ab8e20c99cba7bf637740461a0c90a1893d7234b6f9d75579"

RPROVIDES:${PN} += "ocaml-Luv \
ocaml-Luv-- \
ocaml-Luv--Async \
ocaml-Luv--Barrier \
ocaml-Luv--Buffer \
ocaml-Luv--C \
ocaml-Luv--Check \
ocaml-Luv--Compatibility \
ocaml-Luv--Condition \
ocaml-Luv--DLL \
ocaml-Luv--DNS \
ocaml-Luv--Env \
ocaml-Luv--Error \
ocaml-Luv--FS-event \
ocaml-Luv--FS-poll \
ocaml-Luv--File \
ocaml-Luv--Handle \
ocaml-Luv--Helpers \
ocaml-Luv--Idle \
ocaml-Luv--Loop \
ocaml-Luv--Loop-watcher \
ocaml-Luv--Metrics \
ocaml-Luv--Mutex \
ocaml-Luv--Network \
ocaml-Luv--Once \
ocaml-Luv--Os-fd \
ocaml-Luv--Passwd \
ocaml-Luv--Path \
ocaml-Luv--Pid \
ocaml-Luv--Pipe \
ocaml-Luv--Poll \
ocaml-Luv--Prepare \
ocaml-Luv--Process \
ocaml-Luv--Random \
ocaml-Luv--Request \
ocaml-Luv--Require \
ocaml-Luv--Resource \
ocaml-Luv--Rwlock \
ocaml-Luv--Semaphore \
ocaml-Luv--Signal \
ocaml-Luv--Sockaddr \
ocaml-Luv--Stream \
ocaml-Luv--System-info \
ocaml-Luv--TCP \
ocaml-Luv--TLS \
ocaml-Luv--TTY \
ocaml-Luv--Thread \
ocaml-Luv--Thread-pool \
ocaml-Luv--Time \
ocaml-Luv--Timer \
ocaml-Luv--UDP \
ocaml-Luv--Version \
ocaml-Luv-c-function-descriptions \
ocaml-Luv-c-generated-functions \
ocaml-Luv-c-generated-types \
ocaml-Luv-c-type-descriptions \
ocaml-Luv-c-types \
ocaml-Luv-unix \
ocaml-luv-devel \
ocamlfind-luv \
ocamlfind-luv-unix \
ocamlfind-luv.c \
ocamlfind-luv.c-function-descriptions \
ocamlfind-luv.c-type-descriptions \
ocamlx-Luv \
ocamlx-Luv-- \
ocamlx-Luv--Async \
ocamlx-Luv--Barrier \
ocamlx-Luv--Buffer \
ocamlx-Luv--C \
ocamlx-Luv--Check \
ocamlx-Luv--Compatibility \
ocamlx-Luv--Condition \
ocamlx-Luv--DLL \
ocamlx-Luv--DNS \
ocamlx-Luv--Env \
ocamlx-Luv--Error \
ocamlx-Luv--FS-event \
ocamlx-Luv--FS-poll \
ocamlx-Luv--File \
ocamlx-Luv--Handle \
ocamlx-Luv--Helpers \
ocamlx-Luv--Idle \
ocamlx-Luv--Loop \
ocamlx-Luv--Loop-watcher \
ocamlx-Luv--Metrics \
ocamlx-Luv--Mutex \
ocamlx-Luv--Network \
ocamlx-Luv--Once \
ocamlx-Luv--Os-fd \
ocamlx-Luv--Passwd \
ocamlx-Luv--Path \
ocamlx-Luv--Pid \
ocamlx-Luv--Pipe \
ocamlx-Luv--Poll \
ocamlx-Luv--Prepare \
ocamlx-Luv--Process \
ocamlx-Luv--Random \
ocamlx-Luv--Request \
ocamlx-Luv--Require \
ocamlx-Luv--Resource \
ocamlx-Luv--Rwlock \
ocamlx-Luv--Semaphore \
ocamlx-Luv--Signal \
ocamlx-Luv--Sockaddr \
ocamlx-Luv--Stream \
ocamlx-Luv--System-info \
ocamlx-Luv--TCP \
ocamlx-Luv--TLS \
ocamlx-Luv--TTY \
ocamlx-Luv--Thread \
ocamlx-Luv--Thread-pool \
ocamlx-Luv--Time \
ocamlx-Luv--Timer \
ocamlx-Luv--UDP \
ocamlx-Luv--Version \
ocamlx-Luv-c-function-descriptions \
ocamlx-Luv-c-generated-functions \
ocamlx-Luv-c-generated-types \
ocamlx-Luv-c-type-descriptions \
ocamlx-Luv-c-types \
ocamlx-Luv-unix"

RDEPENDS:${PN} += "libc.so.6 \
libuv.so.1 \
ocaml-Bigarray-compat \
ocaml-CamlinternalFormatBasics \
ocaml-ComplexL \
ocaml-Cstubs-internals \
ocaml-Ctypes \
ocaml-Ctypes-bigarray \
ocaml-Ctypes-memory-stubs \
ocaml-Ctypes-primitive-types \
ocaml-Ctypes-ptr \
ocaml-Ctypes-static \
ocaml-Ctypes-types \
ocaml-LDouble \
ocaml-PosixTypes \
ocaml-Signed \
ocaml-Stdlib \
ocaml-Stdlib--Array \
ocaml-Stdlib--Bigarray \
ocaml-Stdlib--Buffer \
ocaml-Stdlib--Bytes \
ocaml-Stdlib--Complex \
ocaml-Stdlib--Either \
ocaml-Stdlib--Format \
ocaml-Stdlib--Int32 \
ocaml-Stdlib--List \
ocaml-Stdlib--Nativeint \
ocaml-Stdlib--Obj \
ocaml-Stdlib--Printexc \
ocaml-Stdlib--Printf \
ocaml-Stdlib--Seq \
ocaml-Stdlib--String \
ocaml-Stdlib--Sys \
ocaml-Stdlib--Uchar \
ocaml-Unix \
ocaml-Unsigned \
ocaml-luv \
ocamlfind-ctypes \
ocamlfind-threads \
ocamlfind-unix \
ocamlx-Cstubs-internals \
ocamlx-Ctypes \
ocamlx-Ctypes-static \
ocamlx-PosixTypes \
ocamlx-Stdlib \
ocamlx-Stdlib--Array \
ocamlx-Stdlib--Bigarray \
ocamlx-Stdlib--Bytes \
ocamlx-Stdlib--List \
ocamlx-Stdlib--Nativeint \
ocamlx-Stdlib--Printexc \
ocamlx-Stdlib--Printf \
ocamlx-Stdlib--String \
ocamlx-Stdlib--Sys \
ocamlx-Unsigned \
pkgconfig-libuv"

inherit rpm
