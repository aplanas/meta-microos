SUMMARY = "A serif font family"
DESCRIPTION = "Clara is a type family created specially by Seamas O Brogain \
for printing A Dictionary of Editing (2015). The family \
includes italic, bold, bold italic, and small capitals, while \
the character set includes (monotonic) Greek, Cyrillic, ogham, \
phonetic and mathematical ranges, scribal abbreviations and \
other specialist characters. The fonts also include some \
OpenType features (such as ligature substitution, small \
capitals, and old-style numerals) and variant forms for \
particular languages."
LICENSE = "OFL-1.1"

PV = "2023.201.svn54512"

RPM_NAME = "texlive-clara-2023.201.svn54512-53.1.noarch.rpm"
RPM_HASH = "685c8ac82d6849ed6e29d4e53302c661498cc681b8d660315d48563d4c2315de1154cacae7ab2be937befa0aae1896e36e8b3786bdfaedb68c0272e8897ebd05"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-Clara.map \
tex-ClaraBold-sup-lgr--base.tfm \
tex-ClaraBold-sup-lgr.tfm \
tex-ClaraBold-sup-lgr.vf \
tex-ClaraBold-sup-ly1--base.tfm \
tex-ClaraBold-sup-ly1.tfm \
tex-ClaraBold-sup-ly1.vf \
tex-ClaraBold-sup-ot1.tfm \
tex-ClaraBold-sup-t1--base.tfm \
tex-ClaraBold-sup-t1.tfm \
tex-ClaraBold-sup-t1.vf \
tex-ClaraBold-sup-t2a.tfm \
tex-ClaraBold-sup-t2b.tfm \
tex-ClaraBold-sup-t2c.tfm \
tex-ClaraBold-tlf-lgr--base.tfm \
tex-ClaraBold-tlf-lgr.tfm \
tex-ClaraBold-tlf-lgr.vf \
tex-ClaraBold-tlf-ly1--base.tfm \
tex-ClaraBold-tlf-ly1.tfm \
tex-ClaraBold-tlf-ly1.vf \
tex-ClaraBold-tlf-ot1.tfm \
tex-ClaraBold-tlf-t1--base.tfm \
tex-ClaraBold-tlf-t1.tfm \
tex-ClaraBold-tlf-t1.vf \
tex-ClaraBold-tlf-t2a.tfm \
tex-ClaraBold-tlf-t2b.tfm \
tex-ClaraBold-tlf-t2c.tfm \
tex-ClaraBold-tlf-ts1--base.tfm \
tex-ClaraBold-tlf-ts1.tfm \
tex-ClaraBold-tlf-ts1.vf \
tex-ClaraBoldItalic-sup-lgr--base.tfm \
tex-ClaraBoldItalic-sup-lgr.tfm \
tex-ClaraBoldItalic-sup-lgr.vf \
tex-ClaraBoldItalic-sup-ly1--base.tfm \
tex-ClaraBoldItalic-sup-ly1.tfm \
tex-ClaraBoldItalic-sup-ly1.vf \
tex-ClaraBoldItalic-sup-ot1.tfm \
tex-ClaraBoldItalic-sup-t1--base.tfm \
tex-ClaraBoldItalic-sup-t1.tfm \
tex-ClaraBoldItalic-sup-t1.vf \
tex-ClaraBoldItalic-sup-t2a.tfm \
tex-ClaraBoldItalic-sup-t2b.tfm \
tex-ClaraBoldItalic-sup-t2c.tfm \
tex-ClaraBoldItalic-tlf-lgr--base.tfm \
tex-ClaraBoldItalic-tlf-lgr.tfm \
tex-ClaraBoldItalic-tlf-lgr.vf \
tex-ClaraBoldItalic-tlf-ly1--base.tfm \
tex-ClaraBoldItalic-tlf-ly1.tfm \
tex-ClaraBoldItalic-tlf-ly1.vf \
tex-ClaraBoldItalic-tlf-ot1.tfm \
tex-ClaraBoldItalic-tlf-t1--base.tfm \
tex-ClaraBoldItalic-tlf-t1.tfm \
tex-ClaraBoldItalic-tlf-t1.vf \
tex-ClaraBoldItalic-tlf-t2a.tfm \
tex-ClaraBoldItalic-tlf-t2b.tfm \
tex-ClaraBoldItalic-tlf-t2c.tfm \
tex-ClaraBoldItalic-tlf-ts1--base.tfm \
tex-ClaraBoldItalic-tlf-ts1.tfm \
tex-ClaraBoldItalic-tlf-ts1.vf \
tex-ClaraItalic-sup-lgr--base.tfm \
tex-ClaraItalic-sup-lgr.tfm \
tex-ClaraItalic-sup-lgr.vf \
tex-ClaraItalic-sup-ly1--base.tfm \
tex-ClaraItalic-sup-ly1.tfm \
tex-ClaraItalic-sup-ly1.vf \
tex-ClaraItalic-sup-ot1.tfm \
tex-ClaraItalic-sup-t1--base.tfm \
tex-ClaraItalic-sup-t1.tfm \
tex-ClaraItalic-sup-t1.vf \
tex-ClaraItalic-sup-t2a.tfm \
tex-ClaraItalic-sup-t2b.tfm \
tex-ClaraItalic-sup-t2c.tfm \
tex-ClaraItalic-tlf-lgr--base.tfm \
tex-ClaraItalic-tlf-lgr.tfm \
tex-ClaraItalic-tlf-lgr.vf \
tex-ClaraItalic-tlf-ly1--base.tfm \
tex-ClaraItalic-tlf-ly1.tfm \
tex-ClaraItalic-tlf-ly1.vf \
tex-ClaraItalic-tlf-ot1.tfm \
tex-ClaraItalic-tlf-t1--base.tfm \
tex-ClaraItalic-tlf-t1.tfm \
tex-ClaraItalic-tlf-t1.vf \
tex-ClaraItalic-tlf-t2a.tfm \
tex-ClaraItalic-tlf-t2b.tfm \
tex-ClaraItalic-tlf-t2c.tfm \
tex-ClaraItalic-tlf-ts1--base.tfm \
tex-ClaraItalic-tlf-ts1.tfm \
tex-ClaraItalic-tlf-ts1.vf \
tex-ClaraItalic-tosf-lgr--base.tfm \
tex-ClaraItalic-tosf-lgr.tfm \
tex-ClaraItalic-tosf-lgr.vf \
tex-ClaraItalic-tosf-ly1--base.tfm \
tex-ClaraItalic-tosf-ly1.tfm \
tex-ClaraItalic-tosf-ly1.vf \
tex-ClaraItalic-tosf-ot1.tfm \
tex-ClaraItalic-tosf-t1--base.tfm \
tex-ClaraItalic-tosf-t1.tfm \
tex-ClaraItalic-tosf-t1.vf \
tex-ClaraItalic-tosf-t2a.tfm \
tex-ClaraItalic-tosf-t2b.tfm \
tex-ClaraItalic-tosf-t2c.tfm \
tex-ClaraItalic-tosf-ts1--base.tfm \
tex-ClaraItalic-tosf-ts1.tfm \
tex-ClaraItalic-tosf-ts1.vf \
tex-ClaraRegular-sup-lgr--base.tfm \
tex-ClaraRegular-sup-lgr.tfm \
tex-ClaraRegular-sup-lgr.vf \
tex-ClaraRegular-sup-ly1--base.tfm \
tex-ClaraRegular-sup-ly1.tfm \
tex-ClaraRegular-sup-ly1.vf \
tex-ClaraRegular-sup-ot1.tfm \
tex-ClaraRegular-sup-t1--base.tfm \
tex-ClaraRegular-sup-t1.tfm \
tex-ClaraRegular-sup-t1.vf \
tex-ClaraRegular-sup-t2a.tfm \
tex-ClaraRegular-sup-t2b.tfm \
tex-ClaraRegular-sup-t2c.tfm \
tex-ClaraRegular-tlf-lgr--base.tfm \
tex-ClaraRegular-tlf-lgr.tfm \
tex-ClaraRegular-tlf-lgr.vf \
tex-ClaraRegular-tlf-ly1--base.tfm \
tex-ClaraRegular-tlf-ly1.tfm \
tex-ClaraRegular-tlf-ly1.vf \
tex-ClaraRegular-tlf-ot1.tfm \
tex-ClaraRegular-tlf-sc-lgr--base.tfm \
tex-ClaraRegular-tlf-sc-lgr.tfm \
tex-ClaraRegular-tlf-sc-lgr.vf \
tex-ClaraRegular-tlf-sc-ly1--base.tfm \
tex-ClaraRegular-tlf-sc-ly1.tfm \
tex-ClaraRegular-tlf-sc-ly1.vf \
tex-ClaraRegular-tlf-sc-ot1--base.tfm \
tex-ClaraRegular-tlf-sc-ot1.tfm \
tex-ClaraRegular-tlf-sc-ot1.vf \
tex-ClaraRegular-tlf-sc-t1--base.tfm \
tex-ClaraRegular-tlf-sc-t1.tfm \
tex-ClaraRegular-tlf-sc-t1.vf \
tex-ClaraRegular-tlf-sc-t2a.tfm \
tex-ClaraRegular-tlf-sc-t2b.tfm \
tex-ClaraRegular-tlf-sc-t2c.tfm \
tex-ClaraRegular-tlf-t1--base.tfm \
tex-ClaraRegular-tlf-t1.tfm \
tex-ClaraRegular-tlf-t1.vf \
tex-ClaraRegular-tlf-t2a.tfm \
tex-ClaraRegular-tlf-t2b.tfm \
tex-ClaraRegular-tlf-t2c.tfm \
tex-ClaraRegular-tlf-ts1--base.tfm \
tex-ClaraRegular-tlf-ts1.tfm \
tex-ClaraRegular-tlf-ts1.vf \
tex-ClaraRegular-tosf-lgr--base.tfm \
tex-ClaraRegular-tosf-lgr.tfm \
tex-ClaraRegular-tosf-lgr.vf \
tex-ClaraRegular-tosf-ly1--base.tfm \
tex-ClaraRegular-tosf-ly1.tfm \
tex-ClaraRegular-tosf-ly1.vf \
tex-ClaraRegular-tosf-ot1.tfm \
tex-ClaraRegular-tosf-sc-lgr--base.tfm \
tex-ClaraRegular-tosf-sc-lgr.tfm \
tex-ClaraRegular-tosf-sc-lgr.vf \
tex-ClaraRegular-tosf-sc-ly1--base.tfm \
tex-ClaraRegular-tosf-sc-ly1.tfm \
tex-ClaraRegular-tosf-sc-ly1.vf \
tex-ClaraRegular-tosf-sc-ot1--base.tfm \
tex-ClaraRegular-tosf-sc-ot1.tfm \
tex-ClaraRegular-tosf-sc-ot1.vf \
tex-ClaraRegular-tosf-sc-t1--base.tfm \
tex-ClaraRegular-tosf-sc-t1.tfm \
tex-ClaraRegular-tosf-sc-t1.vf \
tex-ClaraRegular-tosf-sc-t2a.tfm \
tex-ClaraRegular-tosf-sc-t2b.tfm \
tex-ClaraRegular-tosf-sc-t2c.tfm \
tex-ClaraRegular-tosf-t1--base.tfm \
tex-ClaraRegular-tosf-t1.tfm \
tex-ClaraRegular-tosf-t1.vf \
tex-ClaraRegular-tosf-t2a.tfm \
tex-ClaraRegular-tosf-t2b.tfm \
tex-ClaraRegular-tosf-t2c.tfm \
tex-ClaraRegular-tosf-ts1--base.tfm \
tex-ClaraRegular-tosf-ts1.tfm \
tex-ClaraRegular-tosf-ts1.vf \
tex-LGRClara-Sup.fd \
tex-LGRClara-TLF.fd \
tex-LGRClara-TOsF.fd \
tex-LY1Clara-Sup.fd \
tex-LY1Clara-TLF.fd \
tex-LY1Clara-TOsF.fd \
tex-OT1Clara-Sup.fd \
tex-OT1Clara-TLF.fd \
tex-OT1Clara-TOsF.fd \
tex-T1Clara-Sup.fd \
tex-T1Clara-TLF.fd \
tex-T1Clara-TOsF.fd \
tex-T2AClara-Sup.fd \
tex-T2AClara-TLF.fd \
tex-T2AClara-TOsF.fd \
tex-T2BClara-Sup.fd \
tex-T2BClara-TLF.fd \
tex-T2BClara-TOsF.fd \
tex-T2CClara-Sup.fd \
tex-T2CClara-TLF.fd \
tex-T2CClara-TOsF.fd \
tex-TS1Clara-TLF.fd \
tex-TS1Clara-TOsF.fd \
tex-a-2loy6v.enc \
tex-a-2qt3g3.enc \
tex-a-2sd372.enc \
tex-a-3o7uxl.enc \
tex-a-3xxmye.enc \
tex-a-4fqbn7.enc \
tex-a-4vguwe.enc \
tex-a-5cnopr.enc \
tex-a-6vj46g.enc \
tex-a-7ho2jb.enc \
tex-a-agquuh.enc \
tex-a-awbndy.enc \
tex-a-bcypke.enc \
tex-a-bgeg5m.enc \
tex-a-bjoktg.enc \
tex-a-cf2qhu.enc \
tex-a-cfejg4.enc \
tex-a-d6finu.enc \
tex-a-e42l7t.enc \
tex-a-evkdvu.enc \
tex-a-fsonrn.enc \
tex-a-fyi7ch.enc \
tex-a-g7oet2.enc \
tex-a-h4oqw4.enc \
tex-a-hbnu3g.enc \
tex-a-hwn42e.enc \
tex-a-hz5tc2.enc \
tex-a-hzws3u.enc \
tex-a-i325yp.enc \
tex-a-iuscur.enc \
tex-a-juafn7.enc \
tex-a-k2goe4.enc \
tex-a-kc6xc3.enc \
tex-a-kkzari.enc \
tex-a-klgvoj.enc \
tex-a-lpkscq.enc \
tex-a-mfkt2q.enc \
tex-a-nggrjd.enc \
tex-a-njaghn.enc \
tex-a-nms33f.enc \
tex-a-nppcjs.enc \
tex-a-nrthq5.enc \
tex-a-nw6hje.enc \
tex-a-nyfqzj.enc \
tex-a-nygz6z.enc \
tex-a-o7cu7p.enc \
tex-a-od3gqf.enc \
tex-a-okrfpx.enc \
tex-a-olbow4.enc \
tex-a-ouhtwv.enc \
tex-a-pq5qh7.enc \
tex-a-rjjgaj.enc \
tex-a-rn6hxp.enc \
tex-a-rxba6k.enc \
tex-a-ryhnwz.enc \
tex-a-sax4h4.enc \
tex-a-sgjkrw.enc \
tex-a-tifa47.enc \
tex-a-tlcr5j.enc \
tex-a-tloikb.enc \
tex-a-tsfqnz.enc \
tex-a-tvfcps.enc \
tex-a-udnfrw.enc \
tex-a-vij5s5.enc \
tex-a-vn5qte.enc \
tex-a-vrmtcj.enc \
tex-a-vzapqb.enc \
tex-a-wtwzna.enc \
tex-a-xhofkf.enc \
tex-a-xojh7w.enc \
tex-a-xxjjii.enc \
tex-a-y2j5na.enc \
tex-a-y55f6a.enc \
tex-a-ylukkp.enc \
tex-a-ytymvu.enc \
tex-clara.sty \
texlive-clara"

RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontaxes.sty \
tex-mweights.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-clara-fonts \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
