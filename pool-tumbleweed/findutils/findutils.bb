SUMMARY = "The GNU versions of find utilities (find and xargs)"
DESCRIPTION = "The findutils package contains programs which will help you locate \
files on your system.  The find utility searches through a hierarchy \
of directories looking for files which match a certain set of criteria \
(such as a file name pattern).  The xargs utility builds and executes \
command lines from standard input arguments (usually lists of file \
names generated by the find command). \
 \
You should install findutils because it includes tools that are very \
useful for finding things on your system."
LICENSE = "GPL-3.0-or-later"

PV = "4.9.0"

RPM_NAME = "findutils-4.9.0-2.3.aarch64.rpm"
RPM_HASH = "065252fe6db40a22d882ae04686e96d1ef2e06ce5b8972b1422bfb3107a66c0b07ed1ccd3310e228f4fd75f56e61c89dbd9a03aaff201887acdd039fd3155498"

RPROVIDES:${PN} += "find \
findutils \
findutils(aarch-64)"

RDEPENDS:${PN} += "ld-linux-aarch64.so.1()(64bit) \
libc.so.6()(64bit) \
libselinux.so.1()(64bit)"

inherit rpm
