SUMMARY = "Kernel firmware files for AMDGPU graphics driver"
DESCRIPTION = "This package contains compressed kernel firmware files for \
AMDGPU graphics driver."
LICENSE = "GPL-2.0-only & SUSE-Firmware & GPL-2.0-or-later & MIT"

PV = "20230707"

RPM_NAME = "kernel-firmware-amdgpu-20230707-1.1.noarch.rpm"
RPM_HASH = "1e696cbb9c6db34c6485e42a9660cb63f2f8b28e9e2882bfe07e447a7fa5b864ad27612a11954fbd9252ff3039639af284df2bb569e311e340720752d143db18"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "firmware-amdgpu/aldebaran-mec.bin \
firmware-amdgpu/aldebaran-mec2.bin \
firmware-amdgpu/aldebaran-rlc.bin \
firmware-amdgpu/aldebaran-sdma.bin \
firmware-amdgpu/aldebaran-sjt-mec.bin \
firmware-amdgpu/aldebaran-sjt-mec2.bin \
firmware-amdgpu/aldebaran-smc.bin \
firmware-amdgpu/aldebaran-sos.bin \
firmware-amdgpu/aldebaran-ta.bin \
firmware-amdgpu/aldebaran-vcn.bin \
firmware-amdgpu/arcturus-asd.bin \
firmware-amdgpu/arcturus-gpu-info.bin \
firmware-amdgpu/arcturus-mec.bin \
firmware-amdgpu/arcturus-mec2.bin \
firmware-amdgpu/arcturus-rlc.bin \
firmware-amdgpu/arcturus-sdma.bin \
firmware-amdgpu/arcturus-smc.bin \
firmware-amdgpu/arcturus-sos.bin \
firmware-amdgpu/arcturus-ta.bin \
firmware-amdgpu/arcturus-vcn.bin \
firmware-amdgpu/banks-k-2-smc.bin \
firmware-amdgpu/beige-goby-ce.bin \
firmware-amdgpu/beige-goby-dmcub.bin \
firmware-amdgpu/beige-goby-me.bin \
firmware-amdgpu/beige-goby-mec.bin \
firmware-amdgpu/beige-goby-mec2.bin \
firmware-amdgpu/beige-goby-pfp.bin \
firmware-amdgpu/beige-goby-rlc.bin \
firmware-amdgpu/beige-goby-sdma.bin \
firmware-amdgpu/beige-goby-smc.bin \
firmware-amdgpu/beige-goby-sos.bin \
firmware-amdgpu/beige-goby-ta.bin \
firmware-amdgpu/beige-goby-vcn.bin \
firmware-amdgpu/bonaire-ce.bin \
firmware-amdgpu/bonaire-k-smc.bin \
firmware-amdgpu/bonaire-mc.bin \
firmware-amdgpu/bonaire-me.bin \
firmware-amdgpu/bonaire-mec.bin \
firmware-amdgpu/bonaire-pfp.bin \
firmware-amdgpu/bonaire-rlc.bin \
firmware-amdgpu/bonaire-sdma.bin \
firmware-amdgpu/bonaire-sdma1.bin \
firmware-amdgpu/bonaire-smc.bin \
firmware-amdgpu/bonaire-uvd.bin \
firmware-amdgpu/bonaire-vce.bin \
firmware-amdgpu/carrizo-ce.bin \
firmware-amdgpu/carrizo-me.bin \
firmware-amdgpu/carrizo-mec.bin \
firmware-amdgpu/carrizo-mec2.bin \
firmware-amdgpu/carrizo-pfp.bin \
firmware-amdgpu/carrizo-rlc.bin \
firmware-amdgpu/carrizo-sdma.bin \
firmware-amdgpu/carrizo-sdma1.bin \
firmware-amdgpu/carrizo-uvd.bin \
firmware-amdgpu/carrizo-vce.bin \
firmware-amdgpu/cyan-skillfish2-ce.bin \
firmware-amdgpu/cyan-skillfish2-me.bin \
firmware-amdgpu/cyan-skillfish2-mec.bin \
firmware-amdgpu/cyan-skillfish2-mec2.bin \
firmware-amdgpu/cyan-skillfish2-pfp.bin \
firmware-amdgpu/cyan-skillfish2-rlc.bin \
firmware-amdgpu/cyan-skillfish2-sdma.bin \
firmware-amdgpu/cyan-skillfish2-sdma1.bin \
firmware-amdgpu/dcn-3-1-4-dmcub.bin \
firmware-amdgpu/dcn-3-1-5-dmcub.bin \
firmware-amdgpu/dcn-3-1-6-dmcub.bin \
firmware-amdgpu/dcn-3-2-0-dmcub.bin \
firmware-amdgpu/dcn-3-2-1-dmcub.bin \
firmware-amdgpu/dimgrey-cavefish-ce.bin \
firmware-amdgpu/dimgrey-cavefish-dmcub.bin \
firmware-amdgpu/dimgrey-cavefish-me.bin \
firmware-amdgpu/dimgrey-cavefish-mec.bin \
firmware-amdgpu/dimgrey-cavefish-mec2.bin \
firmware-amdgpu/dimgrey-cavefish-pfp.bin \
firmware-amdgpu/dimgrey-cavefish-rlc.bin \
firmware-amdgpu/dimgrey-cavefish-sdma.bin \
firmware-amdgpu/dimgrey-cavefish-smc.bin \
firmware-amdgpu/dimgrey-cavefish-sos.bin \
firmware-amdgpu/dimgrey-cavefish-ta.bin \
firmware-amdgpu/dimgrey-cavefish-vcn.bin \
firmware-amdgpu/fiji-ce.bin \
firmware-amdgpu/fiji-mc.bin \
firmware-amdgpu/fiji-me.bin \
firmware-amdgpu/fiji-mec.bin \
firmware-amdgpu/fiji-mec2.bin \
firmware-amdgpu/fiji-pfp.bin \
firmware-amdgpu/fiji-rlc.bin \
firmware-amdgpu/fiji-sdma.bin \
firmware-amdgpu/fiji-sdma1.bin \
firmware-amdgpu/fiji-smc.bin \
firmware-amdgpu/fiji-uvd.bin \
firmware-amdgpu/fiji-vce.bin \
firmware-amdgpu/gc-10-3-6-ce.bin \
firmware-amdgpu/gc-10-3-6-me.bin \
firmware-amdgpu/gc-10-3-6-mec.bin \
firmware-amdgpu/gc-10-3-6-mec2.bin \
firmware-amdgpu/gc-10-3-6-pfp.bin \
firmware-amdgpu/gc-10-3-6-rlc.bin \
firmware-amdgpu/gc-10-3-7-ce.bin \
firmware-amdgpu/gc-10-3-7-me.bin \
firmware-amdgpu/gc-10-3-7-mec.bin \
firmware-amdgpu/gc-10-3-7-mec2.bin \
firmware-amdgpu/gc-10-3-7-pfp.bin \
firmware-amdgpu/gc-10-3-7-rlc.bin \
firmware-amdgpu/gc-11-0-0-imu.bin \
firmware-amdgpu/gc-11-0-0-me.bin \
firmware-amdgpu/gc-11-0-0-mec.bin \
firmware-amdgpu/gc-11-0-0-mes-2.bin \
firmware-amdgpu/gc-11-0-0-mes.bin \
firmware-amdgpu/gc-11-0-0-mes1.bin \
firmware-amdgpu/gc-11-0-0-pfp.bin \
firmware-amdgpu/gc-11-0-0-rlc.bin \
firmware-amdgpu/gc-11-0-1-imu.bin \
firmware-amdgpu/gc-11-0-1-me.bin \
firmware-amdgpu/gc-11-0-1-mec.bin \
firmware-amdgpu/gc-11-0-1-mes-2.bin \
firmware-amdgpu/gc-11-0-1-mes.bin \
firmware-amdgpu/gc-11-0-1-mes1.bin \
firmware-amdgpu/gc-11-0-1-pfp.bin \
firmware-amdgpu/gc-11-0-1-rlc.bin \
firmware-amdgpu/gc-11-0-2-imu.bin \
firmware-amdgpu/gc-11-0-2-me.bin \
firmware-amdgpu/gc-11-0-2-mec.bin \
firmware-amdgpu/gc-11-0-2-mes-2.bin \
firmware-amdgpu/gc-11-0-2-mes.bin \
firmware-amdgpu/gc-11-0-2-mes1.bin \
firmware-amdgpu/gc-11-0-2-pfp.bin \
firmware-amdgpu/gc-11-0-2-rlc.bin \
firmware-amdgpu/gc-11-0-4-imu.bin \
firmware-amdgpu/gc-11-0-4-me.bin \
firmware-amdgpu/gc-11-0-4-mec.bin \
firmware-amdgpu/gc-11-0-4-mes-2.bin \
firmware-amdgpu/gc-11-0-4-mes.bin \
firmware-amdgpu/gc-11-0-4-mes1.bin \
firmware-amdgpu/gc-11-0-4-pfp.bin \
firmware-amdgpu/gc-11-0-4-rlc.bin \
firmware-amdgpu/green-sardine-asd.bin \
firmware-amdgpu/green-sardine-ce.bin \
firmware-amdgpu/green-sardine-dmcub.bin \
firmware-amdgpu/green-sardine-me.bin \
firmware-amdgpu/green-sardine-mec.bin \
firmware-amdgpu/green-sardine-mec2.bin \
firmware-amdgpu/green-sardine-pfp.bin \
firmware-amdgpu/green-sardine-rlc.bin \
firmware-amdgpu/green-sardine-sdma.bin \
firmware-amdgpu/green-sardine-ta.bin \
firmware-amdgpu/green-sardine-vcn.bin \
firmware-amdgpu/hainan-ce.bin \
firmware-amdgpu/hainan-k-smc.bin \
firmware-amdgpu/hainan-mc.bin \
firmware-amdgpu/hainan-me.bin \
firmware-amdgpu/hainan-pfp.bin \
firmware-amdgpu/hainan-rlc.bin \
firmware-amdgpu/hainan-smc.bin \
firmware-amdgpu/hawaii-ce.bin \
firmware-amdgpu/hawaii-k-smc.bin \
firmware-amdgpu/hawaii-mc.bin \
firmware-amdgpu/hawaii-me.bin \
firmware-amdgpu/hawaii-mec.bin \
firmware-amdgpu/hawaii-pfp.bin \
firmware-amdgpu/hawaii-rlc.bin \
firmware-amdgpu/hawaii-sdma.bin \
firmware-amdgpu/hawaii-sdma1.bin \
firmware-amdgpu/hawaii-smc.bin \
firmware-amdgpu/hawaii-uvd.bin \
firmware-amdgpu/hawaii-vce.bin \
firmware-amdgpu/kabini-ce.bin \
firmware-amdgpu/kabini-me.bin \
firmware-amdgpu/kabini-mec.bin \
firmware-amdgpu/kabini-pfp.bin \
firmware-amdgpu/kabini-rlc.bin \
firmware-amdgpu/kabini-sdma.bin \
firmware-amdgpu/kabini-sdma1.bin \
firmware-amdgpu/kabini-uvd.bin \
firmware-amdgpu/kabini-vce.bin \
firmware-amdgpu/kaveri-ce.bin \
firmware-amdgpu/kaveri-me.bin \
firmware-amdgpu/kaveri-mec.bin \
firmware-amdgpu/kaveri-mec2.bin \
firmware-amdgpu/kaveri-pfp.bin \
firmware-amdgpu/kaveri-rlc.bin \
firmware-amdgpu/kaveri-sdma.bin \
firmware-amdgpu/kaveri-sdma1.bin \
firmware-amdgpu/kaveri-uvd.bin \
firmware-amdgpu/kaveri-vce.bin \
firmware-amdgpu/mullins-ce.bin \
firmware-amdgpu/mullins-me.bin \
firmware-amdgpu/mullins-mec.bin \
firmware-amdgpu/mullins-pfp.bin \
firmware-amdgpu/mullins-rlc.bin \
firmware-amdgpu/mullins-sdma.bin \
firmware-amdgpu/mullins-sdma1.bin \
firmware-amdgpu/mullins-uvd.bin \
firmware-amdgpu/mullins-vce.bin \
firmware-amdgpu/navi10-asd.bin \
firmware-amdgpu/navi10-ce.bin \
firmware-amdgpu/navi10-gpu-info.bin \
firmware-amdgpu/navi10-me.bin \
firmware-amdgpu/navi10-mec.bin \
firmware-amdgpu/navi10-mec2.bin \
firmware-amdgpu/navi10-pfp.bin \
firmware-amdgpu/navi10-rlc.bin \
firmware-amdgpu/navi10-sdma.bin \
firmware-amdgpu/navi10-sdma1.bin \
firmware-amdgpu/navi10-smc.bin \
firmware-amdgpu/navi10-sos.bin \
firmware-amdgpu/navi10-ta.bin \
firmware-amdgpu/navi10-vcn.bin \
firmware-amdgpu/navi12-asd.bin \
firmware-amdgpu/navi12-ce.bin \
firmware-amdgpu/navi12-dmcu.bin \
firmware-amdgpu/navi12-gpu-info.bin \
firmware-amdgpu/navi12-me.bin \
firmware-amdgpu/navi12-mec.bin \
firmware-amdgpu/navi12-mec2.bin \
firmware-amdgpu/navi12-pfp.bin \
firmware-amdgpu/navi12-rlc.bin \
firmware-amdgpu/navi12-sdma.bin \
firmware-amdgpu/navi12-sdma1.bin \
firmware-amdgpu/navi12-smc.bin \
firmware-amdgpu/navi12-sos.bin \
firmware-amdgpu/navi12-ta.bin \
firmware-amdgpu/navi12-vcn.bin \
firmware-amdgpu/navi14-asd.bin \
firmware-amdgpu/navi14-ce-wks.bin \
firmware-amdgpu/navi14-ce.bin \
firmware-amdgpu/navi14-gpu-info.bin \
firmware-amdgpu/navi14-me-wks.bin \
firmware-amdgpu/navi14-me.bin \
firmware-amdgpu/navi14-mec-wks.bin \
firmware-amdgpu/navi14-mec.bin \
firmware-amdgpu/navi14-mec2-wks.bin \
firmware-amdgpu/navi14-mec2.bin \
firmware-amdgpu/navi14-pfp-wks.bin \
firmware-amdgpu/navi14-pfp.bin \
firmware-amdgpu/navi14-rlc.bin \
firmware-amdgpu/navi14-sdma.bin \
firmware-amdgpu/navi14-sdma1.bin \
firmware-amdgpu/navi14-smc.bin \
firmware-amdgpu/navi14-sos.bin \
firmware-amdgpu/navi14-ta.bin \
firmware-amdgpu/navi14-vcn.bin \
firmware-amdgpu/navy-flounder-ce.bin \
firmware-amdgpu/navy-flounder-dmcub.bin \
firmware-amdgpu/navy-flounder-me.bin \
firmware-amdgpu/navy-flounder-mec.bin \
firmware-amdgpu/navy-flounder-mec2.bin \
firmware-amdgpu/navy-flounder-pfp.bin \
firmware-amdgpu/navy-flounder-rlc.bin \
firmware-amdgpu/navy-flounder-sdma.bin \
firmware-amdgpu/navy-flounder-smc.bin \
firmware-amdgpu/navy-flounder-sos.bin \
firmware-amdgpu/navy-flounder-ta.bin \
firmware-amdgpu/navy-flounder-vcn.bin \
firmware-amdgpu/oland-ce.bin \
firmware-amdgpu/oland-k-smc.bin \
firmware-amdgpu/oland-mc.bin \
firmware-amdgpu/oland-me.bin \
firmware-amdgpu/oland-pfp.bin \
firmware-amdgpu/oland-rlc.bin \
firmware-amdgpu/oland-smc.bin \
firmware-amdgpu/oland-uvd.bin \
firmware-amdgpu/picasso-asd.bin \
firmware-amdgpu/picasso-ce.bin \
firmware-amdgpu/picasso-gpu-info.bin \
firmware-amdgpu/picasso-me.bin \
firmware-amdgpu/picasso-mec.bin \
firmware-amdgpu/picasso-mec2.bin \
firmware-amdgpu/picasso-pfp.bin \
firmware-amdgpu/picasso-rlc-am4.bin \
firmware-amdgpu/picasso-rlc.bin \
firmware-amdgpu/picasso-sdma.bin \
firmware-amdgpu/picasso-ta.bin \
firmware-amdgpu/picasso-vcn.bin \
firmware-amdgpu/pitcairn-ce.bin \
firmware-amdgpu/pitcairn-k-smc.bin \
firmware-amdgpu/pitcairn-mc.bin \
firmware-amdgpu/pitcairn-me.bin \
firmware-amdgpu/pitcairn-pfp.bin \
firmware-amdgpu/pitcairn-rlc.bin \
firmware-amdgpu/pitcairn-smc.bin \
firmware-amdgpu/pitcairn-uvd.bin \
firmware-amdgpu/polaris10-ce-2.bin \
firmware-amdgpu/polaris10-ce.bin \
firmware-amdgpu/polaris10-k-mc.bin \
firmware-amdgpu/polaris10-k-smc.bin \
firmware-amdgpu/polaris10-k2-smc.bin \
firmware-amdgpu/polaris10-mc.bin \
firmware-amdgpu/polaris10-me-2.bin \
firmware-amdgpu/polaris10-me.bin \
firmware-amdgpu/polaris10-mec-2.bin \
firmware-amdgpu/polaris10-mec.bin \
firmware-amdgpu/polaris10-mec2-2.bin \
firmware-amdgpu/polaris10-mec2.bin \
firmware-amdgpu/polaris10-pfp-2.bin \
firmware-amdgpu/polaris10-pfp.bin \
firmware-amdgpu/polaris10-rlc.bin \
firmware-amdgpu/polaris10-sdma.bin \
firmware-amdgpu/polaris10-sdma1.bin \
firmware-amdgpu/polaris10-smc-sk.bin \
firmware-amdgpu/polaris10-smc.bin \
firmware-amdgpu/polaris10-uvd.bin \
firmware-amdgpu/polaris10-vce.bin \
firmware-amdgpu/polaris11-ce-2.bin \
firmware-amdgpu/polaris11-ce.bin \
firmware-amdgpu/polaris11-k-mc.bin \
firmware-amdgpu/polaris11-k-smc.bin \
firmware-amdgpu/polaris11-k2-smc.bin \
firmware-amdgpu/polaris11-mc.bin \
firmware-amdgpu/polaris11-me-2.bin \
firmware-amdgpu/polaris11-me.bin \
firmware-amdgpu/polaris11-mec-2.bin \
firmware-amdgpu/polaris11-mec.bin \
firmware-amdgpu/polaris11-mec2-2.bin \
firmware-amdgpu/polaris11-mec2.bin \
firmware-amdgpu/polaris11-pfp-2.bin \
firmware-amdgpu/polaris11-pfp.bin \
firmware-amdgpu/polaris11-rlc.bin \
firmware-amdgpu/polaris11-sdma.bin \
firmware-amdgpu/polaris11-sdma1.bin \
firmware-amdgpu/polaris11-smc-sk.bin \
firmware-amdgpu/polaris11-smc.bin \
firmware-amdgpu/polaris11-uvd.bin \
firmware-amdgpu/polaris11-vce.bin \
firmware-amdgpu/polaris12-32-mc.bin \
firmware-amdgpu/polaris12-ce-2.bin \
firmware-amdgpu/polaris12-ce.bin \
firmware-amdgpu/polaris12-k-mc.bin \
firmware-amdgpu/polaris12-k-smc.bin \
firmware-amdgpu/polaris12-mc.bin \
firmware-amdgpu/polaris12-me-2.bin \
firmware-amdgpu/polaris12-me.bin \
firmware-amdgpu/polaris12-mec-2.bin \
firmware-amdgpu/polaris12-mec.bin \
firmware-amdgpu/polaris12-mec2-2.bin \
firmware-amdgpu/polaris12-mec2.bin \
firmware-amdgpu/polaris12-pfp-2.bin \
firmware-amdgpu/polaris12-pfp.bin \
firmware-amdgpu/polaris12-rlc.bin \
firmware-amdgpu/polaris12-sdma.bin \
firmware-amdgpu/polaris12-sdma1.bin \
firmware-amdgpu/polaris12-smc.bin \
firmware-amdgpu/polaris12-uvd.bin \
firmware-amdgpu/polaris12-vce.bin \
firmware-amdgpu/psp-13-0-0-sos.bin \
firmware-amdgpu/psp-13-0-0-ta.bin \
firmware-amdgpu/psp-13-0-11-ta.bin \
firmware-amdgpu/psp-13-0-11-toc.bin \
firmware-amdgpu/psp-13-0-4-ta.bin \
firmware-amdgpu/psp-13-0-4-toc.bin \
firmware-amdgpu/psp-13-0-5-asd.bin \
firmware-amdgpu/psp-13-0-5-ta.bin \
firmware-amdgpu/psp-13-0-5-toc.bin \
firmware-amdgpu/psp-13-0-7-sos.bin \
firmware-amdgpu/psp-13-0-7-ta.bin \
firmware-amdgpu/psp-13-0-8-asd.bin \
firmware-amdgpu/psp-13-0-8-ta.bin \
firmware-amdgpu/psp-13-0-8-toc.bin \
firmware-amdgpu/raven-asd.bin \
firmware-amdgpu/raven-ce.bin \
firmware-amdgpu/raven-dmcu.bin \
firmware-amdgpu/raven-gpu-info.bin \
firmware-amdgpu/raven-kicker-rlc.bin \
firmware-amdgpu/raven-me.bin \
firmware-amdgpu/raven-mec.bin \
firmware-amdgpu/raven-mec2.bin \
firmware-amdgpu/raven-pfp.bin \
firmware-amdgpu/raven-rlc.bin \
firmware-amdgpu/raven-sdma.bin \
firmware-amdgpu/raven-ta.bin \
firmware-amdgpu/raven-vcn.bin \
firmware-amdgpu/raven2-asd.bin \
firmware-amdgpu/raven2-ce.bin \
firmware-amdgpu/raven2-gpu-info.bin \
firmware-amdgpu/raven2-me.bin \
firmware-amdgpu/raven2-mec.bin \
firmware-amdgpu/raven2-mec2.bin \
firmware-amdgpu/raven2-pfp.bin \
firmware-amdgpu/raven2-rlc.bin \
firmware-amdgpu/raven2-sdma.bin \
firmware-amdgpu/raven2-ta.bin \
firmware-amdgpu/raven2-vcn.bin \
firmware-amdgpu/renoir-asd.bin \
firmware-amdgpu/renoir-ce.bin \
firmware-amdgpu/renoir-dmcub.bin \
firmware-amdgpu/renoir-gpu-info.bin \
firmware-amdgpu/renoir-me.bin \
firmware-amdgpu/renoir-mec.bin \
firmware-amdgpu/renoir-mec2.bin \
firmware-amdgpu/renoir-pfp.bin \
firmware-amdgpu/renoir-rlc.bin \
firmware-amdgpu/renoir-sdma.bin \
firmware-amdgpu/renoir-ta.bin \
firmware-amdgpu/renoir-vcn.bin \
firmware-amdgpu/sdma-5-2-6.bin \
firmware-amdgpu/sdma-5-2-7.bin \
firmware-amdgpu/sdma-6-0-0.bin \
firmware-amdgpu/sdma-6-0-1.bin \
firmware-amdgpu/sdma-6-0-2.bin \
firmware-amdgpu/si58-mc.bin \
firmware-amdgpu/sienna-cichlid-ce.bin \
firmware-amdgpu/sienna-cichlid-dmcub.bin \
firmware-amdgpu/sienna-cichlid-me.bin \
firmware-amdgpu/sienna-cichlid-mec.bin \
firmware-amdgpu/sienna-cichlid-mec2.bin \
firmware-amdgpu/sienna-cichlid-pfp.bin \
firmware-amdgpu/sienna-cichlid-rlc.bin \
firmware-amdgpu/sienna-cichlid-sdma.bin \
firmware-amdgpu/sienna-cichlid-smc.bin \
firmware-amdgpu/sienna-cichlid-sos.bin \
firmware-amdgpu/sienna-cichlid-ta.bin \
firmware-amdgpu/sienna-cichlid-vcn.bin \
firmware-amdgpu/smu-13-0-0.bin \
firmware-amdgpu/smu-13-0-7.bin \
firmware-amdgpu/stoney-ce.bin \
firmware-amdgpu/stoney-me.bin \
firmware-amdgpu/stoney-mec.bin \
firmware-amdgpu/stoney-pfp.bin \
firmware-amdgpu/stoney-rlc.bin \
firmware-amdgpu/stoney-sdma.bin \
firmware-amdgpu/stoney-uvd.bin \
firmware-amdgpu/stoney-vce.bin \
firmware-amdgpu/tahiti-ce.bin \
firmware-amdgpu/tahiti-k-smc.bin \
firmware-amdgpu/tahiti-mc.bin \
firmware-amdgpu/tahiti-me.bin \
firmware-amdgpu/tahiti-pfp.bin \
firmware-amdgpu/tahiti-rlc.bin \
firmware-amdgpu/tahiti-smc.bin \
firmware-amdgpu/tahiti-uvd.bin \
firmware-amdgpu/tonga-ce.bin \
firmware-amdgpu/tonga-k-smc.bin \
firmware-amdgpu/tonga-mc.bin \
firmware-amdgpu/tonga-me.bin \
firmware-amdgpu/tonga-mec.bin \
firmware-amdgpu/tonga-mec2.bin \
firmware-amdgpu/tonga-pfp.bin \
firmware-amdgpu/tonga-rlc.bin \
firmware-amdgpu/tonga-sdma.bin \
firmware-amdgpu/tonga-sdma1.bin \
firmware-amdgpu/tonga-smc.bin \
firmware-amdgpu/tonga-uvd.bin \
firmware-amdgpu/tonga-vce.bin \
firmware-amdgpu/topaz-ce.bin \
firmware-amdgpu/topaz-k-smc.bin \
firmware-amdgpu/topaz-mc.bin \
firmware-amdgpu/topaz-me.bin \
firmware-amdgpu/topaz-mec.bin \
firmware-amdgpu/topaz-mec2.bin \
firmware-amdgpu/topaz-pfp.bin \
firmware-amdgpu/topaz-rlc.bin \
firmware-amdgpu/topaz-sdma.bin \
firmware-amdgpu/topaz-sdma1.bin \
firmware-amdgpu/topaz-smc.bin \
firmware-amdgpu/vangogh-asd.bin \
firmware-amdgpu/vangogh-ce.bin \
firmware-amdgpu/vangogh-dmcub.bin \
firmware-amdgpu/vangogh-me.bin \
firmware-amdgpu/vangogh-mec.bin \
firmware-amdgpu/vangogh-mec2.bin \
firmware-amdgpu/vangogh-pfp.bin \
firmware-amdgpu/vangogh-rlc.bin \
firmware-amdgpu/vangogh-sdma.bin \
firmware-amdgpu/vangogh-toc.bin \
firmware-amdgpu/vangogh-vcn.bin \
firmware-amdgpu/vcn-3-1-2.bin \
firmware-amdgpu/vcn-4-0-0.bin \
firmware-amdgpu/vcn-4-0-2.bin \
firmware-amdgpu/vcn-4-0-4.bin \
firmware-amdgpu/vega10-acg-smc.bin \
firmware-amdgpu/vega10-asd.bin \
firmware-amdgpu/vega10-ce.bin \
firmware-amdgpu/vega10-gpu-info.bin \
firmware-amdgpu/vega10-me.bin \
firmware-amdgpu/vega10-mec.bin \
firmware-amdgpu/vega10-mec2.bin \
firmware-amdgpu/vega10-pfp.bin \
firmware-amdgpu/vega10-rlc.bin \
firmware-amdgpu/vega10-sdma.bin \
firmware-amdgpu/vega10-sdma1.bin \
firmware-amdgpu/vega10-smc.bin \
firmware-amdgpu/vega10-sos.bin \
firmware-amdgpu/vega10-uvd.bin \
firmware-amdgpu/vega10-vce.bin \
firmware-amdgpu/vega12-asd.bin \
firmware-amdgpu/vega12-ce.bin \
firmware-amdgpu/vega12-gpu-info.bin \
firmware-amdgpu/vega12-me.bin \
firmware-amdgpu/vega12-mec.bin \
firmware-amdgpu/vega12-mec2.bin \
firmware-amdgpu/vega12-pfp.bin \
firmware-amdgpu/vega12-rlc.bin \
firmware-amdgpu/vega12-sdma.bin \
firmware-amdgpu/vega12-sdma1.bin \
firmware-amdgpu/vega12-smc.bin \
firmware-amdgpu/vega12-sos.bin \
firmware-amdgpu/vega12-uvd.bin \
firmware-amdgpu/vega12-vce.bin \
firmware-amdgpu/vega20-asd.bin \
firmware-amdgpu/vega20-ce.bin \
firmware-amdgpu/vega20-me.bin \
firmware-amdgpu/vega20-mec.bin \
firmware-amdgpu/vega20-mec2.bin \
firmware-amdgpu/vega20-pfp.bin \
firmware-amdgpu/vega20-rlc.bin \
firmware-amdgpu/vega20-sdma.bin \
firmware-amdgpu/vega20-sdma1.bin \
firmware-amdgpu/vega20-smc.bin \
firmware-amdgpu/vega20-sos.bin \
firmware-amdgpu/vega20-ta.bin \
firmware-amdgpu/vega20-uvd.bin \
firmware-amdgpu/vega20-vce.bin \
firmware-amdgpu/vegam-ce.bin \
firmware-amdgpu/vegam-me.bin \
firmware-amdgpu/vegam-mec.bin \
firmware-amdgpu/vegam-mec2.bin \
firmware-amdgpu/vegam-pfp.bin \
firmware-amdgpu/vegam-rlc.bin \
firmware-amdgpu/vegam-sdma.bin \
firmware-amdgpu/vegam-sdma1.bin \
firmware-amdgpu/vegam-smc.bin \
firmware-amdgpu/vegam-uvd.bin \
firmware-amdgpu/vegam-vce.bin \
firmware-amdgpu/verde-ce.bin \
firmware-amdgpu/verde-k-smc.bin \
firmware-amdgpu/verde-mc.bin \
firmware-amdgpu/verde-me.bin \
firmware-amdgpu/verde-pfp.bin \
firmware-amdgpu/verde-rlc.bin \
firmware-amdgpu/verde-smc.bin \
firmware-amdgpu/verde-uvd.bin \
firmware-amdgpu/yellow-carp-asd.bin \
firmware-amdgpu/yellow-carp-ce.bin \
firmware-amdgpu/yellow-carp-dmcub.bin \
firmware-amdgpu/yellow-carp-me.bin \
firmware-amdgpu/yellow-carp-mec.bin \
firmware-amdgpu/yellow-carp-mec2.bin \
firmware-amdgpu/yellow-carp-pfp.bin \
firmware-amdgpu/yellow-carp-rlc.bin \
firmware-amdgpu/yellow-carp-sdma.bin \
firmware-amdgpu/yellow-carp-ta.bin \
firmware-amdgpu/yellow-carp-toc.bin \
firmware-amdgpu/yellow-carp-vcn.bin \
kernel-firmware-amdgpu"

RDEPENDS:${PN} += "/usr/bin/mkdir \
/usr/bin/sh \
/usr/bin/touch \
dracut"

inherit rpm
