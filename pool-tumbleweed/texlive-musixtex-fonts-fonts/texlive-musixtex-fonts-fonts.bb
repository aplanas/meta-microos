SUMMARY = "Severed fonts for texlive-musixtex-fonts"
DESCRIPTION = "The  separated fonts package for texlive-musixtex-fonts"
LICENSE = "GPL-2.0-or-later"

PV = "2023.209.svn65517"

RPM_NAME = "texlive-musixtex-fonts-fonts-2023.209.svn65517-55.1.noarch.rpm"
RPM_HASH = "13d9a3075f88a89ea7d685f189913725832bcef4ecf1e335209948067637349b0e33d7d0e6d8fe27202cdf88e4fc98a758d34ac230faebb6522fb6a54c8274e3"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "config-texlive-musixtex-fonts-fonts \
font--lang=aa \
font--lang=an \
font--lang=ay \
font--lang=bi \
font--lang=br \
font--lang=ch \
font--lang=co \
font--lang=crh \
font--lang=cs \
font--lang=csb \
font--lang=da \
font--lang=de \
font--lang=en \
font--lang=eo \
font--lang=es \
font--lang=et \
font--lang=eu \
font--lang=fi \
font--lang=fil \
font--lang=fj \
font--lang=fo \
font--lang=fr \
font--lang=fur \
font--lang=fy \
font--lang=gd \
font--lang=gl \
font--lang=gv \
font--lang=ho \
font--lang=hsb \
font--lang=ht \
font--lang=hu \
font--lang=ia \
font--lang=id \
font--lang=ie \
font--lang=io \
font--lang=is \
font--lang=it \
font--lang=jv \
font--lang=ki \
font--lang=kj \
font--lang=ku-tr \
font--lang=kwm \
font--lang=la \
font--lang=lb \
font--lang=lg \
font--lang=li \
font--lang=mg \
font--lang=ms \
font--lang=na \
font--lang=nb \
font--lang=nds \
font--lang=ng \
font--lang=nl \
font--lang=nn \
font--lang=no \
font--lang=nr \
font--lang=nso \
font--lang=ny \
font--lang=oc \
font--lang=om \
font--lang=pap-an \
font--lang=pap-aw \
font--lang=pl \
font--lang=pt \
font--lang=rm \
font--lang=rn \
font--lang=rw \
font--lang=sc \
font--lang=sg \
font--lang=sk \
font--lang=sma \
font--lang=smj \
font--lang=sn \
font--lang=so \
font--lang=sq \
font--lang=ss \
font--lang=st \
font--lang=su \
font--lang=sv \
font--lang=sw \
font--lang=tk \
font--lang=tl \
font--lang=tn \
font--lang=tr \
font--lang=ts \
font--lang=uz \
font--lang=vo \
font--lang=vot \
font--lang=wa \
font--lang=wen \
font--lang=wo \
font--lang=xh \
font--lang=yap \
font--lang=za \
font--lang=zu \
font-feta20 \
font-frenchtab \
font-musejazztext \
font-musix11 \
font-musix13 \
font-musix16 \
font-musix20 \
font-musix24 \
font-musix29 \
font-musixsps \
font-musixspx \
font-mxsk \
font-xadf11 \
font-xadf13 \
font-xadf16 \
font-xadf20 \
font-xadf24 \
font-xadf29 \
font-xgreg11 \
font-xgreg13 \
font-xgreg16 \
font-xgreg20 \
font-xgreg24 \
font-xgreg29 \
font-xppff10 \
font-xsld11 \
font-xsld11d \
font-xsld13 \
font-xsld13d \
font-xsld16 \
font-xsld16d \
font-xsld20 \
font-xsld20d \
font-xsld24 \
font-xsld24d \
font-xsld29 \
font-xsld29d \
font-xsldd20 \
font-xsldu20 \
font-xslhd11 \
font-xslhd11d \
font-xslhd13 \
font-xslhd13d \
font-xslhd16 \
font-xslhd16d \
font-xslhd20 \
font-xslhd20d \
font-xslhd24 \
font-xslhd24d \
font-xslhd29 \
font-xslhd29d \
font-xslhu11 \
font-xslhu11d \
font-xslhu13 \
font-xslhu13d \
font-xslhu16 \
font-xslhu16d \
font-xslhu20 \
font-xslhu20d \
font-xslhu24 \
font-xslhu24d \
font-xslhu29 \
font-xslhu29d \
font-xslhz20 \
font-xslhz20d \
font-xslu11 \
font-xslu11d \
font-xslu13 \
font-xslu13d \
font-xslu16 \
font-xslu16d \
font-xslu20 \
font-xslu20d \
font-xslu24 \
font-xslu24d \
font-xslu29 \
font-xslu29d \
font-xslud20 \
font-xslup20 \
font-xslz20 \
font-xslz20d \
font-xtie20 \
texlive-musixtex-fonts-fonts"

RDEPENDS:${PN} += "/usr/bin/sh \
aaa-base \
coreutils \
fontconfig \
ghostscript-fonts-std \
perl"

inherit rpm
