SUMMARY = "GStreamer Streaming-Media Framework Plug-Ins"
DESCRIPTION = "GStreamer is a streaming media framework based on graphs of filters \
that operate on media data. Applications using this library can do \
anything media-related,from real-time sound processing to playing \
videos. Its plug-in-based architecture means that new data types or \
processing capabilities can be added simply by installing new plug-ins."
LICENSE = "LGPL-2.1-or-later"

PV = "1.22.5"

RPM_NAME = "gstreamer-plugins-bad-1.22.5-1.1.aarch64.rpm"
RPM_HASH = "1cf2062f69504131657e4707f776bed6ba04874d0439c32f18f2d8da33fd83b57f9fe19cec3052a9b5c007c8e7ab19c041063f606a46f1a648f9973ead7f2dfe"

RPROVIDES:${PN} += "gst-plugins-bad \
gstreamer-plugins-bad \
gstreamer1 \
libgstaccurip.so \
libgstadpcmdec.so \
libgstadpcmenc.so \
libgstaes.so \
libgstaiff.so \
libgstaom.so \
libgstasfmux.so \
libgstassrender.so \
libgstaudiobuffersplit.so \
libgstaudiofxbad.so \
libgstaudiolatency.so \
libgstaudiomixmatrix.so \
libgstaudiovisualizers.so \
libgstautoconvert.so \
libgstavtp.so \
libgstbayer.so \
libgstbluez.so \
libgstbs2b.so \
libgstbz2.so \
libgstcamerabin.so \
libgstclosedcaption.so \
libgstcodecalpha.so \
libgstcodectimestamper.so \
libgstcoloreffects.so \
libgstcolormanagement.so \
libgstcurl.so \
libgstdash.so \
libgstdc1394.so \
libgstdebugutilsbad.so \
libgstdtls.so \
libgstdtsdec.so \
libgstdvb.so \
libgstdvbsubenc.so \
libgstdvbsuboverlay.so \
libgstdvdspu.so \
libgstfaceoverlay.so \
libgstfbdevsink.so \
libgstfdkaac.so \
libgstfieldanalysis.so \
libgstfreeverb.so \
libgstfrei0r.so \
libgstgaudieffects.so \
libgstgdp.so \
libgstgeometrictransform.so \
libgstgme.so \
libgstgsm.so \
libgstgtkwayland.so \
libgsthls.so \
libgstid3tag.so \
libgstinter.so \
libgstinterlace.so \
libgstipcpipeline.so \
libgstivfparse.so \
libgstivtc.so \
libgstjp2kdecimator.so \
libgstjpegformat.so \
libgstkms.so \
libgstladspa.so \
libgstldac.so \
libgstlegacyrawparse.so \
libgstlv2.so \
libgstmicrodns.so \
libgstmidi.so \
libgstmpeg2enc.so \
libgstmpegpsdemux.so \
libgstmpegpsmux.so \
libgstmpegtsdemux.so \
libgstmpegtsmux.so \
libgstmplex.so \
libgstmusepack.so \
libgstmxf.so \
libgstneonhttpsrc.so \
libgstnetsim.so \
libgstnvcodec.so \
libgstopenal.so \
libgstopenexr.so \
libgstopenjpeg.so \
libgstopenmpt.so \
libgstopusparse.so \
libgstpcapparse.so \
libgstpnm.so \
libgstproxy.so \
libgstqroverlay.so \
libgstremovesilence.so \
libgstrfbsrc.so \
libgstrist.so \
libgstrsvg.so \
libgstrtmp2.so \
libgstrtpmanagerbad.so \
libgstrtponvif.so \
libgstsbc.so \
libgstsdpelem.so \
libgstsegmentclip.so \
libgstshm.so \
libgstsmooth.so \
libgstsmoothstreaming.so \
libgstsndfile.so \
libgstsoundtouch.so \
libgstspandsp.so \
libgstspeed.so \
libgstsrt.so \
libgstsrtp.so \
libgstsubenc.so \
libgstswitchbin.so \
libgstteletext.so \
libgsttimecode.so \
libgstttmlsubs.so \
libgstuvch264.so \
libgstv4l2codecs.so \
libgstva.so \
libgstvideofiltersbad.so \
libgstvideoframe-audiolevel.so \
libgstvideoparsersbad.so \
libgstvideosignal.so \
libgstvmnc.so \
libgstvoamrwbenc.so \
libgstvulkan.so \
libgstwaylandsink.so \
libgstwebp.so \
libgstwebrtc.so \
libgstwebrtcdsp.so \
libgsty4mdec.so \
libgstzbar.so \
libgstzxing.so \
patched-subset"

RDEPENDS:${PN} += "glib2-tools \
ld-linux-aarch64.so.1 \
libIex-3-1.so.30 \
libImath-3-1.so.29 \
libOpenEXR-3-1.so.30 \
libSoundTouch.so.1 \
libX11.so.6 \
libZXing.so.3 \
libaom.so.3 \
libass.so.9 \
libavtp.so.0 \
libbs2b.so.0 \
libbz2.so.1 \
libc.so.6 \
libcairo.so.2 \
libcrypto.so.3 \
libcurl.so.4 \
libdc1394.so.26 \
libdca.so.0 \
libdrm.so.2 \
libfdk-aac.so.2 \
libgcc-s.so.1 \
libgdk-3.so.0 \
libgio-2.0.so.0 \
libglib-2.0.so.0 \
libgme.so.0 \
libgmodule-2.0.so.0 \
libgobject-2.0.so.0 \
libgsm.so.1 \
libgstadaptivedemux-1.0.so.0 \
libgstallocators-1.0.so.0 \
libgstapp-1.0.so.0 \
libgstaudio-1.0.so.0 \
libgstbadaudio-1.0.so.0 \
libgstbase-1.0.so.0 \
libgstbasecamerabinsrc-1.0.so.0 \
libgstcodecparsers-1.0.so.0 \
libgstcodecs-1.0.so.0 \
libgstcuda-1.0.so.0 \
libgstfft-1.0.so.0 \
libgstgl-1.0.so.0 \
libgstisoff-1.0.so.0 \
libgstmpegts-1.0.so.0 \
libgstnet-1.0.so.0 \
libgstpbutils-1.0.so.0 \
libgstphotography-1.0.so.0 \
libgstreamer-1.0.so.0 \
libgstrtp-1.0.so.0 \
libgstsctp-1.0.so.0 \
libgstsdp-1.0.so.0 \
libgsttag-1.0.so.0 \
libgsturidownloader-1.0.so.0 \
libgstva-1.0.so.0 \
libgstvideo-1.0.so.0 \
libgstvulkan-1.0.so.0 \
libgstwayland-1.0.so.0 \
libgstwebrtc-1.0.so.0 \
libgstwebrtcnice-1.0.so.0 \
libgtk-3.so.0 \
libgudev-1.0.so.0 \
libjson-glib-1.0.so.0 \
liblcms2.so.2 \
libldacBT-enc.so.2 \
liblilv-0.so.0 \
liblrdf.so.2 \
libm.so.6 \
libmicrodns.so.1 \
libmjpegutils-2.2.so.0 \
libmpcdec.so.6 \
libmpeg2encpp-2.2.so.0 \
libmplex2-2.2.so.0 \
libneon.so.27 \
libopenal.so.1 \
libopenjp2.so.7 \
libopenmpt.so.0 \
libopus.so.0 \
liborc-0.4.so.0 \
libpango-1.0.so.0 \
libpangocairo-1.0.so.0 \
libqrencode.so.4 \
librsvg-2.so.2 \
libsbc.so.1 \
libsndfile.so.1 \
libspandsp.so.3 \
libsrt.so.1.5 \
libsrtp2.so.1 \
libssl.so.3 \
libstdc++.so.6 \
libusb-1.0.so.0 \
libva.so.2 \
libvo-amrwbenc.so.0 \
libvulkan.so.1 \
libwayland-client.so.0 \
libwebp.so.7 \
libwebrtc-audio-processing.so.1 \
libxml2.so.2 \
libzbar.so.0 \
libzvbi.so.0"

inherit rpm
