SUMMARY = "Computer modern fonts in T1 and TS1 encodings"
DESCRIPTION = "The EC fonts are European Computer Modern Fonts, supporting the \
complete LaTeX T1 encoding defined at the 1990 TUG conference \
hold at Cork/Ireland. These fonts are intended to be stable \
with no changes being made to the tfm files. The set also \
contains a Text Companion Symbol font, called tc, featuring \
many useful characters needed in text typesetting, for example \
oldstyle digits, currency symbols (including the newly created \
Euro symbol), the permille sign, copyright, trade mark and \
servicemark as well as a copyleft sign, and many others. Recent \
releases of LaTeX2e support the EC fonts. The EC fonts \
supersede the preliminary version released as the DC fonts. The \
fonts are available in (traced) Adobe Type 1 format, as part of \
the cm-super bundle. The other Computer Modern-style T1-encoded \
Type 1 set, Latin Modern, is not actually a direct development \
of the EC set, and differs from the EC in a number of \
particulars."
LICENSE = "LPPL-1.0"

PV = "2023.201.1.0svn25033"

RPM_NAME = "texlive-ec-2023.201.1.0svn25033-53.2.noarch.rpm"
RPM_HASH = "f7b110b999ee99ca6b051380818db6dcbcbc8fb2595ef838a7505f437b7e7b5ba0899b412d4002718bb667e3dd7bdda847837af5702784cb3e26c9dacca7a2f1"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-ecbi0500.tfm \
tex-ecbi0600.tfm \
tex-ecbi0700.tfm \
tex-ecbi0800.tfm \
tex-ecbi0900.tfm \
tex-ecbi1000.tfm \
tex-ecbi1095.tfm \
tex-ecbi1200.tfm \
tex-ecbi1440.tfm \
tex-ecbi1728.tfm \
tex-ecbi2074.tfm \
tex-ecbi2488.tfm \
tex-ecbi2986.tfm \
tex-ecbi3583.tfm \
tex-ecbl0500.tfm \
tex-ecbl0600.tfm \
tex-ecbl0700.tfm \
tex-ecbl0800.tfm \
tex-ecbl0900.tfm \
tex-ecbl1000.tfm \
tex-ecbl1095.tfm \
tex-ecbl1200.tfm \
tex-ecbl1440.tfm \
tex-ecbl1728.tfm \
tex-ecbl2074.tfm \
tex-ecbl2488.tfm \
tex-ecbl2986.tfm \
tex-ecbl3583.tfm \
tex-ecbx0500.tfm \
tex-ecbx0600.tfm \
tex-ecbx0700.tfm \
tex-ecbx0800.tfm \
tex-ecbx0900.tfm \
tex-ecbx1000.tfm \
tex-ecbx1095.tfm \
tex-ecbx1200.tfm \
tex-ecbx1440.tfm \
tex-ecbx1728.tfm \
tex-ecbx2074.tfm \
tex-ecbx2488.tfm \
tex-ecbx2986.tfm \
tex-ecbx3583.tfm \
tex-eccc0500.tfm \
tex-eccc0600.tfm \
tex-eccc0700.tfm \
tex-eccc0800.tfm \
tex-eccc0900.tfm \
tex-eccc1000.tfm \
tex-eccc1095.tfm \
tex-eccc1200.tfm \
tex-eccc1440.tfm \
tex-eccc1728.tfm \
tex-eccc2074.tfm \
tex-eccc2488.tfm \
tex-eccc2986.tfm \
tex-eccc3583.tfm \
tex-ecci0500.tfm \
tex-ecci0600.tfm \
tex-ecci0700.tfm \
tex-ecci0800.tfm \
tex-ecci0900.tfm \
tex-ecci1000.tfm \
tex-ecci1095.tfm \
tex-ecci1200.tfm \
tex-ecci1440.tfm \
tex-ecci1728.tfm \
tex-ecci2074.tfm \
tex-ecci2488.tfm \
tex-ecci2986.tfm \
tex-ecci3583.tfm \
tex-ecdh0500.tfm \
tex-ecdh0600.tfm \
tex-ecdh0700.tfm \
tex-ecdh0800.tfm \
tex-ecdh0900.tfm \
tex-ecdh1000.tfm \
tex-ecdh1095.tfm \
tex-ecdh1200.tfm \
tex-ecdh1440.tfm \
tex-ecdh1728.tfm \
tex-ecdh2074.tfm \
tex-ecdh2488.tfm \
tex-ecdh2986.tfm \
tex-ecdh3583.tfm \
tex-ecit0800.tfm \
tex-ecit0900.tfm \
tex-ecit1000.tfm \
tex-ecit1095.tfm \
tex-ecit1200.tfm \
tex-ecit1440.tfm \
tex-ecit1728.tfm \
tex-ecit2074.tfm \
tex-ecit2488.tfm \
tex-ecit2986.tfm \
tex-ecit3583.tfm \
tex-eclb8.tfm \
tex-ecli8.tfm \
tex-eclo8.tfm \
tex-eclq8.tfm \
tex-ecltt8.tfm \
tex-ecoc0500.tfm \
tex-ecoc0600.tfm \
tex-ecoc0700.tfm \
tex-ecoc0800.tfm \
tex-ecoc0900.tfm \
tex-ecoc1000.tfm \
tex-ecoc1095.tfm \
tex-ecoc1200.tfm \
tex-ecoc1440.tfm \
tex-ecoc1728.tfm \
tex-ecoc2074.tfm \
tex-ecoc2488.tfm \
tex-ecoc2986.tfm \
tex-ecoc3583.tfm \
tex-ecrb0500.tfm \
tex-ecrb0600.tfm \
tex-ecrb0700.tfm \
tex-ecrb0800.tfm \
tex-ecrb0900.tfm \
tex-ecrb1000.tfm \
tex-ecrb1095.tfm \
tex-ecrb1200.tfm \
tex-ecrb1440.tfm \
tex-ecrb1728.tfm \
tex-ecrb2074.tfm \
tex-ecrb2488.tfm \
tex-ecrb2986.tfm \
tex-ecrb3583.tfm \
tex-ecrm0500.tfm \
tex-ecrm0600.tfm \
tex-ecrm0700.tfm \
tex-ecrm0800.tfm \
tex-ecrm0900.tfm \
tex-ecrm1000.tfm \
tex-ecrm1095.tfm \
tex-ecrm1200.tfm \
tex-ecrm1440.tfm \
tex-ecrm1728.tfm \
tex-ecrm2074.tfm \
tex-ecrm2488.tfm \
tex-ecrm2986.tfm \
tex-ecrm3583.tfm \
tex-ecsc0500.tfm \
tex-ecsc0600.tfm \
tex-ecsc0700.tfm \
tex-ecsc0800.tfm \
tex-ecsc0900.tfm \
tex-ecsc1000.tfm \
tex-ecsc1095.tfm \
tex-ecsc1200.tfm \
tex-ecsc1440.tfm \
tex-ecsc1728.tfm \
tex-ecsc2074.tfm \
tex-ecsc2488.tfm \
tex-ecsc2986.tfm \
tex-ecsc3583.tfm \
tex-ecsi0500.tfm \
tex-ecsi0600.tfm \
tex-ecsi0700.tfm \
tex-ecsi0800.tfm \
tex-ecsi0900.tfm \
tex-ecsi1000.tfm \
tex-ecsi1095.tfm \
tex-ecsi1200.tfm \
tex-ecsi1440.tfm \
tex-ecsi1728.tfm \
tex-ecsi2074.tfm \
tex-ecsi2488.tfm \
tex-ecsi2986.tfm \
tex-ecsi3583.tfm \
tex-ecsl0500.tfm \
tex-ecsl0600.tfm \
tex-ecsl0700.tfm \
tex-ecsl0800.tfm \
tex-ecsl0900.tfm \
tex-ecsl1000.tfm \
tex-ecsl1095.tfm \
tex-ecsl1200.tfm \
tex-ecsl1440.tfm \
tex-ecsl1728.tfm \
tex-ecsl2074.tfm \
tex-ecsl2488.tfm \
tex-ecsl2986.tfm \
tex-ecsl3583.tfm \
tex-ecso0500.tfm \
tex-ecso0600.tfm \
tex-ecso0700.tfm \
tex-ecso0800.tfm \
tex-ecso0900.tfm \
tex-ecso1000.tfm \
tex-ecso1095.tfm \
tex-ecso1200.tfm \
tex-ecso1440.tfm \
tex-ecso1728.tfm \
tex-ecso2074.tfm \
tex-ecso2488.tfm \
tex-ecso2986.tfm \
tex-ecso3583.tfm \
tex-ecss0500.tfm \
tex-ecss0600.tfm \
tex-ecss0700.tfm \
tex-ecss0800.tfm \
tex-ecss0900.tfm \
tex-ecss1000.tfm \
tex-ecss1095.tfm \
tex-ecss1200.tfm \
tex-ecss1440.tfm \
tex-ecss1728.tfm \
tex-ecss2074.tfm \
tex-ecss2488.tfm \
tex-ecss2986.tfm \
tex-ecss3583.tfm \
tex-ecst0800.tfm \
tex-ecst0900.tfm \
tex-ecst1000.tfm \
tex-ecst1095.tfm \
tex-ecst1200.tfm \
tex-ecst1440.tfm \
tex-ecst1728.tfm \
tex-ecst2074.tfm \
tex-ecst2488.tfm \
tex-ecst2986.tfm \
tex-ecst3583.tfm \
tex-ecsx0500.tfm \
tex-ecsx0600.tfm \
tex-ecsx0700.tfm \
tex-ecsx0800.tfm \
tex-ecsx0900.tfm \
tex-ecsx1000.tfm \
tex-ecsx1095.tfm \
tex-ecsx1200.tfm \
tex-ecsx1440.tfm \
tex-ecsx1728.tfm \
tex-ecsx2074.tfm \
tex-ecsx2488.tfm \
tex-ecsx2986.tfm \
tex-ecsx3583.tfm \
tex-ectc0800.tfm \
tex-ectc0900.tfm \
tex-ectc1000.tfm \
tex-ectc1095.tfm \
tex-ectc1200.tfm \
tex-ectc1440.tfm \
tex-ectc1728.tfm \
tex-ectc2074.tfm \
tex-ectc2488.tfm \
tex-ectc2986.tfm \
tex-ectc3583.tfm \
tex-ecti0500.tfm \
tex-ecti0600.tfm \
tex-ecti0700.tfm \
tex-ecti0800.tfm \
tex-ecti0900.tfm \
tex-ecti1000.tfm \
tex-ecti1095.tfm \
tex-ecti1200.tfm \
tex-ecti1440.tfm \
tex-ecti1728.tfm \
tex-ecti2074.tfm \
tex-ecti2488.tfm \
tex-ecti2986.tfm \
tex-ecti3583.tfm \
tex-ectt0800.tfm \
tex-ectt0900.tfm \
tex-ectt1000.tfm \
tex-ectt1095.tfm \
tex-ectt1200.tfm \
tex-ectt1440.tfm \
tex-ectt1728.tfm \
tex-ectt2074.tfm \
tex-ectt2488.tfm \
tex-ectt2986.tfm \
tex-ectt3583.tfm \
tex-ecui0500.tfm \
tex-ecui0600.tfm \
tex-ecui0700.tfm \
tex-ecui0800.tfm \
tex-ecui0900.tfm \
tex-ecui1000.tfm \
tex-ecui1095.tfm \
tex-ecui1200.tfm \
tex-ecui1440.tfm \
tex-ecui1728.tfm \
tex-ecui2074.tfm \
tex-ecui2488.tfm \
tex-ecui2986.tfm \
tex-ecui3583.tfm \
tex-ecvi0800.tfm \
tex-ecvi0900.tfm \
tex-ecvi1000.tfm \
tex-ecvi1095.tfm \
tex-ecvi1200.tfm \
tex-ecvi1440.tfm \
tex-ecvi1728.tfm \
tex-ecvi2074.tfm \
tex-ecvi2488.tfm \
tex-ecvi2986.tfm \
tex-ecvi3583.tfm \
tex-ecvt0800.tfm \
tex-ecvt0900.tfm \
tex-ecvt1000.tfm \
tex-ecvt1095.tfm \
tex-ecvt1200.tfm \
tex-ecvt1440.tfm \
tex-ecvt1728.tfm \
tex-ecvt2074.tfm \
tex-ecvt2488.tfm \
tex-ecvt2986.tfm \
tex-ecvt3583.tfm \
tex-ecxc0500.tfm \
tex-ecxc0600.tfm \
tex-ecxc0700.tfm \
tex-ecxc0800.tfm \
tex-ecxc0900.tfm \
tex-ecxc1000.tfm \
tex-ecxc1095.tfm \
tex-ecxc1200.tfm \
tex-ecxc1440.tfm \
tex-ecxc1728.tfm \
tex-ecxc2074.tfm \
tex-ecxc2488.tfm \
tex-ecxc2986.tfm \
tex-ecxc3583.tfm \
tex-ieclb8.tfm \
tex-iecli8.tfm \
tex-ieclo8.tfm \
tex-ieclq8.tfm \
tex-iecltt8.tfm \
tex-tcbi0500.tfm \
tex-tcbi0600.tfm \
tex-tcbi0700.tfm \
tex-tcbi0800.tfm \
tex-tcbi0900.tfm \
tex-tcbi1000.tfm \
tex-tcbi1095.tfm \
tex-tcbi1200.tfm \
tex-tcbi1440.tfm \
tex-tcbi1728.tfm \
tex-tcbi2074.tfm \
tex-tcbi2488.tfm \
tex-tcbi2986.tfm \
tex-tcbi3583.tfm \
tex-tcbl0500.tfm \
tex-tcbl0600.tfm \
tex-tcbl0700.tfm \
tex-tcbl0800.tfm \
tex-tcbl0900.tfm \
tex-tcbl1000.tfm \
tex-tcbl1095.tfm \
tex-tcbl1200.tfm \
tex-tcbl1440.tfm \
tex-tcbl1728.tfm \
tex-tcbl2074.tfm \
tex-tcbl2488.tfm \
tex-tcbl2986.tfm \
tex-tcbl3583.tfm \
tex-tcbx0500.tfm \
tex-tcbx0600.tfm \
tex-tcbx0700.tfm \
tex-tcbx0800.tfm \
tex-tcbx0900.tfm \
tex-tcbx1000.tfm \
tex-tcbx1095.tfm \
tex-tcbx1200.tfm \
tex-tcbx1440.tfm \
tex-tcbx1728.tfm \
tex-tcbx2074.tfm \
tex-tcbx2488.tfm \
tex-tcbx2986.tfm \
tex-tcbx3583.tfm \
tex-tcci0500.tfm \
tex-tcci0600.tfm \
tex-tcci0700.tfm \
tex-tcci0800.tfm \
tex-tcci0900.tfm \
tex-tcci1000.tfm \
tex-tcci1095.tfm \
tex-tcci1200.tfm \
tex-tcci1440.tfm \
tex-tcci1728.tfm \
tex-tcci2074.tfm \
tex-tcci2488.tfm \
tex-tcci2986.tfm \
tex-tcci3583.tfm \
tex-tcit0800.tfm \
tex-tcit0900.tfm \
tex-tcit1000.tfm \
tex-tcit1095.tfm \
tex-tcit1200.tfm \
tex-tcit1440.tfm \
tex-tcit1728.tfm \
tex-tcit2074.tfm \
tex-tcit2488.tfm \
tex-tcit2986.tfm \
tex-tcit3583.tfm \
tex-tcrb0500.tfm \
tex-tcrb0600.tfm \
tex-tcrb0700.tfm \
tex-tcrb0800.tfm \
tex-tcrb0900.tfm \
tex-tcrb1000.tfm \
tex-tcrb1095.tfm \
tex-tcrb1200.tfm \
tex-tcrb1440.tfm \
tex-tcrb1728.tfm \
tex-tcrb2074.tfm \
tex-tcrb2488.tfm \
tex-tcrb2986.tfm \
tex-tcrb3583.tfm \
tex-tcrm0500.tfm \
tex-tcrm0600.tfm \
tex-tcrm0700.tfm \
tex-tcrm0800.tfm \
tex-tcrm0900.tfm \
tex-tcrm1000.tfm \
tex-tcrm1095.tfm \
tex-tcrm1200.tfm \
tex-tcrm1440.tfm \
tex-tcrm1728.tfm \
tex-tcrm2074.tfm \
tex-tcrm2488.tfm \
tex-tcrm2986.tfm \
tex-tcrm3583.tfm \
tex-tcsi0500.tfm \
tex-tcsi0600.tfm \
tex-tcsi0700.tfm \
tex-tcsi0800.tfm \
tex-tcsi0900.tfm \
tex-tcsi1000.tfm \
tex-tcsi1095.tfm \
tex-tcsi1200.tfm \
tex-tcsi1440.tfm \
tex-tcsi1728.tfm \
tex-tcsi2074.tfm \
tex-tcsi2488.tfm \
tex-tcsi2986.tfm \
tex-tcsi3583.tfm \
tex-tcsl0500.tfm \
tex-tcsl0600.tfm \
tex-tcsl0700.tfm \
tex-tcsl0800.tfm \
tex-tcsl0900.tfm \
tex-tcsl1000.tfm \
tex-tcsl1095.tfm \
tex-tcsl1200.tfm \
tex-tcsl1440.tfm \
tex-tcsl1728.tfm \
tex-tcsl2074.tfm \
tex-tcsl2488.tfm \
tex-tcsl2986.tfm \
tex-tcsl3583.tfm \
tex-tcso0500.tfm \
tex-tcso0600.tfm \
tex-tcso0700.tfm \
tex-tcso0800.tfm \
tex-tcso0900.tfm \
tex-tcso1000.tfm \
tex-tcso1095.tfm \
tex-tcso1200.tfm \
tex-tcso1440.tfm \
tex-tcso1728.tfm \
tex-tcso2074.tfm \
tex-tcso2488.tfm \
tex-tcso2986.tfm \
tex-tcso3583.tfm \
tex-tcss0500.tfm \
tex-tcss0600.tfm \
tex-tcss0700.tfm \
tex-tcss0800.tfm \
tex-tcss0900.tfm \
tex-tcss1000.tfm \
tex-tcss1095.tfm \
tex-tcss1200.tfm \
tex-tcss1440.tfm \
tex-tcss1728.tfm \
tex-tcss2074.tfm \
tex-tcss2488.tfm \
tex-tcss2986.tfm \
tex-tcss3583.tfm \
tex-tcst0800.tfm \
tex-tcst0900.tfm \
tex-tcst1000.tfm \
tex-tcst1095.tfm \
tex-tcst1200.tfm \
tex-tcst1440.tfm \
tex-tcst1728.tfm \
tex-tcst2074.tfm \
tex-tcst2488.tfm \
tex-tcst2986.tfm \
tex-tcst3583.tfm \
tex-tcsx0500.tfm \
tex-tcsx0600.tfm \
tex-tcsx0700.tfm \
tex-tcsx0800.tfm \
tex-tcsx0900.tfm \
tex-tcsx1000.tfm \
tex-tcsx1095.tfm \
tex-tcsx1200.tfm \
tex-tcsx1440.tfm \
tex-tcsx1728.tfm \
tex-tcsx2074.tfm \
tex-tcsx2488.tfm \
tex-tcsx2986.tfm \
tex-tcsx3583.tfm \
tex-tcti0500.tfm \
tex-tcti0600.tfm \
tex-tcti0700.tfm \
tex-tcti0800.tfm \
tex-tcti0900.tfm \
tex-tcti1000.tfm \
tex-tcti1095.tfm \
tex-tcti1200.tfm \
tex-tcti1440.tfm \
tex-tcti1728.tfm \
tex-tcti2074.tfm \
tex-tcti2488.tfm \
tex-tcti2986.tfm \
tex-tcti3583.tfm \
tex-tctt0800.tfm \
tex-tctt0900.tfm \
tex-tctt1000.tfm \
tex-tctt1095.tfm \
tex-tctt1200.tfm \
tex-tctt1440.tfm \
tex-tctt1728.tfm \
tex-tctt2074.tfm \
tex-tctt2488.tfm \
tex-tctt2986.tfm \
tex-tctt3583.tfm \
tex-tcui0500.tfm \
tex-tcui0600.tfm \
tex-tcui0700.tfm \
tex-tcui0800.tfm \
tex-tcui0900.tfm \
tex-tcui1000.tfm \
tex-tcui1095.tfm \
tex-tcui1200.tfm \
tex-tcui1440.tfm \
tex-tcui1728.tfm \
tex-tcui2074.tfm \
tex-tcui2488.tfm \
tex-tcui2986.tfm \
tex-tcui3583.tfm \
tex-tcvi0800.tfm \
tex-tcvi0900.tfm \
tex-tcvi1000.tfm \
tex-tcvi1095.tfm \
tex-tcvi1200.tfm \
tex-tcvi1440.tfm \
tex-tcvi1728.tfm \
tex-tcvi2074.tfm \
tex-tcvi2488.tfm \
tex-tcvi2986.tfm \
tex-tcvi3583.tfm \
tex-tcvt0800.tfm \
tex-tcvt0900.tfm \
tex-tcvt1000.tfm \
tex-tcvt1095.tfm \
tex-tcvt1200.tfm \
tex-tcvt1440.tfm \
tex-tcvt1728.tfm \
tex-tcvt2074.tfm \
tex-tcvt2488.tfm \
tex-tcvt2986.tfm \
tex-tcvt3583.tfm \
texlive-ec"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
