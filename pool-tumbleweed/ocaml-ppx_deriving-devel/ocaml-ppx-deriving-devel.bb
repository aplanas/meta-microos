SUMMARY = "Development files for ocaml-ppx_deriving"
DESCRIPTION = "The ocaml-ppx_deriving-devel package contains libraries and signature files for \
developing applications that use ocaml-ppx_deriving."
LICENSE = "MIT"

PV = "5.2.1"

RPM_NAME = "ocaml-ppx_deriving-devel-5.2.1-2.2.aarch64.rpm"
RPM_HASH = "201f8bb3513b203a887a73afd50a8e187bea51c16df6d418a5949da7ecb9df3e79777d541801a39badff931d0bf7d9bba6562493e04dc108be243f5520a7a0a9"

RPROVIDES:${PN} += "ocaml-Ppx-deriving \
ocaml-Ppx-deriving-create \
ocaml-Ppx-deriving-enum \
ocaml-Ppx-deriving-eq \
ocaml-Ppx-deriving-fold \
ocaml-Ppx-deriving-iter \
ocaml-Ppx-deriving-make \
ocaml-Ppx-deriving-map \
ocaml-Ppx-deriving-ord \
ocaml-Ppx-deriving-runtime \
ocaml-Ppx-deriving-show \
ocaml-Ppx-deriving-std \
ocaml-ppx-deriving-devel \
ocamlfind-ppx-deriving \
ocamlfind-ppx-deriving.api \
ocamlfind-ppx-deriving.create \
ocamlfind-ppx-deriving.enum \
ocamlfind-ppx-deriving.eq \
ocamlfind-ppx-deriving.fold \
ocamlfind-ppx-deriving.iter \
ocamlfind-ppx-deriving.make \
ocamlfind-ppx-deriving.map \
ocamlfind-ppx-deriving.ord \
ocamlfind-ppx-deriving.runtime \
ocamlfind-ppx-deriving.show \
ocamlfind-ppx-deriving.std \
ocamlx-Ppx-deriving \
ocamlx-Ppx-deriving-create \
ocamlx-Ppx-deriving-enum \
ocamlx-Ppx-deriving-eq \
ocamlx-Ppx-deriving-fold \
ocamlx-Ppx-deriving-iter \
ocamlx-Ppx-deriving-make \
ocamlx-Ppx-deriving-map \
ocamlx-Ppx-deriving-ord \
ocamlx-Ppx-deriving-runtime \
ocamlx-Ppx-deriving-show \
ocamlx-Ppx-deriving-std"

RDEPENDS:${PN} += "libc.so.6 \
libm.so.6 \
ocaml-Astlib \
ocaml-Astlib-- \
ocaml-Astlib--Ast-402 \
ocaml-Astlib--Ast-403 \
ocaml-Astlib--Ast-404 \
ocaml-Astlib--Ast-405 \
ocaml-Astlib--Ast-406 \
ocaml-Astlib--Ast-407 \
ocaml-Astlib--Ast-408 \
ocaml-Astlib--Ast-409 \
ocaml-Astlib--Ast-410 \
ocaml-Astlib--Ast-411 \
ocaml-Astlib--Ast-412 \
ocaml-Astlib--Ast-413 \
ocaml-Astlib--Ast-414 \
ocaml-Astlib--Ast-500 \
ocaml-Astlib--Location \
ocaml-Astlib--Longident \
ocaml-Astlib--Parse \
ocaml-Astlib--Pprintast \
ocaml-Asttypes \
ocaml-Build-path-prefix-map \
ocaml-CamlinternalFormatBasics \
ocaml-CamlinternalLazy \
ocaml-CamlinternalOO \
ocaml-Clflags \
ocaml-Cmi-format \
ocaml-Compmisc \
ocaml-Env \
ocaml-Ident \
ocaml-Identifiable \
ocaml-Load-path \
ocaml-Location \
ocaml-Longident \
ocaml-Misc \
ocaml-Ocaml-common \
ocaml-Ocaml-shadow \
ocaml-Outcometree \
ocaml-Parsetree \
ocaml-Path \
ocaml-Ppx-derivers \
ocaml-Ppxlib \
ocaml-Ppxlib-- \
ocaml-Ppxlib--Ast-pattern \
ocaml-Ppxlib--Ast-pattern-generated \
ocaml-Ppxlib--Ast-pattern0 \
ocaml-Ppxlib--Ast-traverse \
ocaml-Ppxlib--Ast-traverse0 \
ocaml-Ppxlib--Attribute \
ocaml-Ppxlib--Code-path \
ocaml-Ppxlib--Common \
ocaml-Ppxlib--Context-free \
ocaml-Ppxlib--Driver \
ocaml-Ppxlib--Expansion-context \
ocaml-Ppxlib--Extension \
ocaml-Ppxlib--Import \
ocaml-Ppxlib--Loc \
ocaml-Ppxlib--Location \
ocaml-Ppxlib--Longident \
ocaml-Ppxlib--Name \
ocaml-Ppxlib--Utils \
ocaml-Ppxlib-ast \
ocaml-Ppxlib-ast-- \
ocaml-Ppxlib-ast--Ast \
ocaml-Ppxlib-ast--Ast-helper-lite \
ocaml-Ppxlib-ast--Import \
ocaml-Ppxlib-ast--Versions \
ocaml-Ppxlib-traverse-builtins \
ocaml-Primitive \
ocaml-Profile \
ocaml-Result \
ocaml-Sexplib0 \
ocaml-Sexplib0-- \
ocaml-Sexplib0--Sexp \
ocaml-Sexplib0--Sexp-conv \
ocaml-Sexplib0--Sexp-conv-grammar \
ocaml-Sexplib0--Sexp-grammar \
ocaml-Sexplib0--Sexpable \
ocaml-Shape \
ocaml-Stdlib \
ocaml-Stdlib--Arg \
ocaml-Stdlib--Array \
ocaml-Stdlib--Buffer \
ocaml-Stdlib--Bytes \
ocaml-Stdlib--BytesLabels \
ocaml-Stdlib--Char \
ocaml-Stdlib--Digest \
ocaml-Stdlib--Either \
ocaml-Stdlib--Filename \
ocaml-Stdlib--Format \
ocaml-Stdlib--Hashtbl \
ocaml-Stdlib--Int32 \
ocaml-Stdlib--Lazy \
ocaml-Stdlib--Lexing \
ocaml-Stdlib--List \
ocaml-Stdlib--ListLabels \
ocaml-Stdlib--Map \
ocaml-Stdlib--Obj \
ocaml-Stdlib--Option \
ocaml-Stdlib--Printf \
ocaml-Stdlib--Queue \
ocaml-Stdlib--Result \
ocaml-Stdlib--Seq \
ocaml-Stdlib--Set \
ocaml-Stdlib--StdLabels \
ocaml-Stdlib--String \
ocaml-Stdlib--StringLabels \
ocaml-Stdlib--Uchar \
ocaml-Stdppx \
ocaml-Subst \
ocaml-Type-immediacy \
ocaml-Types \
ocaml-Warnings \
ocaml-ppx-deriving \
ocamlfind-compiler-libs.common \
ocamlfind-ppx-derivers \
ocamlfind-ppxlib \
ocamlfind-ppxlib.ast \
ocamlfind-result \
ocamlx-Astlib--Pprintast \
ocamlx-CamlinternalOO \
ocamlx-Location \
ocamlx-Longident \
ocamlx-Ppx-derivers \
ocamlx-Ppxlib--Ast-traverse \
ocamlx-Ppxlib--Driver \
ocamlx-Ppxlib--Longident \
ocamlx-Ppxlib-ast--Ast-helper-lite \
ocamlx-Stdlib \
ocamlx-Stdlib--Filename \
ocamlx-Stdlib--Format \
ocamlx-Stdlib--List \
ocamlx-Stdlib--Option \
ocamlx-Stdlib--Printf \
ocamlx-Stdlib--Queue \
ocamlx-Stdlib--Set \
ocamlx-Stdlib--String"

inherit rpm
