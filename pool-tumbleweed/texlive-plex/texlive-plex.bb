SUMMARY = "Support for IBM Plex fonts"
DESCRIPTION = "The package provides LaTeX, pdfLaTeX, XeLaTeX and LuaLaTeX \
support for the IBM Plex families of fonts. Serif, Sans and \
Mono families are available in eight weights: Regular, Light, \
ExtraLight, Thin, Bold, Text, Medium and SemiBold (with \
corresponding italics)."
LICENSE = "OFL-1.1"

PV = "2023.201.svn64496"

RPM_NAME = "texlive-plex-2023.201.svn64496-52.1.noarch.rpm"
RPM_HASH = "80bdc18e4d36d6ae77141ea8409ee58bc1ecda2a8e4ccfd2ae3f018decbd1bafd6d23272e23764d06b3f3bb18cf2d882624a4a949290e9105011370c09487e02"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-IBMPlexMono-Bold-sup-ly1--base.tfm \
tex-IBMPlexMono-Bold-sup-ly1.tfm \
tex-IBMPlexMono-Bold-sup-ly1.vf \
tex-IBMPlexMono-Bold-sup-ot1.tfm \
tex-IBMPlexMono-Bold-sup-t1--base.tfm \
tex-IBMPlexMono-Bold-sup-t1.tfm \
tex-IBMPlexMono-Bold-sup-t1.vf \
tex-IBMPlexMono-Bold-tlf-ly1--base.tfm \
tex-IBMPlexMono-Bold-tlf-ly1.tfm \
tex-IBMPlexMono-Bold-tlf-ly1.vf \
tex-IBMPlexMono-Bold-tlf-ot1.tfm \
tex-IBMPlexMono-Bold-tlf-t1--base.tfm \
tex-IBMPlexMono-Bold-tlf-t1.tfm \
tex-IBMPlexMono-Bold-tlf-t1.vf \
tex-IBMPlexMono-Bold-tlf-ts1--base.tfm \
tex-IBMPlexMono-Bold-tlf-ts1.tfm \
tex-IBMPlexMono-Bold-tlf-ts1.vf \
tex-IBMPlexMono-BoldItalic-sup-ly1--base.tfm \
tex-IBMPlexMono-BoldItalic-sup-ly1.tfm \
tex-IBMPlexMono-BoldItalic-sup-ly1.vf \
tex-IBMPlexMono-BoldItalic-sup-ot1.tfm \
tex-IBMPlexMono-BoldItalic-sup-t1--base.tfm \
tex-IBMPlexMono-BoldItalic-sup-t1.tfm \
tex-IBMPlexMono-BoldItalic-sup-t1.vf \
tex-IBMPlexMono-BoldItalic-tlf-ly1--base.tfm \
tex-IBMPlexMono-BoldItalic-tlf-ly1.tfm \
tex-IBMPlexMono-BoldItalic-tlf-ly1.vf \
tex-IBMPlexMono-BoldItalic-tlf-ot1.tfm \
tex-IBMPlexMono-BoldItalic-tlf-t1--base.tfm \
tex-IBMPlexMono-BoldItalic-tlf-t1.tfm \
tex-IBMPlexMono-BoldItalic-tlf-t1.vf \
tex-IBMPlexMono-BoldItalic-tlf-ts1--base.tfm \
tex-IBMPlexMono-BoldItalic-tlf-ts1.tfm \
tex-IBMPlexMono-BoldItalic-tlf-ts1.vf \
tex-IBMPlexMono-ExtraLight-sup-ly1--base.tfm \
tex-IBMPlexMono-ExtraLight-sup-ly1.tfm \
tex-IBMPlexMono-ExtraLight-sup-ly1.vf \
tex-IBMPlexMono-ExtraLight-sup-ot1.tfm \
tex-IBMPlexMono-ExtraLight-sup-t1--base.tfm \
tex-IBMPlexMono-ExtraLight-sup-t1.tfm \
tex-IBMPlexMono-ExtraLight-sup-t1.vf \
tex-IBMPlexMono-ExtraLight-tlf-ly1--base.tfm \
tex-IBMPlexMono-ExtraLight-tlf-ly1.tfm \
tex-IBMPlexMono-ExtraLight-tlf-ly1.vf \
tex-IBMPlexMono-ExtraLight-tlf-ot1.tfm \
tex-IBMPlexMono-ExtraLight-tlf-t1--base.tfm \
tex-IBMPlexMono-ExtraLight-tlf-t1.tfm \
tex-IBMPlexMono-ExtraLight-tlf-t1.vf \
tex-IBMPlexMono-ExtraLight-tlf-ts1--base.tfm \
tex-IBMPlexMono-ExtraLight-tlf-ts1.tfm \
tex-IBMPlexMono-ExtraLight-tlf-ts1.vf \
tex-IBMPlexMono-ExtraLightItalic-sup-ly1--base.tfm \
tex-IBMPlexMono-ExtraLightItalic-sup-ly1.tfm \
tex-IBMPlexMono-ExtraLightItalic-sup-ly1.vf \
tex-IBMPlexMono-ExtraLightItalic-sup-ot1.tfm \
tex-IBMPlexMono-ExtraLightItalic-sup-t1--base.tfm \
tex-IBMPlexMono-ExtraLightItalic-sup-t1.tfm \
tex-IBMPlexMono-ExtraLightItalic-sup-t1.vf \
tex-IBMPlexMono-ExtraLightItalic-tlf-ly1--base.tfm \
tex-IBMPlexMono-ExtraLightItalic-tlf-ly1.tfm \
tex-IBMPlexMono-ExtraLightItalic-tlf-ly1.vf \
tex-IBMPlexMono-ExtraLightItalic-tlf-ot1.tfm \
tex-IBMPlexMono-ExtraLightItalic-tlf-t1--base.tfm \
tex-IBMPlexMono-ExtraLightItalic-tlf-t1.tfm \
tex-IBMPlexMono-ExtraLightItalic-tlf-t1.vf \
tex-IBMPlexMono-ExtraLightItalic-tlf-ts1--base.tfm \
tex-IBMPlexMono-ExtraLightItalic-tlf-ts1.tfm \
tex-IBMPlexMono-ExtraLightItalic-tlf-ts1.vf \
tex-IBMPlexMono-Italic-sup-ly1--base.tfm \
tex-IBMPlexMono-Italic-sup-ly1.tfm \
tex-IBMPlexMono-Italic-sup-ly1.vf \
tex-IBMPlexMono-Italic-sup-ot1.tfm \
tex-IBMPlexMono-Italic-sup-t1--base.tfm \
tex-IBMPlexMono-Italic-sup-t1.tfm \
tex-IBMPlexMono-Italic-sup-t1.vf \
tex-IBMPlexMono-Italic-tlf-ly1--base.tfm \
tex-IBMPlexMono-Italic-tlf-ly1.tfm \
tex-IBMPlexMono-Italic-tlf-ly1.vf \
tex-IBMPlexMono-Italic-tlf-ot1.tfm \
tex-IBMPlexMono-Italic-tlf-t1--base.tfm \
tex-IBMPlexMono-Italic-tlf-t1.tfm \
tex-IBMPlexMono-Italic-tlf-t1.vf \
tex-IBMPlexMono-Italic-tlf-ts1--base.tfm \
tex-IBMPlexMono-Italic-tlf-ts1.tfm \
tex-IBMPlexMono-Italic-tlf-ts1.vf \
tex-IBMPlexMono-Light-sup-ly1--base.tfm \
tex-IBMPlexMono-Light-sup-ly1.tfm \
tex-IBMPlexMono-Light-sup-ly1.vf \
tex-IBMPlexMono-Light-sup-ot1.tfm \
tex-IBMPlexMono-Light-sup-t1--base.tfm \
tex-IBMPlexMono-Light-sup-t1.tfm \
tex-IBMPlexMono-Light-sup-t1.vf \
tex-IBMPlexMono-Light-tlf-ly1--base.tfm \
tex-IBMPlexMono-Light-tlf-ly1.tfm \
tex-IBMPlexMono-Light-tlf-ly1.vf \
tex-IBMPlexMono-Light-tlf-ot1.tfm \
tex-IBMPlexMono-Light-tlf-t1--base.tfm \
tex-IBMPlexMono-Light-tlf-t1.tfm \
tex-IBMPlexMono-Light-tlf-t1.vf \
tex-IBMPlexMono-Light-tlf-ts1--base.tfm \
tex-IBMPlexMono-Light-tlf-ts1.tfm \
tex-IBMPlexMono-Light-tlf-ts1.vf \
tex-IBMPlexMono-LightItalic-sup-ly1--base.tfm \
tex-IBMPlexMono-LightItalic-sup-ly1.tfm \
tex-IBMPlexMono-LightItalic-sup-ly1.vf \
tex-IBMPlexMono-LightItalic-sup-ot1.tfm \
tex-IBMPlexMono-LightItalic-sup-t1--base.tfm \
tex-IBMPlexMono-LightItalic-sup-t1.tfm \
tex-IBMPlexMono-LightItalic-sup-t1.vf \
tex-IBMPlexMono-LightItalic-tlf-ly1--base.tfm \
tex-IBMPlexMono-LightItalic-tlf-ly1.tfm \
tex-IBMPlexMono-LightItalic-tlf-ly1.vf \
tex-IBMPlexMono-LightItalic-tlf-ot1.tfm \
tex-IBMPlexMono-LightItalic-tlf-t1--base.tfm \
tex-IBMPlexMono-LightItalic-tlf-t1.tfm \
tex-IBMPlexMono-LightItalic-tlf-t1.vf \
tex-IBMPlexMono-LightItalic-tlf-ts1--base.tfm \
tex-IBMPlexMono-LightItalic-tlf-ts1.tfm \
tex-IBMPlexMono-LightItalic-tlf-ts1.vf \
tex-IBMPlexMono-Medium-sup-ly1--base.tfm \
tex-IBMPlexMono-Medium-sup-ly1.tfm \
tex-IBMPlexMono-Medium-sup-ly1.vf \
tex-IBMPlexMono-Medium-sup-ot1.tfm \
tex-IBMPlexMono-Medium-sup-t1--base.tfm \
tex-IBMPlexMono-Medium-sup-t1.tfm \
tex-IBMPlexMono-Medium-sup-t1.vf \
tex-IBMPlexMono-Medium-tlf-ly1--base.tfm \
tex-IBMPlexMono-Medium-tlf-ly1.tfm \
tex-IBMPlexMono-Medium-tlf-ly1.vf \
tex-IBMPlexMono-Medium-tlf-ot1.tfm \
tex-IBMPlexMono-Medium-tlf-t1--base.tfm \
tex-IBMPlexMono-Medium-tlf-t1.tfm \
tex-IBMPlexMono-Medium-tlf-t1.vf \
tex-IBMPlexMono-Medium-tlf-ts1--base.tfm \
tex-IBMPlexMono-Medium-tlf-ts1.tfm \
tex-IBMPlexMono-Medium-tlf-ts1.vf \
tex-IBMPlexMono-MediumItalic-sup-ly1--base.tfm \
tex-IBMPlexMono-MediumItalic-sup-ly1.tfm \
tex-IBMPlexMono-MediumItalic-sup-ly1.vf \
tex-IBMPlexMono-MediumItalic-sup-ot1.tfm \
tex-IBMPlexMono-MediumItalic-sup-t1--base.tfm \
tex-IBMPlexMono-MediumItalic-sup-t1.tfm \
tex-IBMPlexMono-MediumItalic-sup-t1.vf \
tex-IBMPlexMono-MediumItalic-tlf-ly1--base.tfm \
tex-IBMPlexMono-MediumItalic-tlf-ly1.tfm \
tex-IBMPlexMono-MediumItalic-tlf-ly1.vf \
tex-IBMPlexMono-MediumItalic-tlf-ot1.tfm \
tex-IBMPlexMono-MediumItalic-tlf-t1--base.tfm \
tex-IBMPlexMono-MediumItalic-tlf-t1.tfm \
tex-IBMPlexMono-MediumItalic-tlf-t1.vf \
tex-IBMPlexMono-MediumItalic-tlf-ts1--base.tfm \
tex-IBMPlexMono-MediumItalic-tlf-ts1.tfm \
tex-IBMPlexMono-MediumItalic-tlf-ts1.vf \
tex-IBMPlexMono-SemiBold-sup-ly1--base.tfm \
tex-IBMPlexMono-SemiBold-sup-ly1.tfm \
tex-IBMPlexMono-SemiBold-sup-ly1.vf \
tex-IBMPlexMono-SemiBold-sup-ot1.tfm \
tex-IBMPlexMono-SemiBold-sup-t1--base.tfm \
tex-IBMPlexMono-SemiBold-sup-t1.tfm \
tex-IBMPlexMono-SemiBold-sup-t1.vf \
tex-IBMPlexMono-SemiBold-tlf-ly1--base.tfm \
tex-IBMPlexMono-SemiBold-tlf-ly1.tfm \
tex-IBMPlexMono-SemiBold-tlf-ly1.vf \
tex-IBMPlexMono-SemiBold-tlf-ot1.tfm \
tex-IBMPlexMono-SemiBold-tlf-t1--base.tfm \
tex-IBMPlexMono-SemiBold-tlf-t1.tfm \
tex-IBMPlexMono-SemiBold-tlf-t1.vf \
tex-IBMPlexMono-SemiBold-tlf-ts1--base.tfm \
tex-IBMPlexMono-SemiBold-tlf-ts1.tfm \
tex-IBMPlexMono-SemiBold-tlf-ts1.vf \
tex-IBMPlexMono-SemiBoldItalic-sup-ly1--base.tfm \
tex-IBMPlexMono-SemiBoldItalic-sup-ly1.tfm \
tex-IBMPlexMono-SemiBoldItalic-sup-ly1.vf \
tex-IBMPlexMono-SemiBoldItalic-sup-ot1.tfm \
tex-IBMPlexMono-SemiBoldItalic-sup-t1--base.tfm \
tex-IBMPlexMono-SemiBoldItalic-sup-t1.tfm \
tex-IBMPlexMono-SemiBoldItalic-sup-t1.vf \
tex-IBMPlexMono-SemiBoldItalic-tlf-ly1--base.tfm \
tex-IBMPlexMono-SemiBoldItalic-tlf-ly1.tfm \
tex-IBMPlexMono-SemiBoldItalic-tlf-ly1.vf \
tex-IBMPlexMono-SemiBoldItalic-tlf-ot1.tfm \
tex-IBMPlexMono-SemiBoldItalic-tlf-t1--base.tfm \
tex-IBMPlexMono-SemiBoldItalic-tlf-t1.tfm \
tex-IBMPlexMono-SemiBoldItalic-tlf-t1.vf \
tex-IBMPlexMono-SemiBoldItalic-tlf-ts1--base.tfm \
tex-IBMPlexMono-SemiBoldItalic-tlf-ts1.tfm \
tex-IBMPlexMono-SemiBoldItalic-tlf-ts1.vf \
tex-IBMPlexMono-Text-sup-ly1--base.tfm \
tex-IBMPlexMono-Text-sup-ly1.tfm \
tex-IBMPlexMono-Text-sup-ly1.vf \
tex-IBMPlexMono-Text-sup-ot1.tfm \
tex-IBMPlexMono-Text-sup-t1--base.tfm \
tex-IBMPlexMono-Text-sup-t1.tfm \
tex-IBMPlexMono-Text-sup-t1.vf \
tex-IBMPlexMono-Text-tlf-ly1--base.tfm \
tex-IBMPlexMono-Text-tlf-ly1.tfm \
tex-IBMPlexMono-Text-tlf-ly1.vf \
tex-IBMPlexMono-Text-tlf-ot1.tfm \
tex-IBMPlexMono-Text-tlf-t1--base.tfm \
tex-IBMPlexMono-Text-tlf-t1.tfm \
tex-IBMPlexMono-Text-tlf-t1.vf \
tex-IBMPlexMono-Text-tlf-ts1--base.tfm \
tex-IBMPlexMono-Text-tlf-ts1.tfm \
tex-IBMPlexMono-Text-tlf-ts1.vf \
tex-IBMPlexMono-TextItalic-sup-ly1--base.tfm \
tex-IBMPlexMono-TextItalic-sup-ly1.tfm \
tex-IBMPlexMono-TextItalic-sup-ly1.vf \
tex-IBMPlexMono-TextItalic-sup-ot1.tfm \
tex-IBMPlexMono-TextItalic-sup-t1--base.tfm \
tex-IBMPlexMono-TextItalic-sup-t1.tfm \
tex-IBMPlexMono-TextItalic-sup-t1.vf \
tex-IBMPlexMono-TextItalic-tlf-ly1--base.tfm \
tex-IBMPlexMono-TextItalic-tlf-ly1.tfm \
tex-IBMPlexMono-TextItalic-tlf-ly1.vf \
tex-IBMPlexMono-TextItalic-tlf-ot1.tfm \
tex-IBMPlexMono-TextItalic-tlf-t1--base.tfm \
tex-IBMPlexMono-TextItalic-tlf-t1.tfm \
tex-IBMPlexMono-TextItalic-tlf-t1.vf \
tex-IBMPlexMono-TextItalic-tlf-ts1--base.tfm \
tex-IBMPlexMono-TextItalic-tlf-ts1.tfm \
tex-IBMPlexMono-TextItalic-tlf-ts1.vf \
tex-IBMPlexMono-Thin-sup-ly1--base.tfm \
tex-IBMPlexMono-Thin-sup-ly1.tfm \
tex-IBMPlexMono-Thin-sup-ly1.vf \
tex-IBMPlexMono-Thin-sup-ot1.tfm \
tex-IBMPlexMono-Thin-sup-t1--base.tfm \
tex-IBMPlexMono-Thin-sup-t1.tfm \
tex-IBMPlexMono-Thin-sup-t1.vf \
tex-IBMPlexMono-Thin-tlf-ly1--base.tfm \
tex-IBMPlexMono-Thin-tlf-ly1.tfm \
tex-IBMPlexMono-Thin-tlf-ly1.vf \
tex-IBMPlexMono-Thin-tlf-ot1.tfm \
tex-IBMPlexMono-Thin-tlf-t1--base.tfm \
tex-IBMPlexMono-Thin-tlf-t1.tfm \
tex-IBMPlexMono-Thin-tlf-t1.vf \
tex-IBMPlexMono-Thin-tlf-ts1--base.tfm \
tex-IBMPlexMono-Thin-tlf-ts1.tfm \
tex-IBMPlexMono-Thin-tlf-ts1.vf \
tex-IBMPlexMono-ThinItalic-sup-ly1--base.tfm \
tex-IBMPlexMono-ThinItalic-sup-ly1.tfm \
tex-IBMPlexMono-ThinItalic-sup-ly1.vf \
tex-IBMPlexMono-ThinItalic-sup-ot1.tfm \
tex-IBMPlexMono-ThinItalic-sup-t1--base.tfm \
tex-IBMPlexMono-ThinItalic-sup-t1.tfm \
tex-IBMPlexMono-ThinItalic-sup-t1.vf \
tex-IBMPlexMono-ThinItalic-tlf-ly1--base.tfm \
tex-IBMPlexMono-ThinItalic-tlf-ly1.tfm \
tex-IBMPlexMono-ThinItalic-tlf-ly1.vf \
tex-IBMPlexMono-ThinItalic-tlf-ot1.tfm \
tex-IBMPlexMono-ThinItalic-tlf-t1--base.tfm \
tex-IBMPlexMono-ThinItalic-tlf-t1.tfm \
tex-IBMPlexMono-ThinItalic-tlf-t1.vf \
tex-IBMPlexMono-ThinItalic-tlf-ts1--base.tfm \
tex-IBMPlexMono-ThinItalic-tlf-ts1.tfm \
tex-IBMPlexMono-ThinItalic-tlf-ts1.vf \
tex-IBMPlexMono-sup-ly1--base.tfm \
tex-IBMPlexMono-sup-ly1.tfm \
tex-IBMPlexMono-sup-ly1.vf \
tex-IBMPlexMono-sup-ot1.tfm \
tex-IBMPlexMono-sup-t1--base.tfm \
tex-IBMPlexMono-sup-t1.tfm \
tex-IBMPlexMono-sup-t1.vf \
tex-IBMPlexMono-tlf-ly1--base.tfm \
tex-IBMPlexMono-tlf-ly1.tfm \
tex-IBMPlexMono-tlf-ly1.vf \
tex-IBMPlexMono-tlf-ot1.tfm \
tex-IBMPlexMono-tlf-t1--base.tfm \
tex-IBMPlexMono-tlf-t1.tfm \
tex-IBMPlexMono-tlf-t1.vf \
tex-IBMPlexMono-tlf-ts1--base.tfm \
tex-IBMPlexMono-tlf-ts1.tfm \
tex-IBMPlexMono-tlf-ts1.vf \
tex-IBMPlexSans-Bold-sup-lgr--base.tfm \
tex-IBMPlexSans-Bold-sup-lgr.tfm \
tex-IBMPlexSans-Bold-sup-lgr.vf \
tex-IBMPlexSans-Bold-sup-ly1--base.tfm \
tex-IBMPlexSans-Bold-sup-ly1.tfm \
tex-IBMPlexSans-Bold-sup-ly1.vf \
tex-IBMPlexSans-Bold-sup-ot1.tfm \
tex-IBMPlexSans-Bold-sup-t1--base.tfm \
tex-IBMPlexSans-Bold-sup-t1.tfm \
tex-IBMPlexSans-Bold-sup-t1.vf \
tex-IBMPlexSans-Bold-tlf-lgr--base.tfm \
tex-IBMPlexSans-Bold-tlf-lgr.tfm \
tex-IBMPlexSans-Bold-tlf-lgr.vf \
tex-IBMPlexSans-Bold-tlf-ly1--base.tfm \
tex-IBMPlexSans-Bold-tlf-ly1.tfm \
tex-IBMPlexSans-Bold-tlf-ly1.vf \
tex-IBMPlexSans-Bold-tlf-ot1.tfm \
tex-IBMPlexSans-Bold-tlf-t1--base.tfm \
tex-IBMPlexSans-Bold-tlf-t1.tfm \
tex-IBMPlexSans-Bold-tlf-t1.vf \
tex-IBMPlexSans-Bold-tlf-ts1--base.tfm \
tex-IBMPlexSans-Bold-tlf-ts1.tfm \
tex-IBMPlexSans-Bold-tlf-ts1.vf \
tex-IBMPlexSans-BoldItalic-sup-lgr--base.tfm \
tex-IBMPlexSans-BoldItalic-sup-lgr.tfm \
tex-IBMPlexSans-BoldItalic-sup-lgr.vf \
tex-IBMPlexSans-BoldItalic-sup-ly1--base.tfm \
tex-IBMPlexSans-BoldItalic-sup-ly1.tfm \
tex-IBMPlexSans-BoldItalic-sup-ly1.vf \
tex-IBMPlexSans-BoldItalic-sup-ot1.tfm \
tex-IBMPlexSans-BoldItalic-sup-t1--base.tfm \
tex-IBMPlexSans-BoldItalic-sup-t1.tfm \
tex-IBMPlexSans-BoldItalic-sup-t1.vf \
tex-IBMPlexSans-BoldItalic-tlf-lgr--base.tfm \
tex-IBMPlexSans-BoldItalic-tlf-lgr.tfm \
tex-IBMPlexSans-BoldItalic-tlf-lgr.vf \
tex-IBMPlexSans-BoldItalic-tlf-ly1--base.tfm \
tex-IBMPlexSans-BoldItalic-tlf-ly1.tfm \
tex-IBMPlexSans-BoldItalic-tlf-ly1.vf \
tex-IBMPlexSans-BoldItalic-tlf-ot1.tfm \
tex-IBMPlexSans-BoldItalic-tlf-t1--base.tfm \
tex-IBMPlexSans-BoldItalic-tlf-t1.tfm \
tex-IBMPlexSans-BoldItalic-tlf-t1.vf \
tex-IBMPlexSans-BoldItalic-tlf-ts1--base.tfm \
tex-IBMPlexSans-BoldItalic-tlf-ts1.tfm \
tex-IBMPlexSans-BoldItalic-tlf-ts1.vf \
tex-IBMPlexSans-ExtraLight-sup-lgr--base.tfm \
tex-IBMPlexSans-ExtraLight-sup-lgr.tfm \
tex-IBMPlexSans-ExtraLight-sup-lgr.vf \
tex-IBMPlexSans-ExtraLight-sup-ly1--base.tfm \
tex-IBMPlexSans-ExtraLight-sup-ly1.tfm \
tex-IBMPlexSans-ExtraLight-sup-ly1.vf \
tex-IBMPlexSans-ExtraLight-sup-ot1.tfm \
tex-IBMPlexSans-ExtraLight-sup-t1--base.tfm \
tex-IBMPlexSans-ExtraLight-sup-t1.tfm \
tex-IBMPlexSans-ExtraLight-sup-t1.vf \
tex-IBMPlexSans-ExtraLight-tlf-lgr--base.tfm \
tex-IBMPlexSans-ExtraLight-tlf-lgr.tfm \
tex-IBMPlexSans-ExtraLight-tlf-lgr.vf \
tex-IBMPlexSans-ExtraLight-tlf-ly1--base.tfm \
tex-IBMPlexSans-ExtraLight-tlf-ly1.tfm \
tex-IBMPlexSans-ExtraLight-tlf-ly1.vf \
tex-IBMPlexSans-ExtraLight-tlf-ot1.tfm \
tex-IBMPlexSans-ExtraLight-tlf-t1--base.tfm \
tex-IBMPlexSans-ExtraLight-tlf-t1.tfm \
tex-IBMPlexSans-ExtraLight-tlf-t1.vf \
tex-IBMPlexSans-ExtraLight-tlf-ts1--base.tfm \
tex-IBMPlexSans-ExtraLight-tlf-ts1.tfm \
tex-IBMPlexSans-ExtraLight-tlf-ts1.vf \
tex-IBMPlexSans-ExtraLightItalic-sup-lgr--base.tfm \
tex-IBMPlexSans-ExtraLightItalic-sup-lgr.tfm \
tex-IBMPlexSans-ExtraLightItalic-sup-lgr.vf \
tex-IBMPlexSans-ExtraLightItalic-sup-ly1--base.tfm \
tex-IBMPlexSans-ExtraLightItalic-sup-ly1.tfm \
tex-IBMPlexSans-ExtraLightItalic-sup-ly1.vf \
tex-IBMPlexSans-ExtraLightItalic-sup-ot1.tfm \
tex-IBMPlexSans-ExtraLightItalic-sup-t1--base.tfm \
tex-IBMPlexSans-ExtraLightItalic-sup-t1.tfm \
tex-IBMPlexSans-ExtraLightItalic-sup-t1.vf \
tex-IBMPlexSans-ExtraLightItalic-tlf-lgr--base.tfm \
tex-IBMPlexSans-ExtraLightItalic-tlf-lgr.tfm \
tex-IBMPlexSans-ExtraLightItalic-tlf-lgr.vf \
tex-IBMPlexSans-ExtraLightItalic-tlf-ly1--base.tfm \
tex-IBMPlexSans-ExtraLightItalic-tlf-ly1.tfm \
tex-IBMPlexSans-ExtraLightItalic-tlf-ly1.vf \
tex-IBMPlexSans-ExtraLightItalic-tlf-ot1.tfm \
tex-IBMPlexSans-ExtraLightItalic-tlf-t1--base.tfm \
tex-IBMPlexSans-ExtraLightItalic-tlf-t1.tfm \
tex-IBMPlexSans-ExtraLightItalic-tlf-t1.vf \
tex-IBMPlexSans-ExtraLightItalic-tlf-ts1--base.tfm \
tex-IBMPlexSans-ExtraLightItalic-tlf-ts1.tfm \
tex-IBMPlexSans-ExtraLightItalic-tlf-ts1.vf \
tex-IBMPlexSans-Italic-sup-lgr--base.tfm \
tex-IBMPlexSans-Italic-sup-lgr.tfm \
tex-IBMPlexSans-Italic-sup-lgr.vf \
tex-IBMPlexSans-Italic-sup-ly1--base.tfm \
tex-IBMPlexSans-Italic-sup-ly1.tfm \
tex-IBMPlexSans-Italic-sup-ly1.vf \
tex-IBMPlexSans-Italic-sup-ot1.tfm \
tex-IBMPlexSans-Italic-sup-t1--base.tfm \
tex-IBMPlexSans-Italic-sup-t1.tfm \
tex-IBMPlexSans-Italic-sup-t1.vf \
tex-IBMPlexSans-Italic-tlf-lgr--base.tfm \
tex-IBMPlexSans-Italic-tlf-lgr.tfm \
tex-IBMPlexSans-Italic-tlf-lgr.vf \
tex-IBMPlexSans-Italic-tlf-ly1--base.tfm \
tex-IBMPlexSans-Italic-tlf-ly1.tfm \
tex-IBMPlexSans-Italic-tlf-ly1.vf \
tex-IBMPlexSans-Italic-tlf-ot1.tfm \
tex-IBMPlexSans-Italic-tlf-t1--base.tfm \
tex-IBMPlexSans-Italic-tlf-t1.tfm \
tex-IBMPlexSans-Italic-tlf-t1.vf \
tex-IBMPlexSans-Italic-tlf-ts1--base.tfm \
tex-IBMPlexSans-Italic-tlf-ts1.tfm \
tex-IBMPlexSans-Italic-tlf-ts1.vf \
tex-IBMPlexSans-Light-sup-lgr--base.tfm \
tex-IBMPlexSans-Light-sup-lgr.tfm \
tex-IBMPlexSans-Light-sup-lgr.vf \
tex-IBMPlexSans-Light-sup-ly1--base.tfm \
tex-IBMPlexSans-Light-sup-ly1.tfm \
tex-IBMPlexSans-Light-sup-ly1.vf \
tex-IBMPlexSans-Light-sup-ot1.tfm \
tex-IBMPlexSans-Light-sup-t1--base.tfm \
tex-IBMPlexSans-Light-sup-t1.tfm \
tex-IBMPlexSans-Light-sup-t1.vf \
tex-IBMPlexSans-Light-tlf-lgr--base.tfm \
tex-IBMPlexSans-Light-tlf-lgr.tfm \
tex-IBMPlexSans-Light-tlf-lgr.vf \
tex-IBMPlexSans-Light-tlf-ly1--base.tfm \
tex-IBMPlexSans-Light-tlf-ly1.tfm \
tex-IBMPlexSans-Light-tlf-ly1.vf \
tex-IBMPlexSans-Light-tlf-ot1.tfm \
tex-IBMPlexSans-Light-tlf-t1--base.tfm \
tex-IBMPlexSans-Light-tlf-t1.tfm \
tex-IBMPlexSans-Light-tlf-t1.vf \
tex-IBMPlexSans-Light-tlf-ts1--base.tfm \
tex-IBMPlexSans-Light-tlf-ts1.tfm \
tex-IBMPlexSans-Light-tlf-ts1.vf \
tex-IBMPlexSans-LightItalic-sup-lgr--base.tfm \
tex-IBMPlexSans-LightItalic-sup-lgr.tfm \
tex-IBMPlexSans-LightItalic-sup-lgr.vf \
tex-IBMPlexSans-LightItalic-sup-ly1--base.tfm \
tex-IBMPlexSans-LightItalic-sup-ly1.tfm \
tex-IBMPlexSans-LightItalic-sup-ly1.vf \
tex-IBMPlexSans-LightItalic-sup-ot1.tfm \
tex-IBMPlexSans-LightItalic-sup-t1--base.tfm \
tex-IBMPlexSans-LightItalic-sup-t1.tfm \
tex-IBMPlexSans-LightItalic-sup-t1.vf \
tex-IBMPlexSans-LightItalic-tlf-lgr--base.tfm \
tex-IBMPlexSans-LightItalic-tlf-lgr.tfm \
tex-IBMPlexSans-LightItalic-tlf-lgr.vf \
tex-IBMPlexSans-LightItalic-tlf-ly1--base.tfm \
tex-IBMPlexSans-LightItalic-tlf-ly1.tfm \
tex-IBMPlexSans-LightItalic-tlf-ly1.vf \
tex-IBMPlexSans-LightItalic-tlf-ot1.tfm \
tex-IBMPlexSans-LightItalic-tlf-t1--base.tfm \
tex-IBMPlexSans-LightItalic-tlf-t1.tfm \
tex-IBMPlexSans-LightItalic-tlf-t1.vf \
tex-IBMPlexSans-LightItalic-tlf-ts1--base.tfm \
tex-IBMPlexSans-LightItalic-tlf-ts1.tfm \
tex-IBMPlexSans-LightItalic-tlf-ts1.vf \
tex-IBMPlexSans-Medium-sup-lgr--base.tfm \
tex-IBMPlexSans-Medium-sup-lgr.tfm \
tex-IBMPlexSans-Medium-sup-lgr.vf \
tex-IBMPlexSans-Medium-sup-ly1--base.tfm \
tex-IBMPlexSans-Medium-sup-ly1.tfm \
tex-IBMPlexSans-Medium-sup-ly1.vf \
tex-IBMPlexSans-Medium-sup-ot1.tfm \
tex-IBMPlexSans-Medium-sup-t1--base.tfm \
tex-IBMPlexSans-Medium-sup-t1.tfm \
tex-IBMPlexSans-Medium-sup-t1.vf \
tex-IBMPlexSans-Medium-tlf-lgr--base.tfm \
tex-IBMPlexSans-Medium-tlf-lgr.tfm \
tex-IBMPlexSans-Medium-tlf-lgr.vf \
tex-IBMPlexSans-Medium-tlf-ly1--base.tfm \
tex-IBMPlexSans-Medium-tlf-ly1.tfm \
tex-IBMPlexSans-Medium-tlf-ly1.vf \
tex-IBMPlexSans-Medium-tlf-ot1.tfm \
tex-IBMPlexSans-Medium-tlf-t1--base.tfm \
tex-IBMPlexSans-Medium-tlf-t1.tfm \
tex-IBMPlexSans-Medium-tlf-t1.vf \
tex-IBMPlexSans-Medium-tlf-ts1--base.tfm \
tex-IBMPlexSans-Medium-tlf-ts1.tfm \
tex-IBMPlexSans-Medium-tlf-ts1.vf \
tex-IBMPlexSans-MediumItalic-sup-lgr--base.tfm \
tex-IBMPlexSans-MediumItalic-sup-lgr.tfm \
tex-IBMPlexSans-MediumItalic-sup-lgr.vf \
tex-IBMPlexSans-MediumItalic-sup-ly1--base.tfm \
tex-IBMPlexSans-MediumItalic-sup-ly1.tfm \
tex-IBMPlexSans-MediumItalic-sup-ly1.vf \
tex-IBMPlexSans-MediumItalic-sup-ot1.tfm \
tex-IBMPlexSans-MediumItalic-sup-t1--base.tfm \
tex-IBMPlexSans-MediumItalic-sup-t1.tfm \
tex-IBMPlexSans-MediumItalic-sup-t1.vf \
tex-IBMPlexSans-MediumItalic-tlf-lgr--base.tfm \
tex-IBMPlexSans-MediumItalic-tlf-lgr.tfm \
tex-IBMPlexSans-MediumItalic-tlf-lgr.vf \
tex-IBMPlexSans-MediumItalic-tlf-ly1--base.tfm \
tex-IBMPlexSans-MediumItalic-tlf-ly1.tfm \
tex-IBMPlexSans-MediumItalic-tlf-ly1.vf \
tex-IBMPlexSans-MediumItalic-tlf-ot1.tfm \
tex-IBMPlexSans-MediumItalic-tlf-t1--base.tfm \
tex-IBMPlexSans-MediumItalic-tlf-t1.tfm \
tex-IBMPlexSans-MediumItalic-tlf-t1.vf \
tex-IBMPlexSans-MediumItalic-tlf-ts1--base.tfm \
tex-IBMPlexSans-MediumItalic-tlf-ts1.tfm \
tex-IBMPlexSans-MediumItalic-tlf-ts1.vf \
tex-IBMPlexSans-SemiBold-sup-lgr--base.tfm \
tex-IBMPlexSans-SemiBold-sup-lgr.tfm \
tex-IBMPlexSans-SemiBold-sup-lgr.vf \
tex-IBMPlexSans-SemiBold-sup-ly1--base.tfm \
tex-IBMPlexSans-SemiBold-sup-ly1.tfm \
tex-IBMPlexSans-SemiBold-sup-ly1.vf \
tex-IBMPlexSans-SemiBold-sup-ot1.tfm \
tex-IBMPlexSans-SemiBold-sup-t1--base.tfm \
tex-IBMPlexSans-SemiBold-sup-t1.tfm \
tex-IBMPlexSans-SemiBold-sup-t1.vf \
tex-IBMPlexSans-SemiBold-tlf-lgr--base.tfm \
tex-IBMPlexSans-SemiBold-tlf-lgr.tfm \
tex-IBMPlexSans-SemiBold-tlf-lgr.vf \
tex-IBMPlexSans-SemiBold-tlf-ly1--base.tfm \
tex-IBMPlexSans-SemiBold-tlf-ly1.tfm \
tex-IBMPlexSans-SemiBold-tlf-ly1.vf \
tex-IBMPlexSans-SemiBold-tlf-ot1.tfm \
tex-IBMPlexSans-SemiBold-tlf-t1--base.tfm \
tex-IBMPlexSans-SemiBold-tlf-t1.tfm \
tex-IBMPlexSans-SemiBold-tlf-t1.vf \
tex-IBMPlexSans-SemiBold-tlf-ts1--base.tfm \
tex-IBMPlexSans-SemiBold-tlf-ts1.tfm \
tex-IBMPlexSans-SemiBold-tlf-ts1.vf \
tex-IBMPlexSans-SemiBoldItalic-sup-lgr--base.tfm \
tex-IBMPlexSans-SemiBoldItalic-sup-lgr.tfm \
tex-IBMPlexSans-SemiBoldItalic-sup-lgr.vf \
tex-IBMPlexSans-SemiBoldItalic-sup-ly1--base.tfm \
tex-IBMPlexSans-SemiBoldItalic-sup-ly1.tfm \
tex-IBMPlexSans-SemiBoldItalic-sup-ly1.vf \
tex-IBMPlexSans-SemiBoldItalic-sup-ot1.tfm \
tex-IBMPlexSans-SemiBoldItalic-sup-t1--base.tfm \
tex-IBMPlexSans-SemiBoldItalic-sup-t1.tfm \
tex-IBMPlexSans-SemiBoldItalic-sup-t1.vf \
tex-IBMPlexSans-SemiBoldItalic-tlf-lgr--base.tfm \
tex-IBMPlexSans-SemiBoldItalic-tlf-lgr.tfm \
tex-IBMPlexSans-SemiBoldItalic-tlf-lgr.vf \
tex-IBMPlexSans-SemiBoldItalic-tlf-ly1--base.tfm \
tex-IBMPlexSans-SemiBoldItalic-tlf-ly1.tfm \
tex-IBMPlexSans-SemiBoldItalic-tlf-ly1.vf \
tex-IBMPlexSans-SemiBoldItalic-tlf-ot1.tfm \
tex-IBMPlexSans-SemiBoldItalic-tlf-t1--base.tfm \
tex-IBMPlexSans-SemiBoldItalic-tlf-t1.tfm \
tex-IBMPlexSans-SemiBoldItalic-tlf-t1.vf \
tex-IBMPlexSans-SemiBoldItalic-tlf-ts1--base.tfm \
tex-IBMPlexSans-SemiBoldItalic-tlf-ts1.tfm \
tex-IBMPlexSans-SemiBoldItalic-tlf-ts1.vf \
tex-IBMPlexSans-Text-sup-lgr--base.tfm \
tex-IBMPlexSans-Text-sup-lgr.tfm \
tex-IBMPlexSans-Text-sup-lgr.vf \
tex-IBMPlexSans-Text-sup-ly1--base.tfm \
tex-IBMPlexSans-Text-sup-ly1.tfm \
tex-IBMPlexSans-Text-sup-ly1.vf \
tex-IBMPlexSans-Text-sup-ot1.tfm \
tex-IBMPlexSans-Text-sup-t1--base.tfm \
tex-IBMPlexSans-Text-sup-t1.tfm \
tex-IBMPlexSans-Text-sup-t1.vf \
tex-IBMPlexSans-Text-tlf-lgr--base.tfm \
tex-IBMPlexSans-Text-tlf-lgr.tfm \
tex-IBMPlexSans-Text-tlf-lgr.vf \
tex-IBMPlexSans-Text-tlf-ly1--base.tfm \
tex-IBMPlexSans-Text-tlf-ly1.tfm \
tex-IBMPlexSans-Text-tlf-ly1.vf \
tex-IBMPlexSans-Text-tlf-ot1.tfm \
tex-IBMPlexSans-Text-tlf-t1--base.tfm \
tex-IBMPlexSans-Text-tlf-t1.tfm \
tex-IBMPlexSans-Text-tlf-t1.vf \
tex-IBMPlexSans-Text-tlf-ts1--base.tfm \
tex-IBMPlexSans-Text-tlf-ts1.tfm \
tex-IBMPlexSans-Text-tlf-ts1.vf \
tex-IBMPlexSans-TextItalic-sup-lgr--base.tfm \
tex-IBMPlexSans-TextItalic-sup-lgr.tfm \
tex-IBMPlexSans-TextItalic-sup-lgr.vf \
tex-IBMPlexSans-TextItalic-sup-ly1--base.tfm \
tex-IBMPlexSans-TextItalic-sup-ly1.tfm \
tex-IBMPlexSans-TextItalic-sup-ly1.vf \
tex-IBMPlexSans-TextItalic-sup-ot1.tfm \
tex-IBMPlexSans-TextItalic-sup-t1--base.tfm \
tex-IBMPlexSans-TextItalic-sup-t1.tfm \
tex-IBMPlexSans-TextItalic-sup-t1.vf \
tex-IBMPlexSans-TextItalic-tlf-lgr--base.tfm \
tex-IBMPlexSans-TextItalic-tlf-lgr.tfm \
tex-IBMPlexSans-TextItalic-tlf-lgr.vf \
tex-IBMPlexSans-TextItalic-tlf-ly1--base.tfm \
tex-IBMPlexSans-TextItalic-tlf-ly1.tfm \
tex-IBMPlexSans-TextItalic-tlf-ly1.vf \
tex-IBMPlexSans-TextItalic-tlf-ot1.tfm \
tex-IBMPlexSans-TextItalic-tlf-t1--base.tfm \
tex-IBMPlexSans-TextItalic-tlf-t1.tfm \
tex-IBMPlexSans-TextItalic-tlf-t1.vf \
tex-IBMPlexSans-TextItalic-tlf-ts1--base.tfm \
tex-IBMPlexSans-TextItalic-tlf-ts1.tfm \
tex-IBMPlexSans-TextItalic-tlf-ts1.vf \
tex-IBMPlexSans-Thin-sup-lgr--base.tfm \
tex-IBMPlexSans-Thin-sup-lgr.tfm \
tex-IBMPlexSans-Thin-sup-lgr.vf \
tex-IBMPlexSans-Thin-sup-ly1--base.tfm \
tex-IBMPlexSans-Thin-sup-ly1.tfm \
tex-IBMPlexSans-Thin-sup-ly1.vf \
tex-IBMPlexSans-Thin-sup-ot1.tfm \
tex-IBMPlexSans-Thin-sup-t1--base.tfm \
tex-IBMPlexSans-Thin-sup-t1.tfm \
tex-IBMPlexSans-Thin-sup-t1.vf \
tex-IBMPlexSans-Thin-tlf-lgr--base.tfm \
tex-IBMPlexSans-Thin-tlf-lgr.tfm \
tex-IBMPlexSans-Thin-tlf-lgr.vf \
tex-IBMPlexSans-Thin-tlf-ly1--base.tfm \
tex-IBMPlexSans-Thin-tlf-ly1.tfm \
tex-IBMPlexSans-Thin-tlf-ly1.vf \
tex-IBMPlexSans-Thin-tlf-ot1.tfm \
tex-IBMPlexSans-Thin-tlf-t1--base.tfm \
tex-IBMPlexSans-Thin-tlf-t1.tfm \
tex-IBMPlexSans-Thin-tlf-t1.vf \
tex-IBMPlexSans-Thin-tlf-ts1--base.tfm \
tex-IBMPlexSans-Thin-tlf-ts1.tfm \
tex-IBMPlexSans-Thin-tlf-ts1.vf \
tex-IBMPlexSans-ThinItalic-sup-lgr--base.tfm \
tex-IBMPlexSans-ThinItalic-sup-lgr.tfm \
tex-IBMPlexSans-ThinItalic-sup-lgr.vf \
tex-IBMPlexSans-ThinItalic-sup-ly1--base.tfm \
tex-IBMPlexSans-ThinItalic-sup-ly1.tfm \
tex-IBMPlexSans-ThinItalic-sup-ly1.vf \
tex-IBMPlexSans-ThinItalic-sup-ot1.tfm \
tex-IBMPlexSans-ThinItalic-sup-t1--base.tfm \
tex-IBMPlexSans-ThinItalic-sup-t1.tfm \
tex-IBMPlexSans-ThinItalic-sup-t1.vf \
tex-IBMPlexSans-ThinItalic-tlf-lgr--base.tfm \
tex-IBMPlexSans-ThinItalic-tlf-lgr.tfm \
tex-IBMPlexSans-ThinItalic-tlf-lgr.vf \
tex-IBMPlexSans-ThinItalic-tlf-ly1--base.tfm \
tex-IBMPlexSans-ThinItalic-tlf-ly1.tfm \
tex-IBMPlexSans-ThinItalic-tlf-ly1.vf \
tex-IBMPlexSans-ThinItalic-tlf-ot1.tfm \
tex-IBMPlexSans-ThinItalic-tlf-t1--base.tfm \
tex-IBMPlexSans-ThinItalic-tlf-t1.tfm \
tex-IBMPlexSans-ThinItalic-tlf-t1.vf \
tex-IBMPlexSans-ThinItalic-tlf-ts1--base.tfm \
tex-IBMPlexSans-ThinItalic-tlf-ts1.tfm \
tex-IBMPlexSans-ThinItalic-tlf-ts1.vf \
tex-IBMPlexSans-sup-lgr--base.tfm \
tex-IBMPlexSans-sup-lgr.tfm \
tex-IBMPlexSans-sup-lgr.vf \
tex-IBMPlexSans-sup-ly1--base.tfm \
tex-IBMPlexSans-sup-ly1.tfm \
tex-IBMPlexSans-sup-ly1.vf \
tex-IBMPlexSans-sup-ot1.tfm \
tex-IBMPlexSans-sup-t1--base.tfm \
tex-IBMPlexSans-sup-t1.tfm \
tex-IBMPlexSans-sup-t1.vf \
tex-IBMPlexSans-tlf-lgr--base.tfm \
tex-IBMPlexSans-tlf-lgr.tfm \
tex-IBMPlexSans-tlf-lgr.vf \
tex-IBMPlexSans-tlf-ly1--base.tfm \
tex-IBMPlexSans-tlf-ly1.tfm \
tex-IBMPlexSans-tlf-ly1.vf \
tex-IBMPlexSans-tlf-ot1.tfm \
tex-IBMPlexSans-tlf-t1--base.tfm \
tex-IBMPlexSans-tlf-t1.tfm \
tex-IBMPlexSans-tlf-t1.vf \
tex-IBMPlexSans-tlf-ts1--base.tfm \
tex-IBMPlexSans-tlf-ts1.tfm \
tex-IBMPlexSans-tlf-ts1.vf \
tex-IBMPlexSansCond-Bold-sup-lgr--base.tfm \
tex-IBMPlexSansCond-Bold-sup-lgr.tfm \
tex-IBMPlexSansCond-Bold-sup-lgr.vf \
tex-IBMPlexSansCond-Bold-sup-ly1--base.tfm \
tex-IBMPlexSansCond-Bold-sup-ly1.tfm \
tex-IBMPlexSansCond-Bold-sup-ly1.vf \
tex-IBMPlexSansCond-Bold-sup-ot1.tfm \
tex-IBMPlexSansCond-Bold-sup-t1--base.tfm \
tex-IBMPlexSansCond-Bold-sup-t1.tfm \
tex-IBMPlexSansCond-Bold-sup-t1.vf \
tex-IBMPlexSansCond-Bold-tlf-lgr--base.tfm \
tex-IBMPlexSansCond-Bold-tlf-lgr.tfm \
tex-IBMPlexSansCond-Bold-tlf-lgr.vf \
tex-IBMPlexSansCond-Bold-tlf-ly1--base.tfm \
tex-IBMPlexSansCond-Bold-tlf-ly1.tfm \
tex-IBMPlexSansCond-Bold-tlf-ly1.vf \
tex-IBMPlexSansCond-Bold-tlf-ot1.tfm \
tex-IBMPlexSansCond-Bold-tlf-t1--base.tfm \
tex-IBMPlexSansCond-Bold-tlf-t1.tfm \
tex-IBMPlexSansCond-Bold-tlf-t1.vf \
tex-IBMPlexSansCond-Bold-tlf-ts1--base.tfm \
tex-IBMPlexSansCond-Bold-tlf-ts1.tfm \
tex-IBMPlexSansCond-Bold-tlf-ts1.vf \
tex-IBMPlexSansCond-BoldItalic-sup-lgr--base.tfm \
tex-IBMPlexSansCond-BoldItalic-sup-lgr.tfm \
tex-IBMPlexSansCond-BoldItalic-sup-lgr.vf \
tex-IBMPlexSansCond-BoldItalic-sup-ly1--base.tfm \
tex-IBMPlexSansCond-BoldItalic-sup-ly1.tfm \
tex-IBMPlexSansCond-BoldItalic-sup-ly1.vf \
tex-IBMPlexSansCond-BoldItalic-sup-ot1.tfm \
tex-IBMPlexSansCond-BoldItalic-sup-t1--base.tfm \
tex-IBMPlexSansCond-BoldItalic-sup-t1.tfm \
tex-IBMPlexSansCond-BoldItalic-sup-t1.vf \
tex-IBMPlexSansCond-BoldItalic-tlf-lgr--base.tfm \
tex-IBMPlexSansCond-BoldItalic-tlf-lgr.tfm \
tex-IBMPlexSansCond-BoldItalic-tlf-lgr.vf \
tex-IBMPlexSansCond-BoldItalic-tlf-ly1--base.tfm \
tex-IBMPlexSansCond-BoldItalic-tlf-ly1.tfm \
tex-IBMPlexSansCond-BoldItalic-tlf-ly1.vf \
tex-IBMPlexSansCond-BoldItalic-tlf-ot1.tfm \
tex-IBMPlexSansCond-BoldItalic-tlf-t1--base.tfm \
tex-IBMPlexSansCond-BoldItalic-tlf-t1.tfm \
tex-IBMPlexSansCond-BoldItalic-tlf-t1.vf \
tex-IBMPlexSansCond-BoldItalic-tlf-ts1--base.tfm \
tex-IBMPlexSansCond-BoldItalic-tlf-ts1.tfm \
tex-IBMPlexSansCond-BoldItalic-tlf-ts1.vf \
tex-IBMPlexSansCond-ExtraLight-sup-lgr--base.tfm \
tex-IBMPlexSansCond-ExtraLight-sup-lgr.tfm \
tex-IBMPlexSansCond-ExtraLight-sup-lgr.vf \
tex-IBMPlexSansCond-ExtraLight-sup-ly1--base.tfm \
tex-IBMPlexSansCond-ExtraLight-sup-ly1.tfm \
tex-IBMPlexSansCond-ExtraLight-sup-ly1.vf \
tex-IBMPlexSansCond-ExtraLight-sup-ot1.tfm \
tex-IBMPlexSansCond-ExtraLight-sup-t1--base.tfm \
tex-IBMPlexSansCond-ExtraLight-sup-t1.tfm \
tex-IBMPlexSansCond-ExtraLight-sup-t1.vf \
tex-IBMPlexSansCond-ExtraLight-tlf-lgr--base.tfm \
tex-IBMPlexSansCond-ExtraLight-tlf-lgr.tfm \
tex-IBMPlexSansCond-ExtraLight-tlf-lgr.vf \
tex-IBMPlexSansCond-ExtraLight-tlf-ly1--base.tfm \
tex-IBMPlexSansCond-ExtraLight-tlf-ly1.tfm \
tex-IBMPlexSansCond-ExtraLight-tlf-ly1.vf \
tex-IBMPlexSansCond-ExtraLight-tlf-ot1.tfm \
tex-IBMPlexSansCond-ExtraLight-tlf-t1--base.tfm \
tex-IBMPlexSansCond-ExtraLight-tlf-t1.tfm \
tex-IBMPlexSansCond-ExtraLight-tlf-t1.vf \
tex-IBMPlexSansCond-ExtraLight-tlf-ts1--base.tfm \
tex-IBMPlexSansCond-ExtraLight-tlf-ts1.tfm \
tex-IBMPlexSansCond-ExtraLight-tlf-ts1.vf \
tex-IBMPlexSansCond-ExtraLightItalic-sup-lgr--base.tfm \
tex-IBMPlexSansCond-ExtraLightItalic-sup-lgr.tfm \
tex-IBMPlexSansCond-ExtraLightItalic-sup-lgr.vf \
tex-IBMPlexSansCond-ExtraLightItalic-sup-ly1--base.tfm \
tex-IBMPlexSansCond-ExtraLightItalic-sup-ly1.tfm \
tex-IBMPlexSansCond-ExtraLightItalic-sup-ly1.vf \
tex-IBMPlexSansCond-ExtraLightItalic-sup-ot1.tfm \
tex-IBMPlexSansCond-ExtraLightItalic-sup-t1--base.tfm \
tex-IBMPlexSansCond-ExtraLightItalic-sup-t1.tfm \
tex-IBMPlexSansCond-ExtraLightItalic-sup-t1.vf \
tex-IBMPlexSansCond-ExtraLightItalic-tlf-lgr--base.tfm \
tex-IBMPlexSansCond-ExtraLightItalic-tlf-lgr.tfm \
tex-IBMPlexSansCond-ExtraLightItalic-tlf-lgr.vf \
tex-IBMPlexSansCond-ExtraLightItalic-tlf-ly1--base.tfm \
tex-IBMPlexSansCond-ExtraLightItalic-tlf-ly1.tfm \
tex-IBMPlexSansCond-ExtraLightItalic-tlf-ly1.vf \
tex-IBMPlexSansCond-ExtraLightItalic-tlf-ot1.tfm \
tex-IBMPlexSansCond-ExtraLightItalic-tlf-t1--base.tfm \
tex-IBMPlexSansCond-ExtraLightItalic-tlf-t1.tfm \
tex-IBMPlexSansCond-ExtraLightItalic-tlf-t1.vf \
tex-IBMPlexSansCond-ExtraLightItalic-tlf-ts1--base.tfm \
tex-IBMPlexSansCond-ExtraLightItalic-tlf-ts1.tfm \
tex-IBMPlexSansCond-ExtraLightItalic-tlf-ts1.vf \
tex-IBMPlexSansCond-Italic-sup-lgr--base.tfm \
tex-IBMPlexSansCond-Italic-sup-lgr.tfm \
tex-IBMPlexSansCond-Italic-sup-lgr.vf \
tex-IBMPlexSansCond-Italic-sup-ly1--base.tfm \
tex-IBMPlexSansCond-Italic-sup-ly1.tfm \
tex-IBMPlexSansCond-Italic-sup-ly1.vf \
tex-IBMPlexSansCond-Italic-sup-ot1.tfm \
tex-IBMPlexSansCond-Italic-sup-t1--base.tfm \
tex-IBMPlexSansCond-Italic-sup-t1.tfm \
tex-IBMPlexSansCond-Italic-sup-t1.vf \
tex-IBMPlexSansCond-Italic-tlf-lgr--base.tfm \
tex-IBMPlexSansCond-Italic-tlf-lgr.tfm \
tex-IBMPlexSansCond-Italic-tlf-lgr.vf \
tex-IBMPlexSansCond-Italic-tlf-ly1--base.tfm \
tex-IBMPlexSansCond-Italic-tlf-ly1.tfm \
tex-IBMPlexSansCond-Italic-tlf-ly1.vf \
tex-IBMPlexSansCond-Italic-tlf-ot1.tfm \
tex-IBMPlexSansCond-Italic-tlf-t1--base.tfm \
tex-IBMPlexSansCond-Italic-tlf-t1.tfm \
tex-IBMPlexSansCond-Italic-tlf-t1.vf \
tex-IBMPlexSansCond-Italic-tlf-ts1--base.tfm \
tex-IBMPlexSansCond-Italic-tlf-ts1.tfm \
tex-IBMPlexSansCond-Italic-tlf-ts1.vf \
tex-IBMPlexSansCond-Light-sup-lgr--base.tfm \
tex-IBMPlexSansCond-Light-sup-lgr.tfm \
tex-IBMPlexSansCond-Light-sup-lgr.vf \
tex-IBMPlexSansCond-Light-sup-ly1--base.tfm \
tex-IBMPlexSansCond-Light-sup-ly1.tfm \
tex-IBMPlexSansCond-Light-sup-ly1.vf \
tex-IBMPlexSansCond-Light-sup-ot1.tfm \
tex-IBMPlexSansCond-Light-sup-t1--base.tfm \
tex-IBMPlexSansCond-Light-sup-t1.tfm \
tex-IBMPlexSansCond-Light-sup-t1.vf \
tex-IBMPlexSansCond-Light-tlf-lgr--base.tfm \
tex-IBMPlexSansCond-Light-tlf-lgr.tfm \
tex-IBMPlexSansCond-Light-tlf-lgr.vf \
tex-IBMPlexSansCond-Light-tlf-ly1--base.tfm \
tex-IBMPlexSansCond-Light-tlf-ly1.tfm \
tex-IBMPlexSansCond-Light-tlf-ly1.vf \
tex-IBMPlexSansCond-Light-tlf-ot1.tfm \
tex-IBMPlexSansCond-Light-tlf-t1--base.tfm \
tex-IBMPlexSansCond-Light-tlf-t1.tfm \
tex-IBMPlexSansCond-Light-tlf-t1.vf \
tex-IBMPlexSansCond-Light-tlf-ts1--base.tfm \
tex-IBMPlexSansCond-Light-tlf-ts1.tfm \
tex-IBMPlexSansCond-Light-tlf-ts1.vf \
tex-IBMPlexSansCond-LightItalic-sup-lgr--base.tfm \
tex-IBMPlexSansCond-LightItalic-sup-lgr.tfm \
tex-IBMPlexSansCond-LightItalic-sup-lgr.vf \
tex-IBMPlexSansCond-LightItalic-sup-ly1--base.tfm \
tex-IBMPlexSansCond-LightItalic-sup-ly1.tfm \
tex-IBMPlexSansCond-LightItalic-sup-ly1.vf \
tex-IBMPlexSansCond-LightItalic-sup-ot1.tfm \
tex-IBMPlexSansCond-LightItalic-sup-t1--base.tfm \
tex-IBMPlexSansCond-LightItalic-sup-t1.tfm \
tex-IBMPlexSansCond-LightItalic-sup-t1.vf \
tex-IBMPlexSansCond-LightItalic-tlf-lgr--base.tfm \
tex-IBMPlexSansCond-LightItalic-tlf-lgr.tfm \
tex-IBMPlexSansCond-LightItalic-tlf-lgr.vf \
tex-IBMPlexSansCond-LightItalic-tlf-ly1--base.tfm \
tex-IBMPlexSansCond-LightItalic-tlf-ly1.tfm \
tex-IBMPlexSansCond-LightItalic-tlf-ly1.vf \
tex-IBMPlexSansCond-LightItalic-tlf-ot1.tfm \
tex-IBMPlexSansCond-LightItalic-tlf-t1--base.tfm \
tex-IBMPlexSansCond-LightItalic-tlf-t1.tfm \
tex-IBMPlexSansCond-LightItalic-tlf-t1.vf \
tex-IBMPlexSansCond-LightItalic-tlf-ts1--base.tfm \
tex-IBMPlexSansCond-LightItalic-tlf-ts1.tfm \
tex-IBMPlexSansCond-LightItalic-tlf-ts1.vf \
tex-IBMPlexSansCond-Medium-sup-lgr--base.tfm \
tex-IBMPlexSansCond-Medium-sup-lgr.tfm \
tex-IBMPlexSansCond-Medium-sup-lgr.vf \
tex-IBMPlexSansCond-Medium-sup-ly1--base.tfm \
tex-IBMPlexSansCond-Medium-sup-ly1.tfm \
tex-IBMPlexSansCond-Medium-sup-ly1.vf \
tex-IBMPlexSansCond-Medium-sup-ot1.tfm \
tex-IBMPlexSansCond-Medium-sup-t1--base.tfm \
tex-IBMPlexSansCond-Medium-sup-t1.tfm \
tex-IBMPlexSansCond-Medium-sup-t1.vf \
tex-IBMPlexSansCond-Medium-tlf-lgr--base.tfm \
tex-IBMPlexSansCond-Medium-tlf-lgr.tfm \
tex-IBMPlexSansCond-Medium-tlf-lgr.vf \
tex-IBMPlexSansCond-Medium-tlf-ly1--base.tfm \
tex-IBMPlexSansCond-Medium-tlf-ly1.tfm \
tex-IBMPlexSansCond-Medium-tlf-ly1.vf \
tex-IBMPlexSansCond-Medium-tlf-ot1.tfm \
tex-IBMPlexSansCond-Medium-tlf-t1--base.tfm \
tex-IBMPlexSansCond-Medium-tlf-t1.tfm \
tex-IBMPlexSansCond-Medium-tlf-t1.vf \
tex-IBMPlexSansCond-Medium-tlf-ts1--base.tfm \
tex-IBMPlexSansCond-Medium-tlf-ts1.tfm \
tex-IBMPlexSansCond-Medium-tlf-ts1.vf \
tex-IBMPlexSansCond-MediumItalic-sup-lgr--base.tfm \
tex-IBMPlexSansCond-MediumItalic-sup-lgr.tfm \
tex-IBMPlexSansCond-MediumItalic-sup-lgr.vf \
tex-IBMPlexSansCond-MediumItalic-sup-ly1--base.tfm \
tex-IBMPlexSansCond-MediumItalic-sup-ly1.tfm \
tex-IBMPlexSansCond-MediumItalic-sup-ly1.vf \
tex-IBMPlexSansCond-MediumItalic-sup-ot1.tfm \
tex-IBMPlexSansCond-MediumItalic-sup-t1--base.tfm \
tex-IBMPlexSansCond-MediumItalic-sup-t1.tfm \
tex-IBMPlexSansCond-MediumItalic-sup-t1.vf \
tex-IBMPlexSansCond-MediumItalic-tlf-lgr--base.tfm \
tex-IBMPlexSansCond-MediumItalic-tlf-lgr.tfm \
tex-IBMPlexSansCond-MediumItalic-tlf-lgr.vf \
tex-IBMPlexSansCond-MediumItalic-tlf-ly1--base.tfm \
tex-IBMPlexSansCond-MediumItalic-tlf-ly1.tfm \
tex-IBMPlexSansCond-MediumItalic-tlf-ly1.vf \
tex-IBMPlexSansCond-MediumItalic-tlf-ot1.tfm \
tex-IBMPlexSansCond-MediumItalic-tlf-t1--base.tfm \
tex-IBMPlexSansCond-MediumItalic-tlf-t1.tfm \
tex-IBMPlexSansCond-MediumItalic-tlf-t1.vf \
tex-IBMPlexSansCond-MediumItalic-tlf-ts1--base.tfm \
tex-IBMPlexSansCond-MediumItalic-tlf-ts1.tfm \
tex-IBMPlexSansCond-MediumItalic-tlf-ts1.vf \
tex-IBMPlexSansCond-SemiBold-sup-lgr--base.tfm \
tex-IBMPlexSansCond-SemiBold-sup-lgr.tfm \
tex-IBMPlexSansCond-SemiBold-sup-lgr.vf \
tex-IBMPlexSansCond-SemiBold-sup-ly1--base.tfm \
tex-IBMPlexSansCond-SemiBold-sup-ly1.tfm \
tex-IBMPlexSansCond-SemiBold-sup-ly1.vf \
tex-IBMPlexSansCond-SemiBold-sup-ot1.tfm \
tex-IBMPlexSansCond-SemiBold-sup-t1--base.tfm \
tex-IBMPlexSansCond-SemiBold-sup-t1.tfm \
tex-IBMPlexSansCond-SemiBold-sup-t1.vf \
tex-IBMPlexSansCond-SemiBold-tlf-lgr--base.tfm \
tex-IBMPlexSansCond-SemiBold-tlf-lgr.tfm \
tex-IBMPlexSansCond-SemiBold-tlf-lgr.vf \
tex-IBMPlexSansCond-SemiBold-tlf-ly1--base.tfm \
tex-IBMPlexSansCond-SemiBold-tlf-ly1.tfm \
tex-IBMPlexSansCond-SemiBold-tlf-ly1.vf \
tex-IBMPlexSansCond-SemiBold-tlf-ot1.tfm \
tex-IBMPlexSansCond-SemiBold-tlf-t1--base.tfm \
tex-IBMPlexSansCond-SemiBold-tlf-t1.tfm \
tex-IBMPlexSansCond-SemiBold-tlf-t1.vf \
tex-IBMPlexSansCond-SemiBold-tlf-ts1--base.tfm \
tex-IBMPlexSansCond-SemiBold-tlf-ts1.tfm \
tex-IBMPlexSansCond-SemiBold-tlf-ts1.vf \
tex-IBMPlexSansCond-SemiBoldItalic-sup-lgr--base.tfm \
tex-IBMPlexSansCond-SemiBoldItalic-sup-lgr.tfm \
tex-IBMPlexSansCond-SemiBoldItalic-sup-lgr.vf \
tex-IBMPlexSansCond-SemiBoldItalic-sup-ly1--base.tfm \
tex-IBMPlexSansCond-SemiBoldItalic-sup-ly1.tfm \
tex-IBMPlexSansCond-SemiBoldItalic-sup-ly1.vf \
tex-IBMPlexSansCond-SemiBoldItalic-sup-ot1.tfm \
tex-IBMPlexSansCond-SemiBoldItalic-sup-t1--base.tfm \
tex-IBMPlexSansCond-SemiBoldItalic-sup-t1.tfm \
tex-IBMPlexSansCond-SemiBoldItalic-sup-t1.vf \
tex-IBMPlexSansCond-SemiBoldItalic-tlf-lgr--base.tfm \
tex-IBMPlexSansCond-SemiBoldItalic-tlf-lgr.tfm \
tex-IBMPlexSansCond-SemiBoldItalic-tlf-lgr.vf \
tex-IBMPlexSansCond-SemiBoldItalic-tlf-ly1--base.tfm \
tex-IBMPlexSansCond-SemiBoldItalic-tlf-ly1.tfm \
tex-IBMPlexSansCond-SemiBoldItalic-tlf-ly1.vf \
tex-IBMPlexSansCond-SemiBoldItalic-tlf-ot1.tfm \
tex-IBMPlexSansCond-SemiBoldItalic-tlf-t1--base.tfm \
tex-IBMPlexSansCond-SemiBoldItalic-tlf-t1.tfm \
tex-IBMPlexSansCond-SemiBoldItalic-tlf-t1.vf \
tex-IBMPlexSansCond-SemiBoldItalic-tlf-ts1--base.tfm \
tex-IBMPlexSansCond-SemiBoldItalic-tlf-ts1.tfm \
tex-IBMPlexSansCond-SemiBoldItalic-tlf-ts1.vf \
tex-IBMPlexSansCond-Text-sup-lgr--base.tfm \
tex-IBMPlexSansCond-Text-sup-lgr.tfm \
tex-IBMPlexSansCond-Text-sup-lgr.vf \
tex-IBMPlexSansCond-Text-sup-ly1--base.tfm \
tex-IBMPlexSansCond-Text-sup-ly1.tfm \
tex-IBMPlexSansCond-Text-sup-ly1.vf \
tex-IBMPlexSansCond-Text-sup-ot1.tfm \
tex-IBMPlexSansCond-Text-sup-t1--base.tfm \
tex-IBMPlexSansCond-Text-sup-t1.tfm \
tex-IBMPlexSansCond-Text-sup-t1.vf \
tex-IBMPlexSansCond-Text-tlf-lgr--base.tfm \
tex-IBMPlexSansCond-Text-tlf-lgr.tfm \
tex-IBMPlexSansCond-Text-tlf-lgr.vf \
tex-IBMPlexSansCond-Text-tlf-ly1--base.tfm \
tex-IBMPlexSansCond-Text-tlf-ly1.tfm \
tex-IBMPlexSansCond-Text-tlf-ly1.vf \
tex-IBMPlexSansCond-Text-tlf-ot1.tfm \
tex-IBMPlexSansCond-Text-tlf-t1--base.tfm \
tex-IBMPlexSansCond-Text-tlf-t1.tfm \
tex-IBMPlexSansCond-Text-tlf-t1.vf \
tex-IBMPlexSansCond-Text-tlf-ts1--base.tfm \
tex-IBMPlexSansCond-Text-tlf-ts1.tfm \
tex-IBMPlexSansCond-Text-tlf-ts1.vf \
tex-IBMPlexSansCond-TextItalic-sup-lgr--base.tfm \
tex-IBMPlexSansCond-TextItalic-sup-lgr.tfm \
tex-IBMPlexSansCond-TextItalic-sup-lgr.vf \
tex-IBMPlexSansCond-TextItalic-sup-ly1--base.tfm \
tex-IBMPlexSansCond-TextItalic-sup-ly1.tfm \
tex-IBMPlexSansCond-TextItalic-sup-ly1.vf \
tex-IBMPlexSansCond-TextItalic-sup-ot1.tfm \
tex-IBMPlexSansCond-TextItalic-sup-t1--base.tfm \
tex-IBMPlexSansCond-TextItalic-sup-t1.tfm \
tex-IBMPlexSansCond-TextItalic-sup-t1.vf \
tex-IBMPlexSansCond-TextItalic-tlf-lgr--base.tfm \
tex-IBMPlexSansCond-TextItalic-tlf-lgr.tfm \
tex-IBMPlexSansCond-TextItalic-tlf-lgr.vf \
tex-IBMPlexSansCond-TextItalic-tlf-ly1--base.tfm \
tex-IBMPlexSansCond-TextItalic-tlf-ly1.tfm \
tex-IBMPlexSansCond-TextItalic-tlf-ly1.vf \
tex-IBMPlexSansCond-TextItalic-tlf-ot1.tfm \
tex-IBMPlexSansCond-TextItalic-tlf-t1--base.tfm \
tex-IBMPlexSansCond-TextItalic-tlf-t1.tfm \
tex-IBMPlexSansCond-TextItalic-tlf-t1.vf \
tex-IBMPlexSansCond-TextItalic-tlf-ts1--base.tfm \
tex-IBMPlexSansCond-TextItalic-tlf-ts1.tfm \
tex-IBMPlexSansCond-TextItalic-tlf-ts1.vf \
tex-IBMPlexSansCond-Thin-sup-lgr--base.tfm \
tex-IBMPlexSansCond-Thin-sup-lgr.tfm \
tex-IBMPlexSansCond-Thin-sup-lgr.vf \
tex-IBMPlexSansCond-Thin-sup-ly1--base.tfm \
tex-IBMPlexSansCond-Thin-sup-ly1.tfm \
tex-IBMPlexSansCond-Thin-sup-ly1.vf \
tex-IBMPlexSansCond-Thin-sup-ot1.tfm \
tex-IBMPlexSansCond-Thin-sup-t1--base.tfm \
tex-IBMPlexSansCond-Thin-sup-t1.tfm \
tex-IBMPlexSansCond-Thin-sup-t1.vf \
tex-IBMPlexSansCond-Thin-tlf-lgr--base.tfm \
tex-IBMPlexSansCond-Thin-tlf-lgr.tfm \
tex-IBMPlexSansCond-Thin-tlf-lgr.vf \
tex-IBMPlexSansCond-Thin-tlf-ly1--base.tfm \
tex-IBMPlexSansCond-Thin-tlf-ly1.tfm \
tex-IBMPlexSansCond-Thin-tlf-ly1.vf \
tex-IBMPlexSansCond-Thin-tlf-ot1.tfm \
tex-IBMPlexSansCond-Thin-tlf-t1--base.tfm \
tex-IBMPlexSansCond-Thin-tlf-t1.tfm \
tex-IBMPlexSansCond-Thin-tlf-t1.vf \
tex-IBMPlexSansCond-Thin-tlf-ts1--base.tfm \
tex-IBMPlexSansCond-Thin-tlf-ts1.tfm \
tex-IBMPlexSansCond-Thin-tlf-ts1.vf \
tex-IBMPlexSansCond-ThinItalic-sup-lgr--base.tfm \
tex-IBMPlexSansCond-ThinItalic-sup-lgr.tfm \
tex-IBMPlexSansCond-ThinItalic-sup-lgr.vf \
tex-IBMPlexSansCond-ThinItalic-sup-ly1--base.tfm \
tex-IBMPlexSansCond-ThinItalic-sup-ly1.tfm \
tex-IBMPlexSansCond-ThinItalic-sup-ly1.vf \
tex-IBMPlexSansCond-ThinItalic-sup-ot1.tfm \
tex-IBMPlexSansCond-ThinItalic-sup-t1--base.tfm \
tex-IBMPlexSansCond-ThinItalic-sup-t1.tfm \
tex-IBMPlexSansCond-ThinItalic-sup-t1.vf \
tex-IBMPlexSansCond-ThinItalic-tlf-lgr--base.tfm \
tex-IBMPlexSansCond-ThinItalic-tlf-lgr.tfm \
tex-IBMPlexSansCond-ThinItalic-tlf-lgr.vf \
tex-IBMPlexSansCond-ThinItalic-tlf-ly1--base.tfm \
tex-IBMPlexSansCond-ThinItalic-tlf-ly1.tfm \
tex-IBMPlexSansCond-ThinItalic-tlf-ly1.vf \
tex-IBMPlexSansCond-ThinItalic-tlf-ot1.tfm \
tex-IBMPlexSansCond-ThinItalic-tlf-t1--base.tfm \
tex-IBMPlexSansCond-ThinItalic-tlf-t1.tfm \
tex-IBMPlexSansCond-ThinItalic-tlf-t1.vf \
tex-IBMPlexSansCond-ThinItalic-tlf-ts1--base.tfm \
tex-IBMPlexSansCond-ThinItalic-tlf-ts1.tfm \
tex-IBMPlexSansCond-ThinItalic-tlf-ts1.vf \
tex-IBMPlexSansCond-sup-lgr--base.tfm \
tex-IBMPlexSansCond-sup-lgr.tfm \
tex-IBMPlexSansCond-sup-lgr.vf \
tex-IBMPlexSansCond-sup-ly1--base.tfm \
tex-IBMPlexSansCond-sup-ly1.tfm \
tex-IBMPlexSansCond-sup-ly1.vf \
tex-IBMPlexSansCond-sup-ot1.tfm \
tex-IBMPlexSansCond-sup-t1--base.tfm \
tex-IBMPlexSansCond-sup-t1.tfm \
tex-IBMPlexSansCond-sup-t1.vf \
tex-IBMPlexSansCond-tlf-lgr--base.tfm \
tex-IBMPlexSansCond-tlf-lgr.tfm \
tex-IBMPlexSansCond-tlf-lgr.vf \
tex-IBMPlexSansCond-tlf-ly1--base.tfm \
tex-IBMPlexSansCond-tlf-ly1.tfm \
tex-IBMPlexSansCond-tlf-ly1.vf \
tex-IBMPlexSansCond-tlf-ot1.tfm \
tex-IBMPlexSansCond-tlf-t1--base.tfm \
tex-IBMPlexSansCond-tlf-t1.tfm \
tex-IBMPlexSansCond-tlf-t1.vf \
tex-IBMPlexSansCond-tlf-ts1--base.tfm \
tex-IBMPlexSansCond-tlf-ts1.tfm \
tex-IBMPlexSansCond-tlf-ts1.vf \
tex-IBMPlexSerif-Bold-sup-ly1--base.tfm \
tex-IBMPlexSerif-Bold-sup-ly1.tfm \
tex-IBMPlexSerif-Bold-sup-ly1.vf \
tex-IBMPlexSerif-Bold-sup-ot1.tfm \
tex-IBMPlexSerif-Bold-sup-t1--base.tfm \
tex-IBMPlexSerif-Bold-sup-t1.tfm \
tex-IBMPlexSerif-Bold-sup-t1.vf \
tex-IBMPlexSerif-Bold-tlf-ly1--base.tfm \
tex-IBMPlexSerif-Bold-tlf-ly1.tfm \
tex-IBMPlexSerif-Bold-tlf-ly1.vf \
tex-IBMPlexSerif-Bold-tlf-ot1.tfm \
tex-IBMPlexSerif-Bold-tlf-t1--base.tfm \
tex-IBMPlexSerif-Bold-tlf-t1.tfm \
tex-IBMPlexSerif-Bold-tlf-t1.vf \
tex-IBMPlexSerif-Bold-tlf-ts1--base.tfm \
tex-IBMPlexSerif-Bold-tlf-ts1.tfm \
tex-IBMPlexSerif-Bold-tlf-ts1.vf \
tex-IBMPlexSerif-BoldItalic-sup-ly1--base.tfm \
tex-IBMPlexSerif-BoldItalic-sup-ly1.tfm \
tex-IBMPlexSerif-BoldItalic-sup-ly1.vf \
tex-IBMPlexSerif-BoldItalic-sup-ot1.tfm \
tex-IBMPlexSerif-BoldItalic-sup-t1--base.tfm \
tex-IBMPlexSerif-BoldItalic-sup-t1.tfm \
tex-IBMPlexSerif-BoldItalic-sup-t1.vf \
tex-IBMPlexSerif-BoldItalic-tlf-ly1--base.tfm \
tex-IBMPlexSerif-BoldItalic-tlf-ly1.tfm \
tex-IBMPlexSerif-BoldItalic-tlf-ly1.vf \
tex-IBMPlexSerif-BoldItalic-tlf-ot1.tfm \
tex-IBMPlexSerif-BoldItalic-tlf-t1--base.tfm \
tex-IBMPlexSerif-BoldItalic-tlf-t1.tfm \
tex-IBMPlexSerif-BoldItalic-tlf-t1.vf \
tex-IBMPlexSerif-BoldItalic-tlf-ts1--base.tfm \
tex-IBMPlexSerif-BoldItalic-tlf-ts1.tfm \
tex-IBMPlexSerif-BoldItalic-tlf-ts1.vf \
tex-IBMPlexSerif-ExtraLight-sup-ly1--base.tfm \
tex-IBMPlexSerif-ExtraLight-sup-ly1.tfm \
tex-IBMPlexSerif-ExtraLight-sup-ly1.vf \
tex-IBMPlexSerif-ExtraLight-sup-ot1.tfm \
tex-IBMPlexSerif-ExtraLight-sup-t1--base.tfm \
tex-IBMPlexSerif-ExtraLight-sup-t1.tfm \
tex-IBMPlexSerif-ExtraLight-sup-t1.vf \
tex-IBMPlexSerif-ExtraLight-tlf-ly1--base.tfm \
tex-IBMPlexSerif-ExtraLight-tlf-ly1.tfm \
tex-IBMPlexSerif-ExtraLight-tlf-ly1.vf \
tex-IBMPlexSerif-ExtraLight-tlf-ot1.tfm \
tex-IBMPlexSerif-ExtraLight-tlf-t1--base.tfm \
tex-IBMPlexSerif-ExtraLight-tlf-t1.tfm \
tex-IBMPlexSerif-ExtraLight-tlf-t1.vf \
tex-IBMPlexSerif-ExtraLight-tlf-ts1--base.tfm \
tex-IBMPlexSerif-ExtraLight-tlf-ts1.tfm \
tex-IBMPlexSerif-ExtraLight-tlf-ts1.vf \
tex-IBMPlexSerif-ExtraLightItalic-sup-ly1--base.tfm \
tex-IBMPlexSerif-ExtraLightItalic-sup-ly1.tfm \
tex-IBMPlexSerif-ExtraLightItalic-sup-ly1.vf \
tex-IBMPlexSerif-ExtraLightItalic-sup-ot1.tfm \
tex-IBMPlexSerif-ExtraLightItalic-sup-t1--base.tfm \
tex-IBMPlexSerif-ExtraLightItalic-sup-t1.tfm \
tex-IBMPlexSerif-ExtraLightItalic-sup-t1.vf \
tex-IBMPlexSerif-ExtraLightItalic-tlf-ly1--base.tfm \
tex-IBMPlexSerif-ExtraLightItalic-tlf-ly1.tfm \
tex-IBMPlexSerif-ExtraLightItalic-tlf-ly1.vf \
tex-IBMPlexSerif-ExtraLightItalic-tlf-ot1.tfm \
tex-IBMPlexSerif-ExtraLightItalic-tlf-t1--base.tfm \
tex-IBMPlexSerif-ExtraLightItalic-tlf-t1.tfm \
tex-IBMPlexSerif-ExtraLightItalic-tlf-t1.vf \
tex-IBMPlexSerif-ExtraLightItalic-tlf-ts1--base.tfm \
tex-IBMPlexSerif-ExtraLightItalic-tlf-ts1.tfm \
tex-IBMPlexSerif-ExtraLightItalic-tlf-ts1.vf \
tex-IBMPlexSerif-Italic-sup-ly1--base.tfm \
tex-IBMPlexSerif-Italic-sup-ly1.tfm \
tex-IBMPlexSerif-Italic-sup-ly1.vf \
tex-IBMPlexSerif-Italic-sup-ot1.tfm \
tex-IBMPlexSerif-Italic-sup-t1--base.tfm \
tex-IBMPlexSerif-Italic-sup-t1.tfm \
tex-IBMPlexSerif-Italic-sup-t1.vf \
tex-IBMPlexSerif-Italic-tlf-ly1--base.tfm \
tex-IBMPlexSerif-Italic-tlf-ly1.tfm \
tex-IBMPlexSerif-Italic-tlf-ly1.vf \
tex-IBMPlexSerif-Italic-tlf-ot1.tfm \
tex-IBMPlexSerif-Italic-tlf-t1--base.tfm \
tex-IBMPlexSerif-Italic-tlf-t1.tfm \
tex-IBMPlexSerif-Italic-tlf-t1.vf \
tex-IBMPlexSerif-Italic-tlf-ts1--base.tfm \
tex-IBMPlexSerif-Italic-tlf-ts1.tfm \
tex-IBMPlexSerif-Italic-tlf-ts1.vf \
tex-IBMPlexSerif-Light-sup-ly1--base.tfm \
tex-IBMPlexSerif-Light-sup-ly1.tfm \
tex-IBMPlexSerif-Light-sup-ly1.vf \
tex-IBMPlexSerif-Light-sup-ot1.tfm \
tex-IBMPlexSerif-Light-sup-t1--base.tfm \
tex-IBMPlexSerif-Light-sup-t1.tfm \
tex-IBMPlexSerif-Light-sup-t1.vf \
tex-IBMPlexSerif-Light-tlf-ly1--base.tfm \
tex-IBMPlexSerif-Light-tlf-ly1.tfm \
tex-IBMPlexSerif-Light-tlf-ly1.vf \
tex-IBMPlexSerif-Light-tlf-ot1.tfm \
tex-IBMPlexSerif-Light-tlf-t1--base.tfm \
tex-IBMPlexSerif-Light-tlf-t1.tfm \
tex-IBMPlexSerif-Light-tlf-t1.vf \
tex-IBMPlexSerif-Light-tlf-ts1--base.tfm \
tex-IBMPlexSerif-Light-tlf-ts1.tfm \
tex-IBMPlexSerif-Light-tlf-ts1.vf \
tex-IBMPlexSerif-LightItalic-sup-ly1--base.tfm \
tex-IBMPlexSerif-LightItalic-sup-ly1.tfm \
tex-IBMPlexSerif-LightItalic-sup-ly1.vf \
tex-IBMPlexSerif-LightItalic-sup-ot1.tfm \
tex-IBMPlexSerif-LightItalic-sup-t1--base.tfm \
tex-IBMPlexSerif-LightItalic-sup-t1.tfm \
tex-IBMPlexSerif-LightItalic-sup-t1.vf \
tex-IBMPlexSerif-LightItalic-tlf-ly1--base.tfm \
tex-IBMPlexSerif-LightItalic-tlf-ly1.tfm \
tex-IBMPlexSerif-LightItalic-tlf-ly1.vf \
tex-IBMPlexSerif-LightItalic-tlf-ot1.tfm \
tex-IBMPlexSerif-LightItalic-tlf-t1--base.tfm \
tex-IBMPlexSerif-LightItalic-tlf-t1.tfm \
tex-IBMPlexSerif-LightItalic-tlf-t1.vf \
tex-IBMPlexSerif-LightItalic-tlf-ts1--base.tfm \
tex-IBMPlexSerif-LightItalic-tlf-ts1.tfm \
tex-IBMPlexSerif-LightItalic-tlf-ts1.vf \
tex-IBMPlexSerif-Medium-sup-ly1--base.tfm \
tex-IBMPlexSerif-Medium-sup-ly1.tfm \
tex-IBMPlexSerif-Medium-sup-ly1.vf \
tex-IBMPlexSerif-Medium-sup-ot1.tfm \
tex-IBMPlexSerif-Medium-sup-t1--base.tfm \
tex-IBMPlexSerif-Medium-sup-t1.tfm \
tex-IBMPlexSerif-Medium-sup-t1.vf \
tex-IBMPlexSerif-Medium-tlf-ly1--base.tfm \
tex-IBMPlexSerif-Medium-tlf-ly1.tfm \
tex-IBMPlexSerif-Medium-tlf-ly1.vf \
tex-IBMPlexSerif-Medium-tlf-ot1.tfm \
tex-IBMPlexSerif-Medium-tlf-t1--base.tfm \
tex-IBMPlexSerif-Medium-tlf-t1.tfm \
tex-IBMPlexSerif-Medium-tlf-t1.vf \
tex-IBMPlexSerif-Medium-tlf-ts1--base.tfm \
tex-IBMPlexSerif-Medium-tlf-ts1.tfm \
tex-IBMPlexSerif-Medium-tlf-ts1.vf \
tex-IBMPlexSerif-MediumItalic-sup-ly1--base.tfm \
tex-IBMPlexSerif-MediumItalic-sup-ly1.tfm \
tex-IBMPlexSerif-MediumItalic-sup-ly1.vf \
tex-IBMPlexSerif-MediumItalic-sup-ot1.tfm \
tex-IBMPlexSerif-MediumItalic-sup-t1--base.tfm \
tex-IBMPlexSerif-MediumItalic-sup-t1.tfm \
tex-IBMPlexSerif-MediumItalic-sup-t1.vf \
tex-IBMPlexSerif-MediumItalic-tlf-ly1--base.tfm \
tex-IBMPlexSerif-MediumItalic-tlf-ly1.tfm \
tex-IBMPlexSerif-MediumItalic-tlf-ly1.vf \
tex-IBMPlexSerif-MediumItalic-tlf-ot1.tfm \
tex-IBMPlexSerif-MediumItalic-tlf-t1--base.tfm \
tex-IBMPlexSerif-MediumItalic-tlf-t1.tfm \
tex-IBMPlexSerif-MediumItalic-tlf-t1.vf \
tex-IBMPlexSerif-MediumItalic-tlf-ts1--base.tfm \
tex-IBMPlexSerif-MediumItalic-tlf-ts1.tfm \
tex-IBMPlexSerif-MediumItalic-tlf-ts1.vf \
tex-IBMPlexSerif-SemiBold-sup-ly1--base.tfm \
tex-IBMPlexSerif-SemiBold-sup-ly1.tfm \
tex-IBMPlexSerif-SemiBold-sup-ly1.vf \
tex-IBMPlexSerif-SemiBold-sup-ot1.tfm \
tex-IBMPlexSerif-SemiBold-sup-t1--base.tfm \
tex-IBMPlexSerif-SemiBold-sup-t1.tfm \
tex-IBMPlexSerif-SemiBold-sup-t1.vf \
tex-IBMPlexSerif-SemiBold-tlf-ly1--base.tfm \
tex-IBMPlexSerif-SemiBold-tlf-ly1.tfm \
tex-IBMPlexSerif-SemiBold-tlf-ly1.vf \
tex-IBMPlexSerif-SemiBold-tlf-ot1.tfm \
tex-IBMPlexSerif-SemiBold-tlf-t1--base.tfm \
tex-IBMPlexSerif-SemiBold-tlf-t1.tfm \
tex-IBMPlexSerif-SemiBold-tlf-t1.vf \
tex-IBMPlexSerif-SemiBold-tlf-ts1--base.tfm \
tex-IBMPlexSerif-SemiBold-tlf-ts1.tfm \
tex-IBMPlexSerif-SemiBold-tlf-ts1.vf \
tex-IBMPlexSerif-SemiBoldItalic-sup-ly1--base.tfm \
tex-IBMPlexSerif-SemiBoldItalic-sup-ly1.tfm \
tex-IBMPlexSerif-SemiBoldItalic-sup-ly1.vf \
tex-IBMPlexSerif-SemiBoldItalic-sup-ot1.tfm \
tex-IBMPlexSerif-SemiBoldItalic-sup-t1--base.tfm \
tex-IBMPlexSerif-SemiBoldItalic-sup-t1.tfm \
tex-IBMPlexSerif-SemiBoldItalic-sup-t1.vf \
tex-IBMPlexSerif-SemiBoldItalic-tlf-ly1--base.tfm \
tex-IBMPlexSerif-SemiBoldItalic-tlf-ly1.tfm \
tex-IBMPlexSerif-SemiBoldItalic-tlf-ly1.vf \
tex-IBMPlexSerif-SemiBoldItalic-tlf-ot1.tfm \
tex-IBMPlexSerif-SemiBoldItalic-tlf-t1--base.tfm \
tex-IBMPlexSerif-SemiBoldItalic-tlf-t1.tfm \
tex-IBMPlexSerif-SemiBoldItalic-tlf-t1.vf \
tex-IBMPlexSerif-SemiBoldItalic-tlf-ts1--base.tfm \
tex-IBMPlexSerif-SemiBoldItalic-tlf-ts1.tfm \
tex-IBMPlexSerif-SemiBoldItalic-tlf-ts1.vf \
tex-IBMPlexSerif-Text-sup-ly1--base.tfm \
tex-IBMPlexSerif-Text-sup-ly1.tfm \
tex-IBMPlexSerif-Text-sup-ly1.vf \
tex-IBMPlexSerif-Text-sup-ot1.tfm \
tex-IBMPlexSerif-Text-sup-t1--base.tfm \
tex-IBMPlexSerif-Text-sup-t1.tfm \
tex-IBMPlexSerif-Text-sup-t1.vf \
tex-IBMPlexSerif-Text-tlf-ly1--base.tfm \
tex-IBMPlexSerif-Text-tlf-ly1.tfm \
tex-IBMPlexSerif-Text-tlf-ly1.vf \
tex-IBMPlexSerif-Text-tlf-ot1.tfm \
tex-IBMPlexSerif-Text-tlf-t1--base.tfm \
tex-IBMPlexSerif-Text-tlf-t1.tfm \
tex-IBMPlexSerif-Text-tlf-t1.vf \
tex-IBMPlexSerif-Text-tlf-ts1--base.tfm \
tex-IBMPlexSerif-Text-tlf-ts1.tfm \
tex-IBMPlexSerif-Text-tlf-ts1.vf \
tex-IBMPlexSerif-TextItalic-sup-ly1--base.tfm \
tex-IBMPlexSerif-TextItalic-sup-ly1.tfm \
tex-IBMPlexSerif-TextItalic-sup-ly1.vf \
tex-IBMPlexSerif-TextItalic-sup-ot1.tfm \
tex-IBMPlexSerif-TextItalic-sup-t1--base.tfm \
tex-IBMPlexSerif-TextItalic-sup-t1.tfm \
tex-IBMPlexSerif-TextItalic-sup-t1.vf \
tex-IBMPlexSerif-TextItalic-tlf-ly1--base.tfm \
tex-IBMPlexSerif-TextItalic-tlf-ly1.tfm \
tex-IBMPlexSerif-TextItalic-tlf-ly1.vf \
tex-IBMPlexSerif-TextItalic-tlf-ot1.tfm \
tex-IBMPlexSerif-TextItalic-tlf-t1--base.tfm \
tex-IBMPlexSerif-TextItalic-tlf-t1.tfm \
tex-IBMPlexSerif-TextItalic-tlf-t1.vf \
tex-IBMPlexSerif-TextItalic-tlf-ts1--base.tfm \
tex-IBMPlexSerif-TextItalic-tlf-ts1.tfm \
tex-IBMPlexSerif-TextItalic-tlf-ts1.vf \
tex-IBMPlexSerif-Thin-sup-ly1--base.tfm \
tex-IBMPlexSerif-Thin-sup-ly1.tfm \
tex-IBMPlexSerif-Thin-sup-ly1.vf \
tex-IBMPlexSerif-Thin-sup-ot1.tfm \
tex-IBMPlexSerif-Thin-sup-t1--base.tfm \
tex-IBMPlexSerif-Thin-sup-t1.tfm \
tex-IBMPlexSerif-Thin-sup-t1.vf \
tex-IBMPlexSerif-Thin-tlf-ly1--base.tfm \
tex-IBMPlexSerif-Thin-tlf-ly1.tfm \
tex-IBMPlexSerif-Thin-tlf-ly1.vf \
tex-IBMPlexSerif-Thin-tlf-ot1.tfm \
tex-IBMPlexSerif-Thin-tlf-t1--base.tfm \
tex-IBMPlexSerif-Thin-tlf-t1.tfm \
tex-IBMPlexSerif-Thin-tlf-t1.vf \
tex-IBMPlexSerif-Thin-tlf-ts1--base.tfm \
tex-IBMPlexSerif-Thin-tlf-ts1.tfm \
tex-IBMPlexSerif-Thin-tlf-ts1.vf \
tex-IBMPlexSerif-ThinItalic-sup-ly1--base.tfm \
tex-IBMPlexSerif-ThinItalic-sup-ly1.tfm \
tex-IBMPlexSerif-ThinItalic-sup-ly1.vf \
tex-IBMPlexSerif-ThinItalic-sup-ot1.tfm \
tex-IBMPlexSerif-ThinItalic-sup-t1--base.tfm \
tex-IBMPlexSerif-ThinItalic-sup-t1.tfm \
tex-IBMPlexSerif-ThinItalic-sup-t1.vf \
tex-IBMPlexSerif-ThinItalic-tlf-ly1--base.tfm \
tex-IBMPlexSerif-ThinItalic-tlf-ly1.tfm \
tex-IBMPlexSerif-ThinItalic-tlf-ly1.vf \
tex-IBMPlexSerif-ThinItalic-tlf-ot1.tfm \
tex-IBMPlexSerif-ThinItalic-tlf-t1--base.tfm \
tex-IBMPlexSerif-ThinItalic-tlf-t1.tfm \
tex-IBMPlexSerif-ThinItalic-tlf-t1.vf \
tex-IBMPlexSerif-ThinItalic-tlf-ts1--base.tfm \
tex-IBMPlexSerif-ThinItalic-tlf-ts1.tfm \
tex-IBMPlexSerif-ThinItalic-tlf-ts1.vf \
tex-IBMPlexSerif-sup-ly1--base.tfm \
tex-IBMPlexSerif-sup-ly1.tfm \
tex-IBMPlexSerif-sup-ly1.vf \
tex-IBMPlexSerif-sup-ot1.tfm \
tex-IBMPlexSerif-sup-t1--base.tfm \
tex-IBMPlexSerif-sup-t1.tfm \
tex-IBMPlexSerif-sup-t1.vf \
tex-IBMPlexSerif-tlf-ly1--base.tfm \
tex-IBMPlexSerif-tlf-ly1.tfm \
tex-IBMPlexSerif-tlf-ly1.vf \
tex-IBMPlexSerif-tlf-ot1.tfm \
tex-IBMPlexSerif-tlf-t1--base.tfm \
tex-IBMPlexSerif-tlf-t1.tfm \
tex-IBMPlexSerif-tlf-t1.vf \
tex-IBMPlexSerif-tlf-ts1--base.tfm \
tex-IBMPlexSerif-tlf-ts1.tfm \
tex-IBMPlexSerif-tlf-ts1.vf \
tex-LGRIBMPlexSans-Sup.fd \
tex-LGRIBMPlexSans-TLF.fd \
tex-LY1IBMPlexMono-Sup.fd \
tex-LY1IBMPlexMono-TLF.fd \
tex-LY1IBMPlexSans-Sup.fd \
tex-LY1IBMPlexSans-TLF.fd \
tex-LY1IBMPlexSerif-Sup.fd \
tex-LY1IBMPlexSerif-TLF.fd \
tex-OT1IBMPlexMono-Sup.fd \
tex-OT1IBMPlexMono-TLF.fd \
tex-OT1IBMPlexSans-Sup.fd \
tex-OT1IBMPlexSans-TLF.fd \
tex-OT1IBMPlexSerif-Sup.fd \
tex-OT1IBMPlexSerif-TLF.fd \
tex-T1IBMPlexMono-Sup.fd \
tex-T1IBMPlexMono-TLF.fd \
tex-T1IBMPlexSans-Sup.fd \
tex-T1IBMPlexSans-TLF.fd \
tex-T1IBMPlexSerif-Sup.fd \
tex-T1IBMPlexSerif-TLF.fd \
tex-TS1IBMPlexMono-TLF.fd \
tex-TS1IBMPlexSans-TLF.fd \
tex-TS1IBMPlexSerif-TLF.fd \
tex-plex-mono.sty \
tex-plex-sans.sty \
tex-plex-serif.sty \
tex-plex.map \
tex-plx-2hzyxp.enc \
tex-plx-4hck4s.enc \
tex-plx-6tuc4c.enc \
tex-plx-dzqm4q.enc \
tex-plx-errukl.enc \
tex-plx-eywvcp.enc \
tex-plx-h3p6bl.enc \
tex-plx-hrol52.enc \
tex-plx-imandq.enc \
tex-plx-lfnaaq.enc \
tex-plx-lxmhqh.enc \
tex-plx-mnk4s5.enc \
tex-plx-n2etni.enc \
tex-plx-nzsfse.enc \
tex-plx-ojqnwd.enc \
tex-plx-oqvkyq.enc \
tex-plx-qdoxri.enc \
tex-plx-sebx3h.enc \
tex-plx-tibbib.enc \
tex-plx-toaz2j.enc \
tex-plx-umrhwx.enc \
tex-plx-vf6q7q.enc \
tex-plx-wot2a6.enc \
tex-plx-x4zmfh.enc \
tex-plx-xl2q4z.enc \
texlive-plex"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontaxes.sty \
tex-fontenc.sty \
tex-fontspec.sty \
tex-ifluatex.sty \
tex-ifxetex.sty \
tex-mweights.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-plex-fonts \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
