SUMMARY = "Severed fonts for texlive-drm"
DESCRIPTION = "The  separated fonts package for texlive-drm"
LICENSE = "LPPL-1.0"

PV = "2023.201.4.4svn38157"

RPM_NAME = "texlive-drm-fonts-2023.201.4.4svn38157-52.1.noarch.rpm"
RPM_HASH = "c60744332065bac64d4858c982e5f2d9227e6fce9c226df78486707498fe81309c1f65e6037a1d6ccc5160eea702f24670ba095b5ec1bdeba64f7f90dfaa6a07"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "config(texlive-drm-fonts) \
font(:lang=aa) \
font(:lang=an) \
font(:lang=ay) \
font(:lang=bi) \
font(:lang=br) \
font(:lang=ch) \
font(:lang=co) \
font(:lang=crh) \
font(:lang=cs) \
font(:lang=csb) \
font(:lang=da) \
font(:lang=de) \
font(:lang=en) \
font(:lang=es) \
font(:lang=et) \
font(:lang=eu) \
font(:lang=fi) \
font(:lang=fil) \
font(:lang=fj) \
font(:lang=fo) \
font(:lang=fr) \
font(:lang=fur) \
font(:lang=fy) \
font(:lang=gd) \
font(:lang=gl) \
font(:lang=gv) \
font(:lang=ho) \
font(:lang=hsb) \
font(:lang=ht) \
font(:lang=hu) \
font(:lang=ia) \
font(:lang=id) \
font(:lang=ie) \
font(:lang=io) \
font(:lang=is) \
font(:lang=it) \
font(:lang=jv) \
font(:lang=kj) \
font(:lang=ku-tr) \
font(:lang=kwm) \
font(:lang=lb) \
font(:lang=lg) \
font(:lang=li) \
font(:lang=mg) \
font(:lang=ms) \
font(:lang=nb) \
font(:lang=nds) \
font(:lang=ng) \
font(:lang=nl) \
font(:lang=nn) \
font(:lang=no) \
font(:lang=nr) \
font(:lang=nso) \
font(:lang=oc) \
font(:lang=om) \
font(:lang=pap-an) \
font(:lang=pap-aw) \
font(:lang=pl) \
font(:lang=pt) \
font(:lang=rm) \
font(:lang=rn) \
font(:lang=rw) \
font(:lang=sc) \
font(:lang=sg) \
font(:lang=sk) \
font(:lang=sma) \
font(:lang=smj) \
font(:lang=sn) \
font(:lang=so) \
font(:lang=sq) \
font(:lang=ss) \
font(:lang=st) \
font(:lang=su) \
font(:lang=sv) \
font(:lang=sw) \
font(:lang=tk) \
font(:lang=tl) \
font(:lang=tn) \
font(:lang=tr) \
font(:lang=ts) \
font(:lang=uz) \
font(:lang=vo) \
font(:lang=vot) \
font(:lang=wa) \
font(:lang=wen) \
font(:lang=wo) \
font(:lang=xh) \
font(:lang=yap) \
font(:lang=za) \
font(:lang=zu) \
font(drm10) \
font(drm11) \
font(drm12) \
font(drm14) \
font(drm17) \
font(drm24) \
font(drm6) \
font(drm7) \
font(drm8) \
font(drm9) \
font(drmb10) \
font(drmb11) \
font(drmb12) \
font(drmb14) \
font(drmb17) \
font(drmb24) \
font(drmb6) \
font(drmb7) \
font(drmb8) \
font(drmb9) \
font(drmbx10) \
font(drmbx11) \
font(drmbx12) \
font(drmbx14) \
font(drmbx17) \
font(drmbx24) \
font(drmbx6) \
font(drmbx7) \
font(drmbx8) \
font(drmbx9) \
font(drmdoz10) \
font(drmdoz11) \
font(drmdoz12) \
font(drmdoz14) \
font(drmdoz17) \
font(drmdoz24) \
font(drmdoz6) \
font(drmdoz7) \
font(drmdoz8) \
font(drmdoz9) \
font(drmdozb10) \
font(drmdozb11) \
font(drmdozb12) \
font(drmdozb14) \
font(drmdozb17) \
font(drmdozb24) \
font(drmdozb6) \
font(drmdozb7) \
font(drmdozb8) \
font(drmdozb9) \
font(drmdozbx10) \
font(drmdozbx11) \
font(drmdozbx12) \
font(drmdozbx14) \
font(drmdozbx17) \
font(drmdozbx24) \
font(drmdozbx6) \
font(drmdozbx7) \
font(drmdozbx8) \
font(drmdozbx9) \
font(drmdozit10) \
font(drmdozit11) \
font(drmdozit12) \
font(drmdozit14) \
font(drmdozit17) \
font(drmdozit24) \
font(drmdozit6) \
font(drmdozit7) \
font(drmdozit8) \
font(drmdozit9) \
font(drmdozitbx10) \
font(drmdozitbx11) \
font(drmdozitbx12) \
font(drmdozitbx14) \
font(drmdozitbx17) \
font(drmdozitbx24) \
font(drmdozitbx6) \
font(drmdozitbx7) \
font(drmdozitbx8) \
font(drmdozitbx9) \
font(drmdozitsc10) \
font(drmdozitsc11) \
font(drmdozitsc12) \
font(drmdozitsc14) \
font(drmdozitsc17) \
font(drmdozitsc24) \
font(drmdozitsc6) \
font(drmdozitsc7) \
font(drmdozitsc8) \
font(drmdozitsc9) \
font(drmdozittc10) \
font(drmdozittc11) \
font(drmdozittc12) \
font(drmdozittc14) \
font(drmdozittc17) \
font(drmdozittc24) \
font(drmdozittc6) \
font(drmdozittc7) \
font(drmdozittc8) \
font(drmdozittc9) \
font(drmdozl10) \
font(drmdozl11) \
font(drmdozl12) \
font(drmdozl14) \
font(drmdozl17) \
font(drmdozl24) \
font(drmdozl6) \
font(drmdozl7) \
font(drmdozl8) \
font(drmdozl9) \
font(drmdozsc10) \
font(drmdozsc11) \
font(drmdozsc12) \
font(drmdozsc14) \
font(drmdozsc17) \
font(drmdozsc24) \
font(drmdozsc6) \
font(drmdozsc7) \
font(drmdozsc8) \
font(drmdozsc9) \
font(drmdozscbx10) \
font(drmdozscbx11) \
font(drmdozscbx12) \
font(drmdozscbx14) \
font(drmdozscbx17) \
font(drmdozscbx24) \
font(drmdozscbx6) \
font(drmdozscbx7) \
font(drmdozscbx8) \
font(drmdozscbx9) \
font(drmdozsl10) \
font(drmdozsl11) \
font(drmdozsl12) \
font(drmdozsl14) \
font(drmdozsl17) \
font(drmdozsl24) \
font(drmdozsl6) \
font(drmdozsl7) \
font(drmdozsl8) \
font(drmdozsl9) \
font(drmdoztc10) \
font(drmdoztc11) \
font(drmdoztc12) \
font(drmdoztc14) \
font(drmdoztc17) \
font(drmdoztc24) \
font(drmdoztc6) \
font(drmdoztc7) \
font(drmdoztc8) \
font(drmdoztc9) \
font(drmdoztcbx10) \
font(drmdoztcbx11) \
font(drmdoztcbx12) \
font(drmdoztcbx14) \
font(drmdoztcbx17) \
font(drmdoztcbx24) \
font(drmdoztcbx6) \
font(drmdoztcbx7) \
font(drmdoztcbx8) \
font(drmdoztcbx9) \
font(drmdozui10) \
font(drmdozui11) \
font(drmdozui12) \
font(drmdozui14) \
font(drmdozui17) \
font(drmdozui24) \
font(drmdozui6) \
font(drmdozui7) \
font(drmdozui8) \
font(drmdozui9) \
font(drmdozuibx10) \
font(drmdozuibx11) \
font(drmdozuibx12) \
font(drmdozuibx14) \
font(drmdozuibx17) \
font(drmdozuibx24) \
font(drmdozuibx6) \
font(drmdozuibx7) \
font(drmdozuibx8) \
font(drmdozuibx9) \
font(drmfigs10) \
font(drmfigs11) \
font(drmfigs12) \
font(drmfigs14) \
font(drmfigs17) \
font(drmfigs24) \
font(drmfigs6) \
font(drmfigs7) \
font(drmfigs8) \
font(drmfigs9) \
font(drmgrk10) \
font(drminf10) \
font(drminf11) \
font(drminf12) \
font(drminf14) \
font(drminf17) \
font(drminf24) \
font(drminf6) \
font(drminf7) \
font(drminf8) \
font(drminf9) \
font(drmit10) \
font(drmit11) \
font(drmit12) \
font(drmit14) \
font(drmit17) \
font(drmit24) \
font(drmit6) \
font(drmit7) \
font(drmit8) \
font(drmit9) \
font(drmitbx10) \
font(drmitbx11) \
font(drmitbx12) \
font(drmitbx14) \
font(drmitbx17) \
font(drmitbx24) \
font(drmitbx6) \
font(drmitbx7) \
font(drmitbx8) \
font(drmitbx9) \
font(drmitsc10) \
font(drmitsc11) \
font(drmitsc12) \
font(drmitsc14) \
font(drmitsc17) \
font(drmitsc24) \
font(drmitsc6) \
font(drmitsc7) \
font(drmitsc8) \
font(drmitsc9) \
font(drmittc10) \
font(drmittc11) \
font(drmittc12) \
font(drmittc14) \
font(drmittc17) \
font(drmittc24) \
font(drmittc6) \
font(drmittc7) \
font(drmittc8) \
font(drmittc9) \
font(drml10) \
font(drml11) \
font(drml12) \
font(drml14) \
font(drml17) \
font(drml24) \
font(drml6) \
font(drml7) \
font(drml8) \
font(drml9) \
font(drmmi10) \
font(drmsc10) \
font(drmsc11) \
font(drmsc12) \
font(drmsc14) \
font(drmsc17) \
font(drmsc24) \
font(drmsc6) \
font(drmsc7) \
font(drmsc8) \
font(drmsc9) \
font(drmscbx10) \
font(drmscbx11) \
font(drmscbx12) \
font(drmscbx14) \
font(drmscbx17) \
font(drmscbx24) \
font(drmscbx6) \
font(drmscbx7) \
font(drmscbx8) \
font(drmscbx9) \
font(drmsl10) \
font(drmsl11) \
font(drmsl12) \
font(drmsl14) \
font(drmsl17) \
font(drmsl24) \
font(drmsl6) \
font(drmsl7) \
font(drmsl8) \
font(drmsl9) \
font(drmsy10) \
font(drmsym10) \
font(drmsym11) \
font(drmsym12) \
font(drmsym14) \
font(drmsym17) \
font(drmsym24) \
font(drmsym7) \
font(drmsym8) \
font(drmsym9) \
font(drmtc10) \
font(drmtc11) \
font(drmtc12) \
font(drmtc14) \
font(drmtc17) \
font(drmtc24) \
font(drmtc6) \
font(drmtc7) \
font(drmtc8) \
font(drmtc9) \
font(drmtcbx10) \
font(drmtcbx11) \
font(drmtcbx12) \
font(drmtcbx14) \
font(drmtcbx17) \
font(drmtcbx24) \
font(drmtcbx6) \
font(drmtcbx7) \
font(drmtcbx8) \
font(drmtcbx9) \
font(drmui10) \
font(drmui11) \
font(drmui12) \
font(drmui14) \
font(drmui17) \
font(drmui24) \
font(drmui6) \
font(drmui7) \
font(drmui8) \
font(drmui9) \
font(drmuibx10) \
font(drmuibx11) \
font(drmuibx12) \
font(drmuibx14) \
font(drmuibx17) \
font(drmuibx24) \
font(drmuibx6) \
font(drmuibx7) \
font(drmuibx8) \
font(drmuibx9) \
texlive-drm-fonts"
RDEPENDS:${PN} += "/bin/sh \
aaa_base \
coreutils \
fontconfig \
ghostscript-fonts-std \
perl"

inherit rpm
