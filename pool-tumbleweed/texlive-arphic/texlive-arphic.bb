SUMMARY = "Arphic (Chinese) font packages"
DESCRIPTION = "These are font bundles for the Chinese Arphic fonts which work \
with the CJK package. TrueType versions of these fonts for use \
with XeLaTeX and LuaLaTeX are provided by the arphic-ttf \
package. Arphic is actually the name of the company which \
created these fonts (and put them under a GPL-like licence)."
LICENSE = "LPPL-1.0"

PV = "2023.201.svn15878"

RPM_NAME = "texlive-arphic-2023.201.svn15878-53.1.noarch.rpm"
RPM_HASH = "1c380bedaa16254daeec8387807635ba597e83731d056f0cd290b3c878d20762ec04ca12d1ad36fa6a8633261beb2e8f88d3474da1644372f8a0893f8cd8d071"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-bkaimp00.tfm \
tex-bkaimp00.vf \
tex-bkaimp01.tfm \
tex-bkaimp01.vf \
tex-bkaimp02.tfm \
tex-bkaimp02.vf \
tex-bkaimp03.tfm \
tex-bkaimp03.vf \
tex-bkaimp04.tfm \
tex-bkaimp04.vf \
tex-bkaimp05.tfm \
tex-bkaimp05.vf \
tex-bkaimp06.tfm \
tex-bkaimp06.vf \
tex-bkaimp07.tfm \
tex-bkaimp07.vf \
tex-bkaimp08.tfm \
tex-bkaimp08.vf \
tex-bkaimp09.tfm \
tex-bkaimp09.vf \
tex-bkaimp10.tfm \
tex-bkaimp10.vf \
tex-bkaimp11.tfm \
tex-bkaimp11.vf \
tex-bkaimp12.tfm \
tex-bkaimp12.vf \
tex-bkaimp13.tfm \
tex-bkaimp13.vf \
tex-bkaimp14.tfm \
tex-bkaimp14.vf \
tex-bkaimp15.tfm \
tex-bkaimp15.vf \
tex-bkaimp16.tfm \
tex-bkaimp16.vf \
tex-bkaimp17.tfm \
tex-bkaimp17.vf \
tex-bkaimp18.tfm \
tex-bkaimp18.vf \
tex-bkaimp19.tfm \
tex-bkaimp19.vf \
tex-bkaimp20.tfm \
tex-bkaimp20.vf \
tex-bkaimp21.tfm \
tex-bkaimp21.vf \
tex-bkaimp22.tfm \
tex-bkaimp22.vf \
tex-bkaimp23.tfm \
tex-bkaimp23.vf \
tex-bkaimp25.tfm \
tex-bkaimp25.vf \
tex-bkaimp26.tfm \
tex-bkaimp26.vf \
tex-bkaimp27.tfm \
tex-bkaimp27.vf \
tex-bkaimp28.tfm \
tex-bkaimp28.vf \
tex-bkaimp29.tfm \
tex-bkaimp29.vf \
tex-bkaimp30.tfm \
tex-bkaimp30.vf \
tex-bkaimp31.tfm \
tex-bkaimp31.vf \
tex-bkaimp32.tfm \
tex-bkaimp32.vf \
tex-bkaimp33.tfm \
tex-bkaimp33.vf \
tex-bkaimp34.tfm \
tex-bkaimp34.vf \
tex-bkaimp35.tfm \
tex-bkaimp35.vf \
tex-bkaimp36.tfm \
tex-bkaimp36.vf \
tex-bkaimp37.tfm \
tex-bkaimp37.vf \
tex-bkaimp38.tfm \
tex-bkaimp38.vf \
tex-bkaimp39.tfm \
tex-bkaimp39.vf \
tex-bkaimp40.tfm \
tex-bkaimp40.vf \
tex-bkaimp41.tfm \
tex-bkaimp41.vf \
tex-bkaimp42.tfm \
tex-bkaimp42.vf \
tex-bkaimp43.tfm \
tex-bkaimp43.vf \
tex-bkaimp44.tfm \
tex-bkaimp44.vf \
tex-bkaimp45.tfm \
tex-bkaimp45.vf \
tex-bkaimp46.tfm \
tex-bkaimp46.vf \
tex-bkaimp47.tfm \
tex-bkaimp47.vf \
tex-bkaimp48.tfm \
tex-bkaimp48.vf \
tex-bkaimp49.tfm \
tex-bkaimp49.vf \
tex-bkaimp50.tfm \
tex-bkaimp50.vf \
tex-bkaimp51.tfm \
tex-bkaimp51.vf \
tex-bkaimp52.tfm \
tex-bkaimp52.vf \
tex-bkaimp53.tfm \
tex-bkaimp53.vf \
tex-bkaimp54.tfm \
tex-bkaimp54.vf \
tex-bkaimp55.tfm \
tex-bkaimp55.vf \
tex-bkaimpv.tfm \
tex-bkaimpv.vf \
tex-bkaiu.map \
tex-bkaiu00.tfm \
tex-bkaiu02.tfm \
tex-bkaiu03.tfm \
tex-bkaiu20.tfm \
tex-bkaiu21.tfm \
tex-bkaiu22.tfm \
tex-bkaiu25.tfm \
tex-bkaiu26.tfm \
tex-bkaiu30.tfm \
tex-bkaiu31.tfm \
tex-bkaiu32.tfm \
tex-bkaiu33.tfm \
tex-bkaiu4e.tfm \
tex-bkaiu4f.tfm \
tex-bkaiu50.tfm \
tex-bkaiu51.tfm \
tex-bkaiu52.tfm \
tex-bkaiu53.tfm \
tex-bkaiu54.tfm \
tex-bkaiu55.tfm \
tex-bkaiu56.tfm \
tex-bkaiu57.tfm \
tex-bkaiu58.tfm \
tex-bkaiu59.tfm \
tex-bkaiu5a.tfm \
tex-bkaiu5b.tfm \
tex-bkaiu5c.tfm \
tex-bkaiu5d.tfm \
tex-bkaiu5e.tfm \
tex-bkaiu5f.tfm \
tex-bkaiu60.tfm \
tex-bkaiu61.tfm \
tex-bkaiu62.tfm \
tex-bkaiu63.tfm \
tex-bkaiu64.tfm \
tex-bkaiu65.tfm \
tex-bkaiu66.tfm \
tex-bkaiu67.tfm \
tex-bkaiu68.tfm \
tex-bkaiu69.tfm \
tex-bkaiu6a.tfm \
tex-bkaiu6b.tfm \
tex-bkaiu6c.tfm \
tex-bkaiu6d.tfm \
tex-bkaiu6e.tfm \
tex-bkaiu6f.tfm \
tex-bkaiu70.tfm \
tex-bkaiu71.tfm \
tex-bkaiu72.tfm \
tex-bkaiu73.tfm \
tex-bkaiu74.tfm \
tex-bkaiu75.tfm \
tex-bkaiu76.tfm \
tex-bkaiu77.tfm \
tex-bkaiu78.tfm \
tex-bkaiu79.tfm \
tex-bkaiu7a.tfm \
tex-bkaiu7b.tfm \
tex-bkaiu7c.tfm \
tex-bkaiu7d.tfm \
tex-bkaiu7e.tfm \
tex-bkaiu7f.tfm \
tex-bkaiu80.tfm \
tex-bkaiu81.tfm \
tex-bkaiu82.tfm \
tex-bkaiu83.tfm \
tex-bkaiu84.tfm \
tex-bkaiu85.tfm \
tex-bkaiu86.tfm \
tex-bkaiu87.tfm \
tex-bkaiu88.tfm \
tex-bkaiu89.tfm \
tex-bkaiu8a.tfm \
tex-bkaiu8b.tfm \
tex-bkaiu8c.tfm \
tex-bkaiu8d.tfm \
tex-bkaiu8e.tfm \
tex-bkaiu8f.tfm \
tex-bkaiu90.tfm \
tex-bkaiu91.tfm \
tex-bkaiu92.tfm \
tex-bkaiu93.tfm \
tex-bkaiu94.tfm \
tex-bkaiu95.tfm \
tex-bkaiu96.tfm \
tex-bkaiu97.tfm \
tex-bkaiu98.tfm \
tex-bkaiu99.tfm \
tex-bkaiu9a.tfm \
tex-bkaiu9b.tfm \
tex-bkaiu9c.tfm \
tex-bkaiu9d.tfm \
tex-bkaiu9e.tfm \
tex-bkaiu9f.tfm \
tex-bkaiuee.tfm \
tex-bkaiuf6.tfm \
tex-bkaiuf7.tfm \
tex-bkaiuf8.tfm \
tex-bkaiufa.tfm \
tex-bkaiufe.tfm \
tex-bkaiuff.tfm \
tex-bkaiuv.tfm \
tex-bsmilp00.tfm \
tex-bsmilp00.vf \
tex-bsmilp01.tfm \
tex-bsmilp01.vf \
tex-bsmilp02.tfm \
tex-bsmilp02.vf \
tex-bsmilp03.tfm \
tex-bsmilp03.vf \
tex-bsmilp04.tfm \
tex-bsmilp04.vf \
tex-bsmilp05.tfm \
tex-bsmilp05.vf \
tex-bsmilp06.tfm \
tex-bsmilp06.vf \
tex-bsmilp07.tfm \
tex-bsmilp07.vf \
tex-bsmilp08.tfm \
tex-bsmilp08.vf \
tex-bsmilp09.tfm \
tex-bsmilp09.vf \
tex-bsmilp10.tfm \
tex-bsmilp10.vf \
tex-bsmilp11.tfm \
tex-bsmilp11.vf \
tex-bsmilp12.tfm \
tex-bsmilp12.vf \
tex-bsmilp13.tfm \
tex-bsmilp13.vf \
tex-bsmilp14.tfm \
tex-bsmilp14.vf \
tex-bsmilp15.tfm \
tex-bsmilp15.vf \
tex-bsmilp16.tfm \
tex-bsmilp16.vf \
tex-bsmilp17.tfm \
tex-bsmilp17.vf \
tex-bsmilp18.tfm \
tex-bsmilp18.vf \
tex-bsmilp19.tfm \
tex-bsmilp19.vf \
tex-bsmilp20.tfm \
tex-bsmilp20.vf \
tex-bsmilp21.tfm \
tex-bsmilp21.vf \
tex-bsmilp22.tfm \
tex-bsmilp22.vf \
tex-bsmilp23.tfm \
tex-bsmilp23.vf \
tex-bsmilp25.tfm \
tex-bsmilp25.vf \
tex-bsmilp26.tfm \
tex-bsmilp26.vf \
tex-bsmilp27.tfm \
tex-bsmilp27.vf \
tex-bsmilp28.tfm \
tex-bsmilp28.vf \
tex-bsmilp29.tfm \
tex-bsmilp29.vf \
tex-bsmilp30.tfm \
tex-bsmilp30.vf \
tex-bsmilp31.tfm \
tex-bsmilp31.vf \
tex-bsmilp32.tfm \
tex-bsmilp32.vf \
tex-bsmilp33.tfm \
tex-bsmilp33.vf \
tex-bsmilp34.tfm \
tex-bsmilp34.vf \
tex-bsmilp35.tfm \
tex-bsmilp35.vf \
tex-bsmilp36.tfm \
tex-bsmilp36.vf \
tex-bsmilp37.tfm \
tex-bsmilp37.vf \
tex-bsmilp38.tfm \
tex-bsmilp38.vf \
tex-bsmilp39.tfm \
tex-bsmilp39.vf \
tex-bsmilp40.tfm \
tex-bsmilp40.vf \
tex-bsmilp41.tfm \
tex-bsmilp41.vf \
tex-bsmilp42.tfm \
tex-bsmilp42.vf \
tex-bsmilp43.tfm \
tex-bsmilp43.vf \
tex-bsmilp44.tfm \
tex-bsmilp44.vf \
tex-bsmilp45.tfm \
tex-bsmilp45.vf \
tex-bsmilp46.tfm \
tex-bsmilp46.vf \
tex-bsmilp47.tfm \
tex-bsmilp47.vf \
tex-bsmilp48.tfm \
tex-bsmilp48.vf \
tex-bsmilp49.tfm \
tex-bsmilp49.vf \
tex-bsmilp50.tfm \
tex-bsmilp50.vf \
tex-bsmilp51.tfm \
tex-bsmilp51.vf \
tex-bsmilp52.tfm \
tex-bsmilp52.vf \
tex-bsmilp53.tfm \
tex-bsmilp53.vf \
tex-bsmilp54.tfm \
tex-bsmilp54.vf \
tex-bsmilp55.tfm \
tex-bsmilp55.vf \
tex-bsmilpv.tfm \
tex-bsmilpv.vf \
tex-bsmiu.map \
tex-bsmiu00.tfm \
tex-bsmiu02.tfm \
tex-bsmiu03.tfm \
tex-bsmiu20.tfm \
tex-bsmiu21.tfm \
tex-bsmiu22.tfm \
tex-bsmiu25.tfm \
tex-bsmiu26.tfm \
tex-bsmiu30.tfm \
tex-bsmiu31.tfm \
tex-bsmiu32.tfm \
tex-bsmiu33.tfm \
tex-bsmiu4e.tfm \
tex-bsmiu4f.tfm \
tex-bsmiu50.tfm \
tex-bsmiu51.tfm \
tex-bsmiu52.tfm \
tex-bsmiu53.tfm \
tex-bsmiu54.tfm \
tex-bsmiu55.tfm \
tex-bsmiu56.tfm \
tex-bsmiu57.tfm \
tex-bsmiu58.tfm \
tex-bsmiu59.tfm \
tex-bsmiu5a.tfm \
tex-bsmiu5b.tfm \
tex-bsmiu5c.tfm \
tex-bsmiu5d.tfm \
tex-bsmiu5e.tfm \
tex-bsmiu5f.tfm \
tex-bsmiu60.tfm \
tex-bsmiu61.tfm \
tex-bsmiu62.tfm \
tex-bsmiu63.tfm \
tex-bsmiu64.tfm \
tex-bsmiu65.tfm \
tex-bsmiu66.tfm \
tex-bsmiu67.tfm \
tex-bsmiu68.tfm \
tex-bsmiu69.tfm \
tex-bsmiu6a.tfm \
tex-bsmiu6b.tfm \
tex-bsmiu6c.tfm \
tex-bsmiu6d.tfm \
tex-bsmiu6e.tfm \
tex-bsmiu6f.tfm \
tex-bsmiu70.tfm \
tex-bsmiu71.tfm \
tex-bsmiu72.tfm \
tex-bsmiu73.tfm \
tex-bsmiu74.tfm \
tex-bsmiu75.tfm \
tex-bsmiu76.tfm \
tex-bsmiu77.tfm \
tex-bsmiu78.tfm \
tex-bsmiu79.tfm \
tex-bsmiu7a.tfm \
tex-bsmiu7b.tfm \
tex-bsmiu7c.tfm \
tex-bsmiu7d.tfm \
tex-bsmiu7e.tfm \
tex-bsmiu7f.tfm \
tex-bsmiu80.tfm \
tex-bsmiu81.tfm \
tex-bsmiu82.tfm \
tex-bsmiu83.tfm \
tex-bsmiu84.tfm \
tex-bsmiu85.tfm \
tex-bsmiu86.tfm \
tex-bsmiu87.tfm \
tex-bsmiu88.tfm \
tex-bsmiu89.tfm \
tex-bsmiu8a.tfm \
tex-bsmiu8b.tfm \
tex-bsmiu8c.tfm \
tex-bsmiu8d.tfm \
tex-bsmiu8e.tfm \
tex-bsmiu8f.tfm \
tex-bsmiu90.tfm \
tex-bsmiu91.tfm \
tex-bsmiu92.tfm \
tex-bsmiu93.tfm \
tex-bsmiu94.tfm \
tex-bsmiu95.tfm \
tex-bsmiu96.tfm \
tex-bsmiu97.tfm \
tex-bsmiu98.tfm \
tex-bsmiu99.tfm \
tex-bsmiu9a.tfm \
tex-bsmiu9b.tfm \
tex-bsmiu9c.tfm \
tex-bsmiu9d.tfm \
tex-bsmiu9e.tfm \
tex-bsmiu9f.tfm \
tex-bsmiuee.tfm \
tex-bsmiuf6.tfm \
tex-bsmiuf7.tfm \
tex-bsmiuf8.tfm \
tex-bsmiufa.tfm \
tex-bsmiufe.tfm \
tex-bsmiuff.tfm \
tex-bsmiuv.tfm \
tex-gbsnlp00.tfm \
tex-gbsnlp00.vf \
tex-gbsnlp01.tfm \
tex-gbsnlp01.vf \
tex-gbsnlp02.tfm \
tex-gbsnlp02.vf \
tex-gbsnlp03.tfm \
tex-gbsnlp03.vf \
tex-gbsnlp04.tfm \
tex-gbsnlp04.vf \
tex-gbsnlp06.tfm \
tex-gbsnlp06.vf \
tex-gbsnlp07.tfm \
tex-gbsnlp07.vf \
tex-gbsnlp08.tfm \
tex-gbsnlp08.vf \
tex-gbsnlp09.tfm \
tex-gbsnlp09.vf \
tex-gbsnlp10.tfm \
tex-gbsnlp10.vf \
tex-gbsnlp11.tfm \
tex-gbsnlp11.vf \
tex-gbsnlp12.tfm \
tex-gbsnlp12.vf \
tex-gbsnlp13.tfm \
tex-gbsnlp13.vf \
tex-gbsnlp14.tfm \
tex-gbsnlp14.vf \
tex-gbsnlp15.tfm \
tex-gbsnlp15.vf \
tex-gbsnlp16.tfm \
tex-gbsnlp16.vf \
tex-gbsnlp17.tfm \
tex-gbsnlp17.vf \
tex-gbsnlp18.tfm \
tex-gbsnlp18.vf \
tex-gbsnlp19.tfm \
tex-gbsnlp19.vf \
tex-gbsnlp20.tfm \
tex-gbsnlp20.vf \
tex-gbsnlp21.tfm \
tex-gbsnlp21.vf \
tex-gbsnlp22.tfm \
tex-gbsnlp22.vf \
tex-gbsnlp23.tfm \
tex-gbsnlp23.vf \
tex-gbsnlp24.tfm \
tex-gbsnlp24.vf \
tex-gbsnlp25.tfm \
tex-gbsnlp25.vf \
tex-gbsnlp26.tfm \
tex-gbsnlp26.vf \
tex-gbsnlp27.tfm \
tex-gbsnlp27.vf \
tex-gbsnlp28.tfm \
tex-gbsnlp28.vf \
tex-gbsnlp29.tfm \
tex-gbsnlp29.vf \
tex-gbsnlp30.tfm \
tex-gbsnlp30.vf \
tex-gbsnlp31.tfm \
tex-gbsnlp31.vf \
tex-gbsnlp32.tfm \
tex-gbsnlp32.vf \
tex-gbsnu.map \
tex-gbsnu00.tfm \
tex-gbsnu01.tfm \
tex-gbsnu02.tfm \
tex-gbsnu03.tfm \
tex-gbsnu04.tfm \
tex-gbsnu20.tfm \
tex-gbsnu21.tfm \
tex-gbsnu22.tfm \
tex-gbsnu23.tfm \
tex-gbsnu24.tfm \
tex-gbsnu25.tfm \
tex-gbsnu26.tfm \
tex-gbsnu30.tfm \
tex-gbsnu31.tfm \
tex-gbsnu32.tfm \
tex-gbsnu4e.tfm \
tex-gbsnu4f.tfm \
tex-gbsnu50.tfm \
tex-gbsnu51.tfm \
tex-gbsnu52.tfm \
tex-gbsnu53.tfm \
tex-gbsnu54.tfm \
tex-gbsnu55.tfm \
tex-gbsnu56.tfm \
tex-gbsnu57.tfm \
tex-gbsnu58.tfm \
tex-gbsnu59.tfm \
tex-gbsnu5a.tfm \
tex-gbsnu5b.tfm \
tex-gbsnu5c.tfm \
tex-gbsnu5d.tfm \
tex-gbsnu5e.tfm \
tex-gbsnu5f.tfm \
tex-gbsnu60.tfm \
tex-gbsnu61.tfm \
tex-gbsnu62.tfm \
tex-gbsnu63.tfm \
tex-gbsnu64.tfm \
tex-gbsnu65.tfm \
tex-gbsnu66.tfm \
tex-gbsnu67.tfm \
tex-gbsnu68.tfm \
tex-gbsnu69.tfm \
tex-gbsnu6a.tfm \
tex-gbsnu6b.tfm \
tex-gbsnu6c.tfm \
tex-gbsnu6d.tfm \
tex-gbsnu6e.tfm \
tex-gbsnu6f.tfm \
tex-gbsnu70.tfm \
tex-gbsnu71.tfm \
tex-gbsnu72.tfm \
tex-gbsnu73.tfm \
tex-gbsnu74.tfm \
tex-gbsnu75.tfm \
tex-gbsnu76.tfm \
tex-gbsnu77.tfm \
tex-gbsnu78.tfm \
tex-gbsnu79.tfm \
tex-gbsnu7a.tfm \
tex-gbsnu7b.tfm \
tex-gbsnu7c.tfm \
tex-gbsnu7d.tfm \
tex-gbsnu7e.tfm \
tex-gbsnu7f.tfm \
tex-gbsnu80.tfm \
tex-gbsnu81.tfm \
tex-gbsnu82.tfm \
tex-gbsnu83.tfm \
tex-gbsnu84.tfm \
tex-gbsnu85.tfm \
tex-gbsnu86.tfm \
tex-gbsnu87.tfm \
tex-gbsnu88.tfm \
tex-gbsnu89.tfm \
tex-gbsnu8a.tfm \
tex-gbsnu8b.tfm \
tex-gbsnu8c.tfm \
tex-gbsnu8d.tfm \
tex-gbsnu8e.tfm \
tex-gbsnu8f.tfm \
tex-gbsnu90.tfm \
tex-gbsnu91.tfm \
tex-gbsnu92.tfm \
tex-gbsnu93.tfm \
tex-gbsnu94.tfm \
tex-gbsnu95.tfm \
tex-gbsnu96.tfm \
tex-gbsnu97.tfm \
tex-gbsnu98.tfm \
tex-gbsnu99.tfm \
tex-gbsnu9a.tfm \
tex-gbsnu9b.tfm \
tex-gbsnu9c.tfm \
tex-gbsnu9e.tfm \
tex-gbsnu9f.tfm \
tex-gbsnufe.tfm \
tex-gbsnuff.tfm \
tex-gkaimp00.tfm \
tex-gkaimp00.vf \
tex-gkaimp01.tfm \
tex-gkaimp01.vf \
tex-gkaimp02.tfm \
tex-gkaimp02.vf \
tex-gkaimp03.tfm \
tex-gkaimp03.vf \
tex-gkaimp04.tfm \
tex-gkaimp04.vf \
tex-gkaimp06.tfm \
tex-gkaimp06.vf \
tex-gkaimp07.tfm \
tex-gkaimp07.vf \
tex-gkaimp08.tfm \
tex-gkaimp08.vf \
tex-gkaimp09.tfm \
tex-gkaimp09.vf \
tex-gkaimp10.tfm \
tex-gkaimp10.vf \
tex-gkaimp11.tfm \
tex-gkaimp11.vf \
tex-gkaimp12.tfm \
tex-gkaimp12.vf \
tex-gkaimp13.tfm \
tex-gkaimp13.vf \
tex-gkaimp14.tfm \
tex-gkaimp14.vf \
tex-gkaimp15.tfm \
tex-gkaimp15.vf \
tex-gkaimp16.tfm \
tex-gkaimp16.vf \
tex-gkaimp17.tfm \
tex-gkaimp17.vf \
tex-gkaimp18.tfm \
tex-gkaimp18.vf \
tex-gkaimp19.tfm \
tex-gkaimp19.vf \
tex-gkaimp20.tfm \
tex-gkaimp20.vf \
tex-gkaimp21.tfm \
tex-gkaimp21.vf \
tex-gkaimp22.tfm \
tex-gkaimp22.vf \
tex-gkaimp23.tfm \
tex-gkaimp23.vf \
tex-gkaimp24.tfm \
tex-gkaimp24.vf \
tex-gkaimp25.tfm \
tex-gkaimp25.vf \
tex-gkaimp26.tfm \
tex-gkaimp26.vf \
tex-gkaimp27.tfm \
tex-gkaimp27.vf \
tex-gkaimp28.tfm \
tex-gkaimp28.vf \
tex-gkaimp29.tfm \
tex-gkaimp29.vf \
tex-gkaimp30.tfm \
tex-gkaimp30.vf \
tex-gkaimp31.tfm \
tex-gkaimp31.vf \
tex-gkaimp32.tfm \
tex-gkaimp32.vf \
tex-gkaiu.map \
tex-gkaiu00.tfm \
tex-gkaiu01.tfm \
tex-gkaiu02.tfm \
tex-gkaiu03.tfm \
tex-gkaiu04.tfm \
tex-gkaiu20.tfm \
tex-gkaiu21.tfm \
tex-gkaiu22.tfm \
tex-gkaiu23.tfm \
tex-gkaiu24.tfm \
tex-gkaiu25.tfm \
tex-gkaiu26.tfm \
tex-gkaiu30.tfm \
tex-gkaiu31.tfm \
tex-gkaiu32.tfm \
tex-gkaiu4e.tfm \
tex-gkaiu4f.tfm \
tex-gkaiu50.tfm \
tex-gkaiu51.tfm \
tex-gkaiu52.tfm \
tex-gkaiu53.tfm \
tex-gkaiu54.tfm \
tex-gkaiu55.tfm \
tex-gkaiu56.tfm \
tex-gkaiu57.tfm \
tex-gkaiu58.tfm \
tex-gkaiu59.tfm \
tex-gkaiu5a.tfm \
tex-gkaiu5b.tfm \
tex-gkaiu5c.tfm \
tex-gkaiu5d.tfm \
tex-gkaiu5e.tfm \
tex-gkaiu5f.tfm \
tex-gkaiu60.tfm \
tex-gkaiu61.tfm \
tex-gkaiu62.tfm \
tex-gkaiu63.tfm \
tex-gkaiu64.tfm \
tex-gkaiu65.tfm \
tex-gkaiu66.tfm \
tex-gkaiu67.tfm \
tex-gkaiu68.tfm \
tex-gkaiu69.tfm \
tex-gkaiu6a.tfm \
tex-gkaiu6b.tfm \
tex-gkaiu6c.tfm \
tex-gkaiu6d.tfm \
tex-gkaiu6e.tfm \
tex-gkaiu6f.tfm \
tex-gkaiu70.tfm \
tex-gkaiu71.tfm \
tex-gkaiu72.tfm \
tex-gkaiu73.tfm \
tex-gkaiu74.tfm \
tex-gkaiu75.tfm \
tex-gkaiu76.tfm \
tex-gkaiu77.tfm \
tex-gkaiu78.tfm \
tex-gkaiu79.tfm \
tex-gkaiu7a.tfm \
tex-gkaiu7b.tfm \
tex-gkaiu7c.tfm \
tex-gkaiu7d.tfm \
tex-gkaiu7e.tfm \
tex-gkaiu7f.tfm \
tex-gkaiu80.tfm \
tex-gkaiu81.tfm \
tex-gkaiu82.tfm \
tex-gkaiu83.tfm \
tex-gkaiu84.tfm \
tex-gkaiu85.tfm \
tex-gkaiu86.tfm \
tex-gkaiu87.tfm \
tex-gkaiu88.tfm \
tex-gkaiu89.tfm \
tex-gkaiu8a.tfm \
tex-gkaiu8b.tfm \
tex-gkaiu8c.tfm \
tex-gkaiu8d.tfm \
tex-gkaiu8e.tfm \
tex-gkaiu8f.tfm \
tex-gkaiu90.tfm \
tex-gkaiu91.tfm \
tex-gkaiu92.tfm \
tex-gkaiu93.tfm \
tex-gkaiu94.tfm \
tex-gkaiu95.tfm \
tex-gkaiu96.tfm \
tex-gkaiu97.tfm \
tex-gkaiu98.tfm \
tex-gkaiu99.tfm \
tex-gkaiu9a.tfm \
tex-gkaiu9b.tfm \
tex-gkaiu9c.tfm \
tex-gkaiu9e.tfm \
tex-gkaiu9f.tfm \
tex-gkaiufe.tfm \
tex-gkaiuff.tfm \
texlive-arphic"

RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-updmap.cfg \
texlive \
texlive-arphic-fonts \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
