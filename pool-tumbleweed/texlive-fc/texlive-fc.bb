SUMMARY = "Fonts for African languages"
DESCRIPTION = "The fonts are provided as Metafont source, in the familiar \
arrangement of lots of (autogenerated) preamble files and a \
modest set of glyph specifications. (A similar arrangement \
appears in the ec and lh font bundles.)"
LICENSE = "GPL-2.0-or-later"

PV = "2023.201.1.4svn32796"

RPM_NAME = "texlive-fc-2023.201.1.4svn32796-52.1.noarch.rpm"
RPM_HASH = "fb8ac973e485d8457fbd26c0492771a9d0252ca9abd2ef947e1d5701421bc05dfc516695e4ff9d783d786714b459f1640411ea18c51b274889a5d3e90d498840"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-fcbx10.tfm \
tex-fcbx11.tfm \
tex-fcbx12.tfm \
tex-fcbx14.tfm \
tex-fcbx17.tfm \
tex-fcbx20.tfm \
tex-fcbx25.tfm \
tex-fcbx5.tfm \
tex-fcbx6.tfm \
tex-fcbx7.tfm \
tex-fcbx8.tfm \
tex-fcbx9.tfm \
tex-fcbxi10.tfm \
tex-fcbxi11.tfm \
tex-fcbxi12.tfm \
tex-fcbxi14.tfm \
tex-fcbxi17.tfm \
tex-fcbxi20.tfm \
tex-fcbxi25.tfm \
tex-fcbxi5.tfm \
tex-fcbxi6.tfm \
tex-fcbxi7.tfm \
tex-fcbxi8.tfm \
tex-fcbxi9.tfm \
tex-fcbxsl10.tfm \
tex-fcbxsl11.tfm \
tex-fcbxsl12.tfm \
tex-fcbxsl14.tfm \
tex-fcbxsl17.tfm \
tex-fcbxsl20.tfm \
tex-fcbxsl25.tfm \
tex-fcbxsl5.tfm \
tex-fcbxsl6.tfm \
tex-fcbxsl7.tfm \
tex-fcbxsl8.tfm \
tex-fcbxsl9.tfm \
tex-fcbxu10.tfm \
tex-fcbxu11.tfm \
tex-fcbxu12.tfm \
tex-fcbxu14.tfm \
tex-fcbxu17.tfm \
tex-fcbxu20.tfm \
tex-fcbxu25.tfm \
tex-fcbxu5.tfm \
tex-fcbxu6.tfm \
tex-fcbxu7.tfm \
tex-fcbxu8.tfm \
tex-fcbxu9.tfm \
tex-fccsc10.tfm \
tex-fccsc11.tfm \
tex-fccsc12.tfm \
tex-fccsc14.tfm \
tex-fccsc17.tfm \
tex-fccsc20.tfm \
tex-fccsc25.tfm \
tex-fccsc5.tfm \
tex-fccsc6.tfm \
tex-fccsc7.tfm \
tex-fccsc8.tfm \
tex-fccsc9.tfm \
tex-fci10.tfm \
tex-fci11.tfm \
tex-fci12.tfm \
tex-fci14.tfm \
tex-fci17.tfm \
tex-fci20.tfm \
tex-fci25.tfm \
tex-fci5.tfm \
tex-fci6.tfm \
tex-fci7.tfm \
tex-fci8.tfm \
tex-fci9.tfm \
tex-fcitt10.tfm \
tex-fcitt11.tfm \
tex-fcitt12.tfm \
tex-fcitt14.tfm \
tex-fcitt17.tfm \
tex-fcitt20.tfm \
tex-fcitt25.tfm \
tex-fcitt5.tfm \
tex-fcitt6.tfm \
tex-fcitt7.tfm \
tex-fcitt8.tfm \
tex-fcitt9.tfm \
tex-fclfont.sty \
tex-fcr10.tfm \
tex-fcr11.tfm \
tex-fcr12.tfm \
tex-fcr14.tfm \
tex-fcr17.tfm \
tex-fcr20.tfm \
tex-fcr25.tfm \
tex-fcr5.tfm \
tex-fcr6.tfm \
tex-fcr7.tfm \
tex-fcr8.tfm \
tex-fcr9.tfm \
tex-fcsibx10.tfm \
tex-fcsibx11.tfm \
tex-fcsibx12.tfm \
tex-fcsibx14.tfm \
tex-fcsibx17.tfm \
tex-fcsibx20.tfm \
tex-fcsibx25.tfm \
tex-fcsibx5.tfm \
tex-fcsibx6.tfm \
tex-fcsibx7.tfm \
tex-fcsibx8.tfm \
tex-fcsibx9.tfm \
tex-fcsitt10.tfm \
tex-fcsitt11.tfm \
tex-fcsitt12.tfm \
tex-fcsitt14.tfm \
tex-fcsitt17.tfm \
tex-fcsitt20.tfm \
tex-fcsitt25.tfm \
tex-fcsitt5.tfm \
tex-fcsitt6.tfm \
tex-fcsitt7.tfm \
tex-fcsitt8.tfm \
tex-fcsitt9.tfm \
tex-fcsl10.tfm \
tex-fcsl11.tfm \
tex-fcsl12.tfm \
tex-fcsl14.tfm \
tex-fcsl17.tfm \
tex-fcsl20.tfm \
tex-fcsl25.tfm \
tex-fcsl5.tfm \
tex-fcsl6.tfm \
tex-fcsl7.tfm \
tex-fcsl8.tfm \
tex-fcsl9.tfm \
tex-fcss10.tfm \
tex-fcss11.tfm \
tex-fcss12.tfm \
tex-fcss14.tfm \
tex-fcss17.tfm \
tex-fcss20.tfm \
tex-fcss25.tfm \
tex-fcss5.tfm \
tex-fcss6.tfm \
tex-fcss7.tfm \
tex-fcss8.tfm \
tex-fcss9.tfm \
tex-fcssbx10.tfm \
tex-fcssbx11.tfm \
tex-fcssbx12.tfm \
tex-fcssbx14.tfm \
tex-fcssbx17.tfm \
tex-fcssbx20.tfm \
tex-fcssbx25.tfm \
tex-fcssbx5.tfm \
tex-fcssbx6.tfm \
tex-fcssbx7.tfm \
tex-fcssbx8.tfm \
tex-fcssbx9.tfm \
tex-fcssi10.tfm \
tex-fcssi11.tfm \
tex-fcssi12.tfm \
tex-fcssi14.tfm \
tex-fcssi17.tfm \
tex-fcssi20.tfm \
tex-fcssi25.tfm \
tex-fcssi5.tfm \
tex-fcssi6.tfm \
tex-fcssi7.tfm \
tex-fcssi8.tfm \
tex-fcssi9.tfm \
tex-fcsstt10.tfm \
tex-fcsstt11.tfm \
tex-fcsstt12.tfm \
tex-fcsstt14.tfm \
tex-fcsstt17.tfm \
tex-fcsstt20.tfm \
tex-fcsstt25.tfm \
tex-fcsstt5.tfm \
tex-fcsstt6.tfm \
tex-fcsstt7.tfm \
tex-fcsstt8.tfm \
tex-fcsstt9.tfm \
tex-fctt10.tfm \
tex-fctt11.tfm \
tex-fctt12.tfm \
tex-fctt14.tfm \
tex-fctt17.tfm \
tex-fctt20.tfm \
tex-fctt25.tfm \
tex-fctt5.tfm \
tex-fctt6.tfm \
tex-fctt7.tfm \
tex-fctt8.tfm \
tex-fctt9.tfm \
tex-fcu10.tfm \
tex-fcu11.tfm \
tex-fcu12.tfm \
tex-fcu14.tfm \
tex-fcu17.tfm \
tex-fcu20.tfm \
tex-fcu25.tfm \
tex-fcu5.tfm \
tex-fcu6.tfm \
tex-fcu7.tfm \
tex-fcu8.tfm \
tex-fcu9.tfm \
tex-fcuse.sty \
tex-t4cmr.fd \
tex-t4cmss.fd \
tex-t4cmtt.fd \
tex-t4enc.def \
tex-t4fcr.fd \
tex-t4phonet.sty \
texlive-fc"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontenc.sty \
tex-newlfont.sty \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
