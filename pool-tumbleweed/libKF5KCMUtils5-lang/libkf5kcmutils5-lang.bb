SUMMARY = "Translations for package libKF5KCMUtils5"
DESCRIPTION = "Provides translations for the 'libKF5KCMUtils5' package."
LICENSE = "LGPL-2.1-or-later"

PV = "5.108.0"

RPM_NAME = "libKF5KCMUtils5-lang-5.108.0-1.1.noarch.rpm"
RPM_HASH = "eac466609c37f9ed30401fb8049ef1a5e48b1e35e6b3797254162bb8a7cdd80cda9c30196287c12ca283ae2a55bd3ba2a50004ad4a8b10ac986df534b42955af"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKF5KCMUtils5-lang \
libKF5KCMUtils5-lang-all \
locale-libKF5KCMUtils5-af \
locale-libKF5KCMUtils5-ar \
locale-libKF5KCMUtils5-as \
locale-libKF5KCMUtils5-az \
locale-libKF5KCMUtils5-be \
locale-libKF5KCMUtils5-be@latin \
locale-libKF5KCMUtils5-bg \
locale-libKF5KCMUtils5-bn \
locale-libKF5KCMUtils5-bn-IN \
locale-libKF5KCMUtils5-br \
locale-libKF5KCMUtils5-bs \
locale-libKF5KCMUtils5-ca \
locale-libKF5KCMUtils5-ca@valencia \
locale-libKF5KCMUtils5-cs \
locale-libKF5KCMUtils5-cy \
locale-libKF5KCMUtils5-da \
locale-libKF5KCMUtils5-de \
locale-libKF5KCMUtils5-el \
locale-libKF5KCMUtils5-en-GB \
locale-libKF5KCMUtils5-eo \
locale-libKF5KCMUtils5-es \
locale-libKF5KCMUtils5-et \
locale-libKF5KCMUtils5-eu \
locale-libKF5KCMUtils5-fa \
locale-libKF5KCMUtils5-fi \
locale-libKF5KCMUtils5-fr \
locale-libKF5KCMUtils5-ga \
locale-libKF5KCMUtils5-gd \
locale-libKF5KCMUtils5-gl \
locale-libKF5KCMUtils5-gu \
locale-libKF5KCMUtils5-he \
locale-libKF5KCMUtils5-hi \
locale-libKF5KCMUtils5-hr \
locale-libKF5KCMUtils5-hu \
locale-libKF5KCMUtils5-ia \
locale-libKF5KCMUtils5-id \
locale-libKF5KCMUtils5-is \
locale-libKF5KCMUtils5-it \
locale-libKF5KCMUtils5-ja \
locale-libKF5KCMUtils5-ka \
locale-libKF5KCMUtils5-kk \
locale-libKF5KCMUtils5-km \
locale-libKF5KCMUtils5-kn \
locale-libKF5KCMUtils5-ko \
locale-libKF5KCMUtils5-lt \
locale-libKF5KCMUtils5-lv \
locale-libKF5KCMUtils5-mai \
locale-libKF5KCMUtils5-mk \
locale-libKF5KCMUtils5-ml \
locale-libKF5KCMUtils5-mr \
locale-libKF5KCMUtils5-ms \
locale-libKF5KCMUtils5-nb \
locale-libKF5KCMUtils5-nds \
locale-libKF5KCMUtils5-ne \
locale-libKF5KCMUtils5-nl \
locale-libKF5KCMUtils5-nn \
locale-libKF5KCMUtils5-oc \
locale-libKF5KCMUtils5-or \
locale-libKF5KCMUtils5-pa \
locale-libKF5KCMUtils5-pl \
locale-libKF5KCMUtils5-pt \
locale-libKF5KCMUtils5-pt-BR \
locale-libKF5KCMUtils5-ro \
locale-libKF5KCMUtils5-ru \
locale-libKF5KCMUtils5-si \
locale-libKF5KCMUtils5-sk \
locale-libKF5KCMUtils5-sl \
locale-libKF5KCMUtils5-sq \
locale-libKF5KCMUtils5-sr \
locale-libKF5KCMUtils5-sr@ijekavian \
locale-libKF5KCMUtils5-sr@ijekavianlatin \
locale-libKF5KCMUtils5-sr@latin \
locale-libKF5KCMUtils5-sv \
locale-libKF5KCMUtils5-ta \
locale-libKF5KCMUtils5-te \
locale-libKF5KCMUtils5-th \
locale-libKF5KCMUtils5-tr \
locale-libKF5KCMUtils5-ug \
locale-libKF5KCMUtils5-uk \
locale-libKF5KCMUtils5-vi \
locale-libKF5KCMUtils5-wa \
locale-libKF5KCMUtils5-zh-CN \
locale-libKF5KCMUtils5-zh-HK \
locale-libKF5KCMUtils5-zh-TW"

RDEPENDS:${PN} += "libKF5KCMUtils5"

inherit rpm
