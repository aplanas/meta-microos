SUMMARY = "Representation of Python source as an AST for pylint"
DESCRIPTION = "This module provides a common base representation of Python source code for \
projects such as pychecker, pyreverse, pylint. The development of this library \
is governed by pylint's needs. \
 \
It provides a compatible representation which comes from the _ast \
module. It rebuilds the tree generated by the builtin _ast module by \
recursively walking down the AST and building an extended ast. The new \
node classes have additional methods and attributes for different \
usages. They include some support for static inference and local name \
scopes. Furthermore, astroid builds partial trees by inspecting living \
objects."
LICENSE = "LGPL-2.1-or-later"

PV = "2.15.6"

RPM_NAME = "python311-astroid-2.15.6-1.1.noarch.rpm"
RPM_HASH = "6589fdd9aa3f2388127330caafbc077b22a8ed63dc848b19e5638d6947e7365b6eb23b7f245a4550f8eae487ea3cca20afd406cdfffa125fab72bc791359f7e7"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "python3-astroid \
python3.11dist-astroid \
python311-astroid \
python3dist-astroid"

RDEPENDS:${PN} += "python-abi \
python311-lazy-object-proxy \
python311-wrapt"

inherit rpm
