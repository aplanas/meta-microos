SUMMARY = "Severed fonts for texlive-nanumtype1"
DESCRIPTION = "The  separated fonts package for texlive-nanumtype1"
LICENSE = "OFL-1.1"

PV = "2023.209.3.0svn29558"

RPM_NAME = "texlive-nanumtype1-fonts-2023.209.3.0svn29558-55.1.noarch.rpm"
RPM_HASH = "d80f7f15dd1070e840ab992865ad180af8b239b56f84f5a9e1492d639f40d23edda3eb2b069467eb8488896170ae0478d2b99a3c807e8f6798218af86f62f87b"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "font--lang=aa \
font--lang=an \
font--lang=ay \
font--lang=bg \
font--lang=bi \
font--lang=br \
font--lang=ch \
font--lang=co \
font--lang=crh \
font--lang=cs \
font--lang=csb \
font--lang=da \
font--lang=de \
font--lang=en \
font--lang=es \
font--lang=et \
font--lang=eu \
font--lang=fi \
font--lang=fil \
font--lang=fj \
font--lang=fo \
font--lang=fr \
font--lang=fur \
font--lang=fy \
font--lang=gd \
font--lang=gl \
font--lang=gv \
font--lang=ho \
font--lang=hsb \
font--lang=ht \
font--lang=hu \
font--lang=ia \
font--lang=id \
font--lang=ie \
font--lang=io \
font--lang=is \
font--lang=it \
font--lang=jv \
font--lang=kj \
font--lang=ku-tr \
font--lang=kum \
font--lang=kwm \
font--lang=lb \
font--lang=lg \
font--lang=li \
font--lang=mg \
font--lang=ms \
font--lang=nb \
font--lang=nds \
font--lang=ng \
font--lang=nl \
font--lang=nn \
font--lang=no \
font--lang=nr \
font--lang=nso \
font--lang=oc \
font--lang=om \
font--lang=os \
font--lang=pap-an \
font--lang=pap-aw \
font--lang=pl \
font--lang=pt \
font--lang=rm \
font--lang=rn \
font--lang=ru \
font--lang=rw \
font--lang=sc \
font--lang=sel \
font--lang=sg \
font--lang=sk \
font--lang=sma \
font--lang=smj \
font--lang=sn \
font--lang=so \
font--lang=sq \
font--lang=ss \
font--lang=st \
font--lang=su \
font--lang=sv \
font--lang=sw \
font--lang=tk \
font--lang=tl \
font--lang=tn \
font--lang=tr \
font--lang=ts \
font--lang=uz \
font--lang=vo \
font--lang=vot \
font--lang=wa \
font--lang=wen \
font--lang=wo \
font--lang=xh \
font--lang=yap \
font--lang=za \
font--lang=zu \
font-nanumgtb00 \
font-nanumgtb01 \
font-nanumgtb02 \
font-nanumgtb03 \
font-nanumgtb04 \
font-nanumgtb11 \
font-nanumgtb20 \
font-nanumgtb21 \
font-nanumgtb22 \
font-nanumgtb23 \
font-nanumgtb24 \
font-nanumgtb25 \
font-nanumgtb26 \
font-nanumgtb27 \
font-nanumgtb2a \
font-nanumgtb30 \
font-nanumgtb31 \
font-nanumgtb32 \
font-nanumgtb33 \
font-nanumgtb4e \
font-nanumgtb4f \
font-nanumgtb50 \
font-nanumgtb51 \
font-nanumgtb52 \
font-nanumgtb53 \
font-nanumgtb54 \
font-nanumgtb55 \
font-nanumgtb56 \
font-nanumgtb57 \
font-nanumgtb58 \
font-nanumgtb59 \
font-nanumgtb5a \
font-nanumgtb5b \
font-nanumgtb5c \
font-nanumgtb5d \
font-nanumgtb5e \
font-nanumgtb5f \
font-nanumgtb60 \
font-nanumgtb61 \
font-nanumgtb62 \
font-nanumgtb63 \
font-nanumgtb64 \
font-nanumgtb65 \
font-nanumgtb66 \
font-nanumgtb67 \
font-nanumgtb68 \
font-nanumgtb69 \
font-nanumgtb6a \
font-nanumgtb6b \
font-nanumgtb6c \
font-nanumgtb6d \
font-nanumgtb6e \
font-nanumgtb6f \
font-nanumgtb70 \
font-nanumgtb71 \
font-nanumgtb72 \
font-nanumgtb73 \
font-nanumgtb74 \
font-nanumgtb75 \
font-nanumgtb76 \
font-nanumgtb77 \
font-nanumgtb78 \
font-nanumgtb79 \
font-nanumgtb7a \
font-nanumgtb7b \
font-nanumgtb7c \
font-nanumgtb7d \
font-nanumgtb7e \
font-nanumgtb7f \
font-nanumgtb80 \
font-nanumgtb81 \
font-nanumgtb82 \
font-nanumgtb83 \
font-nanumgtb84 \
font-nanumgtb85 \
font-nanumgtb86 \
font-nanumgtb87 \
font-nanumgtb88 \
font-nanumgtb89 \
font-nanumgtb8a \
font-nanumgtb8b \
font-nanumgtb8c \
font-nanumgtb8d \
font-nanumgtb8e \
font-nanumgtb8f \
font-nanumgtb90 \
font-nanumgtb91 \
font-nanumgtb92 \
font-nanumgtb93 \
font-nanumgtb94 \
font-nanumgtb95 \
font-nanumgtb96 \
font-nanumgtb97 \
font-nanumgtb98 \
font-nanumgtb99 \
font-nanumgtb9a \
font-nanumgtb9b \
font-nanumgtb9c \
font-nanumgtb9d \
font-nanumgtb9e \
font-nanumgtb9f \
font-nanumgtbac \
font-nanumgtbad \
font-nanumgtbae \
font-nanumgtbaf \
font-nanumgtbb0 \
font-nanumgtbb1 \
font-nanumgtbb2 \
font-nanumgtbb3 \
font-nanumgtbb4 \
font-nanumgtbb5 \
font-nanumgtbb6 \
font-nanumgtbb7 \
font-nanumgtbb8 \
font-nanumgtbb9 \
font-nanumgtbba \
font-nanumgtbbb \
font-nanumgtbbc \
font-nanumgtbbd \
font-nanumgtbbe \
font-nanumgtbbf \
font-nanumgtbc0 \
font-nanumgtbc1 \
font-nanumgtbc2 \
font-nanumgtbc3 \
font-nanumgtbc4 \
font-nanumgtbc5 \
font-nanumgtbc6 \
font-nanumgtbc7 \
font-nanumgtbc8 \
font-nanumgtbc9 \
font-nanumgtbca \
font-nanumgtbcb \
font-nanumgtbcc \
font-nanumgtbcd \
font-nanumgtbce \
font-nanumgtbcf \
font-nanumgtbd0 \
font-nanumgtbd1 \
font-nanumgtbd2 \
font-nanumgtbd3 \
font-nanumgtbd4 \
font-nanumgtbd5 \
font-nanumgtbd6 \
font-nanumgtbd7 \
font-nanumgtbf9 \
font-nanumgtbfa \
font-nanumgtbff \
font-nanumgtm00 \
font-nanumgtm01 \
font-nanumgtm02 \
font-nanumgtm03 \
font-nanumgtm04 \
font-nanumgtm11 \
font-nanumgtm20 \
font-nanumgtm21 \
font-nanumgtm22 \
font-nanumgtm23 \
font-nanumgtm24 \
font-nanumgtm25 \
font-nanumgtm26 \
font-nanumgtm27 \
font-nanumgtm2a \
font-nanumgtm30 \
font-nanumgtm31 \
font-nanumgtm32 \
font-nanumgtm33 \
font-nanumgtm4e \
font-nanumgtm4f \
font-nanumgtm50 \
font-nanumgtm51 \
font-nanumgtm52 \
font-nanumgtm53 \
font-nanumgtm54 \
font-nanumgtm55 \
font-nanumgtm56 \
font-nanumgtm57 \
font-nanumgtm58 \
font-nanumgtm59 \
font-nanumgtm5a \
font-nanumgtm5b \
font-nanumgtm5c \
font-nanumgtm5d \
font-nanumgtm5e \
font-nanumgtm5f \
font-nanumgtm60 \
font-nanumgtm61 \
font-nanumgtm62 \
font-nanumgtm63 \
font-nanumgtm64 \
font-nanumgtm65 \
font-nanumgtm66 \
font-nanumgtm67 \
font-nanumgtm68 \
font-nanumgtm69 \
font-nanumgtm6a \
font-nanumgtm6b \
font-nanumgtm6c \
font-nanumgtm6d \
font-nanumgtm6e \
font-nanumgtm6f \
font-nanumgtm70 \
font-nanumgtm71 \
font-nanumgtm72 \
font-nanumgtm73 \
font-nanumgtm74 \
font-nanumgtm75 \
font-nanumgtm76 \
font-nanumgtm77 \
font-nanumgtm78 \
font-nanumgtm79 \
font-nanumgtm7a \
font-nanumgtm7b \
font-nanumgtm7c \
font-nanumgtm7d \
font-nanumgtm7e \
font-nanumgtm7f \
font-nanumgtm80 \
font-nanumgtm81 \
font-nanumgtm82 \
font-nanumgtm83 \
font-nanumgtm84 \
font-nanumgtm85 \
font-nanumgtm86 \
font-nanumgtm87 \
font-nanumgtm88 \
font-nanumgtm89 \
font-nanumgtm8a \
font-nanumgtm8b \
font-nanumgtm8c \
font-nanumgtm8d \
font-nanumgtm8e \
font-nanumgtm8f \
font-nanumgtm90 \
font-nanumgtm91 \
font-nanumgtm92 \
font-nanumgtm93 \
font-nanumgtm94 \
font-nanumgtm95 \
font-nanumgtm96 \
font-nanumgtm97 \
font-nanumgtm98 \
font-nanumgtm99 \
font-nanumgtm9a \
font-nanumgtm9b \
font-nanumgtm9c \
font-nanumgtm9d \
font-nanumgtm9e \
font-nanumgtm9f \
font-nanumgtmac \
font-nanumgtmad \
font-nanumgtmae \
font-nanumgtmaf \
font-nanumgtmb0 \
font-nanumgtmb1 \
font-nanumgtmb2 \
font-nanumgtmb3 \
font-nanumgtmb4 \
font-nanumgtmb5 \
font-nanumgtmb6 \
font-nanumgtmb7 \
font-nanumgtmb8 \
font-nanumgtmb9 \
font-nanumgtmba \
font-nanumgtmbb \
font-nanumgtmbc \
font-nanumgtmbd \
font-nanumgtmbe \
font-nanumgtmbf \
font-nanumgtmc0 \
font-nanumgtmc1 \
font-nanumgtmc2 \
font-nanumgtmc3 \
font-nanumgtmc4 \
font-nanumgtmc5 \
font-nanumgtmc6 \
font-nanumgtmc7 \
font-nanumgtmc8 \
font-nanumgtmc9 \
font-nanumgtmca \
font-nanumgtmcb \
font-nanumgtmcc \
font-nanumgtmcd \
font-nanumgtmce \
font-nanumgtmcf \
font-nanumgtmd0 \
font-nanumgtmd1 \
font-nanumgtmd2 \
font-nanumgtmd3 \
font-nanumgtmd4 \
font-nanumgtmd5 \
font-nanumgtmd6 \
font-nanumgtmd7 \
font-nanumgtmf9 \
font-nanumgtmfa \
font-nanumgtmff \
font-nanummjb00 \
font-nanummjb01 \
font-nanummjb02 \
font-nanummjb03 \
font-nanummjb04 \
font-nanummjb20 \
font-nanummjb21 \
font-nanummjb22 \
font-nanummjb23 \
font-nanummjb24 \
font-nanummjb25 \
font-nanummjb26 \
font-nanummjb27 \
font-nanummjb2a \
font-nanummjb30 \
font-nanummjb31 \
font-nanummjb32 \
font-nanummjb33 \
font-nanummjbac \
font-nanummjbad \
font-nanummjbae \
font-nanummjbaf \
font-nanummjbb0 \
font-nanummjbb1 \
font-nanummjbb2 \
font-nanummjbb3 \
font-nanummjbb4 \
font-nanummjbb5 \
font-nanummjbb6 \
font-nanummjbb7 \
font-nanummjbb8 \
font-nanummjbb9 \
font-nanummjbba \
font-nanummjbbb \
font-nanummjbbc \
font-nanummjbbd \
font-nanummjbbe \
font-nanummjbbf \
font-nanummjbc0 \
font-nanummjbc1 \
font-nanummjbc2 \
font-nanummjbc3 \
font-nanummjbc4 \
font-nanummjbc5 \
font-nanummjbc6 \
font-nanummjbc7 \
font-nanummjbc8 \
font-nanummjbc9 \
font-nanummjbca \
font-nanummjbcb \
font-nanummjbcc \
font-nanummjbcd \
font-nanummjbce \
font-nanummjbcf \
font-nanummjbd0 \
font-nanummjbd1 \
font-nanummjbd2 \
font-nanummjbd3 \
font-nanummjbd4 \
font-nanummjbd5 \
font-nanummjbd6 \
font-nanummjbd7 \
font-nanummjbff \
font-nanummjm00 \
font-nanummjm01 \
font-nanummjm02 \
font-nanummjm03 \
font-nanummjm04 \
font-nanummjm20 \
font-nanummjm21 \
font-nanummjm22 \
font-nanummjm23 \
font-nanummjm24 \
font-nanummjm25 \
font-nanummjm26 \
font-nanummjm27 \
font-nanummjm30 \
font-nanummjm31 \
font-nanummjm32 \
font-nanummjm33 \
font-nanummjmac \
font-nanummjmad \
font-nanummjmae \
font-nanummjmaf \
font-nanummjmb0 \
font-nanummjmb1 \
font-nanummjmb2 \
font-nanummjmb3 \
font-nanummjmb4 \
font-nanummjmb5 \
font-nanummjmb6 \
font-nanummjmb7 \
font-nanummjmb8 \
font-nanummjmb9 \
font-nanummjmba \
font-nanummjmbb \
font-nanummjmbc \
font-nanummjmbd \
font-nanummjmbe \
font-nanummjmbf \
font-nanummjmc0 \
font-nanummjmc1 \
font-nanummjmc2 \
font-nanummjmc3 \
font-nanummjmc4 \
font-nanummjmc5 \
font-nanummjmc6 \
font-nanummjmc7 \
font-nanummjmc8 \
font-nanummjmc9 \
font-nanummjmca \
font-nanummjmcb \
font-nanummjmcc \
font-nanummjmcd \
font-nanummjmce \
font-nanummjmcf \
font-nanummjmd0 \
font-nanummjmd1 \
font-nanummjmd2 \
font-nanummjmd3 \
font-nanummjmd4 \
font-nanummjmd5 \
font-nanummjmd6 \
font-nanummjmd7 \
font-nanummjmff \
font-t1nanumgtb \
font-t1nanumgtm \
font-t1nanummjb \
font-t1nanummjm \
texlive-nanumtype1-fonts"

RDEPENDS:${PN} += "/usr/bin/sh \
aaa-base \
coreutils \
fontconfig \
ghostscript-fonts-std \
perl"

inherit rpm
