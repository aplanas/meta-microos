SUMMARY = "Translations for package libKF5WidgetsAddons5"
DESCRIPTION = "Provides translations for the 'libKF5WidgetsAddons5' package."
LICENSE = "LGPL-2.1-or-later"

PV = "5.106.0"

RPM_NAME = "libKF5WidgetsAddons5-lang-5.106.0-1.1.noarch.rpm"
RPM_HASH = "22c8f2f9a44f4d5207a7b6bb19bfe8265784f3f229c71d1e41b49ba50e3563f40a21d6034be3d1d80c1c7f1159ec84c639687597e652f9330d93aca91591cb63"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKF5WidgetsAddons5-lang \
libKF5WidgetsAddons5-lang-all \
locale(libKF5WidgetsAddons5:af) \
locale(libKF5WidgetsAddons5:ar) \
locale(libKF5WidgetsAddons5:as) \
locale(libKF5WidgetsAddons5:az) \
locale(libKF5WidgetsAddons5:be) \
locale(libKF5WidgetsAddons5:be@latin) \
locale(libKF5WidgetsAddons5:bg) \
locale(libKF5WidgetsAddons5:bn) \
locale(libKF5WidgetsAddons5:bn_IN) \
locale(libKF5WidgetsAddons5:br) \
locale(libKF5WidgetsAddons5:bs) \
locale(libKF5WidgetsAddons5:ca) \
locale(libKF5WidgetsAddons5:ca@valencia) \
locale(libKF5WidgetsAddons5:cs) \
locale(libKF5WidgetsAddons5:cy) \
locale(libKF5WidgetsAddons5:da) \
locale(libKF5WidgetsAddons5:de) \
locale(libKF5WidgetsAddons5:el) \
locale(libKF5WidgetsAddons5:en) \
locale(libKF5WidgetsAddons5:en_GB) \
locale(libKF5WidgetsAddons5:eo) \
locale(libKF5WidgetsAddons5:es) \
locale(libKF5WidgetsAddons5:et) \
locale(libKF5WidgetsAddons5:eu) \
locale(libKF5WidgetsAddons5:fa) \
locale(libKF5WidgetsAddons5:fi) \
locale(libKF5WidgetsAddons5:fr) \
locale(libKF5WidgetsAddons5:ga) \
locale(libKF5WidgetsAddons5:gl) \
locale(libKF5WidgetsAddons5:gu) \
locale(libKF5WidgetsAddons5:he) \
locale(libKF5WidgetsAddons5:hi) \
locale(libKF5WidgetsAddons5:hr) \
locale(libKF5WidgetsAddons5:hu) \
locale(libKF5WidgetsAddons5:ia) \
locale(libKF5WidgetsAddons5:id) \
locale(libKF5WidgetsAddons5:is) \
locale(libKF5WidgetsAddons5:it) \
locale(libKF5WidgetsAddons5:ja) \
locale(libKF5WidgetsAddons5:ka) \
locale(libKF5WidgetsAddons5:kk) \
locale(libKF5WidgetsAddons5:km) \
locale(libKF5WidgetsAddons5:kn) \
locale(libKF5WidgetsAddons5:ko) \
locale(libKF5WidgetsAddons5:lt) \
locale(libKF5WidgetsAddons5:lv) \
locale(libKF5WidgetsAddons5:mai) \
locale(libKF5WidgetsAddons5:mk) \
locale(libKF5WidgetsAddons5:ml) \
locale(libKF5WidgetsAddons5:mr) \
locale(libKF5WidgetsAddons5:ms) \
locale(libKF5WidgetsAddons5:nb) \
locale(libKF5WidgetsAddons5:nds) \
locale(libKF5WidgetsAddons5:ne) \
locale(libKF5WidgetsAddons5:nl) \
locale(libKF5WidgetsAddons5:nn) \
locale(libKF5WidgetsAddons5:oc) \
locale(libKF5WidgetsAddons5:or) \
locale(libKF5WidgetsAddons5:pa) \
locale(libKF5WidgetsAddons5:pl) \
locale(libKF5WidgetsAddons5:pt) \
locale(libKF5WidgetsAddons5:pt_BR) \
locale(libKF5WidgetsAddons5:ro) \
locale(libKF5WidgetsAddons5:ru) \
locale(libKF5WidgetsAddons5:si) \
locale(libKF5WidgetsAddons5:sk) \
locale(libKF5WidgetsAddons5:sl) \
locale(libKF5WidgetsAddons5:sq) \
locale(libKF5WidgetsAddons5:sr) \
locale(libKF5WidgetsAddons5:sr@ijekavian) \
locale(libKF5WidgetsAddons5:sr@ijekavianlatin) \
locale(libKF5WidgetsAddons5:sr@latin) \
locale(libKF5WidgetsAddons5:sv) \
locale(libKF5WidgetsAddons5:ta) \
locale(libKF5WidgetsAddons5:te) \
locale(libKF5WidgetsAddons5:th) \
locale(libKF5WidgetsAddons5:tr) \
locale(libKF5WidgetsAddons5:ug) \
locale(libKF5WidgetsAddons5:uk) \
locale(libKF5WidgetsAddons5:vi) \
locale(libKF5WidgetsAddons5:wa) \
locale(libKF5WidgetsAddons5:zh_CN) \
locale(libKF5WidgetsAddons5:zh_HK) \
locale(libKF5WidgetsAddons5:zh_TW)"

RDEPENDS:${PN} += "libKF5WidgetsAddons5"

inherit rpm
