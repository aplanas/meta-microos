SUMMARY = "Libraries used internal to the OCaml Compiler"
DESCRIPTION = "OCaml is a high-level, strongly-typed, functional and object-oriented \
programming language from the ML family of languages. \
 \
This package contains several modules used internally by the OCaml \
compilers. They are not needed for normal OCaml development, but may \
be helpful in the development of certain applications."
LICENSE = "QPL-1.0"

PV = "4.14.1"

RPM_NAME = "ocaml-compiler-libs-4.14.1-1.4.aarch64.rpm"
RPM_HASH = "664a28dd7cbf8ac0eb4a40ddf2385a54f1789d0c8a207bdfc4dfe48a4a63dd53f8bcb3b484de48b3e91b20168d261abda46fdc2557244c704a430c22195e2ead"

RPROVIDES:${PN} += "ocaml-Afl-instrument \
ocaml-Alias-analysis \
ocaml-Allocated-const \
ocaml-Annot \
ocaml-Arch \
ocaml-Arg-helper \
ocaml-Asmgen \
ocaml-Asmlibrarian \
ocaml-Asmlink \
ocaml-Asmpackager \
ocaml-Ast-helper \
ocaml-Ast-invariants \
ocaml-Ast-iterator \
ocaml-Ast-mapper \
ocaml-Asttypes \
ocaml-Attr-helper \
ocaml-Augment-specialised-args \
ocaml-Backend-intf \
ocaml-Backend-var \
ocaml-Binutils \
ocaml-Branch-relaxation \
ocaml-Branch-relaxation-intf \
ocaml-Btype \
ocaml-Build-export-info \
ocaml-Build-path-prefix-map \
ocaml-Builtin-attributes \
ocaml-Bytegen \
ocaml-Bytelibrarian \
ocaml-Bytelink \
ocaml-Bytepackager \
ocaml-Bytesections \
ocaml-CSE \
ocaml-CSEgen \
ocaml-CamlinternalMenhirLib \
ocaml-Ccomp \
ocaml-Clambda \
ocaml-Clambda-primitives \
ocaml-Clflags \
ocaml-Closure \
ocaml-Closure-conversion \
ocaml-Closure-conversion-aux \
ocaml-Closure-element \
ocaml-Closure-id \
ocaml-Closure-middle-end \
ocaml-Closure-offsets \
ocaml-Closure-origin \
ocaml-Cmi-format \
ocaml-Cmm \
ocaml-Cmm-helpers \
ocaml-Cmm-invariants \
ocaml-Cmmgen \
ocaml-Cmmgen-state \
ocaml-Cmo-format \
ocaml-Cmt-format \
ocaml-Cmt2annot \
ocaml-Cmx-format \
ocaml-Cmxs-format \
ocaml-Coloring \
ocaml-Comballoc \
ocaml-Compenv \
ocaml-Compilation-unit \
ocaml-Compile \
ocaml-Compile-common \
ocaml-Compilenv \
ocaml-Compmisc \
ocaml-Config \
ocaml-Consistbl \
ocaml-Convert-primitives \
ocaml-Ctype \
ocaml-Dataflow \
ocaml-Datarepr \
ocaml-Deadcode \
ocaml-Debuginfo \
ocaml-Depend \
ocaml-Diffing \
ocaml-Diffing-with-keys \
ocaml-Dll \
ocaml-Docstrings \
ocaml-Domainstate \
ocaml-Effect-analysis \
ocaml-Emit \
ocaml-Emitaux \
ocaml-Emitcode \
ocaml-Emitenv \
ocaml-Env \
ocaml-Envaux \
ocaml-Errors \
ocaml-Errortrace \
ocaml-Export-id \
ocaml-Export-info \
ocaml-Export-info-for-pack \
ocaml-Expunge \
ocaml-Extract-projections \
ocaml-Find-recursive-functions \
ocaml-Flambda \
ocaml-Flambda-invariants \
ocaml-Flambda-iterators \
ocaml-Flambda-middle-end \
ocaml-Flambda-to-clambda \
ocaml-Flambda-utils \
ocaml-Freshening \
ocaml-Genprintval \
ocaml-Id-types \
ocaml-Ident \
ocaml-Identifiable \
ocaml-Import-approx \
ocaml-Includeclass \
ocaml-Includecore \
ocaml-Includemod \
ocaml-Includemod-errorprinter \
ocaml-Inconstant-idents \
ocaml-Initialize-symbol-to-let-symbol \
ocaml-Inline-and-simplify \
ocaml-Inline-and-simplify-aux \
ocaml-Inlining-cost \
ocaml-Inlining-decision \
ocaml-Inlining-decision-intf \
ocaml-Inlining-stats \
ocaml-Inlining-stats-types \
ocaml-Inlining-transforms \
ocaml-Instruct \
ocaml-Int-replace-polymorphic-compare \
ocaml-Interf \
ocaml-Internal-variable-names \
ocaml-Interval \
ocaml-Invariant-params \
ocaml-Lambda \
ocaml-Lazy-backtrack \
ocaml-Lexer \
ocaml-Lift-code \
ocaml-Lift-constants \
ocaml-Lift-let-to-initialize-symbol \
ocaml-Linear \
ocaml-Linear-format \
ocaml-Linearize \
ocaml-Linkage-name \
ocaml-Linscan \
ocaml-Liveness \
ocaml-Load-path \
ocaml-Local-store \
ocaml-Location \
ocaml-Longident \
ocaml-Mach \
ocaml-Main \
ocaml-Main-args \
ocaml-Maindriver \
ocaml-Makedepend \
ocaml-Matching \
ocaml-Meta \
ocaml-Misc \
ocaml-Mtype \
ocaml-Mutable-variable \
ocaml-Numbers \
ocaml-Opcodes \
ocaml-Oprint \
ocaml-Optcompile \
ocaml-Opterrors \
ocaml-Optmain \
ocaml-Optmaindriver \
ocaml-Outcometree \
ocaml-Parameter \
ocaml-Parmatch \
ocaml-Parse \
ocaml-Parser \
ocaml-Parsetree \
ocaml-Pass-wrapper \
ocaml-Path \
ocaml-Patterns \
ocaml-Persistent-env \
ocaml-Polling \
ocaml-Pparse \
ocaml-Pprintast \
ocaml-Predef \
ocaml-Primitive \
ocaml-Printast \
ocaml-Printclambda \
ocaml-Printclambda-primitives \
ocaml-Printcmm \
ocaml-Printinstr \
ocaml-Printlambda \
ocaml-Printlinear \
ocaml-Printmach \
ocaml-Printpat \
ocaml-Printtyp \
ocaml-Printtyped \
ocaml-Proc \
ocaml-Profile \
ocaml-Projection \
ocaml-Rec-check \
ocaml-Ref-to-variables \
ocaml-Reg \
ocaml-Reload \
ocaml-Reloadgen \
ocaml-Remove-free-vars-equal-to-args \
ocaml-Remove-unused-arguments \
ocaml-Remove-unused-closure-vars \
ocaml-Remove-unused-program-constructs \
ocaml-Runtimedef \
ocaml-Schedgen \
ocaml-Scheduling \
ocaml-Selectgen \
ocaml-Selection \
ocaml-Semantics-of-primitives \
ocaml-Set-of-closures-id \
ocaml-Set-of-closures-origin \
ocaml-Shape \
ocaml-Share-constants \
ocaml-Signature-group \
ocaml-Simple-value-approx \
ocaml-Simplif \
ocaml-Simplify-boxed-integer-ops \
ocaml-Simplify-boxed-integer-ops-intf \
ocaml-Simplify-common \
ocaml-Simplify-primitives \
ocaml-Spill \
ocaml-Split \
ocaml-Static-exception \
ocaml-Strmatch \
ocaml-Strongly-connected-components \
ocaml-Stypes \
ocaml-Subst \
ocaml-Switch \
ocaml-Symbol \
ocaml-Symtable \
ocaml-Syntaxerr \
ocaml-Tag \
ocaml-Targetint \
ocaml-Tast-iterator \
ocaml-Tast-mapper \
ocaml-Terminfo \
ocaml-Tmc \
ocaml-Topcommon \
ocaml-Topdirs \
ocaml-Topeval \
ocaml-Tophooks \
ocaml-Toploop \
ocaml-Topmain \
ocaml-Topstart \
ocaml-Trace \
ocaml-Translattribute \
ocaml-Translclass \
ocaml-Translcore \
ocaml-Translmod \
ocaml-Translobj \
ocaml-Translprim \
ocaml-Traverse-for-exported-symbols \
ocaml-Type-immediacy \
ocaml-Typeclass \
ocaml-Typecore \
ocaml-Typedecl \
ocaml-Typedecl-immediacy \
ocaml-Typedecl-properties \
ocaml-Typedecl-separability \
ocaml-Typedecl-unboxed \
ocaml-Typedecl-variance \
ocaml-Typedtree \
ocaml-Typemod \
ocaml-Typeopt \
ocaml-Types \
ocaml-Typetexp \
ocaml-Un-anf \
ocaml-Unbox-closures \
ocaml-Unbox-free-vars-of-closures \
ocaml-Unbox-specialised-args \
ocaml-Untypeast \
ocaml-Var-within-closure \
ocaml-Variable \
ocaml-Warnings \
ocaml-X86-ast \
ocaml-X86-dsl \
ocaml-X86-gas \
ocaml-X86-masm \
ocaml-X86-proc \
ocaml-compiler-libs"

RDEPENDS:${PN} += "ocaml \
ocaml-CamlinternalFormat \
ocaml-CamlinternalFormatBasics \
ocaml-CamlinternalLazy \
ocaml-CamlinternalOO \
ocaml-Stdlib \
ocaml-Stdlib--Arg \
ocaml-Stdlib--Array \
ocaml-Stdlib--Buffer \
ocaml-Stdlib--Bytes \
ocaml-Stdlib--Char \
ocaml-Stdlib--Digest \
ocaml-Stdlib--Either \
ocaml-Stdlib--Filename \
ocaml-Stdlib--Float \
ocaml-Stdlib--Format \
ocaml-Stdlib--Fun \
ocaml-Stdlib--Gc \
ocaml-Stdlib--Hashtbl \
ocaml-Stdlib--Int \
ocaml-Stdlib--Int32 \
ocaml-Stdlib--Int64 \
ocaml-Stdlib--Lazy \
ocaml-Stdlib--Lexing \
ocaml-Stdlib--List \
ocaml-Stdlib--Map \
ocaml-Stdlib--Marshal \
ocaml-Stdlib--Nativeint \
ocaml-Stdlib--Obj \
ocaml-Stdlib--Option \
ocaml-Stdlib--Parsing \
ocaml-Stdlib--Printexc \
ocaml-Stdlib--Printf \
ocaml-Stdlib--Queue \
ocaml-Stdlib--Random \
ocaml-Stdlib--Result \
ocaml-Stdlib--Scanf \
ocaml-Stdlib--Seq \
ocaml-Stdlib--Set \
ocaml-Stdlib--Stack \
ocaml-Stdlib--String \
ocaml-Stdlib--StringLabels \
ocaml-Stdlib--Sys \
ocaml-Stdlib--Uchar"

inherit rpm
