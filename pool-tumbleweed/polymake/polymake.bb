SUMMARY = "Application for studying combinatorics and geometry of convex polytopes"
DESCRIPTION = "polymake is a tool to study the combinatorics and the geometry of \
convex polytopes and polyhedra. It is also capable of dealing with \
simplicial complexes, matroids, polyhedral fans, graphs, tropical \
objects, and other objects."
LICENSE = "GPL-2.0-or-later"

PV = "4.9"

RPM_NAME = "polymake-4.9-1.3.aarch64.rpm"
RPM_HASH = "9dbe47d455e8db0ba30a03425cfa61a7c67395fb3c7c780ab8d84176c0983ae11630d669828552bf4ebf49a2003ac2bb06d291a0b42d3d5c9096f3e766b08266"

RPROVIDES:${PN} += "perl-Geomview--File \
perl-Geomview--OFF \
perl-Geomview--SKEL \
perl-Geomview--element \
perl-Geomview--geom \
perl-Graphviz--File \
perl-JSON--XS \
perl-Metapost--Element \
perl-Metapost--Figure \
perl-Metapost--File \
perl-Metapost--Graph \
perl-Metapost--Lattice \
perl-PerlIO--via--gzip \
perl-PmSvg \
perl-PmSvg--Element \
perl-PmSvg--File \
perl-PmSvg--Lattice \
perl-PmSvg--PointSet \
perl-PmSvg--Solid \
perl-PmSvg--Wire \
perl-PolyDB \
perl-PolyDB--Client \
perl-PolyDB--Collection \
perl-PolyDB--Cursor \
perl-PolyDB--Schema \
perl-Polymake \
perl-Polymake--AtEnd \
perl-Polymake--BSONbooleanAdapter \
perl-Polymake--Background \
perl-Polymake--Background--Process \
perl-Polymake--Background--Viewer \
perl-Polymake--ClientSocket \
perl-Polymake--Configure \
perl-Polymake--Core \
perl-Polymake--Core--Application \
perl-Polymake--Core--Application--CppDummy \
perl-Polymake--Core--Application--LoadPreamble \
perl-Polymake--Core--Application--Reconf \
perl-Polymake--Core--Application--SuspendedItems \
perl-Polymake--Core--Application--Unconf \
perl-Polymake--Core--BigObject \
perl-Polymake--Core--BigObject--Replacement \
perl-Polymake--Core--BigObjectArray \
perl-Polymake--Core--BigObjectType \
perl-Polymake--Core--BigObjectType--Augmented \
perl-Polymake--Core--BigObjectType--Permuted \
perl-Polymake--Core--BigObjectType--RuleLikeMethodNode \
perl-Polymake--Core--BigObjectType--Specialization \
perl-Polymake--Core--CPlusPlus \
perl-Polymake--Core--CPlusPlus--AutoFunction \
perl-Polymake--Core--CPlusPlus--AutoFunction--ArgDescr \
perl-Polymake--Core--CPlusPlus--BigObjectOptions \
perl-Polymake--Core--CPlusPlus--BoolProxy \
perl-Polymake--Core--CPlusPlus--CPPerlFile \
perl-Polymake--Core--CPlusPlus--Constructor \
perl-Polymake--Core--CPlusPlus--Deserializing \
perl-Polymake--Core--CPlusPlus--FuncDescr \
perl-Polymake--Core--CPlusPlus--Generator \
perl-Polymake--Core--CPlusPlus--HeaderFile \
perl-Polymake--Core--CPlusPlus--Iterator \
perl-Polymake--Core--CPlusPlus--LackingFunctionInstance \
perl-Polymake--Core--CPlusPlus--LackingTypeInstance \
perl-Polymake--Core--CPlusPlus--NumProxy \
perl-Polymake--Core--CPlusPlus--Operator \
perl-Polymake--Core--CPlusPlus--Options \
perl-Polymake--Core--CPlusPlus--OptionsForArray \
perl-Polymake--Core--CPlusPlus--PrivateWrappers \
perl-Polymake--Core--CPlusPlus--SharedModule \
perl-Polymake--Core--CPlusPlus--SpecialOperator \
perl-Polymake--Core--CPlusPlus--StdConstr \
perl-Polymake--Core--CPlusPlus--StringProxy \
perl-Polymake--Core--CPlusPlus--TypeDescr \
perl-Polymake--Core--CPlusPlus--perApplication \
perl-Polymake--Core--ClassTypeParam \
perl-Polymake--Core--CustomizetoJSON \
perl-Polymake--Core--Datafile \
perl-Polymake--Core--Extension \
perl-Polymake--Core--Extension--Credit \
perl-Polymake--Core--FunctionTypeParam \
perl-Polymake--Core--Help \
perl-Polymake--Core--Help--HTML \
perl-Polymake--Core--Help--PlainText \
perl-Polymake--Core--Help--Topic \
perl-Polymake--Core--Help--Topic--Example \
perl-Polymake--Core--Help--Topic--Param \
perl-Polymake--Core--Help--Topic--ParamValue \
perl-Polymake--Core--Help--Topic--ReturnValue \
perl-Polymake--Core--Help--Topic--Specialization \
perl-Polymake--Core--InitTransaction \
perl-Polymake--Core--InteractiveCommands \
perl-Polymake--Core--Permutation \
perl-Polymake--Core--Permutation--Recovery \
perl-Polymake--Core--PlainFile \
perl-Polymake--Core--Preference \
perl-Polymake--Core--Preference--ControlList \
perl-Polymake--Core--Preference--Label \
perl-Polymake--Core--Preference--List \
perl-Polymake--Core--Preference--perApplication \
perl-Polymake--Core--Property \
perl-Polymake--Core--Property--NewMultiInstance \
perl-Polymake--Core--Property--Path \
perl-Polymake--Core--Property--SelectMultiInstance \
perl-Polymake--Core--Property--SubobjKey \
perl-Polymake--Core--PropertyParamedType \
perl-Polymake--Core--PropertyType \
perl-Polymake--Core--PropertyType--ConvertTo \
perl-Polymake--Core--PropertyType--Upgrade \
perl-Polymake--Core--PropertyType--UpgradesTo \
perl-Polymake--Core--PropertyTypeInstance \
perl-Polymake--Core--PropertyValue \
perl-Polymake--Core--PropertyValue--BackRefToParent \
perl-Polymake--Core--PropertyValue--Multiple \
perl-Polymake--Core--Rule \
perl-Polymake--Core--Rule--CreatingPermutation \
perl-Polymake--Core--Rule--Credit \
perl-Polymake--Core--Rule--Deputy \
perl-Polymake--Core--Rule--Dummy \
perl-Polymake--Core--Rule--FakeCreatingPermutation \
perl-Polymake--Core--Rule--PermAction \
perl-Polymake--Core--Rule--PermutationPath \
perl-Polymake--Core--Rule--Shortcut \
perl-Polymake--Core--RuleFilter \
perl-Polymake--Core--RuleTransaction \
perl-Polymake--Core--RuleTransactionWithPerm \
perl-Polymake--Core--Scheduler \
perl-Polymake--Core--Scheduler--Debug \
perl-Polymake--Core--Scheduler--DeputyObject \
perl-Polymake--Core--Scheduler--Heap \
perl-Polymake--Core--Scheduler--InitRuleChain \
perl-Polymake--Core--Scheduler--RuleChain \
perl-Polymake--Core--Scheduler--RuleDeputy \
perl-Polymake--Core--Scheduler--RuleGraph \
perl-Polymake--Core--Scheduler--TentativeRuleChain \
perl-Polymake--Core--Serializer \
perl-Polymake--Core--Serializer--BigObjectForFlatSchema \
perl-Polymake--Core--Serializer--ExtCollector \
perl-Polymake--Core--Serializer--Sparse \
perl-Polymake--Core--Serializer--TypeCollector \
perl-Polymake--Core--Shell \
perl-Polymake--Core--Shell--Completion \
perl-Polymake--Core--Shell--Completion--Context \
perl-Polymake--Core--Shell--Completion--Param \
perl-Polymake--Core--Shell--Mock \
perl-Polymake--Core--StoredScript \
perl-Polymake--Core--Transaction \
perl-Polymake--Core--UpgradeGroup \
perl-Polymake--Core--UpgradeRule \
perl-Polymake--Core--Upgrades \
perl-Polymake--Core--UserSettings \
perl-Polymake--Core--UserSettings--Item \
perl-Polymake--Core--UserSettings--Item--Array \
perl-Polymake--Core--UserSettings--Item--Hash \
perl-Polymake--Core--UserSettings--Item--Scalar \
perl-Polymake--Core--XMLtoJSON \
perl-Polymake--Core--XMLtoJSON--Handler \
perl-Polymake--Enum \
perl-Polymake--Ext \
perl-Polymake--Interrupts \
perl-Polymake--LocalServer \
perl-Polymake--Main \
perl-Polymake--NoShell \
perl-Polymake--Overload \
perl-Polymake--Overload--Global \
perl-Polymake--Overload--GlobalLabeledNode \
perl-Polymake--Overload--LabeledNode \
perl-Polymake--Overload--Node \
perl-Polymake--OverwriteFile \
perl-Polymake--Pipe \
perl-Polymake--Pipe--Collaborative \
perl-Polymake--RefHash \
perl-Polymake--Schema \
perl-Polymake--Schema--Validator \
perl-Polymake--Schema--Validator--All \
perl-Polymake--Schema--Validator--Any \
perl-Polymake--Schema--Validator--Array \
perl-Polymake--Schema--Validator--Boolean \
perl-Polymake--Schema--Validator--False \
perl-Polymake--Schema--Validator--If \
perl-Polymake--Schema--Validator--MergeIntoFlat \
perl-Polymake--Schema--Validator--MultiType \
perl-Polymake--Schema--Validator--Not \
perl-Polymake--Schema--Validator--Null \
perl-Polymake--Schema--Validator--Number \
perl-Polymake--Schema--Validator--Object \
perl-Polymake--Schema--Validator--One \
perl-Polymake--Schema--Validator--Ref \
perl-Polymake--Schema--Validator--Scalar \
perl-Polymake--Schema--Validator--String \
perl-Polymake--Schema--Validator--True \
perl-Polymake--Scope \
perl-Polymake--Selector \
perl-Polymake--Selector--Closed \
perl-Polymake--Selector--Member \
perl-Polymake--ServerSocket \
perl-Polymake--SimpleViewer \
perl-Polymake--SourceTree \
perl-Polymake--StandaloneExt \
perl-Polymake--Struct \
perl-Polymake--TempChangeDir \
perl-Polymake--TempTextFile \
perl-Polymake--Tempdir \
perl-Polymake--Tempfile \
perl-Polymake--Test \
perl-Polymake--Test--BigObject \
perl-Polymake--Test--BigObject--Transform \
perl-Polymake--Test--BigObject--WithRule \
perl-Polymake--Test--Case \
perl-Polymake--Test--Environment \
perl-Polymake--Test--ExampleCase \
perl-Polymake--Test--Examples \
perl-Polymake--Test--ExamplesInTopic \
perl-Polymake--Test--Group \
perl-Polymake--Test--Output \
perl-Polymake--Test--Rule \
perl-Polymake--Test--Rule--TestFinalizer \
perl-Polymake--Test--Schedule \
perl-Polymake--Test--Shell \
perl-Polymake--Test--Shell--Completion \
perl-Polymake--Test--Shell--ContextHelp \
perl-Polymake--Test--Stream \
perl-Polymake--Test--Subgroup \
perl-Polymake--Test--Tutorial \
perl-Polymake--Test--TutorialCase \
perl-Polymake--Test--Tutorials \
perl-Polymake--Test--Value \
perl-Polymake--Test--Value--Boolean \
perl-Polymake--Test--Value--FromAttachment \
perl-Polymake--Test--Value--FromData \
perl-Polymake--User \
perl-Polymake--User--Verbose \
perl-Polymake--common \
perl-Polymake--polytope--LPparser \
perl-Polymake--polytope--PortaConverter \
perl-Polymake--polytope--PortaParser \
perl-Postscript \
perl-Postscript--Element \
perl-Postscript--File \
perl-Postscript--Gale \
perl-Postscript--Graph \
perl-Postscript--Lattice \
perl-Postscript--Page \
perl-Postscript--PointSet \
perl-Postscript--Polygon \
perl-Postscript--Polygons \
perl-Povray--File \
perl-Povray--PointSet \
perl-Povray--Solid \
perl-Povray--Wire \
perl-Sage \
perl-Sketch--File \
perl-Sketch--PointSet \
perl-Sketch--Solid \
perl-Sketch--Wire \
perl-SplitsTree--File \
perl-ThreeJS \
perl-ThreeJS--File \
perl-ThreeJS--PointSet \
perl-ThreeJS--Solid \
perl-ThreeJS--Utils \
perl-ThreeJS--Wire \
perl-TikZ--File \
perl-TikZ--Lattice \
perl-TikZ--PhylogeneticTree \
perl-TikZ--PointSet \
perl-TikZ--Solid \
perl-TikZ--Utils \
perl-TikZ--Wire \
perl-Visual \
perl-Visual--Container \
perl-Visual--DegeneratedPolygon \
perl-Visual--Drawing \
perl-Visual--DynamicCoords \
perl-Visual--FileWriter \
perl-Visual--FileWriter--Auto \
perl-Visual--Gale \
perl-Visual--Graph \
perl-Visual--Graph--EdgeIterator \
perl-Visual--Graph--EdgeIteratorWithGaps \
perl-Visual--Lattice \
perl-Visual--Object \
perl-Visual--PhylogeneticTree \
perl-Visual--PointSet \
perl-Visual--Polygon \
perl-Visual--Polygons \
perl-Visual--Transformation \
perl-Visual--Wire \
perl-Visual--Wire--EdgeIterator \
perl-Visual--WireBase \
perl-X3d \
perl-X3d--Element \
perl-X3d--File \
perl-X3d--PointSet \
perl-X3d--Solid \
perl-X3d--Wire \
perl-application \
perl-namespaces \
polymake"

RDEPENDS:${PN} += "/usr/bin/bash \
/usr/bin/perl \
ld-linux-aarch64.so.1 \
libbliss.so.0.77 \
libc.so.6 \
libcddgmp.so.0 \
libflint.so.17 \
libgcc-s.so.1 \
libgmp.so.10 \
libgomp.so.1 \
liblrs.so.1 \
libm.so.6 \
libmpfr.so.6 \
libppl.so.14 \
libstdc++.so.6 \
libsympol.so.0.1"

inherit rpm
