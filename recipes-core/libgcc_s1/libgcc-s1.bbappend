PROVIDES += "libgcc libgcc-initial"
RPROVIDES:${PN} += "libgcc libgcc-initial"
