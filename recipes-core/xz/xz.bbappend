RPROVIDES:${PN} += "/usr/bin/xz"
