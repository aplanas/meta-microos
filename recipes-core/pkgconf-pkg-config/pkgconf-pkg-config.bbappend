RPROVIDES:${PN} += "/usr/bin/pkg-config"

# See providers.inc why this is not a good idea
# PROVIDES += "pkgconfig"
