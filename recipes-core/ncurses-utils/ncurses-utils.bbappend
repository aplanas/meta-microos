RPROVIDES:${PN} += "/usr/bin/tput"
