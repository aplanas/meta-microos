RPROVIDES:${PN} += "/usr/bin/bash"
