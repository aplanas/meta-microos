RPROVIDES:${PN} += "/usr/bin/gzip"
