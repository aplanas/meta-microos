RPROVIDES:${PN} += "/usr/bin/date"
RPROVIDES:${PN} += "/usr/bin/env"
RPROVIDES:${PN} += "/usr/bin/readlink"
