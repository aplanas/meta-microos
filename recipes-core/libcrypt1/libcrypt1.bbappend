PROVIDES += "virtual/crypt"
RPROVIDES:${PN} += "virtual/crypt"
