RPROVIDES:${PN} += "/usr/bin/perl"
