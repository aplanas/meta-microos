PROVIDES += "zlib"
