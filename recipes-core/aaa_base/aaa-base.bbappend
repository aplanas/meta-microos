RPROVIDES:${PN} += "/usr/bin/get-kernel-version"
