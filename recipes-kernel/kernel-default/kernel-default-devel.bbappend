PROVIDES += "kernel-devsrc"
