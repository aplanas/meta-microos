PROVIDES += "virtual/kernel"
