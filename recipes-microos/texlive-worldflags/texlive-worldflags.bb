SUMMARY = "Drawing flags with TikZ"
DESCRIPTION = "This is a package for drawing flags using TikZ. Currently the \
national flags of all independent nations are included, \
additionally some other flags of various organizations. A flag \
can be drawn ... as a single TikZ-picture within ordinary text, \
as a picture element within a TikZ-picture. The appearance of a \
flag (size, frame etc.) can be adapted using optional \
parameters."
LICENSE = "LPPL-1.0"

PV = "2023.201.svn59171"

RPM_NAME = "texlive-worldflags-2023.201.svn59171-53.1.noarch.rpm"
RPM_HASH = "9437501c85dd18d97211cfa36567a305fd74bd4c9abe7fe937f90b8a2c2f37c478d33fbbd616b35d069bab40e6bf19decf0768e5e13a086cdbea58d018731eab"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex(worldflag_0.tex) \
tex(worldflag_1.tex) \
tex(worldflag_2.tex) \
tex(worldflag_3.tex) \
tex(worldflag_4.tex) \
tex(worldflag_5.tex) \
tex(worldflag_6.tex) \
tex(worldflag_7.tex) \
tex(worldflag_8.tex) \
tex(worldflag_9.tex) \
tex(worldflag_A.tex) \
tex(worldflag_AD.tex) \
tex(worldflag_AE.tex) \
tex(worldflag_AF.tex) \
tex(worldflag_AG.tex) \
tex(worldflag_AL.tex) \
tex(worldflag_AM.tex) \
tex(worldflag_AO.tex) \
tex(worldflag_AQ.tex) \
tex(worldflag_AR.tex) \
tex(worldflag_AT-B.tex) \
tex(worldflag_AT-K.tex) \
tex(worldflag_AT-N.tex) \
tex(worldflag_AT-O.tex) \
tex(worldflag_AT-S.tex) \
tex(worldflag_AT-St.tex) \
tex(worldflag_AT-T.tex) \
tex(worldflag_AT-V.tex) \
tex(worldflag_AT-W.tex) \
tex(worldflag_AT.tex) \
tex(worldflag_AU.tex) \
tex(worldflag_AX.tex) \
tex(worldflag_AZ.tex) \
tex(worldflag_Abkhazia.tex) \
tex(worldflag_Artsakh.tex) \
tex(worldflag_B.tex) \
tex(worldflag_BA.tex) \
tex(worldflag_BB.tex) \
tex(worldflag_BD.tex) \
tex(worldflag_BE.tex) \
tex(worldflag_BF.tex) \
tex(worldflag_BG.tex) \
tex(worldflag_BH.tex) \
tex(worldflag_BI.tex) \
tex(worldflag_BJ.tex) \
tex(worldflag_BN.tex) \
tex(worldflag_BO.tex) \
tex(worldflag_BR.tex) \
tex(worldflag_BS.tex) \
tex(worldflag_BT.tex) \
tex(worldflag_BW.tex) \
tex(worldflag_BY.tex) \
tex(worldflag_BZ.tex) \
tex(worldflag_Bonaire.tex) \
tex(worldflag_Buddhism.tex) \
tex(worldflag_C.tex) \
tex(worldflag_CA.tex) \
tex(worldflag_CD.tex) \
tex(worldflag_CF.tex) \
tex(worldflag_CG.tex) \
tex(worldflag_CH.tex) \
tex(worldflag_CI.tex) \
tex(worldflag_CK.tex) \
tex(worldflag_CL.tex) \
tex(worldflag_CM.tex) \
tex(worldflag_CN.tex) \
tex(worldflag_CO.tex) \
tex(worldflag_CR.tex) \
tex(worldflag_CU.tex) \
tex(worldflag_CV.tex) \
tex(worldflag_CY.tex) \
tex(worldflag_CZ.tex) \
tex(worldflag_Christian.tex) \
tex(worldflag_D.tex) \
tex(worldflag_DE.tex) \
tex(worldflag_DJ.tex) \
tex(worldflag_DK.tex) \
tex(worldflag_DM.tex) \
tex(worldflag_DO.tex) \
tex(worldflag_DZ.tex) \
tex(worldflag_E.tex) \
tex(worldflag_EC.tex) \
tex(worldflag_EE.tex) \
tex(worldflag_EG.tex) \
tex(worldflag_EH.tex) \
tex(worldflag_ER.tex) \
tex(worldflag_ES.tex) \
tex(worldflag_ET.tex) \
tex(worldflag_EU.tex) \
tex(worldflag_Esperanto.tex) \
tex(worldflag_F.tex) \
tex(worldflag_FI.tex) \
tex(worldflag_FJ.tex) \
tex(worldflag_FM.tex) \
tex(worldflag_FO.tex) \
tex(worldflag_FR.tex) \
tex(worldflag_G.tex) \
tex(worldflag_GA.tex) \
tex(worldflag_GB.tex) \
tex(worldflag_GD.tex) \
tex(worldflag_GE.tex) \
tex(worldflag_GF.tex) \
tex(worldflag_GG.tex) \
tex(worldflag_GH.tex) \
tex(worldflag_GI.tex) \
tex(worldflag_GL.tex) \
tex(worldflag_GM.tex) \
tex(worldflag_GN.tex) \
tex(worldflag_GQ.tex) \
tex(worldflag_GR.tex) \
tex(worldflag_GT.tex) \
tex(worldflag_GW.tex) \
tex(worldflag_GY.tex) \
tex(worldflag_H.tex) \
tex(worldflag_HN.tex) \
tex(worldflag_HR.tex) \
tex(worldflag_HT.tex) \
tex(worldflag_HU.tex) \
tex(worldflag_I.tex) \
tex(worldflag_ID.tex) \
tex(worldflag_IE.tex) \
tex(worldflag_IL.tex) \
tex(worldflag_IM.tex) \
tex(worldflag_IN.tex) \
tex(worldflag_IQ.tex) \
tex(worldflag_IR.tex) \
tex(worldflag_IS.tex) \
tex(worldflag_IT.tex) \
tex(worldflag_J.tex) \
tex(worldflag_JE.tex) \
tex(worldflag_JM.tex) \
tex(worldflag_JO.tex) \
tex(worldflag_JP.tex) \
tex(worldflag_JollyRoger.tex) \
tex(worldflag_K.tex) \
tex(worldflag_KE.tex) \
tex(worldflag_KG.tex) \
tex(worldflag_KH.tex) \
tex(worldflag_KI.tex) \
tex(worldflag_KM.tex) \
tex(worldflag_KN.tex) \
tex(worldflag_KO.tex) \
tex(worldflag_KP.tex) \
tex(worldflag_KR.tex) \
tex(worldflag_KW.tex) \
tex(worldflag_KZ.tex) \
tex(worldflag_L.tex) \
tex(worldflag_LA.tex) \
tex(worldflag_LB.tex) \
tex(worldflag_LC.tex) \
tex(worldflag_LI.tex) \
tex(worldflag_LK.tex) \
tex(worldflag_LR.tex) \
tex(worldflag_LS.tex) \
tex(worldflag_LT.tex) \
tex(worldflag_LU.tex) \
tex(worldflag_LV.tex) \
tex(worldflag_LY.tex) \
tex(worldflag_M.tex) \
tex(worldflag_MA.tex) \
tex(worldflag_MD.tex) \
tex(worldflag_ME.tex) \
tex(worldflag_MG.tex) \
tex(worldflag_MH.tex) \
tex(worldflag_MK.tex) \
tex(worldflag_ML.tex) \
tex(worldflag_MM.tex) \
tex(worldflag_MN.tex) \
tex(worldflag_MR.tex) \
tex(worldflag_MT.tex) \
tex(worldflag_MU.tex) \
tex(worldflag_MV.tex) \
tex(worldflag_MW.tex) \
tex(worldflag_MX.tex) \
tex(worldflag_MY.tex) \
tex(worldflag_MZ.tex) \
tex(worldflag_N.tex) \
tex(worldflag_NA.tex) \
tex(worldflag_NATO.tex) \
tex(worldflag_NE.tex) \
tex(worldflag_NG.tex) \
tex(worldflag_NI.tex) \
tex(worldflag_NL.tex) \
tex(worldflag_NO.tex) \
tex(worldflag_NP.tex) \
tex(worldflag_NR.tex) \
tex(worldflag_NU.tex) \
tex(worldflag_NZ.tex) \
tex(worldflag_O.tex) \
tex(worldflag_OM.tex) \
tex(worldflag_Olympics.tex) \
tex(worldflag_P.tex) \
tex(worldflag_PA.tex) \
tex(worldflag_PE.tex) \
tex(worldflag_PG.tex) \
tex(worldflag_PH.tex) \
tex(worldflag_PK.tex) \
tex(worldflag_PL.tex) \
tex(worldflag_PR.tex) \
tex(worldflag_PS.tex) \
tex(worldflag_PT.tex) \
tex(worldflag_PW.tex) \
tex(worldflag_PY.tex) \
tex(worldflag_Q.tex) \
tex(worldflag_QA.tex) \
tex(worldflag_R.tex) \
tex(worldflag_RE.tex) \
tex(worldflag_RO.tex) \
tex(worldflag_RS.tex) \
tex(worldflag_RU.tex) \
tex(worldflag_RW.tex) \
tex(worldflag_Rainbow.tex) \
tex(worldflag_RedCrescent.tex) \
tex(worldflag_RedCross.tex) \
tex(worldflag_RedCrystal.tex) \
tex(worldflag_S.tex) \
tex(worldflag_SA.tex) \
tex(worldflag_SB.tex) \
tex(worldflag_SC.tex) \
tex(worldflag_SD.tex) \
tex(worldflag_SE.tex) \
tex(worldflag_SG.tex) \
tex(worldflag_SI.tex) \
tex(worldflag_SK.tex) \
tex(worldflag_SL.tex) \
tex(worldflag_SM.tex) \
tex(worldflag_SN.tex) \
tex(worldflag_SO.tex) \
tex(worldflag_SR.tex) \
tex(worldflag_SS.tex) \
tex(worldflag_ST.tex) \
tex(worldflag_SV.tex) \
tex(worldflag_SY.tex) \
tex(worldflag_SZ.tex) \
tex(worldflag_Saba.tex) \
tex(worldflag_Somaliland.tex) \
tex(worldflag_StEustasius.tex) \
tex(worldflag_T.tex) \
tex(worldflag_TD.tex) \
tex(worldflag_TG.tex) \
tex(worldflag_TH.tex) \
tex(worldflag_TJ.tex) \
tex(worldflag_TL.tex) \
tex(worldflag_TM.tex) \
tex(worldflag_TN.tex) \
tex(worldflag_TO.tex) \
tex(worldflag_TR.tex) \
tex(worldflag_TT.tex) \
tex(worldflag_TV.tex) \
tex(worldflag_TW.tex) \
tex(worldflag_TZ.tex) \
tex(worldflag_Tibet.tex) \
tex(worldflag_Transnistria.tex) \
tex(worldflag_U.tex) \
tex(worldflag_UA.tex) \
tex(worldflag_UG.tex) \
tex(worldflag_UNESCO.tex) \
tex(worldflag_UNO.tex) \
tex(worldflag_US.tex) \
tex(worldflag_UY.tex) \
tex(worldflag_UZ.tex) \
tex(worldflag_V.tex) \
tex(worldflag_VA.tex) \
tex(worldflag_VC.tex) \
tex(worldflag_VE.tex) \
tex(worldflag_VN.tex) \
tex(worldflag_VU.tex) \
tex(worldflag_W.tex) \
tex(worldflag_WB.tex) \
tex(worldflag_WHO.tex) \
tex(worldflag_WS.tex) \
tex(worldflag_X.tex) \
tex(worldflag_Y.tex) \
tex(worldflag_YE.tex) \
tex(worldflag_Z.tex) \
tex(worldflag_ZA.tex) \
tex(worldflag_ZM.tex) \
tex(worldflag_ZW.tex) \
tex(worldflags.sty) \
texlive-worldflags"
RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex(etex.sty) \
tex(ifthen.sty) \
tex(tikz.sty) \
tex(xcolor.sty) \
tex(xkeyval.sty) \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
