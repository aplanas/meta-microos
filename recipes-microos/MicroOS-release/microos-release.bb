in) weakremover(psi+-plugins-psimediaplugin) weakremover(psi+-plugins-qipxstatusesplugin) weakremover(psi+-plugins-screenshotplugin) weakremover(psi+-plugins-skinsplugin) weakremover(psi+-plugins-stopspamplugin) weakremover(psi+-plugins-storagenotesplugin) weakremover(psi+-plugins-translateplugin) weakremover(psi+-plugins-videostatusplugin) weakremover(psi+-plugins-watcherplugin) weakremover(psiconv) weakremover(psiconv-devel) weakremover(psl) weakremover(psmisc) weakremover(pspg) weakremover(pspp) weakremover(pspp-devel) weakremover(pspp-devel-doc) weakremover(pspp-doc) weakremover(psqlODBC) weakremover(pstoedit) weakremover(pstoedit-devel) weakremover(psutils) weakremover(pt2-clone) weakremover(pthread-stubs-devel) weakremover(ptl-devel) weakremover(ptlib-devel) weakremover(ptokax) weakremover(ptools) weakremover(ptpd) weakremover(ptscotch-gnu-mpich-hpc-devel-static) weakremover(ptscotch-gnu-mvapich2-hpc-devel-static) weakremover(ptscotch-gnu-openmpi1-hpc-devel-static) weakremover(ptscotch-gnu-openmpi2-hpc-devel-static) weakremover(ptscotch-gnu-openmpi3-hpc-devel-static) weakremover(ptscotch-mpich) weakremover(ptscotch-mpich-devel) weakremover(ptscotch-mpich-devel-static) weakremover(ptscotch-mvapich2) weakremover(ptscotch-mvapich2-devel) weakremover(ptscotch-mvapich2-devel-static) weakremover(ptscotch-openmpi) weakremover(ptscotch-openmpi-devel) weakremover(ptscotch-openmpi-devel-static) weakremover(ptscotch-openmpi1) weakremover(ptscotch-openmpi1-devel) weakremover(ptscotch-openmpi1-devel-static) weakremover(ptscotch-openmpi2) weakremover(ptscotch-openmpi2-devel) weakremover(ptscotch-openmpi2-devel-static) weakremover(ptscotch-openmpi3) weakremover(ptscotch-openmpi3-devel) weakremover(ptscotch-openmpi3-devel-static) weakremover(ptscotch-openmpi4) weakremover(ptscotch-openmpi4-devel) weakremover(ptscotch-openmpi4-devel-static) weakremover(ptscotch-parmetis-mpich-devel) weakremover(ptscotch-parmetis-mvapich2-devel) weakremover(ptscotch-parmetis-openmpi-devel) weakremover(ptscotch-parmetis-openmpi1-devel) weakremover(ptscotch-parmetis-openmpi2-devel) weakremover(ptscotch-parmetis-openmpi3-devel) weakremover(ptscotch-parmetis-openmpi4-devel) weakremover(ptscotch_6_0_6-gnu-mpich-hpc) weakremover(ptscotch_6_0_6-gnu-mpich-hpc-devel) weakremover(ptscotch_6_0_6-gnu-mpich-hpc-devel-static) weakremover(ptscotch_6_0_6-gnu-mvapich2-hpc) weakremover(ptscotch_6_0_6-gnu-mvapich2-hpc-devel) weakremover(ptscotch_6_0_6-gnu-mvapich2-hpc-devel-static) weakremover(ptscotch_6_0_6-gnu-openmpi1-hpc) weakremover(ptscotch_6_0_6-gnu-openmpi1-hpc-devel) weakremover(ptscotch_6_0_6-gnu-openmpi1-hpc-devel-static) weakremover(ptscotch_6_0_6-gnu-openmpi2-hpc) weakremover(ptscotch_6_0_6-gnu-openmpi2-hpc-devel) weakremover(ptscotch_6_0_6-gnu-openmpi2-hpc-devel-static) weakremover(ptscotch_6_0_6-gnu-openmpi3-hpc) weakremover(ptscotch_6_0_6-gnu-openmpi3-hpc-devel) weakremover(ptscotch_6_0_6-gnu-openmpi3-hpc-devel-static) weakremover(ptscotch_6_0_7-gnu-mpich-hpc) weakremover(ptscotch_6_0_7-gnu-mpich-hpc-devel) weakremover(ptscotch_6_0_7-gnu-mpich-hpc-devel-static) weakremover(ptscotch_6_0_7-gnu-mvapich2-hpc) weakremover(ptscotch_6_0_7-gnu-mvapich2-hpc-devel) weakremover(ptscotch_6_0_7-gnu-mvapich2-hpc-devel-static) weakremover(ptscotch_6_0_7-gnu-openmpi1-hpc) weakremover(ptscotch_6_0_7-gnu-openmpi1-hpc-devel) weakremover(ptscotch_6_0_7-gnu-openmpi1-hpc-devel-static) weakremover(ptscotch_6_0_7-gnu-openmpi2-hpc) weakremover(ptscotch_6_0_7-gnu-openmpi2-hpc-devel) weakremover(ptscotch_6_0_7-gnu-openmpi2-hpc-devel-static) weakremover(ptscotch_6_0_7-gnu-openmpi3-hpc) weakremover(ptscotch_6_0_7-gnu-openmpi3-hpc-devel) weakremover(ptscotch_6_0_7-gnu-openmpi3-hpc-devel-static) weakremover(ptscotch_6_0_9-gnu-mpich-hpc) weakremover(ptscotch_6_0_9-gnu-mpich-hpc-devel) weakremover(ptscotch_6_0_9-gnu-mpich-hpc-devel-static) weakremover(ptscotch_6_0_9-gnu-mvapich2-hpc) weakremover(ptscotch_6_0_9-gnu-mvapich2-hpc-devel) weakremover(ptscotch_6_0_9-gnu-mvapich2-hpc-devel-static) weakremover(ptscotch_6_0_9-gnu-openmpi1-hpc) weakremover(ptscotch_6_0_9-gnu-openmpi1-hpc-devel) weakremover(ptscotch_6_0_9-gnu-openmpi1-hpc-devel-static) weakremover(ptscotch_6_0_9-gnu-openmpi2-hpc) weakremover(ptscotch_6_0_9-gnu-openmpi2-hpc-devel) weakremover(ptscotch_6_0_9-gnu-openmpi2-hpc-devel-static) weakremover(ptscotch_6_0_9-gnu-openmpi3-hpc) weakremover(ptscotch_6_0_9-gnu-openmpi3-hpc-devel) weakremover(ptscotch_6_0_9-gnu-openmpi3-hpc-devel-static) weakremover(ptscotch_6_1_0-gnu-mpich-hpc) weakremover(ptscotch_6_1_0-gnu-mpich-hpc-devel) weakremover(ptscotch_6_1_0-gnu-mpich-hpc-devel-static) weakremover(ptscotch_6_1_0-gnu-mvapich2-hpc) weakremover(ptscotch_6_1_0-gnu-mvapich2-hpc-devel) weakremover(ptscotch_6_1_0-gnu-mvapich2-hpc-devel-static) weakremover(ptscotch_6_1_0-gnu-openmpi1-hpc) weakremover(ptscotch_6_1_0-gnu-openmpi1-hpc-devel) weakremover(ptscotch_6_1_0-gnu-openmpi1-hpc-devel-static) weakremover(ptscotch_6_1_0-gnu-openmpi2-hpc) weakremover(ptscotch_6_1_0-gnu-openmpi2-hpc-devel) weakremover(ptscotch_6_1_0-gnu-openmpi2-hpc-devel-static) weakremover(ptscotch_6_1_0-gnu-openmpi3-hpc) weakremover(ptscotch_6_1_0-gnu-openmpi3-hpc-devel) weakremover(ptscotch_6_1_0-gnu-openmpi3-hpc-devel-static) weakremover(ptscotch_6_1_0-gnu-openmpi4-hpc) weakremover(ptscotch_6_1_0-gnu-openmpi4-hpc-devel) weakremover(ptscotch_6_1_0-gnu-openmpi4-hpc-devel-static) weakremover(puddletag) weakremover(pugixml-devel) weakremover(pullin-fluendo-mp3) weakremover(pulseaudio) weakremover(pulseaudio-bash-completion) weakremover(pulseaudio-esound-compat) weakremover(pulseaudio-gdm-hooks) weakremover(pulseaudio-module-bluetooth) weakremover(pulseaudio-module-gconf) weakremover(pulseaudio-module-gsettings) weakremover(pulseaudio-module-jack) weakremover(pulseaudio-module-lirc) weakremover(pulseaudio-module-x11) weakremover(pulseaudio-module-zeroconf) weakremover(pulseaudio-qt-devel) weakremover(pulseaudio-setup) weakremover(pulseaudio-system-wide) weakremover(pulseaudio-utils) weakremover(pulseaudio-zsh-completion) weakremover(pulseeffects) weakremover(pulseview) weakremover(pumpa) weakremover(pure-ftpd) weakremover(purple-libsteam) weakremover(purple-plugin-pack-lang) weakremover(purpose) weakremover(purpose-devel) weakremover(putty) weakremover(pv) weakremover(pw3270) weakremover(pw3270-devel) weakremover(pw3270-java) weakremover(pw3270-javadoc) weakremover(pw3270-keypads) weakremover(pw3270-plugin-dbus) weakremover(pw3270-plugin-java) weakremover(pw3270-plugin-rexx) weakremover(pwgen) weakremover(pwlib) weakremover(pwlib-devel) weakremover(pwlib-plugins-v4l2) weakremover(py-fishcrypt) weakremover(pyalsa) weakremover(pybliographer) weakremover(pycarddav) weakremover(pychecker) weakremover(pyenv) weakremover(pyldb) weakremover(pyldb-devel) weakremover(pyliblo-tools) weakremover(pymol) weakremover(pyrex) weakremover(pyspacewar) weakremover(pystring-devel) weakremover(pytalloc) weakremover(pytalloc-devel) weakremover(pythia-devel) weakremover(pythia-doc) weakremover(python) weakremover(python-3parclient) weakremover(python-4Suite-XML) weakremover(python-APScheduler) weakremover(python-Attest) weakremover(python-Axiom) weakremover(python-BTrees) weakremover(python-BTrees-devel) weakremover(python-BTrees-doc) weakremover(python-Babel) weakremover(python-Babel-doc) weakremover(python-Beaker) weakremover(python-Brownie) weakremover(python-CDDB) weakremover(python-CXX) weakremover(python-CXX-devel) weakremover(python-Chameleon) weakremover(python-Cheetah) weakremover(python-CherryPy) weakremover(python-ClientForm) weakremover(python-Coffin) weakremover(python-Coherence) weakremover(python-CommonMark-doc) weakremover(python-CouchDB) weakremover(python-CouchDB-doc) weakremover(python-Cycler) weakremover(python-Cython) weakremover(python-Cython-doc) weakremover(python-Distutils2) weakremover(python-Django) weakremover(python-Durus) weakremover(python-EasyProcess) weakremover(python-Epsilon) weakremover(python-Fabric) weakremover(python-Flask) weakremover(python-Flask-WTF) weakremover(python-Flask-WTF-doc) weakremover(python-Flask-doc) weakremover(python-FormEncode) weakremover(python-FormEncode-doc) weakremover(python-Frozen-Flask) weakremover(python-Genshi) weakremover(python-GeoIP) weakremover(python-GitPython) weakremover(python-GooCalendar) weakremover(python-Hamlib) weakremover(python-Jinja2) weakremover(python-Jinja2-emacs) weakremover(python-Jinja2-vim) weakremover(python-JsonWeb) weakremover(python-Kajiki) weakremover(python-Kivy) weakremover(python-Kivy-devel) weakremover(python-Kivy-doc) weakremover(python-LHAPDF) weakremover(python-Levenshtein) weakremover(python-Louie) weakremover(python-M2Crypto) weakremover(python-Mako) weakremover(python-Markdown) weakremover(python-MarkupSafe) weakremover(python-Markups) weakremover(python-Ming) weakremover(python-MiniMock) weakremover(python-MySQL-python) weakremover(python-OleFileIO_PL) weakremover(python-OpenColorIO) weakremover(python-OpenColorIO-devel) weakremover(python-OpenEXR) weakremover(python-OpenEXR-doc) weakremover(python-OpenImageIO) weakremover(python-Parsley) weakremover(python-Paste) weakremover(python-PasteDeploy) weakremover(python-PasteScript) weakremover(python-Pillow) weakremover(python-Pillow-tk) weakremover(python-Pint) weakremover(python-PrettyTable) weakremover(python-PyAudio) weakremover(python-PyAudio-docs) weakremover(python-PyECLib) weakremover(python-PyGithub) weakremover(python-PyICU) weakremover(python-PyJWT) weakremover(python-PyMuPDF-doc) weakremover(python-PyMySQL) weakremover(python-PyPDF2) weakremover(python-PySocks) weakremover(python-PyVirtualDisplay) weakremover(python-PyWavelets-doc) weakremover(python-PyWebDAV) weakremover(python-PyYAML) weakremover(python-Pygments) weakremover(python-Pylons) weakremover(python-Rivet) weakremover(python-Routes) weakremover(python-SHERPA-MC) weakremover(python-SPARQLWrapper) weakremover(python-SQLAlchemy) weakremover(python-SQLAlchemy-Utils) weakremover(python-SecretStorage) weakremover(python-Shapely) weakremover(python-Shed_Skin) weakremover(python-Shed_Skin-doc) weakremover(python-SocksiPy) weakremover(python-Sphinx) weakremover(python-Sphinx-doc) weakremover(python-Sphinx-latex) weakremover(python-Sphinx2-doc-html) weakremover(python-Sphinx2-doc-man) weakremover(python-SpiceClientGtk) weakremover(python-Tempita) weakremover(python-Trolly) weakremover(python-Twisted) weakremover(python-UcsSdk) weakremover(python-Unidecode) weakremover(python-WSGIProxy) weakremover(python-WSGIProxy2) weakremover(python-WSME) weakremover(python-WTForms) weakremover(python-WTForms-lang) weakremover(python-WebError) weakremover(python-WebHelpers) weakremover(python-WebOb) weakremover(python-WebTest) weakremover(python-Werkzeug) weakremover(python-Werkzeug-doc) weakremover(python-Whoosh) weakremover(python-XlsxWriter) weakremover(python-YODA) weakremover(python-Yapsy-doc) weakremover(python-ZConfig) weakremover(python-ZConfig-doc) weakremover(python-ZEO) weakremover(python-ZEO-doc) weakremover(python-ZODB) weakremover(python-ZODB3) weakremover(python-acme) weakremover(python-acme-doc) weakremover(python-adal) weakremover(python-aedir) weakremover(python-aioeventlet) weakremover(python-aiohttp-doc) weakremover(python-alabaster) weakremover(python-alembic) weakremover(python-alembic-doc) weakremover(python-amqp) weakremover(python-amqplib) weakremover(python-antlr) weakremover(python-antlr3_runtime) weakremover(python-anyjson) weakremover(python-ao) weakremover(python-aodhclient) weakremover(python-aodhclient-doc) weakremover(python-apache-libcloud) weakremover(python-apfel) weakremover(python-apipkg) weakremover(python-appdirs) weakremover(python-appindicator) weakremover(python-apsw) weakremover(python-apsw-doc) weakremover(python-argcomplete) weakremover(python-argh) weakremover(python-argparse) weakremover(python-astroid) weakremover(python-async) weakremover(python-atomicwrites-doc) weakremover(python-atspi) weakremover(python-attrs) weakremover(python-augeas) weakremover(python-autodoc) weakremover(python-automaton) weakremover(python-autopep8) weakremover(python-avahi) weakremover(python-avahi-gtk) weakremover(python-avogadro) weakremover(python-azure-sdk) weakremover(python-babelfish) weakremover(python-backports) weakremover(python-backports.functools_lru_cache) weakremover(python-backports.ssl_match_hostname) weakremover(python-backports.unittest_mock) weakremover(python-backports_abc) weakremover(python-barbicanclient) weakremover(python-base) weakremover(python-bcdoc) weakremover(python-bcrypt) weakremover(python-beautifulsoup) weakremover(python-beautifulsoup4) weakremover(python-bencode) weakremover(python-betamax) weakremover(python-bibtex) weakremover(python-billiard) weakremover(python-binplist) weakremover(python-biplist) weakremover(python-bjoern) weakremover(python-blessings) weakremover(python-blinker) weakremover(python-blist) weakremover(python-blosc) weakremover(python-bonobo) weakremover(python-boost_parallel_mpi) weakremover(python-boto) weakremover(python-boto-doc) weakremover(python-boto3) weakremover(python-botocore) weakremover(python-bottle) weakremover(python-braille) weakremover(python-bsddb3) weakremover(python-bsddb3-devel) weakremover(python-btrfsutil) weakremover(python-bugzilla) weakremover(python-bugzillatools) weakremover(python-cached-property) weakremover(python-cachetools) weakremover(python-cairo) weakremover(python-cairo-common-devel) weakremover(python-cairo-devel) weakremover(python-cairocffi) weakremover(python-cairocffi-pixbuf) weakremover(python-caja) weakremover(python-caja-devel) weakremover(python-caldav) weakremover(python-camgm) weakremover(python-capng) weakremover(python-carrot) weakremover(python-castellan) weakremover(python-cdecimal) weakremover(python-ceilometerclient) weakremover(python-ceilometerclient-doc) weakremover(python-celery) weakremover(python-celerymon) weakremover(python-ceph-cfg) weakremover(python-ceph-compat) weakremover(python-cephfs) weakremover(python-cerealizer) weakremover(python-certbot) weakremover(python-certbot-apache) weakremover(python-certbot-dns-cloudflare) weakremover(python-certbot-dns-cloudxns) weakremover(python-certbot-dns-digitalocean) weakremover(python-certbot-dns-dnsimple) weakremover(python-certbot-dns-dnsmadeeasy) weakremover(python-certbot-dns-google) weakremover(python-certbot-dns-luadns) weakremover(python-certbot-dns-nsone) weakremover(python-certbot-dns-rfc2136) weakremover(python-certbot-dns-route53) weakremover(python-certbot-nginx) weakremover(python-certifi) weakremover(python-cffi) weakremover(python-characteristic) weakremover(python-chardet) weakremover(python-chewing) weakremover(python-cinderclient) weakremover(python-ciscoconfparse) weakremover(python-cl) weakremover(python-clang) weakremover(python-click) weakremover(python-cliff) weakremover(python-cliff-tablib) weakremover(python-cloud-sptheme-doc) weakremover(python-cloudfiles) weakremover(python-cly) weakremover(python-cmd2) weakremover(python-cmdln) weakremover(python-colorama) weakremover(python-colorlog) weakremover(python-compizconfig) weakremover(python-concurrentloghandler) weakremover(python-configargparse) weakremover(python-configobj) weakremover(python-configparser) weakremover(python-configshell) weakremover(python-configshell-doc) weakremover(python-configshell-fb) weakremover(python-configshell-fb-doc) weakremover(python-congressclient) weakremover(python-congressclient-doc) weakremover(python-construct) weakremover(python-contextlib2) weakremover(python-cotyledon-doc) weakremover(python-couchdbkit) weakremover(python-cov-core) weakremover(python-coverage) weakremover(python-cracklib) weakremover(python-crcmod) weakremover(python-croniter) weakremover(python-cryptography) weakremover(python-cryptopp) weakremover(python-cssselect) weakremover(python-cssutils) weakremover(python-ctypesgen) weakremover(python-cups) weakremover(python-curses) weakremover(python-cursive) weakremover(python-curtsies) weakremover(python-cwiid) weakremover(python-d2to1) weakremover(python-dateutil) weakremover(python-dbus-python-common-devel) weakremover(python-ddt) weakremover(python-debtcollector) weakremover(python-decorator) weakremover(python-dee) weakremover(python-defusedxml) weakremover(python-deltarpm) weakremover(python-demjson) weakremover(python-demo) weakremover(python-dephell-rpm-macros) weakremover(python-deprecation) weakremover(python-designateclient) weakremover(python-detox) weakremover(python-devel) weakremover(python-dfVFS) weakremover(python-dfdatetime) weakremover(python-dfwinreg) weakremover(python-dialog) weakremover(python-dib-utils) weakremover(python-diff_match_patch) weakremover(python-dingus) weakremover(python-discid) weakremover(python-discover) weakremover(python-distorm3) weakremover(python-distutils-extra) weakremover(python-django-appconf) weakremover(python-django-athumb) weakremover(python-django-auth-ldap) weakremover(python-django-authopenid) weakremover(python-django-avatar) weakremover(python-django-celery) weakremover(python-django-dajax) weakremover(python-django-dajaxice) weakremover(python-django-dbtemplates) weakremover(python-django-debug-toolbar) weakremover(python-django-grappelli) weakremover(python-django-guardian) weakremover(python-django-international) weakremover(python-django-mailer) weakremover(python-django-mediasync) weakremover(python-django-navigation) weakremover(python-django-nose) weakremover(python-django-nose-selenium) weakremover(python-django-picklefield) weakremover(python-django-piston) weakremover(python-django-registration) weakremover(python-django-reversion) weakremover(python-django-reversion-doc) weakremover(python-django-static) weakremover(python-django-tastypie) weakremover(python-django_compressor) weakremover(python-django_openstack_auth) weakremover(python-djvulibre) weakremover(python-dmidecode) weakremover(python-dnspython) weakremover(python-doc) weakremover(python-doc-pdf) weakremover(python-docker-py) weakremover(python-docker-py-test) weakremover(python-docker-pycreds) weakremover(python-dockerpty) weakremover(python-docopt) weakremover(python-docutils) weakremover(python-dogpile.cache) weakremover(python-dojango) weakremover(python-dpkt) weakremover(python-dtopt) weakremover(python-dulwich) weakremover(python-dulwich-doc) weakremover(python-ecdsa) weakremover(python-ed25519ll) weakremover(python-editdistance) weakremover(python-efilter) weakremover(python-efl) weakremover(python-efl-doc) weakremover(python-efl-examples) weakremover(python-egenix-mx-base) weakremover(python-egenix-mx-base-devel) weakremover(python-egg) weakremover(python-elasticsearch) weakremover(python-entrypoint2) weakremover(python-enum34) weakremover(python-enzyme) weakremover(python-espeak) weakremover(python-espressopp) weakremover(python-ethtool) weakremover(python-etude) weakremover(python-evemu) weakremover(python-eventlet) weakremover(python-eventlet-doc) weakremover(python-evtx) weakremover(python-execnet) weakremover(python-execnet-doc) weakremover(python-extras) weakremover(python-eyeD3) weakremover(python-factory_boy) weakremover(python-fake-factory) weakremover(python-falcon) weakremover(python-fastcluster-doc) weakremover(python-fasteners) weakremover(python-fastimport) weakremover(python-faulthandler) weakremover(python-fcgi) weakremover(python-fedmsg-base) weakremover(python-fedmsg-doc) weakremover(python-feedparser) weakremover(python-feedzilla) weakremover(python-fityk) weakremover(python-fixtures) weakremover(python-flake8) weakremover(python-flickrapi) weakremover(python-flup) weakremover(python-fs) weakremover(python-fudge) weakremover(python-funcparserlib) weakremover(python-funcsigs) weakremover(python-functional) weakremover(python-functools32) weakremover(python-fuse) weakremover(python-future) weakremover(python-futures) weakremover(python-futurist) weakremover(python-gamin) weakremover(python-gconf) weakremover(python-gcs-oauth2-boto-plugin) weakremover(python-gdal) weakremover(python-gdata) weakremover(python-gdata-doc) weakremover(python-gdbm) weakremover(python-genders) weakremover(python-geopy) weakremover(python-geos) weakremover(python-getdata) weakremover(python-gevent) weakremover(python-gexiv2) weakremover(python-gitdb) weakremover(python-glanceclient) weakremover(python-glareclient) weakremover(python-glareclient-doc) weakremover(python-glucat) weakremover(python-gnocchiclient) weakremover(python-gnocchiclient-doc) weakremover(python-gnome) weakremover(python-gnome-devel) weakremover(python-gnome-dvb-daemon) weakremover(python-gnome-extras) weakremover(python-gnome-extras-devel) weakremover(python-gnomecanvas) weakremover(python-gnomedesktop) weakremover(python-gnomekeyring) weakremover(python-gnomeprint) weakremover(python-gnomevfs) weakremover(python-gnucash) weakremover(python-gnupg) weakremover(python-gobject) weakremover(python-gobject-Gdk) weakremover(python-gobject-cairo) weakremover(python-gobject-common-devel) weakremover(python-gobject-devel) weakremover(python-gobject2) weakremover(python-gobject2-devel) weakremover(python-goocanvas) weakremover(python-goocanvas-devel) weakremover(python-google-api-python-client) weakremover(python-google-apitools) weakremover(python-google-apputils) weakremover(python-gpgme) weakremover(python-gpod) weakremover(python-gpsd) weakremover(python-gr-fcdproplus) weakremover(python-gr-iqbal) weakremover(python-gr-osmosdr) weakremover(python-greenlet) weakremover(python-greenlet-devel) weakremover(python-grequests) weakremover(python-gst) weakremover(python-gstreamer-0_10) weakremover(python-gstreamer-0_10-devel) weakremover(python-gtk) weakremover(python-gtk-devel) weakremover(python-gtk-vnc) weakremover(python-gtksourceview) weakremover(python-gtksourceview-devel) weakremover(python-gtkspell) weakremover(python-gtop) weakremover(python-gudev) weakremover(python-guessit) weakremover(python-gunicorn) weakremover(python-gupnp-igd) weakremover(python-h5py) weakremover(python-hachoir-core) weakremover(python-hachoir-metadata) weakremover(python-hachoir-parser) weakremover(python-halite) weakremover(python-happybase) weakremover(python-heatclient) weakremover(python-hgtools) weakremover(python-hivex) weakremover(python-hl7apy) weakremover(python-holoviews) weakremover(python-hp3parclient) weakremover(python-html2text) weakremover(python-html5lib) weakremover(python-http-parser) weakremover(python-httplib2) weakremover(python-httpretty) weakremover(python-humanfriendly) weakremover(python-hupper-doc) weakremover(python-hypothesis) weakremover(python-ibus) weakremover(python-icalendar) weakremover(python-idle) weakremover(python-idna) weakremover(python-imagesize) weakremover(python-imagestore) weakremover(python-imobiledevice) weakremover(python-iniparse) weakremover(python-interlude) weakremover(python-invoke) weakremover(python-ioflo) weakremover(python-ipa_hbac) weakremover(python-ipaddr) weakremover(python-ipaddress) weakremover(python-iptables) weakremover(python-ipy) weakremover(python-ipython-doc) weakremover(python-ipython_genutils) weakremover(python-ipywidgets-doc) weakremover(python-irclib) weakremover(python-ironic-inspector-client) weakremover(python-ironicclient) weakremover(python-iso8601) weakremover(python-isodate) weakremover(python-isort) weakremover(python-itsdangerous) weakremover(python-jdcal) weakremover(python-jedi) weakremover(python-jenkins) weakremover(python-jenkins-job-builder) weakremover(python-jenkinsapi) weakremover(python-jmespath) weakremover(python-josepy-doc) weakremover(python-jrnl) weakremover(python-jsonpatch) weakremover(python-jsonpath-rw) weakremover(python-jsonpointer) weakremover(python-jsonrpclib) weakremover(python-jsonschema) weakremover(python-junitxml) weakremover(python-jupyter-doc) weakremover(python-jupyter_client-doc) weakremover(python-jupyter_console-doc) weakremover(python-jupyter_core) weakremover(python-jupyter_core-doc) weakremover(python-jupyter_core-doc-html) weakremover(python-jupyter_ipykernel-doc) weakremover(python-jupyter_ipyparallel-doc) weakremover(python-jupyter_ipython-doc) weakremover(python-jupyter_ipywidgets-doc) weakremover(python-jupyter_nbconvert-doc) weakremover(python-jupyter_nbformat) weakremover(python-jupyter_nbformat-doc) weakremover(python-jupyter_notebook-doc) weakremover(python-jupyter_qtconsole-doc) weakremover(python-jwcrypto) weakremover(python-k8sclient) weakremover(python-k8sclient-doc) weakremover(python-kaa-base) weakremover(python-kaa-metadata) weakremover(python-kafka-python) weakremover(python-katedj) weakremover(python-kazoo) weakremover(python-kde4) weakremover(python-kde4-akonadi) weakremover(python-kde4-devel) weakremover(python-kde4-doc) weakremover(python-kde4-khtml) weakremover(python-kde4-knewstuff) weakremover(python-kde4-phonon) weakremover(python-kde4-plasma) weakremover(python-kdebase4) weakremover(python-kerberos) weakremover(python-keybinder) weakremover(python-keyczar) weakremover(python-keyring) weakremover(python-keystoneauth1) weakremover(python-keystoneclient) weakremover(python-keystonemiddleware) weakremover(python-kid) weakremover(python-kid-doc) weakremover(python-killswitch) weakremover(python-kmod) weakremover(python-kombu) weakremover(python-kopano) weakremover(python-krbV) weakremover(python-ktoblzcheck) weakremover(python-lammps) weakremover(python-lash) weakremover(python-launchpadlib) weakremover(python-lazr.uri) weakremover(python-lazy-object-proxy) weakremover(python-lazy_object_proxy) weakremover(python-lcms) weakremover(python-ldap) weakremover(python-ldap3) weakremover(python-ldb) weakremover(python-ldb-devel) weakremover(python-ldns) weakremover(python-lesscpy) weakremover(python-libaccounts) weakremover(python-libaddrxlat) weakremover(python-libbde) weakremover(python-libcec) weakremover(python-libesedb) weakremover(python-libevt) weakremover(python-libevtx) weakremover(python-libewf) weakremover(python-libexe) weakremover(python-libfsntfs) weakremover(python-libfvde) weakremover(python-libfwnt) weakremover(python-libfwsi) weakremover(python-libgpiod) weakremover(python-libgsignon) weakremover(python-libguestfs) weakremover(python-libkdumpfile) weakremover(python-libkolab0) weakremover(python-libkolab1) weakremover(python-libkolabxml1) weakremover(python-liblarch) weakremover(python-liblarch_gtk) weakremover(python-liblnk) weakremover(python-libmount) weakremover(python-libmsiecf) weakremover(python-libnacl) weakremover(python-libolecf) weakremover(python-libpamtest) weakremover(python-libpff) weakremover(python-libpfm) weakremover(python-libprelude) weakremover(python-libpreludedb) weakremover(python-libproxy) weakremover(python-libqcow) weakremover(python-libregf) weakremover(python-libscca) weakremover(python-libsigscan) weakremover(python-libsmdev) weakremover(python-libsmraw) weakremover(python-libstoragemgmt) weakremover(python-libstoragemgmt-clibs) weakremover(python-libteam) weakremover(python-libtorrent-rasterbar) weakremover(python-libvhdi) weakremover(python-libvmdk) weakremover(python-libvshadow) weakremover(python-libvslvm) weakremover(python-libxml2) weakremover(python-lilv) weakremover(python-linecache2) weakremover(python-llfuse-docs) weakremover(python-lmiwbem) weakremover(python-lockfile) weakremover(python-logilab-common) weakremover(python-logutils) weakremover(python-louis) weakremover(python-lxc-python2) weakremover(python-lxml) weakremover(python-lxml-devel) weakremover(python-magic) weakremover(python-magnumclient) weakremover(python-managesieve) weakremover(python-manilaclient) weakremover(python-manilaclient-test) weakremover(python-manuel) weakremover(python-manuel-doc) weakremover(python-mapi) weakremover(python-mapscript) weakremover(python-marisa) weakremover(python-marshmallow-docs) weakremover(python-mate-menus) weakremover(python-mateweather) weakremover(python-mathgl) weakremover(python-matplotlib) weakremover(python-matplotlib-cairo) weakremover(python-matplotlib-designer) weakremover(python-matplotlib-gtk2) weakremover(python-matplotlib-gtk3) weakremover(python-matplotlib-latex) weakremover(python-matplotlib-qt-shared) weakremover(python-matplotlib-qt4) weakremover(python-matplotlib-tk) weakremover(python-matplotlib-web) weakremover(python-matplotlib-wx) weakremover(python-maxminddb) weakremover(python-mccabe) weakremover(python-mechanize) weakremover(python-mechanoid) weakremover(python-metaextract) weakremover(python-microversion_parse) weakremover(python-microversion_parse-doc) weakremover(python-miniupnpc) weakremover(python-mistralclient) weakremover(python-mistune) weakremover(python-mlt) weakremover(python-mock) weakremover(python-mockito) weakremover(python-mockldap) weakremover(python-monascaclient) weakremover(python-mongodict) weakremover(python-monkeysign) weakremover(python-monotonic) weakremover(python-morbid) weakremover(python-mox) weakremover(python-mox3) weakremover(python-mox3-doc) weakremover(python-mpi4py) weakremover(python-mpi4py-common-devel) weakremover(python-mpi4py-devel) weakremover(python-mpi4py-doc) weakremover(python-mpmath-doc) weakremover(python-mpservlets) weakremover(python-mpservlets-doc) weakremover(python-mpservlets-tutorial) weakremover(python-mraa) weakremover(python-msgpack-python) weakremover(python-msrest) weakremover(python-msrestazure) weakremover(python-multi_key_dict) weakremover(python-murano-pkg-check) weakremover(python-muranoclient) weakremover(python-muranoclient-doc) weakremover(python-mutagen) weakremover(python-mysql-connector-python) weakremover(python-nautilus) weakremover(python-nautilus-common-devel) weakremover(python-nautilus-common-files) weakremover(python-nautilus-devel) weakremover(python-nbxmpp) weakremover(python-nbxmpp-doc) weakremover(python-ncclient) weakremover(python-ndg-httpsclient) weakremover(python-nemo) weakremover(python-neovim) weakremover(python-netaddr) weakremover(python-netifaces) weakremover(python-networkx) weakremover(python-neutronclient) weakremover(python-newt) weakremover(python-nghttp2) weakremover(python-nlopt) weakremover(python-nose) weakremover(python-nose-cover3) weakremover(python-nose-doc) weakremover(python-nose-exclude) weakremover(python-nosehtmloutput) weakremover(python-nosexcover) weakremover(python-notify) weakremover(python-notify-devel) weakremover(python-notify2) weakremover(python-notmuch) weakremover(python-notmuch-doc) weakremover(python-novaclient) weakremover(python-novaclient-test) weakremover(python-nss) weakremover(python-nss-doc) weakremover(python-numexpr) weakremover(python-numpy) weakremover(python-numpy-devel) weakremover(python-numpy-doc-html) weakremover(python-numpy-doc-pdf) weakremover(python-numpydoc) weakremover(python-oauth) weakremover(python-oauth2) weakremover(python-oauth2-test) weakremover(python-oauth2client) weakremover(python-oauth2client-django) weakremover(python-oauth2client-flask) weakremover(python-oauth2client-gce) weakremover(python-oauth2client-test) weakremover(python-oauthlib) weakremover(python-obexftp) weakremover(python-odfpy) weakremover(python-odict) weakremover(python-odorik) weakremover(python-openbabel) weakremover(python-opencv) weakremover(python-opencv-qt5) weakremover(python-opengl) weakremover(python-opengl-accelerate) weakremover(python-openpyxl) weakremover(python-openqa_review) weakremover(python-openstack-doc-tools) weakremover(python-openstack.nose_plugin) weakremover(python-openstackclient) weakremover(python-openstackdocstheme) weakremover(python-openstacksdk) weakremover(python-opensync) weakremover(python-openvswitch) weakremover(python-openvswitch-test) weakremover(python-optcomplete) weakremover(python-orbit) weakremover(python-orbit-devel) weakremover(python-os-api-ref) weakremover(python-os-client-config) weakremover(python-os-cloud-config) weakremover(python-os-testr) weakremover(python-os-testr-doc) weakremover(python-os-win) weakremover(python-os-win-doc) weakremover(python-osc-lib) weakremover(python-osdlyrics) weakremover(python-oslo-middleware-doc) weakremover(python-oslo.cache) weakremover(python-oslo.concurrency) weakremover(python-oslo.config) weakremover(python-oslo.context) weakremover(python-oslo.db) weakremover(python-oslo.db-doc) weakremover(python-oslo.i18n) weakremover(python-oslo.log) weakremover(python-oslo.messaging) weakremover(python-oslo.messaging-doc) weakremover(python-oslo.middleware) weakremover(python-oslo.middleware-doc) weakremover(python-oslo.policy) weakremover(python-oslo.privsep) weakremover(python-oslo.reports) weakremover(python-oslo.rootwrap) weakremover(python-oslo.serialization) weakremover(python-oslo.service) weakremover(python-oslo.utils) weakremover(python-oslo.versionedobjects) weakremover(python-oslo.vmware) weakremover(python-oslosphinx) weakremover(python-oslotest) weakremover(python-osprofiler) weakremover(python-ovsdbapp) weakremover(python-packaging) weakremover(python-pam) weakremover(python-pandas-doc) weakremover(python-param) weakremover(python-paramiko) weakremover(python-parsedatetime) weakremover(python-parted) weakremover(python-pass_python_keyring) weakremover(python-passlib) weakremover(python-path.py) weakremover(python-pathlib2) weakremover(python-pathtools) weakremover(python-patsy) weakremover(python-pbr) weakremover(python-pbr-doc) weakremover(python-pcp) weakremover(python-pdfrw) weakremover(python-pecan) weakremover(python-pefile) weakremover(python-pep8) weakremover(python-persistent) weakremover(python-persistent-devel) weakremover(python-persistent-doc) weakremover(python-pexpect) weakremover(python-pickleshare) weakremover(python-pifpaf) weakremover(python-pika) weakremover(python-pika-pool) weakremover(python-pip) weakremover(python-pisock) weakremover(python-piston-mini-client) weakremover(python-pkgconfig) weakremover(python-pkginfo) weakremover(python-plaso) weakremover(python-platformdirs-doc) weakremover(python-plist) weakremover(python-pluggy) weakremover(python-ply) weakremover(python-plyvel) weakremover(python-pmw) weakremover(python-podcastparser) weakremover(python-polib) weakremover(python-poppler) weakremover(python-poppler-qt4) weakremover(python-poppler-qt5) weakremover(python-portpicker) weakremover(python-positional) weakremover(python-posix_ipc) weakremover(python-presage) weakremover(python-pretend) weakremover(python-proboscis) weakremover(python-process-tests) weakremover(python-progressbar) weakremover(python-proliantutils) weakremover(python-promise) weakremover(python-protobuf) weakremover(python-psutil) weakremover(python-psycopg2) weakremover(python-psycopg2-doc) weakremover(python-ptyprocess) weakremover(python-puppetboard) weakremover(python-puppetboard-apache) weakremover(python-puppetboard-uwsgi) weakremover(python-pushy) weakremover(python-pwquality) weakremover(python-py) weakremover(python-py-bcrypt) weakremover(python-py-cpuinfo) weakremover(python-py-doc) weakremover(python-py2pack) weakremover(python-pyBarcode) weakremover(python-pyOpenSSL) weakremover(python-pyOpenSSL-doc) weakremover(python-pyPEG2) weakremover(python-pyRFC3339) weakremover(python-pyasn1) weakremover(python-pyasn1-modules) weakremover(python-pybeam) weakremover(python-pybind11-devel) weakremover(python-pybluez) weakremover(python-pybtex) weakremover(python-pybtex-doc) weakremover(python-pycadf) weakremover(python-pycairo-common-devel) weakremover(python-pycdio) weakremover(python-pycha) weakremover(python-pycountry) weakremover(python-pycparser) weakremover(python-pycrypto) weakremover(python-pycryptopp) weakremover(python-pycurl) weakremover(python-pycurl-test-doc) weakremover(python-pydot) weakremover(python-pydot3) weakremover(python-pydotplus) weakremover(python-pyenchant) weakremover(python-pyexiv2) weakremover(python-pyflakes) weakremover(python-pyftpdlib) weakremover(python-pygame) weakremover(python-pygame-devel) weakremover(python-pygame-doc) weakremover(python-pyghmi) weakremover(python-pygit2) weakremover(python-pyglet) weakremover(python-pygraphviz) weakremover(python-pygraphviz-doc) weakremover(python-pyinotify) weakremover(python-pyinsane) weakremover(python-pyinsane2) weakremover(python-pykerberos) weakremover(python-pylibacl) weakremover(python-pylibacl-doc) weakremover(python-pyliblzma) weakremover(python-pyliblzma-doc) weakremover(python-pylibmc) weakremover(python-pylint) weakremover(python-pylons_sphinx_theme) weakremover(python-pylzma) weakremover(python-pymemcache) weakremover(python-pymod2pkg) weakremover(python-pymongo) weakremover(python-pynag) weakremover(python-pyocr) weakremover(python-pyotherside) weakremover(python-pyparsing) weakremover(python-pyparsing-doc) weakremover(python-pypdf) weakremover(python-pyplete) weakremover(python-pypuppetdb) weakremover(python-pyquery) weakremover(python-pyramid) weakremover(python-pyramid-doc) weakremover(python-pyroute2) weakremover(python-pyrrd) weakremover(python-pyrrd-docs) weakremover(python-pysaml2) weakremover(python-pyscard) weakremover(python-pysendfile) weakremover(python-pyserial) weakremover(python-pyside) weakremover(python-pyside-common) weakremover(python-pyside-devel) weakremover(python-pyside-doc) weakremover(python-pyside-shiboken) weakremover(python-pyside-shiboken-doc) weakremover(python-pyside-tools) weakremover(python-pysmell) weakremover(python-pysmi) weakremover(python-pysnmp) weakremover(python-pysnmp-utils) weakremover(python-pysqlite) weakremover(python-pysrt) weakremover(python-pysvn) weakremover(python-pyte) weakremover(python-pytest) weakremover(python-pytest-cov) weakremover(python-pytest-doc) weakremover(python-pytest-runner) weakremover(python-python-daemon) weakremover(python-python-digest) weakremover(python-python-editor) weakremover(python-python-gammu) weakremover(python-python-gflags) weakremover(python-python-jenkins) weakremover(python-python-memcached) weakremover(python-python-mimeparse) weakremover(python-python-openid) weakremover(python-python-rtmidi-doc) weakremover(python-python-sql) weakremover(python-python-stdnum) weakremover(python-python-subunit) weakremover(python-python-termstyle) weakremover(python-python-urljr) weakremover(python-pytidylib) weakremover(python-pytidylib6) weakremover(python-pytools) weakremover(python-pytz) weakremover(python-pyuca) weakremover(python-pyudev) weakremover(python-pywbem) weakremover(python-pyweblib) weakremover(python-pyxb) weakremover(python-pyzmq) weakremover(python-pyzmq-devel) weakremover(python-qpid) weakremover(python-qpid-common) weakremover(python-qpid-proton) weakremover(python-qpid-proton-doc) weakremover(python-qpid-qmf) weakremover(python-qpid_messaging) weakremover(python-qrcode) weakremover(python-qscintilla) weakremover(python-qscintilla-qt4-sip) weakremover(python-qscintilla-qt5-sip) weakremover(python-qscintilla-sip) weakremover(python-qt3d-qt5-api) weakremover(python-qt3d-qt5-examples) weakremover(python-qt3d-qt5-sip) weakremover(python-qt4) weakremover(python-qt4-devel) weakremover(python-qt4-doc) weakremover(python-qt4-utils) weakremover(python-qt5) weakremover(python-qt5-common-devel) weakremover(python-qt5-devel) weakremover(python-qt5-doc) weakremover(python-qt5-utils) weakremover(python-qtcharts-qt5-api) weakremover(python-qtcharts-qt5-examples) weakremover(python-qtcharts-qt5-sip) weakremover(python-qtdatavis3d-qt5-api) weakremover(python-qtdatavis3d-qt5-examples) weakremover(python-qtdatavis3d-qt5-sip) weakremover(python-qtwebengine-qt5-api) weakremover(python-qtwebengine-qt5-sip) weakremover(python-rados) weakremover(python-raet) weakremover(python-random2) weakremover(python-rarfile) weakremover(python-rarfile-doc) weakremover(python-ravello-sdk) weakremover(python-rbd) weakremover(python-rcssmin-docs) weakremover(python-rdflib) weakremover(python-rebulk) weakremover(python-redis) weakremover(python-redland) weakremover(python-rednose) weakremover(python-regex) weakremover(python-relatorio) weakremover(python-remoto) weakremover(python-renderspec) weakremover(python-reno) weakremover(python-reportlab) weakremover(python-repoze.lru) weakremover(python-repoze.sphinx.autointerface) weakremover(python-repoze.who) weakremover(python-requestbuilder) weakremover(python-requests) weakremover(python-requests-kerberos) weakremover(python-requests-mock) weakremover(python-requests-oauthlib) weakremover(python-requests-toolbelt) weakremover(python-requestsexceptions) weakremover(python-requirements-detector) weakremover(python-requirements-parser) weakremover(python-restkit) weakremover(python-retry_decorator) weakremover(python-retrying) weakremover(python-rfc3986) weakremover(python-rgw) weakremover(python-rjsmin-docs) weakremover(python-roman) weakremover(python-rope) weakremover(python-rrdtool) weakremover(python-rsa) weakremover(python-rst2pdf) weakremover(python-rsvg) weakremover(python-rtslib) weakremover(python-rtslib-fb-doc) weakremover(python-ruamel.base) weakremover(python-ruamel.ordereddict) weakremover(python-ruamel.yaml) weakremover(python-ryu-common) weakremover(python-s3transfer) weakremover(python-saharaclient) weakremover(python-salt-testing) weakremover(python-sanlock) weakremover(python-scgi) weakremover(python-scipy) weakremover(python-scipy-weave) weakremover(python-scitools) weakremover(python-scour) weakremover(python-scripttest) weakremover(python-seacucumber) weakremover(python-selinux) weakremover(python-semanage) weakremover(python-semantic_version) weakremover(python-semver) weakremover(python-send2trash) weakremover(python-senlinclient) weakremover(python-service_identity) weakremover(python-setools) weakremover(python-setproctitle) weakremover(python-setuptools) weakremover(python-setuptools-git) weakremover(python-setuptools_scm) weakremover(python-sh) weakremover(python-sievelib) weakremover(python-simplebayes) weakremover(python-simpleeval) weakremover(python-simplegeneric) weakremover(python-simplejson) weakremover(python-singledispatch) weakremover(python-sip) weakremover(python-sip-common) weakremover(python-sip-devel) weakremover(python-sip5-doc) weakremover(python-sip6-doc) weakremover(python-six) weakremover(python-slapdsock) weakremover(python-sleekxmpp) weakremover(python-slimit) weakremover(python-slimmer) weakremover(python-slip) weakremover(python-slip-dbus) weakremover(python-slip-gtk) weakremover(python-slowaes) weakremover(python-slumber) weakremover(python-smbc) weakremover(python-smmap) weakremover(python-snowballstemmer) weakremover(python-socketpool) weakremover(python-solo-python) weakremover(python-solv) weakremover(python-sortedcontainers) weakremover(python-sortedcontainers-doc) weakremover(python-sphinx-testing) weakremover(python-sphinx_rtd_theme) weakremover(python-sphinxcontrib) weakremover(python-sphinxcontrib-breathe) weakremover(python-sphinxcontrib-docbookrestapi) weakremover(python-sphinxcontrib-httpdomain) weakremover(python-sphinxcontrib-issuetracker) weakremover(python-sphinxcontrib-pecanwsme) weakremover(python-sphinxcontrib-programoutput) weakremover(python-sphinxcontrib-websupport) weakremover(python-spyderlib) weakremover(python-sqlalchemy-migrate) weakremover(python-sqlparse) weakremover(python-sss_nss_idmap) weakremover(python-sssd-config) weakremover(python-statsd) weakremover(python-stevedore) weakremover(python-stomper) weakremover(python-storm) weakremover(python-storm-django) weakremover(python-storm-mysql) weakremover(python-storm-postgresql) weakremover(python-storm-twisted) weakremover(python-subprocess32) weakremover(python-suds) weakremover(python-suds-jurko) weakremover(python-sure) weakremover(python-sushy) weakremover(python-svg2rlg) weakremover(python-swiftclient) weakremover(python-sympy) weakremover(python-systemd) weakremover(python-tables) weakremover(python-tables-doc) weakremover(python-tablib) weakremover(python-tabulate) weakremover(python-tagpy) weakremover(python-talloc) weakremover(python-talloc-devel) weakremover(python-taskflow) weakremover(python-taskflow-doc) weakremover(python-tdb) weakremover(python-tempest-lib) weakremover(python-temps) weakremover(python-tenacity) weakremover(python-termcolor) weakremover(python-terminado) weakremover(python-testpath) weakremover(python-testrepository) weakremover(python-testresources) weakremover(python-testscenarios) weakremover(python-testtools) weakremover(python-testtools-doc) weakremover(python-tevent) weakremover(python-textX-doc) weakremover(python-texttable) weakremover(python-thrift) weakremover(python-tk) weakremover(python-tlslite) weakremover(python-tlslite-doc) weakremover(python-tn3270) weakremover(python-tooz) weakremover(python-tornado) weakremover(python-totem) weakremover(python-tox) weakremover(python-tox-doc) weakremover(python-traceback2) weakremover(python-traitlets) weakremover(python-transaction) weakremover(python-transaction-doc) weakremover(python-translationstring) weakremover(python-tre) weakremover(python-trollius) weakremover(python-troveclient) weakremover(python-troveclient-doc) weakremover(python-tsk) weakremover(python-tweepy) weakremover(python-twine) weakremover(python-txsocksx) weakremover(python-typing) weakremover(python-tzlocal) weakremover(python-ujson) weakremover(python-uncertainties) weakremover(python-unicodecsv) weakremover(python-unittest-xml-reporting) weakremover(python-unittest2) weakremover(python-uritemplate) weakremover(python-urlgrabber) weakremover(python-urllib3) weakremover(python-urwid) weakremover(python-usb) weakremover(python-utidy) weakremover(python-utidy-devel-doc) weakremover(python-vcs) weakremover(python-vcversioner) weakremover(python-venusian) weakremover(python-venusian-doc) weakremover(python-versiontools) weakremover(python-veusz) weakremover(python-vips) weakremover(python-virtkey) weakremover(python-virtualenv) weakremover(python-virtualenv-clone) weakremover(python-virtualenv-doc) weakremover(python-virtualenvwrapper) weakremover(python-vobject) weakremover(python-volatility) weakremover(python-voluptuous) weakremover(python-vte) weakremover(python-wadllib) weakremover(python-waitress) weakremover(python-warlock) weakremover(python-watcherclient) weakremover(python-watcherclient-doc) weakremover(python-wcwidth) weakremover(python-weakrefmethod) weakremover(python-weave) weakremover(python-web.py) weakremover(python-webkitgtk) weakremover(python-webkitgtk-devel) weakremover(python-websocket-client) weakremover(python-websocket-client-test) weakremover(python-websockify) weakremover(python-websockify-common) weakremover(python-webunit) weakremover(python-wheel) weakremover(python-wikipedia) weakremover(python-wnck) weakremover(python-wrapt) weakremover(python-wsgi_intercept) weakremover(python-wsgiref) weakremover(python-wxWidgets) weakremover(python-wxWidgets-3_0) weakremover(python-wxWidgets-3_0-devel) weakremover(python-wxWidgets-3_0-lang) weakremover(python-wxWidgets-devel) weakremover(python-wxWidgets-lang) weakremover(python-xapian) weakremover(python-xapp) weakremover(python-xattr) weakremover(python-xcaplib-bash-completion) weakremover(python-xcb-proto-devel) weakremover(python-xdg) weakremover(python-xklavier) weakremover(python-xlib) weakremover(python-xlrd) weakremover(python-xlwt) weakremover(python-xml) weakremover(python-xmldiff) weakremover(python-xmms2) weakremover(python-yaql) weakremover(python-yara) weakremover(python-youtube-dl) weakremover(python-yubico) weakremover(python-yui) weakremover(python-yum) weakremover(python-z3) weakremover(python-zake) weakremover(python-zaqarclient) weakremover(python-zaqarclient-doc) weakremover(python-zbar) weakremover(python-zbar-gtk) weakremover(python-zc.lockfile) weakremover(python-zc_buildout) weakremover(python-zdaemon) weakremover(python-zeroconf) weakremover(python-zinnia) weakremover(python-zope.component) weakremover(python-zope.component-doc) weakremover(python-zope.configuration) weakremover(python-zope.configuration-doc) weakremover(python-zope.deprecation) weakremover(python-zope.event) weakremover(python-zope.exceptions) weakremover(python-zope.exceptions-doc) weakremover(python-zope.hookable) weakremover(python-zope.i18nmessageid) weakremover(python-zope.interface) weakremover(python-zope.interface-doc) weakremover(python-zope.location-doc) weakremover(python-zope.proxy) weakremover(python-zope.proxy-devel) weakremover(python-zope.proxy-doc) weakremover(python-zope.schema) weakremover(python-zope.schema-doc) weakremover(python-zope.security-doc) weakremover(python-zope.testbrowser) weakremover(python-zope.testing) weakremover(python-zope.testrunner) weakremover(python-zypp) weakremover(python2-3to2) weakremover(python2-APScheduler) weakremover(python2-AnyQt) weakremover(python2-Arpeggio) weakremover(python2-Automat) weakremover(python2-BTrees) weakremover(python2-BTrees-devel) weakremover(python2-BTrees-doc) weakremover(python2-Babel) weakremover(python2-Beaker) weakremover(python2-BitVector) weakremover(python2-Bottleneck) weakremover(python2-Brotli) weakremover(python2-CDDB) weakremover(python2-CXX) weakremover(python2-CXX-devel) weakremover(python2-CacheControl) weakremover(python2-Cerberus) weakremover(python2-Chameleon) weakremover(python2-Chameleon-doc) weakremover(python2-Cheetah3) weakremover(python2-CherryPy) weakremover(python2-CommonMark) weakremover(python2-Cycler) weakremover(python2-Cython) weakremover(python2-DataProperty) weakremover(python2-DataShape) weakremover(python2-DateTime) weakremover(python2-Delorean) weakremover(python2-Deprecated) weakremover(python2-Django1) weakremover(python2-Durus) weakremover(python2-EasyProcess) weakremover(python2-EditorConfig) weakremover(python2-ExifRead) weakremover(python2-Fabric) weakremover(python2-Fabric3) weakremover(python2-Faker) weakremover(python2-Fiona) weakremover(python2-Flask) weakremover(python2-Flask-Admin) weakremover(python2-Flask-Babel) weakremover(python2-Flask-BabelEx) weakremover(python2-Flask-Bootstrap) weakremover(python2-Flask-Cache) weakremover(python2-Flask-Cache-doc) weakremover(python2-Flask-Compress) weakremover(python2-Flask-Cors) weakremover(python2-Flask-Gravatar) weakremover(python2-Flask-HTMLmin) weakremover(python2-Flask-HTTPAuth) weakremover(python2-Flask-Login) weakremover(python2-Flask-Mail) weakremover(python2-Flask-Migrate) weakremover(python2-Flask-Paranoid) weakremover(python2-Flask-Principal) weakremover(python2-Flask-PyMongo) weakremover(python2-Flask-RESTful) weakremover(python2-Flask-RSTPages) weakremover(python2-Flask-SQLAlchemy) weakremover(python2-Flask-Script) weakremover(python2-Flask-Security) weakremover(python2-Flask-Testing) weakremover(python2-Flask-WTF) weakremover(python2-Flask-doc) weakremover(python2-FontTools) weakremover(python2-FormEncode) weakremover(python2-Frozen-Flask) weakremover(python2-GDAL) weakremover(python2-Genshi) weakremover(python2-GeoIP) weakremover(python2-GitPython) weakremover(python2-Glances) weakremover(python2-Gloo) weakremover(python2-Glymur) weakremover(python2-GooCalendar) weakremover(python2-GridDataFormats) weakremover(python2-HTTPolice) weakremover(python2-HeapDict) weakremover(python2-Jinja2) weakremover(python2-Js2Py) weakremover(python2-JsonWeb) weakremover(python2-Kajiki) weakremover(python2-Keras-Applications) weakremover(python2-Keras-Preprocessing) weakremover(python2-Kivy) weakremover(python2-Kivy-devel) weakremover(python2-LEPL) weakremover(python2-Lektor) weakremover(python2-Levenshtein) weakremover(python2-Logbook) weakremover(python2-M2Crypto) weakremover(python2-Mako) weakremover(python2-MapProxy) weakremover(python2-Markdown) weakremover(python2-MarkupPy) weakremover(python2-MarkupSafe) weakremover(python2-Markups) weakremover(python2-Mathics) weakremover(python2-MechanicalSoup) weakremover(python2-Ming) weakremover(python2-MiniMock) weakremover(python2-Morfessor) weakremover(python2-MulticoreTSNE) weakremover(python2-OWSLib) weakremover(python2-PGet) weakremover(python2-Parsley) weakremover(python2-Paste) weakremover(python2-PasteDeploy) weakremover(python2-PasteScript) weakremover(python2-Paver) weakremover(python2-PeakUtils) weakremover(python2-Pebble) weakremover(python2-Pillow) weakremover(python2-Pillow-tk) weakremover(python2-Pint) weakremover(python2-PrettyTable) weakremover(python2-Protego) weakremover(python2-PsyLab) weakremover(python2-PsychoPy) weakremover(python2-PsychoPy-lang) weakremover(python2-PyAudio) weakremover(python2-PyAutoGUI) weakremover(python2-PyBindGen) weakremover(python2-PyBrowserID) weakremover(python2-PyChart) weakremover(python2-PyDispatcher) weakremover(python2-PyECLib) weakremover(python2-PyExecJS) weakremover(python2-PyFxA) weakremover(python2-PyGithub) weakremover(python2-PyHamcrest) weakremover(python2-PyICU) weakremover(python2-PyInstaller) weakremover(python2-PyJWT) weakremover(python2-PyKMIP) weakremover(python2-PyMeeus) weakremover(python2-PyMeta3) weakremover(python2-PyMsgBox) weakremover(python2-PyMuPDF) weakremover(python2-PyMySQL) weakremover(python2-PyNaCl) weakremover(python2-PyNamecheap) weakremover(python2-PyOgg) weakremover(python2-PyOpenAL) weakremover(python2-PyPDF2) weakremover(python2-PyPrind) weakremover(python2-PyQRCode) weakremover(python2-PyRIC) weakremover(python2-PyRSS2Gen) weakremover(python2-PySDL2) weakremover(python2-PyScreeze) weakremover(python2-PySocks) weakremover(python2-PyTrie) weakremover(python2-PyTweening) weakremover(python2-PyVirtualDisplay) weakremover(python2-PyWavelets) weakremover(python2-PyWebDAV3) weakremover(python2-PyX) weakremover(python2-PyYAML) weakremover(python2-Pydap) weakremover(python2-Pygments) weakremover(python2-Pykka) weakremover(python2-Pympler) weakremover(python2-Pyphen) weakremover(python2-Pyrex) weakremover(python2-Pyro4) weakremover(python2-QDarkStyle) weakremover(python2-QR-Code-generator) weakremover(python2-Qt.py) weakremover(python2-QtAwesome) weakremover(python2-QtPy) weakremover(python2-Quandl) weakremover(python2-Routes) weakremover(python2-SPARQLWrapper) weakremover(python2-SQLAlchemy) weakremover(python2-SQLAlchemy-Utils) weakremover(python2-Scrapy) weakremover(python2-SecretStorage) weakremover(python2-Send2Trash) weakremover(python2-Shapely) weakremover(python2-SimpleWebSocketServer) weakremover(python2-SoundFile) weakremover(python2-SpeechRecognition) weakremover(python2-Sphinx) weakremover(python2-Sphinx-doc) weakremover(python2-Sphinx-doc-html) weakremover(python2-Sphinx-doc-man) weakremover(python2-Sphinx-latex) weakremover(python2-Sphinx-test) weakremover(python2-Tempita) weakremover(python2-TermRecord) weakremover(python2-Theano) weakremover(python2-Trolly) weakremover(python2-Trololio) weakremover(python2-Twisted) weakremover(python2-TxSNI) weakremover(python2-URLObject) weakremover(python2-UkPostcodeParser) weakremover(python2-Unidecode) weakremover(python2-WSGIProxy2) weakremover(python2-WSME) weakremover(python2-WTForms) weakremover(python2-WTForms-lang) weakremover(python2-WebHelpers) weakremover(python2-WebOb) weakremover(python2-WebTest) weakremover(python2-Werkzeug) weakremover(python2-Whoosh) weakremover(python2-XStatic) weakremover(python2-XStatic-Angular-Schema-Form) weakremover(python2-XStatic-jQuery) weakremover(python2-XStatic-jquery-ui) weakremover(python2-XStatic-objectpath) weakremover(python2-XStatic-term.js) weakremover(python2-XStatic-tv4) weakremover(python2-XlsxWriter) weakremover(python2-Yapsy) weakremover(python2-ZConfig) weakremover(python2-ZConfig-doc) weakremover(python2-ZEO) weakremover(python2-ZODB) weakremover(python2-abclient) weakremover(python2-abimap) weakremover(python2-abimap-doc) weakremover(python2-abseil) weakremover(python2-aci-integration-module) weakremover(python2-acitoolkit) weakremover(python2-acme) weakremover(python2-actdiag) weakremover(python2-adal) weakremover(python2-adapt-parser) weakremover(python2-addict) weakremover(python2-aenum) weakremover(python2-aexpect) weakremover(python2-affine) weakremover(python2-agate) weakremover(python2-agate-dbf) weakremover(python2-agate-excel) weakremover(python2-agate-lookup) weakremover(python2-agate-remote) weakremover(python2-agate-sql) weakremover(python2-agate-stats) weakremover(python2-aiodns) weakremover(python2-aioeventlet) weakremover(python2-aiohttp-theme) weakremover(python2-akismet) weakremover(python2-alabaster) weakremover(python2-alembic) weakremover(python2-allpairspy) weakremover(python2-alsa) weakremover(python2-altair) weakremover(python2-altair-widgets) weakremover(python2-altgraph) weakremover(python2-amqp) weakremover(python2-amqplib) weakremover(python2-amqpstorm) weakremover(python2-ana) weakremover(python2-aniso8601) weakremover(python2-annoy) weakremover(python2-ansel) weakremover(python2-ansi2html) weakremover(python2-ansicolor) weakremover(python2-ansicolors) weakremover(python2-ansiwrap) weakremover(python2-antlr) weakremover(python2-anyjson) weakremover(python2-apache-libcloud) weakremover(python2-apicapi) weakremover(python2-apipkg) weakremover(python2-appdirs) weakremover(python2-appindicator) weakremover(python2-application) weakremover(python2-applicationinsights) weakremover(python2-apptools) weakremover(python2-apsw) weakremover(python2-arabic-reshaper) weakremover(python2-arf) weakremover(python2-argcomplete) weakremover(python2-argh) weakremover(python2-argon2-cffi) weakremover(python2-argparse-manpage) weakremover(python2-args) weakremover(python2-arrow) weakremover(python2-asciimatics) weakremover(python2-asn1crypto) weakremover(python2-aspectlib) weakremover(python2-aspy.yaml) weakremover(python2-asteval) weakremover(python2-astor) weakremover(python2-astral) weakremover(python2-astroid) weakremover(python2-astropy) weakremover(python2-astropy-helpers) weakremover(python2-astunparse) weakremover(python2-asv) weakremover(python2-atlassian-python-api) weakremover(python2-atom) weakremover(python2-atomicwrites) weakremover(python2-atspi) weakremover(python2-attr) weakremover(python2-attrs) weakremover(python2-aubio) weakremover(python2-audiogrep) weakremover(python2-audiolazy) weakremover(python2-audioread) weakremover(python2-audit) weakremover(python2-augeas) weakremover(python2-autobahn) weakremover(python2-autodoc) weakremover(python2-autoflake) weakremover(python2-automaton) weakremover(python2-autopep8) weakremover(python2-autoupgrade-ng) weakremover(python2-av) weakremover(python2-avocado) weakremover(python2-avocado-plugins-glib) weakremover(python2-avocado-plugins-golang) weakremover(python2-avocado-plugins-loader-yaml) weakremover(python2-avocado-plugins-output-html) weakremover(python2-avocado-plugins-result-upload) weakremover(python2-avocado-plugins-resultsdb) weakremover(python2-avocado-plugins-runner-docker) weakremover(python2-avocado-plugins-runner-remote) weakremover(python2-avocado-plugins-runner-vm) weakremover(python2-avocado-plugins-varianter-pict) weakremover(python2-avocado-plugins-varianter-yaml-to-mux) weakremover(python2-avocado-plugins-vt) weakremover(python2-avro) weakremover(python2-aws-sam-translator) weakremover(python2-aws-xray-sdk) weakremover(python2-aws-xray-sdk-Django) weakremover(python2-aws-xray-sdk-Flask-SQLAlchemy) weakremover(python2-aws-xray-sdk-SQLAlchemy) weakremover(python2-aws-xray-sdk-all) weakremover(python2-aws-xray-sdk-mysql-connector) weakremover(python2-aws-xray-sdk-psycopg2) weakremover(python2-aws-xray-sdk-pymongo) weakremover(python2-aws-xray-sdk-pynamodb) weakremover(python2-aws-xray-sdk-requests) weakremover(python2-axolotl) weakremover(python2-axolotl-curve25519) weakremover(python2-ayatana-appindicator) weakremover(python2-azure-ai-nspkg) weakremover(python2-azure-ai-textanalytics) weakremover(python2-azure-appconfiguration) weakremover(python2-azure-applicationinsights) weakremover(python2-azure-batch) weakremover(python2-azure-cognitiveservices-anomalydetector) weakremover(python2-azure-cognitiveservices-formrecognizer) weakremover(python2-azure-cognitiveservices-inkrecognizer) weakremover(python2-azure-cognitiveservices-knowledge-nspkg) weakremover(python2-azure-cognitiveservices-knowledge-qnamaker) weakremover(python2-azure-cognitiveservices-language-luis) weakremover(python2-azure-cognitiveservices-language-nspkg) weakremover(python2-azure-cognitiveservices-language-spellcheck) weakremover(python2-azure-cognitiveservices-language-textanalytics) weakremover(python2-azure-cognitiveservices-nspkg) weakremover(python2-azure-cognitiveservices-personalizer) weakremover(python2-azure-cognitiveservices-search-autosuggest) weakremover(python2-azure-cognitiveservices-search-customimagesearch) weakremover(python2-azure-cognitiveservices-search-customsearch) weakremover(python2-azure-cognitiveservices-search-entitysearch) weakremover(python2-azure-cognitiveservices-search-imagesearch) weakremover(python2-azure-cognitiveservices-search-newssearch) weakremover(python2-azure-cognitiveservices-search-nspkg) weakremover(python2-azure-cognitiveservices-search-videosearch) weakremover(python2-azure-cognitiveservices-search-visualsearch) weakremover(python2-azure-cognitiveservices-search-websearch) weakremover(python2-azure-cognitiveservices-vision-computervision) weakremover(python2-azure-cognitiveservices-vision-contentmoderator) weakremover(python2-azure-cognitiveservices-vision-customvision) weakremover(python2-azure-cognitiveservices-vision-face) weakremover(python2-azure-cognitiveservices-vision-nspkg) weakremover(python2-azure-common) weakremover(python2-azure-core) weakremover(python2-azure-core-tracing-opencensus) weakremover(python2-azure-cosmos) weakremover(python2-azure-datalake-store) weakremover(python2-azure-devops) weakremover(python2-azure-eventgrid) weakremover(python2-azure-eventhub) weakremover(python2-azure-eventhub-checkpointstoreblob) weakremover(python2-azure-functions-devops-build) weakremover(python2-azure-graphrbac) weakremover(python2-azure-identity) weakremover(python2-azure-keyvault) weakremover(python2-azure-keyvault-certificates) weakremover(python2-azure-keyvault-keys) weakremover(python2-azure-keyvault-nspkg) weakremover(python2-azure-keyvault-secrets) weakremover(python2-azure-loganalytics) weakremover(python2-azure-mgmt) weakremover(python2-azure-mgmt-advisor) weakremover(python2-azure-mgmt-alertsmanagement) weakremover(python2-azure-mgmt-apimanagement) weakremover(python2-azure-mgmt-appconfiguration) weakremover(python2-azure-mgmt-applicationinsights) weakremover(python2-azure-mgmt-appplatform) weakremover(python2-azure-mgmt-attestation) weakremover(python2-azure-mgmt-authorization) weakremover(python2-azure-mgmt-automation) weakremover(python2-azure-mgmt-azurestack) weakremover(python2-azure-mgmt-batch) weakremover(python2-azure-mgmt-batchai) weakremover(python2-azure-mgmt-billing) weakremover(python2-azure-mgmt-botservice) weakremover(python2-azure-mgmt-cdn) weakremover(python2-azure-mgmt-cognitiveservices) weakremover(python2-azure-mgmt-commerce) weakremover(python2-azure-mgmt-compute) weakremover(python2-azure-mgmt-consumption) weakremover(python2-azure-mgmt-containerinstance) weakremover(python2-azure-mgmt-containerregistry) weakremover(python2-azure-mgmt-containerservice) weakremover(python2-azure-mgmt-cosmosdb) weakremover(python2-azure-mgmt-costmanagement) weakremover(python2-azure-mgmt-databoxedge) weakremover(python2-azure-mgmt-databricks) weakremover(python2-azure-mgmt-datafactory) weakremover(python2-azure-mgmt-datalake-analytics) weakremover(python2-azure-mgmt-datalake-nspkg) weakremover(python2-azure-mgmt-datalake-store) weakremover(python2-azure-mgmt-datamigration) weakremover(python2-azure-mgmt-datashare) weakremover(python2-azure-mgmt-deploymentmanager) weakremover(python2-azure-mgmt-devspaces) weakremover(python2-azure-mgmt-devtestlabs) weakremover(python2-azure-mgmt-dns) weakremover(python2-azure-mgmt-documentdb) weakremover(python2-azure-mgmt-edgegateway) weakremover(python2-azure-mgmt-eventgrid) weakremover(python2-azure-mgmt-eventhub) weakremover(python2-azure-mgmt-frontdoor) weakremover(python2-azure-mgmt-hanaonazure) weakremover(python2-azure-mgmt-hdinsight) weakremover(python2-azure-mgmt-healthcareapis) weakremover(python2-azure-mgmt-hybridcompute) weakremover(python2-azure-mgmt-imagebuilder) weakremover(python2-azure-mgmt-iotcentral) weakremover(python2-azure-mgmt-iothub) weakremover(python2-azure-mgmt-iothubprovisioningservices) weakremover(python2-azure-mgmt-keyvault) weakremover(python2-azure-mgmt-kusto) weakremover(python2-azure-mgmt-labservices) weakremover(python2-azure-mgmt-loganalytics) weakremover(python2-azure-mgmt-logic) weakremover(python2-azure-mgmt-machinelearningcompute) weakremover(python2-azure-mgmt-machinelearningservices) weakremover(python2-azure-mgmt-managedservices) weakremover(python2-azure-mgmt-managementgroups) weakremover(python2-azure-mgmt-managementpartner) weakremover(python2-azure-mgmt-maps) weakremover(python2-azure-mgmt-marketplaceordering) weakremover(python2-azure-mgmt-media) weakremover(python2-azure-mgmt-mixedreality) weakremover(python2-azure-mgmt-monitor) weakremover(python2-azure-mgmt-msi) weakremover(python2-azure-mgmt-netapp) weakremover(python2-azure-mgmt-network) weakremover(python2-azure-mgmt-notificationhubs) weakremover(python2-azure-mgmt-nspkg) weakremover(python2-azure-mgmt-peering) weakremover(python2-azure-mgmt-policyinsights) weakremover(python2-azure-mgmt-powerbiembedded) weakremover(python2-azure-mgmt-privatedns) weakremover(python2-azure-mgmt-rdbms) weakremover(python2-azure-mgmt-recoveryservices) weakremover(python2-azure-mgmt-recoveryservicesbackup) weakremover(python2-azure-mgmt-redis) weakremover(python2-azure-mgmt-relay) weakremover(python2-azure-mgmt-reservations) weakremover(python2-azure-mgmt-resource) weakremover(python2-azure-mgmt-resourcegraph) weakremover(python2-azure-mgmt-scheduler) weakremover(python2-azure-mgmt-search) weakremover(python2-azure-mgmt-security) weakremover(python2-azure-mgmt-serialconsole) weakremover(python2-azure-mgmt-servermanager) weakremover(python2-azure-mgmt-servicebus) weakremover(python2-azure-mgmt-servicefabric) weakremover(python2-azure-mgmt-signalr) weakremover(python2-azure-mgmt-sql) weakremover(python2-azure-mgmt-sqlvirtualmachine) weakremover(python2-azure-mgmt-storage) weakremover(python2-azure-mgmt-storagecache) weakremover(python2-azure-mgmt-storagesync) weakremover(python2-azure-mgmt-subscription) weakremover(python2-azure-mgmt-trafficmanager) weakremover(python2-azure-mgmt-vmwarecloudsimple) weakremover(python2-azure-mgmt-web) weakremover(python2-azure-monitor) weakremover(python2-azure-multiapi-storage) weakremover(python2-azure-nspkg) weakremover(python2-azure-servicebus) weakremover(python2-azure-servicefabric) weakremover(python2-azure-servicemanagement-legacy) weakremover(python2-azure-storage) weakremover(python2-azure-storage-blob) weakremover(python2-azure-storage-common) weakremover(python2-azure-storage-file) weakremover(python2-azure-storage-file-datalake) weakremover(python2-azure-storage-file-share) weakremover(python2-azure-storage-nspkg) weakremover(python2-azure-storage-queue) weakremover(python2-babelfish) weakremover(python2-backcall) weakremover(python2-backoff) weakremover(python2-backports) weakremover(python2-backports.csv) weakremover(python2-backports.functools_lru_cache) weakremover(python2-backports.functools_partialmethod) weakremover(python2-backports.html) weakremover(python2-backports.os) weakremover(python2-backports.shutil_get_terminal_size) weakremover(python2-backports.shutil_which) weakremover(python2-backports.ssl_match_hostname) weakremover(python2-backports.tempfile) weakremover(python2-backports.test.support) weakremover(python2-backports.time-perf-counter) weakremover(python2-backports.unittest_mock) weakremover(python2-backports.weakref) weakremover(python2-backports_abc) weakremover(python2-bandit) weakremover(python2-baron) weakremover(python2-bashate) weakremover(python2-bcc) weakremover(python2-bcrypt) weakremover(python2-beautifulsoup4) weakremover(python2-behave) weakremover(python2-bencode) weakremover(python2-beniget) weakremover(python2-betamax) weakremover(python2-betamax-matchers) weakremover(python2-bibtexparser) weakremover(python2-bidict) weakremover(python2-billiard) weakremover(python2-binary) weakremover(python2-binaryornot) weakremover(python2-bindep) weakremover(python2-binplist) weakremover(python2-biopython) weakremover(python2-biplist) weakremover(python2-bitarray) weakremover(python2-bitstring) weakremover(python2-bjoern) weakremover(python2-bleach) weakremover(python2-blessed) weakremover(python2-blessings) weakremover(python2-blindspin) weakremover(python2-blinker) weakremover(python2-blist) weakremover(python2-blockdiag) weakremover(python2-bobo) weakremover(python2-bobodoctestumentation) weakremover(python2-bokeh) weakremover(python2-boltons) weakremover(python2-boolean.py) weakremover(python2-boost_parallel_mpi1_66_0) weakremover(python2-boost_parallel_mpi1_68_0) weakremover(python2-boost_parallel_mpi1_69_0) weakremover(python2-boost_parallel_mpi1_71_0) weakremover(python2-boto) weakremover(python2-boto3) weakremover(python2-botocore) weakremover(python2-bottle) weakremover(python2-bpython) weakremover(python2-bqplot) weakremover(python2-braille) weakremover(python2-branca) weakremover(python2-breathe) weakremover(python2-brewer2mpl) weakremover(python2-brotlipy) weakremover(python2-bsddb3) weakremover(python2-bsddb3-devel) weakremover(python2-bson) weakremover(python2-bugzillatools) weakremover(python2-bz2file) weakremover(python2-cPyparsing) weakremover(python2-cached-property) weakremover(python2-cachelib) weakremover(python2-cachetools) weakremover(python2-cachey) weakremover(python2-cachy) weakremover(python2-cairo) weakremover(python2-cairo-devel) weakremover(python2-cairocffi) weakremover(python2-cairocffi-pixbuf) weakremover(python2-caja) weakremover(python2-caldav) weakremover(python2-calmjs) weakremover(python2-calmjs.parse) weakremover(python2-calmjs.types) weakremover(python2-cangjie) weakremover(python2-canonicaljson) weakremover(python2-capng) weakremover(python2-capturer) weakremover(python2-case) weakremover(python2-cassandra-driver) weakremover(python2-cassowary) weakremover(python2-castellan) weakremover(python2-casttube) weakremover(python2-catkin-pkg) weakremover(python2-cbor) weakremover(python2-cbor2) weakremover(python2-cchardet) weakremover(python2-cdecimal) weakremover(python2-ceilometerclient) weakremover(python2-celery) weakremover(python2-celery-batches) weakremover(python2-celerymon) weakremover(python2-cerealizer) weakremover(python2-certbot) weakremover(python2-certbot-apache) weakremover(python2-certbot-dns-cloudflare) weakremover(python2-certbot-dns-cloudxns) weakremover(python2-certbot-dns-digitalocean) weakremover(python2-certbot-dns-dnsimple) weakremover(python2-certbot-dns-dnsmadeeasy) weakremover(python2-certbot-dns-google) weakremover(python2-certbot-dns-linode) weakremover(python2-certbot-dns-luadns) weakremover(python2-certbot-dns-nsone) weakremover(python2-certbot-dns-rfc2136) weakremover(python2-certbot-dns-route53) weakremover(python2-certbot-nginx) weakremover(python2-certifi) weakremover(python2-certstream) weakremover(python2-cffi) weakremover(python2-cfgv) weakremover(python2-cfn-lint) weakremover(python2-cfscrape) weakremover(python2-cftime) weakremover(python2-chai) weakremover(python2-chainmap) weakremover(python2-characteristic) weakremover(python2-chardet) weakremover(python2-chart-studio) weakremover(python2-check-manifest) weakremover(python2-cheroot) weakremover(python2-chest) weakremover(python2-cilium-microscope) weakremover(python2-ciscoconfparse) weakremover(python2-cl) weakremover(python2-cleo) weakremover(python2-cli-helpers) weakremover(python2-click) weakremover(python2-click-aliases) weakremover(python2-click-completion) weakremover(python2-click-didyoumean) weakremover(python2-click-help-colors) weakremover(python2-click-log) weakremover(python2-click-man) weakremover(python2-click-plugins) weakremover(python2-click-spinner) weakremover(python2-click-threading) weakremover(python2-cliff) weakremover(python2-cligj) weakremover(python2-clikit) weakremover(python2-clinkgrammar) weakremover(python2-clint) weakremover(python2-cloudflare) weakremover(python2-cloudpickle) weakremover(python2-cluster) weakremover(python2-cluster-preflight-check) weakremover(python2-cmarkgfm) weakremover(python2-cmd2) weakremover(python2-cmdln) weakremover(python2-coards) weakremover(python2-coconut) weakremover(python2-codecov) weakremover(python2-cogapp) weakremover(python2-colander) weakremover(python2-colorama) weakremover(python2-colorcet) weakremover(python2-colorclass) weakremover(python2-coloredlogs) weakremover(python2-colorlog) weakremover(python2-colorlover) weakremover(python2-colormap) weakremover(python2-colorspacious) weakremover(python2-colour) weakremover(python2-combi) weakremover(python2-commentjson) weakremover(python2-compizconfig) weakremover(python2-concurrentloghandler) weakremover(python2-configargparse) weakremover(python2-configobj) weakremover(python2-configparser) weakremover(python2-configparser2) weakremover(python2-configshell-fb) weakremover(python2-confluent-kafka) weakremover(python2-confusable-homoglyphs) weakremover(python2-constantly) weakremover(python2-construct) weakremover(python2-contexter) weakremover(python2-contextlib2) weakremover(python2-convertdate) weakremover(python2-cookies) weakremover(python2-cooldict) weakremover(python2-coreapi) weakremover(python2-coreapi-cli) weakremover(python2-coreschema) weakremover(python2-cotyledon) weakremover(python2-cov-core) weakremover(python2-coverage) weakremover(python2-coverage-config-reload-plugin) weakremover(python2-coverage-env-plugin) weakremover(python2-coveralls) weakremover(python2-coveralls-check) weakremover(python2-cppclean) weakremover(python2-cpplint) weakremover(python2-cracklib) weakremover(python2-cram) weakremover(python2-crayons) weakremover(python2-crcmod) weakremover(python2-createrepo_c) weakremover(python2-cron-descriptor) weakremover(python2-croniter) weakremover(python2-crontab) weakremover(python2-crumbs) weakremover(python2-cryptography) weakremover(python2-cryptography-vectors) weakremover(python2-css-parser) weakremover(python2-csscompressor) weakremover(python2-cssselect) weakremover(python2-cssselect2) weakremover(python2-cssutils) weakremover(python2-csvkit) weakremover(python2-ctypescrypto) weakremover(python2-ctypesgen) weakremover(python2-cufflinks) weakremover(python2-cursive) weakremover(python2-curtsies) weakremover(python2-cx_Freeze) weakremover(python2-cymruwhois) weakremover(python2-cyordereddict) weakremover(python2-cytoolz) weakremover(python2-d2to1) weakremover(python2-daemonize) weakremover(python2-daiquiri) weakremover(python2-dash) weakremover(python2-dash-renderer) weakremover(python2-dask) weakremover(python2-dask-all) weakremover(python2-dask-array) weakremover(python2-dask-bag) weakremover(python2-dask-dataframe) weakremover(python2-dask-distributed) weakremover(python2-dask-dot) weakremover(python2-dask-multiprocessing) weakremover(python2-datadiff) weakremover(python2-datashader) weakremover(python2-dateparser) weakremover(python2-datrie) weakremover(python2-dbf) weakremover(python2-dbfread) weakremover(python2-dbus-python) weakremover(python2-dbus-python-devel) weakremover(python2-ddt) weakremover(python2-deap) weakremover(python2-debian) weakremover(python2-debtcollector) weakremover(python2-decorator) weakremover(python2-deepdiff) weakremover(python2-defusedxml) weakremover(python2-delegator) weakremover(python2-delegator.py) weakremover(python2-deltarpm) weakremover(python2-demjson) weakremover(python2-dennis) weakremover(python2-deprecation) weakremover(python2-derpconf) weakremover(python2-designateclient) weakremover(python2-detox) weakremover(python2-devpi-client) weakremover(python2-devpi-common) weakremover(python2-devpi-server) weakremover(python2-dfdatetime) weakremover(python2-dfwinreg) weakremover(python2-dialite) weakremover(python2-dicttoxml) weakremover(python2-diff-match-patch) weakremover(python2-diff_match_patch) weakremover(python2-digitalocean) weakremover(python2-dill) weakremover(python2-dirtyjson) weakremover(python2-dis3) weakremover(python2-discid) weakremover(python2-discogs-client) weakremover(python2-discover) weakremover(python2-diskcache) weakremover(python2-dist) weakremover(python2-distlib) weakremover(python2-distorm3) weakremover(python2-distributed) weakremover(python2-distro) weakremover(python2-distroinfo) weakremover(python2-distutils-extra) weakremover(python2-dj-database-url) weakremover(python2-django-allauth) weakremover(python2-django-allauth-lang) weakremover(python2-django-appconf) weakremover(python2-django-auth-ldap) weakremover(python2-django-avatar) weakremover(python2-django-babel) weakremover(python2-django-braces) weakremover(python2-django-ckeditor) weakremover(python2-django-classy-tags) weakremover(python2-django-compressor) weakremover(python2-django-contrib-comments) weakremover(python2-django-cors-headers) weakremover(python2-django-coverage-plugin) weakremover(python2-django-crispy-forms) weakremover(python2-django-debreach) weakremover(python2-django-debug-toolbar) weakremover(python2-django-environ) weakremover(python2-django-extensions) weakremover(python2-django-formtools) weakremover(python2-django-grappelli) weakremover(python2-django-guardian) weakremover(python2-django-invitations) weakremover(python2-django-jinja) weakremover(python2-django-js-asset) weakremover(python2-django-json-widget) weakremover(python2-django-jsonfield) weakremover(python2-django-minio-storage) weakremover(python2-django-model-utils) weakremover(python2-django-nine) weakremover(python2-django-nose) weakremover(python2-django-oauth-toolkit) weakremover(python2-django-oidc-provider) weakremover(python2-django-picklefield) weakremover(python2-django-pipeline) weakremover(python2-django-pyscss) weakremover(python2-django-redis) weakremover(python2-django-registration) weakremover(python2-django-rest-framework-client) weakremover(python2-django-rest-framework-social-oauth2) weakremover(python2-django-rest-invitations) weakremover(python2-django-rest-knox) weakremover(python2-django-reversion) weakremover(python2-django-reversion-lang) weakremover(python2-django-rosetta) weakremover(python2-django-seed) weakremover(python2-django-sekizai) weakremover(python2-django-silk) weakremover(python2-django-storages) weakremover(python2-django-tagging) weakremover(python2-django-tastypie) weakremover(python2-django-threadedcomments) weakremover(python2-django-webpack-loader) weakremover(python2-django-webtest) weakremover(python2-django_compressor) weakremover(python2-django_coverage_plugin) weakremover(python2-djangorestframework) weakremover(python2-djet) weakremover(python2-djvulibre) weakremover(python2-dns-lexicon) weakremover(python2-dnspython) weakremover(python2-docformatter) weakremover(python2-docker) weakremover(python2-docker-compose) weakremover(python2-docker-pycreds) weakremover(python2-dockerpty) weakremover(python2-docopt) weakremover(python2-docrepr) weakremover(python2-docutils) weakremover(python2-docutils-ast-writer) weakremover(python2-dogpile.cache) weakremover(python2-dogslow) weakremover(python2-dominate) weakremover(python2-dotmap) weakremover(python2-dparse) weakremover(python2-dpkt) weakremover(python2-dragonmapper) weakremover(python2-drf-jwt-knox) weakremover(python2-drf-nested-routers) weakremover(python2-drms) weakremover(python2-dropbox) weakremover(python2-duckduckgo2) weakremover(python2-dukpy) weakremover(python2-dukpy-kovidgoyal) weakremover(python2-dulwich) weakremover(python2-dynaconf) weakremover(python2-easydev) weakremover(python2-easygui) weakremover(python2-easypysmb) weakremover(python2-easywatch) weakremover(python2-ebcdic) weakremover(python2-ecdsa) weakremover(python2-ed25519) weakremover(python2-ed25519ll) weakremover(python2-edgegrid-python) weakremover(python2-editdistance) weakremover(python2-editdistance-devel) weakremover(python2-efilter) weakremover(python2-efl) weakremover(python2-efl-doc) weakremover(python2-efl-examples) weakremover(python2-elasticsearch) weakremover(python2-elementpath) weakremover(python2-eliot) weakremover(python2-email_validator) weakremover(python2-emoji) weakremover(python2-empy) weakremover(python2-enable) weakremover(python2-enable-kiva) weakremover(python2-enaml) weakremover(python2-encore) weakremover(python2-entrypoint2) weakremover(python2-entrypoints) weakremover(python2-enum-compat) weakremover(python2-environmental-override) weakremover(python2-enzyme) weakremover(python2-ephem) weakremover(python2-epubmerge) weakremover(python2-eradicate) weakremover(python2-espeak) weakremover(python2-esptool) weakremover(python2-et_xmlfile) weakremover(python2-etcd) weakremover(python2-etcd-test) weakremover(python2-ethtool) weakremover(python2-evdev) weakremover(python2-evemu) weakremover(python2-eventlet) weakremover(python2-eventlet-doc) weakremover(python2-evtx) weakremover(python2-exam) weakremover(python2-execnet) weakremover(python2-execnet-doc) weakremover(python2-expects) weakremover(python2-exrex) weakremover(python2-extras) weakremover(python2-ez_setup) weakremover(python2-factory_boy) weakremover(python2-fake-useragent) weakremover(python2-fakeredis) weakremover(python2-falcon) weakremover(python2-fanficfare) weakremover(python2-fann2) weakremover(python2-fastcluster) weakremover(python2-fasteners) weakremover(python2-fastimport) weakremover(python2-fastnumbers) weakremover(python2-fastparquet) weakremover(python2-fastremap) weakremover(python2-fb-re2) weakremover(python2-featureflow) weakremover(python2-fedmsg) weakremover(python2-feedgenerator) weakremover(python2-feedparser) weakremover(python2-fido2) weakremover(python2-fields) weakremover(python2-filelock) weakremover(python2-filetype) weakremover(python2-finance_enums) weakremover(python2-fire) weakremover(python2-first) weakremover(python2-fixtures) weakremover(python2-flake8) weakremover(python2-flake8-blind-except) weakremover(python2-flake8-builtins) weakremover(python2-flake8-class-newline) weakremover(python2-flake8-debugger) weakremover(python2-flake8-deprecated) weakremover(python2-flake8-docstrings) weakremover(python2-flake8-future-import) weakremover(python2-flake8-import-order) weakremover(python2-flake8-imports) weakremover(python2-flake8-isort) weakremover(python2-flake8-pep3101) weakremover(python2-flake8-polyfill) weakremover(python2-flake8-quotes) weakremover(python2-flaky) weakremover(python2-flasgger) weakremover(python2-flask-jwt-extended) weakremover(python2-flask-mongoengine) weakremover(python2-flask-peewee) weakremover(python2-flask-restplus) weakremover(python2-flatbuffers) weakremover(python2-flatdict) weakremover(python2-flex) weakremover(python2-flexmock) weakremover(python2-flexx) weakremover(python2-flickrapi) weakremover(python2-flit-core) weakremover(python2-flower) weakremover(python2-fluent) weakremover(python2-fluidity-sm) weakremover(python2-flup) weakremover(python2-forbiddenfruit) weakremover(python2-formats) weakremover(python2-freeipa) weakremover(python2-freetype-py) weakremover(python2-freezegun) weakremover(python2-frozendict) weakremover(python2-fs) weakremover(python2-ftputil) weakremover(python2-fudge) weakremover(python2-funcparserlib) weakremover(python2-funcy) weakremover(python2-furl) weakremover(python2-fuse) weakremover(python2-fusepy) weakremover(python2-future) weakremover(python2-futures) weakremover(python2-futurist) weakremover(python2-fuzzywuzzy) weakremover(python2-fysom) weakremover(python2-gTTS) weakremover(python2-gTTS-token) weakremover(python2-gabbi) weakremover(python2-gast) weakremover(python2-gcsfs) weakremover(python2-gcsfs-fuse) weakremover(python2-gdata) weakremover(python2-gear) weakremover(python2-ged4py) weakremover(python2-genty) weakremover(python2-geographiclib) weakremover(python2-geoip2) weakremover(python2-geojson) weakremover(python2-geolib) weakremover(python2-geolinks) weakremover(python2-geomet) weakremover(python2-geopy) weakremover(python2-geos) weakremover(python2-gevent) weakremover(python2-geventhttpclient) weakremover(python2-ggplot) weakremover(python2-girder-client) weakremover(python2-git-pw) weakremover(python2-git-review) weakremover(python2-git-url-parse) weakremover(python2-gitdb2) weakremover(python2-github3.py) weakremover(python2-gitlint) weakremover(python2-glean) weakremover(python2-glfw) weakremover(python2-glob2) weakremover(python2-gmpy) weakremover(python2-gmpy2) weakremover(python2-gobject) weakremover(python2-gobject-Dee) weakremover(python2-gobject-Gdk) weakremover(python2-gobject-cairo) weakremover(python2-gobject-devel) weakremover(python2-gogs_client) weakremover(python2-goocanvas) weakremover(python2-goocanvas-devel) weakremover(python2-google-api-core) weakremover(python2-google-api-python-client) weakremover(python2-google-auth) weakremover(python2-google-auth-httplib2) weakremover(python2-google-auth-oauthlib) weakremover(python2-google-cloud-core) weakremover(python2-google-cloud-kms) weakremover(python2-google-cloud-speech) weakremover(python2-google-cloud-storage) weakremover(python2-google-resumable-media) weakremover(python2-googleapis-common-protos) weakremover(python2-googlemaps) weakremover(python2-gpg) weakremover(python2-gpgme) weakremover(python2-gphoto2) weakremover(python2-gpod) weakremover(python2-gprof2dot) weakremover(python2-gps3) weakremover(python2-gpsd) weakremover(python2-gpxpy) weakremover(python2-grab) weakremover(python2-graphviz) weakremover(python2-greenlet) weakremover(python2-greenlet-devel) weakremover(python2-grpc-google-iam-v1) weakremover(python2-grpcio) weakremover(python2-grpcio-gcp) weakremover(python2-gscholar) weakremover(python2-gspread) weakremover(python2-gssapi) weakremover(python2-gst) weakremover(python2-gsw) weakremover(python2-guessit) weakremover(python2-gunicorn) weakremover(python2-guzzle_sphinx_theme) weakremover(python2-gv) weakremover(python2-h11) weakremover(python2-h2) weakremover(python2-h5netcdf) weakremover(python2-h5py) weakremover(python2-hamcrest) weakremover(python2-hankel) weakremover(python2-hanzidentifier) weakremover(python2-happybase) weakremover(python2-hawkauthlib) weakremover(python2-hawkey) weakremover(python2-hdf5storage) weakremover(python2-helpdev) weakremover(python2-hetzner) weakremover(python2-hexdump) weakremover(python2-hiredis) weakremover(python2-hkdf) weakremover(python2-hl7apy) weakremover(python2-holidays) weakremover(python2-hp3parclient) weakremover(python2-hpack) weakremover(python2-html2text) weakremover(python2-html5-parser) weakremover(python2-html5lib) weakremover(python2-htmlmin) weakremover(python2-httmock) weakremover(python2-http-parser) weakremover(python2-httpbin) weakremover(python2-httplib2) weakremover(python2-httpretty) weakremover(python2-httpsig_cffi) weakremover(python2-httpstatus35) weakremover(python2-humanfriendly) weakremover(python2-humanfriendly-test) weakremover(python2-humanhash3) weakremover(python2-humanize) weakremover(python2-humanreadable) weakremover(python2-hupper) weakremover(python2-husl) weakremover(python2-hvac) weakremover(python2-hyper) weakremover(python2-hyperframe) weakremover(python2-hyperlink) weakremover(python2-hypothesis) weakremover(python2-hypothesis-fspaths) weakremover(python2-hypothesis-test) weakremover(python2-i3ipc) weakremover(python2-icalendar) weakremover(python2-identify) weakremover(python2-idna) weakremover(python2-ifaddr) weakremover(python2-ifconfig-parser) weakremover(python2-ijson) weakremover(python2-imageio) weakremover(python2-imagesize) weakremover(python2-img2pdf) weakremover(python2-iminuit) weakremover(python2-importlab) weakremover(python2-importlib-metadata) weakremover(python2-importlib_resources) weakremover(python2-imread) weakremover(python2-incremental) weakremover(python2-infinity) weakremover(python2-inflect) weakremover(python2-inflection) weakremover(python2-influxdb) weakremover(python2-inifile) weakremover(python2-iniparse) weakremover(python2-inspect2) weakremover(python2-inspektor) weakremover(python2-intervals) weakremover(python2-intervaltree) weakremover(python2-invocations) weakremover(python2-invoke) weakremover(python2-iocapture) weakremover(python2-ioflo) weakremover(python2-ipaddr) weakremover(python2-ipdb) weakremover(python2-iptables) weakremover(python2-ipy) weakremover(python2-ipydatawidgets) weakremover(python2-ipykernel) weakremover(python2-ipympl) weakremover(python2-ipyparallel) weakremover(python2-ipyscales) weakremover(python2-ipython) weakremover(python2-ipython-iptest) weakremover(python2-ipython_genutils) weakremover(python2-ipyvolume) weakremover(python2-ipywebrtc) weakremover(python2-ipywidgets) weakremover(python2-ironic-inspector-client) weakremover(python2-ironicclient) weakremover(python2-iso8601) weakremover(python2-isodate) weakremover(python2-isort) weakremover(python2-itsdangerous) weakremover(python2-itypes) weakremover(python2-iwlib) weakremover(python2-jaraco.base) weakremover(python2-jaraco.classes) weakremover(python2-jaraco.collections) weakremover(python2-jaraco.functools) weakremover(python2-jaraco.itertools) weakremover(python2-jaraco.logging) weakremover(python2-jaraco.packaging) weakremover(python2-jaraco.stream) weakremover(python2-jaraco.text) weakremover(python2-javaproperties) weakremover(python2-jdatetime) weakremover(python2-jdcal) weakremover(python2-jedi) weakremover(python2-jedihttp) weakremover(python2-jellyfish) weakremover(python2-jenkins-job-builder) weakremover(python2-jenkinsapi) weakremover(python2-jgraph) weakremover(python2-jinja2-fsloader) weakremover(python2-jinja2-pluralize) weakremover(python2-jinja2-time) weakremover(python2-jira) weakremover(python2-jirafs) weakremover(python2-jmespath) weakremover(python2-joblib) weakremover(python2-josepy) weakremover(python2-jplephem) weakremover(python2-jsbeautifier) weakremover(python2-jsmin) weakremover(python2-json-rpc) weakremover(python2-json5) weakremover(python2-json_tricks) weakremover(python2-jsondate) weakremover(python2-jsondiff) weakremover(python2-jsonextended) weakremover(python2-jsonlines) weakremover(python2-jsonpatch) weakremover(python2-jsonpath-rw) weakremover(python2-jsonpath-rw-ext) weakremover(python2-jsonpickle) weakremover(python2-jsonpointer) weakremover(python2-jsonref) weakremover(python2-jsonrpclib-pelix) weakremover(python2-jsonschema) weakremover(python2-jsonxs) weakremover(python2-junit-xml) weakremover(python2-junitxml) weakremover(python2-junos-eznc) weakremover(python2-jupyter) weakremover(python2-jupyter-client) weakremover(python2-jupyter-contrib-nbextensions) weakremover(python2-jupyter-core) weakremover(python2-jupyter-packaging) weakremover(python2-jupyter-require) weakremover(python2-jupyter-server) weakremover(python2-jupyter-sphinx) weakremover(python2-jupyter_Video_Widget) weakremover(python2-jupyter_altair-widgets) weakremover(python2-jupyter_bqplot) weakremover(python2-jupyter_client) weakremover(python2-jupyter_cms) weakremover(python2-jupyter_console) weakremover(python2-jupyter_console-doc) weakremover(python2-jupyter_contrib_core) weakremover(python2-jupyter_contrib_nbextensions) weakremover(python2-jupyter_core) weakremover(python2-jupyter_dashboards) weakremover(python2-jupyter_full_width) weakremover(python2-jupyter_hide_code) weakremover(python2-jupyter_highlight_selected_word) weakremover(python2-jupyter_ipdb) weakremover(python2-jupyter_ipydatawidgets) weakremover(python2-jupyter_ipykernel) weakremover(python2-jupyter_ipympl) weakremover(python2-jupyter_ipyparallel) weakremover(python2-jupyter_ipyscales) weakremover(python2-jupyter_ipython) weakremover(python2-jupyter_ipython-iptest) weakremover(python2-jupyter_ipywidgets) weakremover(python2-jupyter_jgraph) weakremover(python2-jupyter_latex_envs) weakremover(python2-jupyter_matlab_kernel) weakremover(python2-jupyter_metakernel) weakremover(python2-jupyter_nbconvert) weakremover(python2-jupyter_nbconvert-latex) weakremover(python2-jupyter_nbdime) weakremover(python2-jupyter_nbdime-git) weakremover(python2-jupyter_nbdime-hg) weakremover(python2-jupyter_nbextensions_configurator) weakremover(python2-jupyter_nbformat) weakremover(python2-jupyter_nbpresent) weakremover(python2-jupyter_nbsmoke) weakremover(python2-jupyter_nbsphinx) weakremover(python2-jupyter_nbsphinx_link) weakremover(python2-jupyter_nbval) weakremover(python2-jupyter_notebook) weakremover(python2-jupyter_notebook-lang) weakremover(python2-jupyter_notebook-latex) weakremover(python2-jupyter_octave_kernel) weakremover(python2-jupyter_qgrid) weakremover(python2-jupyter_qtconsole) weakremover(python2-jupyter_rise) weakremover(python2-jupyter_sphinx) weakremover(python2-jupyter_sphinx_theme) weakremover(python2-jupyter_themer) weakremover(python2-jupyter_vega) weakremover(python2-jupyter_watermark) weakremover(python2-jupyter_widgetsnbextension) weakremover(python2-jupyter_wysiwyg) weakremover(python2-jupyterlab-pygments) weakremover(python2-jupytext) weakremover(python2-jwcrypto) weakremover(python2-k5test) weakremover(python2-kafka-python) weakremover(python2-kaitaistruct) weakremover(python2-kazoo) weakremover(python2-keepalive) weakremover(python2-kerberos) weakremover(python2-keyczar) weakremover(python2-keyring) weakremover(python2-keyrings.alt) weakremover(python2-keystoneauth1) weakremover(python2-keystoneclient) weakremover(python2-keystonemiddleware) weakremover(python2-kid) weakremover(python2-killswitch) weakremover(python2-kismet-rest) weakremover(python2-kismetdb) weakremover(python2-kitchen) weakremover(python2-kiwi) weakremover(python2-kiwisolver) weakremover(python2-kmatch) weakremover(python2-kmod) weakremover(python2-knack) weakremover(python2-kombu) weakremover(python2-kubernetes) weakremover(python2-l20n) weakremover(python2-lancet-ioam) weakremover(python2-langdetect) weakremover(python2-lark-parser) weakremover(python2-latexcodec) weakremover(python2-lazr.uri) weakremover(python2-lazy) weakremover(python2-lazy-object-proxy) weakremover(python2-lazyarray) weakremover(python2-ldap) weakremover(python2-ldap3) weakremover(python2-ldappool) weakremover(python2-ldaptor) weakremover(python2-leather) weakremover(python2-lesscpy) weakremover(python2-leveldb) weakremover(python2-lexicon) weakremover(python2-lhafile) weakremover(python2-libarchive) weakremover(python2-libarchive-c) weakremover(python2-libbde) weakremover(python2-libcomps) weakremover(python2-libesedb) weakremover(python2-libevt) weakremover(python2-libevtx) weakremover(python2-libewf) weakremover(python2-libfsntfs) weakremover(python2-libfvde) weakremover(python2-libfwnt) weakremover(python2-libfwsi) weakremover(python2-libguestfs) weakremover(python2-liblarch) weakremover(python2-liblarch-gtk) weakremover(python2-liblnk) weakremover(python2-libluksde) weakremover(python2-libmsiecf) weakremover(python2-libnacl) weakremover(python2-libolecf) weakremover(python2-libpamtest) weakremover(python2-libpfm) weakremover(python2-libprelude) weakremover(python2-libpreludedb) weakremover(python2-libqcow) weakremover(python2-libregf) weakremover(python2-librepo) weakremover(python2-librosa) weakremover(python2-librouteros) weakremover(python2-libsass) weakremover(python2-libscca) weakremover(python2-libsigscan) weakremover(python2-libsmdev) weakremover(python2-libsmraw) weakremover(python2-libtorrent-rasterbar) weakremover(python2-libunity) weakremover(python2-libusb1) weakremover(python2-libvhdi) weakremover(python2-libvirt-python) weakremover(python2-libvmdk) weakremover(python2-libvshadow) weakremover(python2-libvslvm) weakremover(python2-libxml2) weakremover(python2-libxml2-python) weakremover(python2-license-expression) weakremover(python2-limnoria) weakremover(python2-line_profiler) weakremover(python2-linecache2) weakremover(python2-lineup-widget) weakremover(python2-linux-procfs) weakremover(python2-lit) weakremover(python2-llfuse) weakremover(python2-llvmlite) weakremover(python2-lmdb) weakremover(python2-lmfit) weakremover(python2-lml) weakremover(python2-localzone) weakremover(python2-locket) weakremover(python2-lockfile) weakremover(python2-logilab-astng) weakremover(python2-logilab-common) weakremover(python2-logutils) weakremover(python2-logzero) weakremover(python2-lupa) weakremover(python2-lws) weakremover(python2-lxml) weakremover(python2-lxml-devel) weakremover(python2-lxml-doc) weakremover(python2-lz4) weakremover(python2-lzmaffi) weakremover(python2-m2r) weakremover(python2-macholib) weakremover(python2-magic) weakremover(python2-magic-wormhole) weakremover(python2-magic-wormhole-mailbox-server) weakremover(python2-magic-wormhole-transit-relay) weakremover(python2-managesieve) weakremover(python2-mando) weakremover(python2-manuel) weakremover(python2-manuel-doc) weakremover(python2-marathon) weakremover(python2-markdown-math) weakremover(python2-markdown2) weakremover(python2-marshmallow) weakremover(python2-masakariclient) weakremover(python2-mate-menus) weakremover(python2-matplotlib) weakremover(python2-matplotlib-cairo) weakremover(python2-matplotlib-gtk3) weakremover(python2-matplotlib-latex) weakremover(python2-matplotlib-qt-shared) weakremover(python2-matplotlib-qt4) weakremover(python2-matplotlib-qt5) weakremover(python2-matplotlib-tk) weakremover(python2-matplotlib-web) weakremover(python2-matplotlib-wx) weakremover(python2-matrix-synapse) weakremover(python2-matrix-synapse-ldap3) weakremover(python2-maxminddb) weakremover(python2-mbstrdecoder) weakremover(python2-mccabe) weakremover(python2-md2workflow) weakremover(python2-mechanize) weakremover(python2-meld3) weakremover(python2-memory_profiler) weakremover(python2-metaextract) weakremover(python2-metakernel) weakremover(python2-mhash) weakremover(python2-microversion_parse) weakremover(python2-minio) weakremover(python2-miniupnpc) weakremover(python2-misaka) weakremover(python2-mistralclient) weakremover(python2-mistune) weakremover(python2-moban) weakremover(python2-mock) weakremover(python2-mocket) weakremover(python2-mockito) weakremover(python2-mockldap) weakremover(python2-modernize) weakremover(python2-mohawk) weakremover(python2-moksha-common) weakremover(python2-moksha-hub) weakremover(python2-mongoengine) weakremover(python2-monotonic) weakremover(python2-more-itertools) weakremover(python2-moretools) weakremover(python2-moto) weakremover(python2-moviepy) weakremover(python2-mox3) weakremover(python2-mpi4py) weakremover(python2-mpi4py-devel) weakremover(python2-mpmath) weakremover(python2-mraa) weakremover(python2-msal) weakremover(python2-msal-extensions) weakremover(python2-msgpack) weakremover(python2-msgpack-numpy) weakremover(python2-msoffcrypto-tool) weakremover(python2-msrest) weakremover(python2-msrestazure) weakremover(python2-mujson) weakremover(python2-mulpyplexer) weakremover(python2-multi_key_dict) weakremover(python2-multipledispatch) weakremover(python2-munch) weakremover(python2-munkres) weakremover(python2-musicbrainzngs) weakremover(python2-mutagen) weakremover(python2-mutt-ics) weakremover(python2-mygpoclient) weakremover(python2-mypy_extensions) weakremover(python2-mysql-connector-python) weakremover(python2-mysqlclient) weakremover(python2-nagiosplugin) weakremover(python2-napalm) weakremover(python2-napalm-asa) weakremover(python2-napalm-procurve) weakremover(python2-natsort) weakremover(python2-nautilus) weakremover(python2-nautilus-devel) weakremover(python2-nbconvert) weakremover(python2-nbdime) weakremover(python2-nbformat) weakremover(python2-nbindex-jupyter) weakremover(python2-nbsmoke) weakremover(python2-nbsphinx) weakremover(python2-nbsphinx-link) weakremover(python2-nbval) weakremover(python2-nbxmpp) weakremover(python2-nbxmpp-doc) weakremover(python2-ncclient) weakremover(python2-ndg-httpsclient) weakremover(python2-nemo) weakremover(python2-neovim) weakremover(python2-net-snmp) weakremover(python2-netCDF4) weakremover(python2-netaddr) weakremover(python2-netifaces) weakremover(python2-netmiko) weakremover(python2-networkx) weakremover(python2-networkx-doc) weakremover(python2-newt) weakremover(python2-nine) weakremover(python2-nltk) weakremover(python2-nodeenv) weakremover(python2-nose) weakremover(python2-nose-cov) weakremover(python2-nose-cover3) weakremover(python2-nose-exclude) weakremover(python2-nose-progressive) weakremover(python2-nose-random) weakremover(python2-nose-timer) weakremover(python2-nose2) weakremover(python2-nose_warnings_filters) weakremover(python2-nosexcover) weakremover(python2-notebook) weakremover(python2-notebook-lang) weakremover(python2-notify2) weakremover(python2-nss) weakremover(python2-ntlm-auth) weakremover(python2-ntplib) weakremover(python2-num2words) weakremover(python2-numba) weakremover(python2-numba-devel) weakremover(python2-numericalunits) weakremover(python2-numexpr) weakremover(python2-numpy) weakremover(python2-numpy-devel) weakremover(python2-numpy-gnu-hpc) weakremover(python2-numpy-gnu-hpc-devel) weakremover(python2-numpy_1_14_0-gnu-hpc) weakremover(python2-numpy_1_14_0-gnu-hpc-devel) weakremover(python2-numpy_1_15_4-gnu-hpc) weakremover(python2-numpy_1_15_4-gnu-hpc-devel) weakremover(python2-numpy_1_16_1-gnu-hpc) weakremover(python2-numpy_1_16_1-gnu-hpc-devel) weakremover(python2-numpy_1_16_2-gnu-hpc) weakremover(python2-numpy_1_16_2-gnu-hpc-devel) weakremover(python2-numpy_1_16_3-gnu-hpc) weakremover(python2-numpy_1_16_3-gnu-hpc-devel) weakremover(python2-numpy_1_16_4-gnu-hpc) weakremover(python2-numpy_1_16_4-gnu-hpc-devel) weakremover(python2-numpy_1_16_5-gnu-hpc) weakremover(python2-numpy_1_16_5-gnu-hpc-devel) weakremover(python2-numpydoc) weakremover(python2-nwdiag) weakremover(python2-nxapi-plumbing) weakremover(python2-oauth2) weakremover(python2-oauth2client) weakremover(python2-oauth2client-django) weakremover(python2-oauth2client-flask) weakremover(python2-oauth2client-gce) weakremover(python2-oauthlib) weakremover(python2-objgraph) weakremover(python2-oci-sdk) weakremover(python2-oct2py) weakremover(python2-octaviaclient) weakremover(python2-odfpy) weakremover(python2-odict) weakremover(python2-odorik) weakremover(python2-oic) weakremover(python2-olefile) weakremover(python2-opcodes) weakremover(python2-openapi-core) weakremover(python2-openapi-schema-validator) weakremover(python2-openapi-spec-validator) weakremover(python2-opencensus) weakremover(python2-opencensus-context) weakremover(python2-opencensus-ext-azure) weakremover(python2-opencensus-ext-threading) weakremover(python2-opencv) weakremover(python2-opencv3) weakremover(python2-opengl) weakremover(python2-opengl-accelerate) weakremover(python2-openmesh) weakremover(python2-openpyxl) weakremover(python2-openqa_client) weakremover(python2-openqa_review) weakremover(python2-openstack.nose_plugin) weakremover(python2-openstackclient) weakremover(python2-openstackdocstheme) weakremover(python2-openvswitch) weakremover(python2-openvswitch-test) weakremover(python2-ordered-namespace) weakremover(python2-ordered-set) weakremover(python2-orderedmultidict) weakremover(python2-os-api-ref) weakremover(python2-os-client-config) weakremover(python2-os-service-types) weakremover(python2-os-testr) weakremover(python2-os-win) weakremover(python2-osc-lib) weakremover(python2-osc-tiny) weakremover(python2-oscfs) weakremover(python2-oscrypto) weakremover(python2-oslo.cache) weakremover(python2-oslo.context) weakremover(python2-oslo.db) weakremover(python2-oslo.i18n) weakremover(python2-oslo.middleware) weakremover(python2-oslo.reports) weakremover(python2-oslo.serialization) weakremover(python2-oslo.service) weakremover(python2-oslo.utils) weakremover(python2-oslo.versionedobjects) weakremover(python2-oslo.vmware) weakremover(python2-oslosphinx) weakremover(python2-oslotest) weakremover(python2-osmviz) weakremover(python2-outcome) weakremover(python2-ovirt-engine-sdk) weakremover(python2-ovs) weakremover(python2-ovsdbapp) weakremover(python2-pa-ringbuffer) weakremover(python2-packaging) weakremover(python2-padatious) weakremover(python2-paho-mqtt) weakremover(python2-pako) weakremover(python2-palettable) weakremover(python2-pamela) weakremover(python2-pamqp) weakremover(python2-pan-python) weakremover(python2-pandas) weakremover(python2-pandas-datareader) weakremover(python2-pandocfilters) weakremover(python2-panflute) weakremover(python2-parallax) weakremover(python2-param) weakremover(python2-parameterized) weakremover(python2-paramiko) weakremover(python2-paramiko-expect) weakremover(python2-parse) weakremover(python2-parse_type) weakremover(python2-parsedatetime) weakremover(python2-parsel) weakremover(python2-parsimonious) weakremover(python2-parso) weakremover(python2-partd) weakremover(python2-parted) weakremover(python2-parver) weakremover(python2-pass_python_keyring) weakremover(python2-passa) weakremover(python2-passivetotal) weakremover(python2-passlib) weakremover(python2-pastel) weakremover(python2-pastream) weakremover(python2-path.py) weakremover(python2-pathlib) weakremover(python2-pathlib2) weakremover(python2-pathspec) weakremover(python2-pathtools) weakremover(python2-patsy) weakremover(python2-pbkdf2) weakremover(python2-pbr) weakremover(python2-pbr-test) weakremover(python2-pdfkit) weakremover(python2-pdfrw) weakremover(python2-pecan) weakremover(python2-peewee) weakremover(python2-pefile) weakremover(python2-pelican) weakremover(python2-pem) weakremover(python2-pendulum) weakremover(python2-pep517) weakremover(python2-pep8) weakremover(python2-pep8-naming) weakremover(python2-peppercorn) weakremover(python2-percy) weakremover(python2-persistent) weakremover(python2-persistent-devel) weakremover(python2-persistent-doc) weakremover(python2-petact) weakremover(python2-pexpect) weakremover(python2-pgmagick) weakremover(python2-phabricator) weakremover(python2-phonenumbers) weakremover(python2-phply) weakremover(python2-phue) weakremover(python2-pick) weakremover(python2-pickleshare) weakremover(python2-piexif) weakremover(python2-pifpaf) weakremover(python2-pika) weakremover(python2-pika-pool) weakremover(python2-pilkit) weakremover(python2-pingparsing) weakremover(python2-pip-api) weakremover(python2-pip-licenses) weakremover(python2-pip-run) weakremover(python2-pip-shims) weakremover(python2-pip-tools) weakremover(python2-pip-wheel) weakremover(python2-pipdeptree) weakremover(python2-pipenv) weakremover(python2-pipreqs) weakremover(python2-piston-mini-client) weakremover(python2-pivy) weakremover(python2-pkgconfig) weakremover(python2-pkginfo) weakremover(python2-plaster) weakremover(python2-plaster-pastedeploy) weakremover(python2-plette) weakremover(python2-plotly) weakremover(python2-plotly-jupyter) weakremover(python2-pluggy) weakremover(python2-plumbum) weakremover(python2-ply) weakremover(python2-plyvel) weakremover(python2-pmw) weakremover(python2-pname) weakremover(python2-pocketsphinx) weakremover(python2-pocketsphinx-python) weakremover(python2-podcastparser) weakremover(python2-podman) weakremover(python2-polib) weakremover(python2-pomegranate) weakremover(python2-pomegranate-devel) weakremover(python2-pony) weakremover(python2-pook) weakremover(python2-port-for) weakremover(python2-portalocker) weakremover(python2-portend) weakremover(python2-portpicker) weakremover(python2-positional) weakremover(python2-posix_ipc) weakremover(python2-power) weakremover(python2-poyo) weakremover(python2-pprintpp) weakremover(python2-praatio) weakremover(python2-precise-runner) weakremover(python2-preggy) weakremover(python2-prelude-correlator) weakremover(python2-premailer) weakremover(python2-pretend) weakremover(python2-prewikka) weakremover(python2-proboscis) weakremover(python2-process-tests) weakremover(python2-proglog) weakremover(python2-progress) weakremover(python2-progressbar) weakremover(python2-proliantutils) weakremover(python2-prometheus_client) weakremover(python2-promise) weakremover(python2-prompt_toolkit) weakremover(python2-prompt_toolkit1) weakremover(python2-proselint) weakremover(python2-protobuf) weakremover(python2-pscript) weakremover(python2-psutil) weakremover(python2-psycopg2) weakremover(python2-ptpython) weakremover(python2-ptyprocess) weakremover(python2-publicsuffix2) weakremover(python2-publicsuffixlist) weakremover(python2-pudb) weakremover(python2-pulsectl) weakremover(python2-pure-sasl) weakremover(python2-purl) weakremover(python2-pushy) weakremover(python2-pwquality) weakremover(python2-py) weakremover(python2-py-cpuinfo) weakremover(python2-py-espeak-ng) weakremover(python2-py-radix) weakremover(python2-py-ubjson) weakremover(python2-py2pack) weakremover(python2-py3status) weakremover(python2-pyBarcode) weakremover(python2-pyDOE2) weakremover(python2-pyFFTW) weakremover(python2-pyIOSXR) weakremover(python2-pyLibravatar) weakremover(python2-pyModis) weakremover(python2-pyOCD) weakremover(python2-pyOpenSSL) weakremover(python2-pyPEG2) weakremover(python2-pyRFC3339) weakremover(python2-pyScss) weakremover(python2-pyVows) weakremover(python2-pyacoustid) weakremover(python2-pyaes) weakremover(python2-pyalsaaudio) weakremover(python2-pyaml) weakremover(python2-pyannotate) weakremover(python2-pyasn1) weakremover(python2-pyasn1-modules) weakremover(python2-pybars3) weakremover(python2-pybeam) weakremover(python2-pybind11) weakremover(python2-pybind11-devel) weakremover(python2-pyblake2) weakremover(python2-pybluez) weakremover(python2-pybtex) weakremover(python2-pybugz) weakremover(python2-pycadf) weakremover(python2-pycairo) weakremover(python2-pycairo-common-devel) weakremover(python2-pycairo-devel) weakremover(python2-pycallgraph) weakremover(python2-pycares) weakremover(python2-pycdio) weakremover(python2-pycha) weakremover(python2-pychm) weakremover(python2-pyclipper) weakremover(python2-pycocotools) weakremover(python2-pycodestyle) weakremover(python2-pycountry) weakremover(python2-pycparser) weakremover(python2-pycrypto) weakremover(python2-pycryptodome) weakremover(python2-pycryptodomex) weakremover(python2-pycsw) weakremover(python2-pyct) weakremover(python2-pycups) weakremover(python2-pycurl) weakremover(python2-pycurl-test) weakremover(python2-pycxx) weakremover(python2-pycxx-devel) weakremover(python2-pydata-google-auth) weakremover(python2-pydbus) weakremover(python2-pydenticon) weakremover(python2-pydicom) weakremover(python2-pydns) weakremover(python2-pydocstyle) weakremover(python2-pydocumentdb) weakremover(python2-pydot) weakremover(python2-pydot3) weakremover(python2-pydotplus) weakremover(python2-pydub) weakremover(python2-pyeapi) weakremover(python2-pyee) weakremover(python2-pyelftools) weakremover(python2-pyemd) weakremover(python2-pyenchant) weakremover(python2-pyface) weakremover(python2-pyfakefs) weakremover(python2-pyfeyn) weakremover(python2-pyfg) weakremover(python2-pyfiglet) weakremover(python2-pyflakes) weakremover(python2-pyftpdlib) weakremover(python2-pygal) weakremover(python2-pygaljs) weakremover(python2-pygame) weakremover(python2-pygame-devel) weakremover(python2-pygerrit2) weakremover(python2-pygit2) weakremover(python2-pyglet) weakremover(python2-pygments-ansi-color) weakremover(python2-pygments-pytest) weakremover(python2-pygments-style-railscasts) weakremover(python2-pygraphviz) weakremover(python2-pyhcl) weakremover(python2-pyhibp) weakremover(python2-pyinotify) weakremover(python2-pyinsane2) weakremover(python2-pyjavaproperties) weakremover(python2-pyjokes) weakremover(python2-pyjsparser) weakremover(python2-pyjwkest) weakremover(python2-pykafka) weakremover(python2-pykeepass) weakremover(python2-pykerberos) weakremover(python2-pykwalify) weakremover(python2-pylama) weakremover(python2-pylast) weakremover(python2-pylev) weakremover(python2-pylibacl) weakremover(python2-pyliblzma) weakremover(python2-pylibmc) weakremover(python2-pylint) weakremover(python2-pylons-sphinx-themes) weakremover(python2-pylru) weakremover(python2-pylzma) weakremover(python2-pymacaroons) weakremover(python2-pymacaroons-pynacl) weakremover(python2-pymad) weakremover(python2-pymarc) weakremover(python2-pymavlink) weakremover(python2-pymediainfo) weakremover(python2-pymemcache) weakremover(python2-pymisp) weakremover(python2-pymol) weakremover(python2-pymongo) weakremover(python2-pymssql) weakremover(python2-pynamodb) weakremover(python2-pynetbox) weakremover(python2-pyngus) weakremover(python2-pynxos) weakremover(python2-pyocr) weakremover(python2-pyodbc) weakremover(python2-pyosf) weakremover(python2-pyotp) weakremover(python2-pyowm) weakremover(python2-pyparallel) weakremover(python2-pyparsing) weakremover(python2-pyparsing-doc) weakremover(python2-pyparsing-test) weakremover(python2-pyperclip) weakremover(python2-pyperf) weakremover(python2-pypiserver) weakremover(python2-pypng) weakremover(python2-pyprel) weakremover(python2-pyprimes) weakremover(python2-pyproj) weakremover(python2-pypsexec) weakremover(python2-pypuppetdb) weakremover(python2-pyqtgraph) weakremover(python2-pyquery) weakremover(python2-pyrad) weakremover(python2-pyramid) weakremover(python2-pyramid-chameleon) weakremover(python2-pyramid-debugtoolbar) weakremover(python2-pyramid-mako) weakremover(python2-pyreadstat) weakremover(python2-pyroma) weakremover(python2-pyroomacoustics) weakremover(python2-pyroute2) weakremover(python2-pyrrd) weakremover(python2-pyrsistent) weakremover(python2-pysaml2) weakremover(python2-pyscard) weakremover(python2-pysendfile) weakremover(python2-pyserial) weakremover(python2-pyshould) weakremover(python2-pyshp) weakremover(python2-pysmb) weakremover(python2-pysmbc) weakremover(python2-pysmi) weakremover(python2-pysndfile) weakremover(python2-pysnmp) weakremover(python2-pysofaconventions) weakremover(python2-pysrt) weakremover(python2-pyssim) weakremover(python2-pystache) weakremover(python2-pysvn) weakremover(python2-pytaglib) weakremover(python2-pyte) weakremover(python2-pytesseract) weakremover(python2-pytest) weakremover(python2-pytest-arraydiff) weakremover(python2-pytest-astropy) weakremover(python2-pytest-attrib) weakremover(python2-pytest-bdd) weakremover(python2-pytest-benchmark) weakremover(python2-pytest-cache) weakremover(python2-pytest-check-links) weakremover(python2-pytest-click) weakremover(python2-pytest-codestyle) weakremover(python2-pytest-console-scripts) weakremover(python2-pytest-cov) weakremover(python2-pytest-datadir) weakremover(python2-pytest-django) weakremover(python2-pytest-doctestplus) weakremover(python2-pytest-dotenv) weakremover(python2-pytest-env) weakremover(python2-pytest-error-for-skips) weakremover(python2-pytest-expect) weakremover(python2-pytest-faulthandler) weakremover(python2-pytest-fixture-config) weakremover(python2-pytest-flake8) weakremover(python2-pytest-flakes) weakremover(python2-pytest-flask) weakremover(python2-pytest-forked) weakremover(python2-pytest-freezegun) weakremover(python2-pytest-git) weakremover(python2-pytest-helpers-namespace) weakremover(python2-pytest-html) weakremover(python2-pytest-httpbin) weakremover(python2-pytest-instafail) weakremover(python2-pytest-isort) weakremover(python2-pytest-lazy-fixture) weakremover(python2-pytest-listener) weakremover(python2-pytest-localserver) weakremover(python2-pytest-metadata) weakremover(python2-pytest-mock) weakremover(python2-pytest-mpl) weakremover(python2-pytest-openfiles) weakremover(python2-pytest-ordering) weakremover(python2-pytest-profiling) weakremover(python2-pytest-pyramid-server) weakremover(python2-pytest-pythonpath) weakremover(python2-pytest-qt) weakremover(python2-pytest-random-order) weakremover(python2-pytest-randomly) weakremover(python2-pytest-relaxed) weakremover(python2-pytest-remotedata) weakremover(python2-pytest-reorder) weakremover(python2-pytest-repeat) weakremover(python2-pytest-reqs) weakremover(python2-pytest-rerunfailures) weakremover(python2-pytest-runner) weakremover(python2-pytest-server-fixtures) weakremover(python2-pytest-services) weakremover(python2-pytest-shutil) weakremover(python2-pytest-socket) weakremover(python2-pytest-spec) weakremover(python2-pytest-sphinx) weakremover(python2-pytest-subtesthack) weakremover(python2-pytest-sugar) weakremover(python2-pytest-super-check) weakremover(python2-pytest-svn) weakremover(python2-pytest-test) weakremover(python2-pytest-testconfig) weakremover(python2-pytest-timeout) weakremover(python2-pytest-tldr) weakremover(python2-pytest-tornado) weakremover(python2-pytest-translations) weakremover(python2-pytest-travis-fold) weakremover(python2-pytest-twisted) weakremover(python2-pytest-vcr) weakremover(python2-pytest-verbose-parametrize) weakremover(python2-pytest-virtualenv) weakremover(python2-pytest-xdist) weakremover(python2-pytest-xvfb) weakremover(python2-pytest3) weakremover(python2-pytest4) weakremover(python2-python-afl) weakremover(python2-python-aiml) weakremover(python2-python-bidi) weakremover(python2-python-box) weakremover(python2-python-cjson) weakremover(python2-python-consul) weakremover(python2-python-coveralls) weakremover(python2-python-crfsuite) weakremover(python2-python-crontab) weakremover(python2-python-daemon) weakremover(python2-python-datamatrix) weakremover(python2-python-dateutil) weakremover(python2-python-dbusmock) weakremover(python2-python-docs-theme) weakremover(python2-python-dotenv) weakremover(python2-python-editor) weakremover(python2-python-fileinspector) weakremover(python2-python-gammu) weakremover(python2-python-gflags) weakremover(python2-python-gitlab) weakremover(python2-python-gnupg) weakremover(python2-python-jenkins) weakremover(python2-python-jose) weakremover(python2-python-json-logger) weakremover(python2-python-jsonrpc-server) weakremover(python2-python-jsonschema-objects) weakremover(python2-python-language-server) weakremover(python2-python-louvain) weakremover(python2-python-lzo) weakremover(python2-python-magic) weakremover(python2-python-memcached) weakremover(python2-python-mimeparse) weakremover(python2-python-mpd2) weakremover(python2-python-mpv) weakremover(python2-python-nmap) weakremover(python2-python-openid-cla) weakremover(python2-python-openid-teams) weakremover(python2-python-pam) weakremover(python2-python-pseudorandom) weakremover(python2-python-qdatamatrix) weakremover(python2-python-qnotifications) weakremover(python2-python-qpid-proton) weakremover(python2-python-qprogedit) weakremover(python2-python-redmine) weakremover(python2-python-slugify) weakremover(python2-python-snappy) weakremover(python2-python-sofa) weakremover(python2-python-sql) weakremover(python2-python-stdnum) weakremover(python2-python-subunit) weakremover(python2-python-ternary) weakremover(python2-python-twitter) weakremover(python2-python-utils) weakremover(python2-python-vlc) weakremover(python2-python-whois) weakremover(python2-python-xlib) weakremover(python2-python-yubico) weakremover(python2-python3-saml) weakremover(python2-pythonfinder) weakremover(python2-pythonwhois) weakremover(python2-pythreejs) weakremover(python2-pytidylib) weakremover(python2-pytils) weakremover(python2-pytimeparse) weakremover(python2-pytoml) weakremover(python2-pytools) weakremover(python2-pytricia) weakremover(python2-pytz) weakremover(python2-pytzdata) weakremover(python2-pyuca) weakremover(python2-pyudev) weakremover(python2-pyusb) weakremover(python2-pyutf8) weakremover(python2-pyuv) weakremover(python2-pyux) weakremover(python2-pyviz-comms) weakremover(python2-pyvmomi) weakremover(python2-pywbem) weakremover(python2-pywinrm) weakremover(python2-pyxattr) weakremover(python2-pyxb) weakremover(python2-pyxdg) weakremover(python2-pyzmq) weakremover(python2-pyzmq-devel) weakremover(python2-q) weakremover(python2-qgrid) weakremover(python2-qrcode) weakremover(python2-qscintilla-qt4) weakremover(python2-qscintilla-qt5) weakremover(python2-qt3d-qt5) weakremover(python2-qt4) weakremover(python2-qt4-devel) weakremover(python2-qt5) weakremover(python2-qt5-devel) weakremover(python2-qtcharts-qt5) weakremover(python2-qtconsole) weakremover(python2-qtdatavis3d-qt5) weakremover(python2-qtwebengine-qt5) weakremover(python2-quantities) weakremover(python2-queuelib) weakremover(python2-quicktions) weakremover(python2-radon) weakremover(python2-raet) weakremover(python2-random2) weakremover(python2-rarfile) weakremover(python2-rarfile-doc) weakremover(python2-ravello-sdk) weakremover(python2-raven) weakremover(python2-rawkit) weakremover(python2-rcssmin) weakremover(python2-rdflib) weakremover(python2-readme_renderer) weakremover(python2-readthedocs-sphinx-ext) weakremover(python2-rebulk) weakremover(python2-recommonmark) weakremover(python2-redbaron) weakremover(python2-redfish) weakremover(python2-redis) weakremover(python2-rednose) weakremover(python2-regex) weakremover(python2-relatorio) weakremover(python2-releases) weakremover(python2-releases-test) weakremover(python2-remoto) weakremover(python2-rencode) weakremover(python2-renderspec) weakremover(python2-reno) weakremover(python2-repex) weakremover(python2-reportlab) weakremover(python2-repoze.lru) weakremover(python2-repoze.sphinx.autointerface) weakremover(python2-repoze.who) weakremover(python2-requests) weakremover(python2-requests-aws) weakremover(python2-requests-cache) weakremover(python2-requests-download) weakremover(python2-requests-file) weakremover(python2-requests-ftp) weakremover(python2-requests-futures) weakremover(python2-requests-gssapi) weakremover(python2-requests-hawk) weakremover(python2-requests-kerberos) weakremover(python2-requests-mock) weakremover(python2-requests-oauthlib) weakremover(python2-requests-test) weakremover(python2-requests-toolbelt) weakremover(python2-requests-unixsocket) weakremover(python2-requests_ntlm) weakremover(python2-requestsexceptions) weakremover(python2-requirements-detector) weakremover(python2-requirements-parser) weakremover(python2-requirementslib) weakremover(python2-resampy) weakremover(python2-resolvelib) weakremover(python2-responses) weakremover(python2-restructuredtext_lint) weakremover(python2-restview) weakremover(python2-resultsdb_api) weakremover(python2-rethinkdb) weakremover(python2-retry) weakremover(python2-retry_decorator) weakremover(python2-retrying) weakremover(python2-retryrequests) weakremover(python2-rfc3986) weakremover(python2-rfc3987) weakremover(python2-rfc6266) weakremover(python2-rfc6555) weakremover(python2-rjsmin) weakremover(python2-rnginline) weakremover(python2-rollbar) weakremover(python2-roman) weakremover(python2-rope) weakremover(python2-rply) weakremover(python2-rpm) weakremover(python2-rpmfile) weakremover(python2-rpyc) weakremover(python2-rq) weakremover(python2-rrdtool) weakremover(python2-rsa) weakremover(python2-rst.linker) weakremover(python2-rstcheck) weakremover(python2-rt) weakremover(python2-rtslib-fb) weakremover(python2-ruamel.base) weakremover(python2-ruamel.std.argparse) weakremover(python2-ruamel.std.pathlib) weakremover(python2-ruamel.yaml) weakremover(python2-ruamel.yaml.clib) weakremover(python2-ruamel.yaml.cmd) weakremover(python2-ruamel.yaml.convert) weakremover(python2-ruffus) weakremover(python2-ryu) weakremover(python2-s3fs) weakremover(python2-s3transfer) weakremover(python2-sadisplay) weakremover(python2-saharaclient) weakremover(python2-salt) weakremover(python2-samplerate) weakremover(python2-sane) weakremover(python2-sanlock) weakremover(python2-sarge) weakremover(python2-sas7bdat) weakremover(python2-sasl) weakremover(python2-scales) weakremover(python2-scandir) weakremover(python2-schedule) weakremover(python2-schema) weakremover(python2-scikit-build) weakremover(python2-scikit-dsp-comm) weakremover(python2-scikit-image) weakremover(python2-scikit-learn) weakremover(python2-scikit-sparse) weakremover(python2-scikits.example) weakremover(python2-scipy) weakremover(python2-scipy-gnu-hpc) weakremover(python2-scipy_1_2_0-gnu-hpc) weakremover(python2-scipy_1_2_1-gnu-hpc) weakremover(python2-scitools) weakremover(python2-scour) weakremover(python2-scp) weakremover(python2-scripttest) weakremover(python2-scrypt) weakremover(python2-scspell3k) weakremover(python2-sdnotify) weakremover(python2-seaborn) weakremover(python2-selection) weakremover(python2-selectors2) weakremover(python2-selectors34) weakremover(python2-selinux) weakremover(python2-semanage) weakremover(python2-semantic_version) weakremover(python2-semver) weakremover(python2-senlinclient) weakremover(python2-sentry-sdk) weakremover(python2-seqdiag) weakremover(python2-serpent) weakremover(python2-serpy) weakremover(python2-serverfiles) weakremover(python2-service_identity) weakremover(python2-setools) weakremover(python2-setproctitle) weakremover(python2-setuptools-git) weakremover(python2-setuptools-test) weakremover(python2-setuptools-wheel) weakremover(python2-setuptools_scm) weakremover(python2-setuptools_scm-test) weakremover(python2-setuptools_scm_git_archive) weakremover(python2-sge-pygame) weakremover(python2-sh) weakremover(python2-shaptools) weakremover(python2-shellingham) weakremover(python2-shijian) weakremover(python2-shodan) weakremover(python2-shortuuid) weakremover(python2-shouldbe) weakremover(python2-shutilwhich) weakremover(python2-sievelib) weakremover(python2-sigal) weakremover(python2-signedjson) weakremover(python2-simplebayes) weakremover(python2-simpleeval) weakremover(python2-simplegeneric) weakremover(python2-simplejson) weakremover(python2-simplejson-test) weakremover(python2-simplekml) weakremover(python2-sip) weakremover(python2-sip-devel) weakremover(python2-siphashc) weakremover(python2-six) weakremover(python2-six-test) weakremover(python2-sklearn-pandas) weakremover(python2-sleekxmpp) weakremover(python2-slimit) weakremover(python2-slip) weakremover(python2-slip-dbus) weakremover(python2-slip-gtk) weakremover(python2-slumber) weakremover(python2-slycot) weakremover(python2-smartypants) weakremover(python2-smbprotocol) weakremover(python2-smmap) weakremover(python2-smmap2) weakremover(python2-snakefood) weakremover(python2-snimpy) weakremover(python2-snowballstemmer) weakremover(python2-snuggs) weakremover(python2-social-auth-app-django) weakremover(python2-social-auth-core) weakremover(python2-socketpool) weakremover(python2-softlayer) weakremover(python2-sortedcollections) weakremover(python2-sortedcontainers) weakremover(python2-sortinghat) weakremover(python2-soundcloud) weakremover(python2-sounddevice) weakremover(python2-soupsieve) weakremover(python2-sox) weakremover(python2-spake2) weakremover(python2-spark_parser) weakremover(python2-sparse) weakremover(python2-speaklater) weakremover(python2-spec) weakremover(python2-sphinx-bootstrap-theme) weakremover(python2-sphinx-feature-classification) weakremover(python2-sphinx-issues) weakremover(python2-sphinx-removed-in) weakremover(python2-sphinx-testing) weakremover(python2-sphinx-version-warning) weakremover(python2-sphinx_rtd_theme) weakremover(python2-sphinxbase) weakremover(python2-sphinxcontrib) weakremover(python2-sphinxcontrib-actdiag) weakremover(python2-sphinxcontrib-apidoc) weakremover(python2-sphinxcontrib-asyncio) weakremover(python2-sphinxcontrib-autoprogram) weakremover(python2-sphinxcontrib-autoprogram-doc) weakremover(python2-sphinxcontrib-blockdiag) weakremover(python2-sphinxcontrib-documentedlist) weakremover(python2-sphinxcontrib-github-alt) weakremover(python2-sphinxcontrib-httpdomain) weakremover(python2-sphinxcontrib-issuetracker) weakremover(python2-sphinxcontrib-newsfeed) weakremover(python2-sphinxcontrib-nwdiag) weakremover(python2-sphinxcontrib-pecanwsme) weakremover(python2-sphinxcontrib-plantuml) weakremover(python2-sphinxcontrib-programoutput) weakremover(python2-sphinxcontrib-seqdiag) weakremover(python2-sphinxcontrib-svg2pdfconverter) weakremover(python2-sphinxcontrib-websupport) weakremover(python2-spidev) weakremover(python2-spotipy) weakremover(python2-spyder-kernels) weakremover(python2-sqlalchemy-migrate) weakremover(python2-sqlitedict) weakremover(python2-sqlparse) weakremover(python2-sqlsoup) weakremover(python2-srcinfo) weakremover(python2-ssdeep) weakremover(python2-sshpubkeys) weakremover(python2-sshtunnel) weakremover(python2-statistics) weakremover(python2-statsd) weakremover(python2-statsmodels) weakremover(python2-stdeb) weakremover(python2-stestr) weakremover(python2-stevedore) weakremover(python2-stomp.py) weakremover(python2-stomper) weakremover(python2-storm) weakremover(python2-storm-django) weakremover(python2-storm-mysql) weakremover(python2-storm-postgresql) weakremover(python2-storm-twisted) weakremover(python2-straight-plugin) weakremover(python2-streamz) weakremover(python2-strict-rfc3339) weakremover(python2-strictyaml) weakremover(python2-structlog) weakremover(python2-subgrab) weakremover(python2-subliminal) weakremover(python2-subprocess32) weakremover(python2-subst) weakremover(python2-subunit) weakremover(python2-suds-jurko) weakremover(python2-sunpy) weakremover(python2-suntime) weakremover(python2-sure) weakremover(python2-sushy) weakremover(python2-svgwrite) weakremover(python2-swapper) weakremover(python2-sybil) weakremover(python2-sympy) weakremover(python2-systemd) weakremover(python2-tables) weakremover(python2-tablib) weakremover(python2-tabulate) weakremover(python2-tagpy) weakremover(python2-tap.py) weakremover(python2-targetcli-fb) weakremover(python2-tasklib) weakremover(python2-taskw) weakremover(python2-tbb) weakremover(python2-tblib) weakremover(python2-technicolor) weakremover(python2-telepot) weakremover(python2-template-remover) weakremover(python2-tempora) weakremover(python2-tenacity) weakremover(python2-tensorpac) weakremover(python2-termcolor) weakremover(python2-terminado) weakremover(python2-terminaltables) weakremover(python2-termstyle) weakremover(python2-tesserocr) weakremover(python2-test-server) weakremover(python2-testfixtures) weakremover(python2-testflo) weakremover(python2-testinfra) weakremover(python2-testpath) weakremover(python2-testrepository) weakremover(python2-testresources) weakremover(python2-testscenarios) weakremover(python2-testtools) weakremover(python2-text-unidecode) weakremover(python2-textX) weakremover(python2-textfsm) weakremover(python2-textile) weakremover(python2-texttable) weakremover(python2-textwrap3) weakremover(python2-thLib) weakremover(python2-thespian) weakremover(python2-threevis) weakremover(python2-thrift) weakremover(python2-thriftpy) weakremover(python2-thriftpy2) weakremover(python2-tinycss2) weakremover(python2-tinydb) weakremover(python2-tinyrecord) weakremover(python2-tinyrpc) weakremover(python2-titlecase) weakremover(python2-tkreadonly) weakremover(python2-tld) weakremover(python2-tldextract) weakremover(python2-tmx) weakremover(python2-toml) weakremover(python2-tomlkit) weakremover(python2-toolz) weakremover(python2-tooz) weakremover(python2-topy) weakremover(python2-tornado) weakremover(python2-tornado4) weakremover(python2-tornado5) weakremover(python2-toro) weakremover(python2-tortilla) weakremover(python2-towncrier) weakremover(python2-tox) weakremover(python2-tox-no-internet) weakremover(python2-tox-travis) weakremover(python2-tox-wheel) weakremover(python2-tpfd) weakremover(python2-tqdm) weakremover(python2-traceback2) weakremover(python2-traitlets) weakremover(python2-traits) weakremover(python2-traitsui) weakremover(python2-traittypes) weakremover(python2-transaction) weakremover(python2-transip) weakremover(python2-transitions) weakremover(python2-translation-finder) weakremover(python2-translationstring) weakremover(python2-translitcodec) weakremover(python2-trello) weakremover(python2-treq) weakremover(python2-tri.struct) weakremover(python2-trustme) weakremover(python2-tsk) weakremover(python2-tweepy) weakremover(python2-twine) weakremover(python2-twitter.common.finagle-thrift) weakremover(python2-twitter.common.lang) weakremover(python2-twitter.common.rpc) weakremover(python2-twodict) weakremover(python2-twython) weakremover(python2-txWS) weakremover(python2-txZMQ) weakremover(python2-txaio) weakremover(python2-txt2tags) weakremover(python2-txtorcon) weakremover(python2-typepy) weakremover(python2-typing) weakremover(python2-typing_extensions) weakremover(python2-tzlocal) weakremover(python2-u-msgpack-python) weakremover(python2-ua-parser) weakremover(python2-uamqp) weakremover(python2-ucsmsdk) weakremover(python2-ujson) weakremover(python2-unbound) weakremover(python2-uncertainties) weakremover(python2-uncompyle6) weakremover(python2-unicodecsv) weakremover(python2-unicodedata2) weakremover(python2-unidiff) weakremover(python2-unify) weakremover(python2-uniseg) weakremover(python2-units) weakremover(python2-unittest-mixins) weakremover(python2-unittest-xml-reporting) weakremover(python2-unittest2) weakremover(python2-unpaddedbase64) weakremover(python2-untokenize) weakremover(python2-upm) weakremover(python2-uritemplate) weakremover(python2-urlgrabber) weakremover(python2-urllib3) weakremover(python2-urllib3-test) weakremover(python2-urwid) weakremover(python2-usb) weakremover(python2-user-agents) weakremover(python2-user_agent) weakremover(python2-userpath) weakremover(python2-validate_email) weakremover(python2-validators) weakremover(python2-varlink) weakremover(python2-vcrpy) weakremover(python2-vcs) weakremover(python2-vcver) weakremover(python2-vcversioner) weakremover(python2-vdirsyncer) weakremover(python2-vega) weakremover(python2-vega_datasets) weakremover(python2-venusian) weakremover(python2-venusian-doc) weakremover(python2-verboselogs) weakremover(python2-versioneer) weakremover(python2-versiontag) weakremover(python2-versiontools) weakremover(python2-veusz) weakremover(python2-vim-vint) weakremover(python2-vine) weakremover(python2-virt-bootstrap) weakremover(python2-virtkey) weakremover(python2-virtualbmc) weakremover(python2-virtualenv) weakremover(python2-virtualenv-clone) weakremover(python2-virtualenvwrapper) weakremover(python2-visitor) weakremover(python2-vispy) weakremover(python2-vistir) weakremover(python2-vobject) weakremover(python2-voila) weakremover(python2-voluptuous) weakremover(python2-vsts) weakremover(python2-vsts-cd-manager) weakremover(python2-vulkan) weakremover(python2-vulture) weakremover(python2-w3lib) weakremover(python2-wadllib) weakremover(python2-waitress) weakremover(python2-waitress-doc) weakremover(python2-wakeonlan) weakremover(python2-warlock) weakremover(python2-watchdog) weakremover(python2-watchdog-doc) weakremover(python2-watermark) weakremover(python2-wcwidth) weakremover(python2-weave) weakremover(python2-web.py) weakremover(python2-webassets) weakremover(python2-webcolors) weakremover(python2-webencodings) weakremover(python2-weblib) weakremover(python2-websocket-client) weakremover(python2-websockify) weakremover(python2-whatever) weakremover(python2-whatthepatch) weakremover(python2-wheel) weakremover(python2-whichcraft) weakremover(python2-whitenoise) weakremover(python2-whois_similarity_distance) weakremover(python2-wikipedia) weakremover(python2-wiring) weakremover(python2-wolframalpha) weakremover(python2-wptools) weakremover(python2-wrapt) weakremover(python2-ws4py) weakremover(python2-wsaccel) weakremover(python2-wsgi_intercept) weakremover(python2-wsproto) weakremover(python2-wstools) weakremover(python2-wtf-peewee) weakremover(python2-wurlitzer) weakremover(python2-wxPython) weakremover(python2-wxPython-lang) weakremover(python2-xapp) weakremover(python2-xarray) weakremover(python2-xattr) weakremover(python2-xcaplib) weakremover(python2-xcffib) weakremover(python2-xdis) weakremover(python2-xerox) weakremover(python2-xhtml2pdf) weakremover(python2-xkbgroup) weakremover(python2-xlrd) weakremover(python2-xlwt) weakremover(python2-xmldiff) weakremover(python2-xmlschema) weakremover(python2-xmlsec) weakremover(python2-xmltodict) weakremover(python2-xpybutil) weakremover(python2-xsge_gui) weakremover(python2-xsge_lighting) weakremover(python2-xsge_particle) weakremover(python2-xsge_path) weakremover(python2-xsge_physics) weakremover(python2-xsge_tmx) weakremover(python2-xvfbwrapper) weakremover(python2-xxhash) weakremover(python2-yamldoc) weakremover(python2-yamllint) weakremover(python2-yamlloader) weakremover(python2-yapf) weakremover(python2-yappi) weakremover(python2-yaql) weakremover(python2-yara) weakremover(python2-yarb) weakremover(python2-yarg) weakremover(python2-yaspin) weakremover(python2-youtube-dl) weakremover(python2-yq) weakremover(python2-yubico) weakremover(python2-yum) weakremover(python2-zake) weakremover(python2-zaqarclient) weakremover(python2-zc.buildout) weakremover(python2-zc.customdoctests) weakremover(python2-zc.lockfile) weakremover(python2-zdaemon) weakremover(python2-zeep) weakremover(python2-zeroconf) weakremover(python2-zetup) weakremover(python2-zhon) weakremover(python2-zict) weakremover(python2-zipp) weakremover(python2-zipstream) weakremover(python2-zodbpickle) weakremover(python2-zope.cachedescriptors) weakremover(python2-zope.component) weakremover(python2-zope.configuration) weakremover(python2-zope.copy) weakremover(python2-zope.deferredimport) weakremover(python2-zope.deprecation) weakremover(python2-zope.event) weakremover(python2-zope.exceptions) weakremover(python2-zope.hookable) weakremover(python2-zope.i18nmessageid) weakremover(python2-zope.interface) weakremover(python2-zope.location) weakremover(python2-zope.proxy) weakremover(python2-zope.proxy-devel) weakremover(python2-zope.schema) weakremover(python2-zope.security) weakremover(python2-zope.testbrowser) weakremover(python2-zope.testing) weakremover(python2-zope.testrunner) weakremover(python2-zstandard) weakremover(python2-zstd) weakremover(python2-zxcvbn) weakremover(python2-zypp-plugin) weakremover(python22-scipy-gnu-hpc) weakremover(python3) weakremover(python3-3to2) weakremover(python3-96BoardsGPIO) weakremover(python3-Arcus) weakremover(python3-Attest) weakremover(python3-BTrees) weakremover(python3-BTrees-devel) weakremover(python3-BTrees-doc) weakremover(python3-Babel-doc) weakremover(python3-Bottleneck) weakremover(python3-Brotli) weakremover(python3-CCColUtils) weakremover(python3-Chameleon-doc) weakremover(python3-Cheetah3) weakremover(python3-CommonMark-doc) weakremover(python3-Cython) weakremover(python3-Django1) weakremover(python3-Durus) weakremover(python3-Fabric3) weakremover(python3-Fiona) weakremover(python3-Flask-Cache) weakremover(python3-Flask-Cache-doc) weakremover(python3-Flask-PyMongo) weakremover(python3-Flask-Script) weakremover(python3-Frozen-Flask) weakremover(python3-GDAL) weakremover(python3-Genshi) weakremover(python3-Genshi-doc) weakremover(python3-GeoIP) weakremover(python3-GitgExt) weakremover(python3-Hamlib) weakremover(python3-HepMC) weakremover(python3-JPype1) weakremover(python3-Jinja2) weakremover(python3-Jinja2-emacs) weakremover(python3-Jinja2-vim) weakremover(python3-Kajiki) weakremover(python3-Keras) weakremover(python3-Keras-Applications) weakremover(python3-Keras-Preprocessing) weakremover(python3-Keras-examples) weakremover(python3-Kivy) weakremover(python3-Kivy-devel) weakremover(python3-LEPL) weakremover(python3-LHAPDF) weakremover(python3-Levenshtein) weakremover(python3-Logbook) weakremover(python3-M2Crypto) weakremover(python3-MarkupSafe) weakremover(python3-Mathics) weakremover(python3-Ming) weakremover(python3-MulticoreTSNE) weakremover(python3-OpenColorIO) weakremover(python3-OpenImageIO) weakremover(python3-PasteScript) weakremover(python3-Paver) weakremover(python3-Pillow) weakremover(python3-Pillow-tk) weakremover(python3-PsychoPy) weakremover(python3-PsychoPy-lang) weakremover(python3-PyAudio) weakremover(python3-PyECLib) weakremover(python3-PyExecJS) weakremover(python3-PyGetWindow) weakremover(python3-PyICU) weakremover(python3-PyInstaller) weakremover(python3-PyMuPDF) weakremover(python3-PyNaCl) weakremover(python3-PyPrint) weakremover(python3-PyWavelets) weakremover(python3-PyYAML) weakremover(python3-Pydap) weakremover(python3-Pykka) weakremover(python3-QR-Code-generator) weakremover(python3-Qt.py) weakremover(python3-Quandl) weakremover(python3-Rivet) weakremover(python3-SHERPA-MC) weakremover(python3-SQLAlchemy) weakremover(python3-SQLAlchemy-doc) weakremover(python3-Shapely) weakremover(python3-SoapySDR) weakremover(python3-Sphinx-doc) weakremover(python3-Sphinx-doc-man) weakremover(python3-Sphinx-test) weakremover(python3-Sphinx2) weakremover(python3-Sphinx2-latex) weakremover(python3-Theano) weakremover(python3-Twisted-doc) weakremover(python3-WebOb-doc) weakremover(python3-XStatic-jQuery) weakremover(python3-XStatic-term.js) weakremover(python3-YODA) weakremover(python3-abclient) weakremover(python3-acefile) weakremover(python3-acoular) weakremover(python3-afdko) weakremover(python3-aiobotocore) weakremover(python3-aiohttp) weakremover(python3-aioredis) weakremover(python3-alsa) weakremover(python3-amqplib) weakremover(python3-annoy) weakremover(python3-apparmor) weakremover(python3-application) weakremover(python3-apsw) weakremover(python3-apsw-doc) weakremover(python3-argon2-cffi) weakremover(python3-arpack-ng) weakremover(python3-astropy) weakremover(python3-astropy-helpers) weakremover(python3-astunparse) weakremover(python3-asv) weakremover(python3-asyncpg) weakremover(python3-asynctest) weakremover(python3-atom) weakremover(python3-aubio) weakremover(python3-audiolazy) weakremover(python3-audit) weakremover(python3-autobahn) weakremover(python3-autodoc) weakremover(python3-av) weakremover(python3-avahi) weakremover(python3-avahi-gtk) weakremover(python3-avogadro) weakremover(python3-aws-xray-sdk-aiobotocore) weakremover(python3-axolotl-curve25519) weakremover(python3-azure-mgmt-azurestack) weakremover(python3-azure-sdk) weakremover(python3-azure-synapse) weakremover(python3-babeltrace) weakremover(python3-babeltrace2) weakremover(python3-backports) weakremover(python3-backports.shutil_get_terminal_size) weakremover(python3-backports.ssl_match_hostname) weakremover(python3-backports_abc) weakremover(python3-base) weakremover(python3-bcolz) weakremover(python3-bcrypt) weakremover(python3-beren) weakremover(python3-bind) weakremover(python3-biopython) weakremover(python3-bitarray) weakremover(python3-bitstruct) weakremover(python3-bjoern) weakremover(python3-blindspin) weakremover(python3-blist) weakremover(python3-blosc) weakremover(python3-boost_parallel_mpi1_66_0) weakremover(python3-boost_parallel_mpi1_68_0) weakremover(python3-boost_parallel_mpi1_69_0) weakremover(python3-boost_parallel_mpi1_71_0) weakremover(python3-boost_parallel_mpi1_74_0) weakremover(python3-boost_parallel_mpi1_75_0) weakremover(python3-boost_parallel_mpi1_76_0) weakremover(python3-boost_parallel_mpi1_77_0) weakremover(python3-boost_parallel_mpi1_78_0) weakremover(python3-boost_parallel_mpi1_79_0) weakremover(python3-boost_parallel_mpi1_80_0) weakremover(python3-boost_parallel_mpi1_81_0) weakremover(python3-boost_parallel_mpi1_82_0) weakremover(python3-botan) weakremover(python3-boto) weakremover(python3-boto-doc) weakremover(python3-brlapi) weakremover(python3-brotlipy) weakremover(python3-bsddb3) weakremover(python3-bsddb3-devel) weakremover(python3-buku) weakremover(python3-buku-bash-completion) weakremover(python3-buku-fish-completion) weakremover(python3-buku-zsh-completion) weakremover(python3-cPyparsing) weakremover(python3-caffe) weakremover(python3-caffe-gnu-hpc) weakremover(python3-caffe_1_0-gnu-hpc) weakremover(python3-cairo) weakremover(python3-cairo-devel) weakremover(python3-cangjie) weakremover(python3-capng) weakremover(python3-casacore) weakremover(python3-cassandra-driver) weakremover(python3-cbor) weakremover(python3-cbor2) weakremover(python3-cchardet) weakremover(python3-ceilometerclient) weakremover(python3-celerymon) weakremover(python3-ceph-argparse) weakremover(python3-ceph-common) weakremover(python3-cephfs) weakremover(python3-cerealizer) weakremover(python3-cffi) weakremover(python3-cffi-doc) weakremover(python3-cftime) weakremover(python3-chainmap) weakremover(python3-characteristic) weakremover(python3-chart-studio) weakremover(python3-cilium-microscope) weakremover(python3-clang16) weakremover(python3-clingo) weakremover(python3-clinkgrammar) weakremover(python3-cloud-sptheme) weakremover(python3-cluster-preflight-check) weakremover(python3-cmarkgfm) weakremover(python3-colorlog) weakremover(python3-combi) weakremover(python3-compizconfig) weakremover(python3-condor) weakremover(python3-configparser) weakremover(python3-configparser2) weakremover(python3-confluent-kafka) weakremover(python3-congressclient) weakremover(python3-contextlib2) weakremover(python3-cotyledon) weakremover(python3-cov-core) weakremover(python3-coverage) weakremover(python3-coverage-config-reload-plugin) weakremover(python3-coverage-env-plugin) weakremover(python3-coveralls) weakremover(python3-cracklib) weakremover(python3-cram) weakremover(python3-crcmod) weakremover(python3-createrepo_c) weakremover(python3-cryptography) weakremover(python3-csound) weakremover(python3-ctypescrypto) weakremover(python3-ctypesgen) weakremover(python3-cu2qu) weakremover(python3-cups) weakremover(python3-curses) weakremover(python3-cursive) weakremover(python3-cx_Freeze) weakremover(python3-cyordereddict) weakremover(python3-cytoolz) weakremover(python3-datadiff) weakremover(python3-datrie) weakremover(python3-dbm) weakremover(python3-dbus-presage) weakremover(python3-dbus-python) weakremover(python3-dbus-python-devel) weakremover(python3-deap) weakremover(python3-deltarpm) weakremover(python3-demjson) weakremover(python3-dephell) weakremover(python3-dephell-archive) weakremover(python3-dephell-argparse) weakremover(python3-dephell-discover) weakremover(python3-dephell-licenses) weakremover(python3-dephell-links) weakremover(python3-dephell-markers) weakremover(python3-dephell-pythons) weakremover(python3-dephell-setuptools) weakremover(python3-dephell-shells) weakremover(python3-dephell-specifier) weakremover(python3-dephell-venvs) weakremover(python3-dephell-versioning) weakremover(python3-dephell_changelogs) weakremover(python3-devel) weakremover(python3-discover) weakremover(python3-dist) weakremover(python3-distorm3) weakremover(python3-django-action-framework) weakremover(python3-django-allauth-lang) weakremover(python3-django-args) weakremover(python3-django-babel) weakremover(python3-django-collectd-rest) weakremover(python3-django-dynamic-fixture) weakremover(python3-django-multiselectfield) weakremover(python3-django-nose) weakremover(python3-django-pyscss) weakremover(python3-django-threadedcomments) weakremover(python3-django-webtest) weakremover(python3-djvulibre) weakremover(python3-dnsdiag) weakremover(python3-doc) weakremover(python3-doc-devhelp) weakremover(python3-doc-pdf) weakremover(python3-docker-py-test) weakremover(python3-drf-jwt-knox) weakremover(python3-drf-nested-routers) weakremover(python3-dtaidistance) weakremover(python3-dtaidistance-devel) weakremover(python3-dukpy) weakremover(python3-dukpy-kovidgoyal) weakremover(python3-dulwich) weakremover(python3-ed25519) weakremover(python3-editdistance) weakremover(python3-editdistance-devel) weakremover(python3-efilter) weakremover(python3-efl) weakremover(python3-efl-doc) weakremover(python3-efl-examples) weakremover(python3-eliot) weakremover(python3-enable) weakremover(python3-enable-kiva) weakremover(python3-enaml) weakremover(python3-enforce-pep8) weakremover(python3-enum-compat) weakremover(python3-ephem) weakremover(python3-espeak) weakremover(python3-espressomd) weakremover(python3-etcd-test) weakremover(python3-ethtool) weakremover(python3-evdev) weakremover(python3-evemu) weakremover(python3-eventlet-doc) weakremover(python3-execnet-doc) weakremover(python3-exiv2) weakremover(python3-experimentator) weakremover(python3-ezdxf) weakremover(python3-fabio) weakremover(python3-fann2) weakremover(python3-fastTSNE) weakremover(python3-fastcluster) weakremover(python3-fastjet) weakremover(python3-fastnumbers) weakremover(python3-fastparquet) weakremover(python3-fastremap) weakremover(python3-fb-re2) weakremover(python3-featureflow) weakremover(python3-fedmsg) weakremover(python3-fedmsg-tests) weakremover(python3-fife) weakremover(python3-fityk) weakremover(python3-flake8-future-import) weakremover(python3-flask-mongoengine) weakremover(python3-flask-restplus) weakremover(python3-forbiddenfruit) weakremover(python3-framel) weakremover(python3-frozendict) weakremover(python3-fuse) weakremover(python3-fysom) weakremover(python3-gabbi) weakremover(python3-gdal) weakremover(python3-gdata) weakremover(python3-gdcm) weakremover(python3-geis) weakremover(python3-genders) weakremover(python3-gensio) weakremover(python3-gevent) weakremover(python3-geventhttpclient) weakremover(python3-gexiv2) weakremover(python3-git-deps) weakremover(python3-gitdb) weakremover(python3-gitdb2) weakremover(python3-glom) weakremover(python3-glucat) weakremover(python3-gmpy) weakremover(python3-gmpy2) weakremover(python3-gnucash) weakremover(python3-gobject) weakremover(python3-gobject-Dee) weakremover(python3-gobject-Gdk) weakremover(python3-gobject-cairo) weakremover(python3-gobject-devel) weakremover(python3-gobject2) weakremover(python3-gobject2-devel) weakremover(python3-gogs_client) weakremover(python3-gom) weakremover(python3-goobook) weakremover(python3-google-pasta) weakremover(python3-gpg) weakremover(python3-gpgme) weakremover(python3-gphoto2) weakremover(python3-gpiod) weakremover(python3-gpsd) weakremover(python3-gr-funcube) weakremover(python3-gr-iqbal) weakremover(python3-gr-osmosdr) weakremover(python3-graphene-django) weakremover(python3-greenlet) weakremover(python3-grpcio) weakremover(python3-grpcio-tools) weakremover(python3-gssapi) weakremover(python3-gst) weakremover(python3-gsw) weakremover(python3-gunicorn-doc) weakremover(python3-gv) weakremover(python3-h5py) weakremover(python3-h5py-openmpi1) weakremover(python3-h5py-openmpi2) weakremover(python3-h5py-openmpi3) weakremover(python3-h5py-openmpi4) weakremover(python3-hawkey) weakremover(python3-hdf5storage) weakremover(python3-healpy) weakremover(python3-hide-code) weakremover(python3-hiredis) weakremover(python3-hivex) weakremover(python3-hotdoc) weakremover(python3-hp3parclient) weakremover(python3-html5-parser) weakremover(python3-http-parser) weakremover(python3-httptools) weakremover(python3-hug) weakremover(python3-humanfriendly-test) weakremover(python3-hyper) weakremover(python3-hypothesis-auto) weakremover(python3-hypothesis-test) weakremover(python3-ibus) weakremover(python3-idle) weakremover(python3-ijson) weakremover(python3-imagecodecs) weakremover(python3-imbox) weakremover(python3-img-proof) weakremover(python3-img-proof-tests) weakremover(python3-iminuit) weakremover(python3-immutables) weakremover(python3-imobiledevice) weakremover(python3-imread) weakremover(python3-influxdb) weakremover(python3-ioflo) weakremover(python3-ipa) weakremover(python3-ipa-tests) weakremover(python3-ipa_hbac) weakremover(python3-iptables) weakremover(python3-ipython-iptest) weakremover(python3-ipython715) weakremover(python3-ipython715-iptest) weakremover(python3-itemadapter) weakremover(python3-itk) weakremover(python3-iwlib) weakremover(python3-jaraco.base) weakremover(python3-jellyfish) weakremover(python3-jenkins-job-builder) weakremover(python3-jgraph) weakremover(python3-jsondate) weakremover(python3-jsonextended) weakremover(python3-jsonlib-python3) weakremover(python3-jsonpath-rw-ext) weakremover(python3-jsonslicer) weakremover(python3-jupyter-contrib-nbextensions) weakremover(python3-jupyter-datatables) weakremover(python3-jupyter-nbutils) weakremover(python3-jupyter-protocol) weakremover(python3-jupyter-require) weakremover(python3-jupyter_Video_Widget) weakremover(python3-jupyter_client-doc) weakremover(python3-jupyter_cms) weakremover(python3-jupyter_contrib_nbextensions) weakremover(python3-jupyter_core-doc-html) weakremover(python3-jupyter_dashboards) weakremover(python3-jupyter_full_width) weakremover(python3-jupyter_hide_code) weakremover(python3-jupyter_ipydatawidgets_jupyterlab) weakremover(python3-jupyter_ipympl_jupyterlab) weakremover(python3-jupyter_ipyscales_jupyterlab) weakremover(python3-jupyter_ipython-iptest) weakremover(python3-jupyter_jgraph) weakremover(python3-jupyter_jupyterlab_discovery) weakremover(python3-jupyter_jupyterlab_github) weakremover(python3-jupyter_jupyterlab_widgets) weakremover(python3-jupyter_nbconvert-latex) weakremover(python3-jupyter_nbdime_jupyterlab) weakremover(python3-jupyter_nbformat-doc-html) weakremover(python3-jupyter_nbpresent) weakremover(python3-jupyter_nbsphinx_link) weakremover(python3-jupyter_notebook-latex) weakremover(python3-jupyter_qgrid) weakremover(python3-jupyter_rise) weakremover(python3-jupyter_sphinx_theme) weakremover(python3-jupyter_themer) weakremover(python3-jupytext) weakremover(python3-kde4-akonadi) weakremover(python3-kde4-devel) weakremover(python3-kde4-doc) weakremover(python3-kde4-khtml) weakremover(python3-kde4-knewstuff) weakremover(python3-kde4-phonon) weakremover(python3-kde4-plasma) weakremover(python3-kea) weakremover(python3-keepalive) weakremover(python3-keras2onnx) weakremover(python3-kerberos) weakremover(python3-keyczar) weakremover(python3-kiwi) weakremover(python3-kiwi_crossprepare_plugin) weakremover(python3-kiwisolver) weakremover(python3-kmod) weakremover(python3-kopano) weakremover(python3-ktoblzcheck) weakremover(python3-kwant) weakremover(python3-labelImg) weakremover(python3-lal) weakremover(python3-lalapps) weakremover(python3-lalburst) weakremover(python3-lalframe) weakremover(python3-lalinference) weakremover(python3-lalinspiral) weakremover(python3-lalmetaio) weakremover(python3-lalpulsar) weakremover(python3-lalsimulation) weakremover(python3-lammps) weakremover(python3-lash) weakremover(python3-lasso) weakremover(python3-lazy-object-proxy) weakremover(python3-lazy_object_proxy) weakremover(python3-ldap) weakremover(python3-ldas-tools-al-swig) weakremover(python3-ldb) weakremover(python3-ldb-devel) weakremover(python3-ldns) weakremover(python3-lensfun) weakremover(python3-leveldb) weakremover(python3-lfdfiles) weakremover(python3-lhafile) weakremover(python3-libaccounts) weakremover(python3-libbde) weakremover(python3-libblockdev) weakremover(python3-libbytesize) weakremover(python3-libcaes) weakremover(python3-libcec) weakremover(python3-libcomps) weakremover(python3-libcreg) weakremover(python3-libcst) weakremover(python3-libdnf) weakremover(python3-libesedb) weakremover(python3-libevt) weakremover(python3-libevtx) weakremover(python3-libewf) weakremover(python3-libexe) weakremover(python3-libfdt) weakremover(python3-libfsapfs) weakremover(python3-libfsext) weakremover(python3-libfshfs) weakremover(python3-libfsntfs) weakremover(python3-libfsxfs) weakremover(python3-libftdi1) weakremover(python3-libfvde) weakremover(python3-libfwnt) weakremover(python3-libfwps) weakremover(python3-libfwsi) weakremover(python3-libgsignon) weakremover(python3-libguestfs) weakremover(python3-libixion) weakremover(python3-libkdumpfile) weakremover(python3-liblnk) weakremover(python3-libluksde) weakremover(python3-libmodi) weakremover(python3-libmodulemd) weakremover(python3-libmount) weakremover(python3-libmsiecf) weakremover(python3-libnacl) weakremover(python3-libnbd) weakremover(python3-libnvme) weakremover(python3-libolecf) weakremover(python3-liborcus) weakremover(python3-libpamtest) weakremover(python3-libpff) weakremover(python3-libpfm) weakremover(python3-libphdi) weakremover(python3-libprelude) weakremover(python3-libpreludedb) weakremover(python3-libqcow) weakremover(python3-libregf) weakremover(python3-librepo) weakremover(python3-libsass) weakremover(python3-libscca) weakremover(python3-libsignon-glib) weakremover(python3-libsigscan) weakremover(python3-libsmdev) weakremover(python3-libsmraw) weakremover(python3-libsoc) weakremover(python3-libstoragemgmt) weakremover(python3-libstoragemgmt-clibs) weakremover(python3-libtorrent-rasterbar) weakremover(python3-libtorrent-rasterbar-1) weakremover(python3-libunity) weakremover(python3-libvhdi) weakremover(python3-libvirt-python) weakremover(python3-libvmdk) weakremover(python3-libvsapm) weakremover(python3-libvsgpt) weakremover(python3-libvshadow) weakremover(python3-libvslvm) weakremover(python3-libvsmbr) weakremover(python3-libwrc) weakremover(python3-libxml2) weakremover(python3-libxml2-python) weakremover(python3-ligo-lw) weakremover(python3-ligo-segments) weakremover(python3-lilv) weakremover(python3-line_profiler) weakremover(python3-linstor) weakremover(python3-linstor-client) weakremover(python3-lldb) weakremover(python3-lldb16) weakremover(python3-llfuse) weakremover(python3-llvmlite) weakremover(python3-lmdb) weakremover(python3-logilab-astng) weakremover(python3-louis) weakremover(python3-lscsoft-glue) weakremover(python3-lttngust) weakremover(python3-lupa) weakremover(python3-lws) weakremover(python3-lxml) weakremover(python3-lxml-devel) weakremover(python3-lxml-doc) weakremover(python3-lz4) weakremover(python3-lzmaffi) weakremover(python3-m2r) weakremover(python3-magic) weakremover(python3-mailman-hyperkitty) weakremover(python3-mailman-web) weakremover(python3-mapi) weakremover(python3-marisa) weakremover(python3-matplotlib) weakremover(python3-matplotlib-cairo) weakremover(python3-matplotlib-gtk2) weakremover(python3-matplotlib-gtk3) weakremover(python3-matplotlib-qt-shared) weakremover(python3-matplotlib-qt4) weakremover(python3-matplotlib-qt5) weakremover(python3-matplotlib-testdata) weakremover(python3-matplotlib-tk) weakremover(python3-matplotlib-web) weakremover(python3-matplotlib-wx) weakremover(python3-matrix-synapse) weakremover(python3-matrix-synapse-ldap3) weakremover(python3-mautrix-telegram) weakremover(python3-maxminddb) weakremover(python3-metamagic.json) weakremover(python3-microversion_parse) weakremover(python3-miniupnpc) weakremover(python3-misaka) weakremover(python3-missingno) weakremover(python3-mlt) weakremover(python3-mlt6) weakremover(python3-mock) weakremover(python3-mock-doc) weakremover(python3-mockldap) weakremover(python3-moksha-common) weakremover(python3-moksha-hub) weakremover(python3-moretools) weakremover(python3-moviepy) weakremover(python3-mox3) weakremover(python3-mpi4py) weakremover(python3-mpi4py-devel) weakremover(python3-mpmath-doc) weakremover(python3-mraa) weakremover(python3-msgpack) weakremover(python3-msgpack-python) weakremover(python3-multidict) weakremover(python3-murano-pkg-check) weakremover(python3-mysqlclient) weakremover(python3-nagios-http-json) weakremover(python3-napalm-ansible) weakremover(python3-napalm-exos) weakremover(python3-nautilus) weakremover(python3-nautilus-devel) weakremover(python3-nbindex-jupyter) weakremover(python3-nbinteract) weakremover(python3-nbsphinx-link) weakremover(python3-nbxmpp-doc) weakremover(python3-nemo) weakremover(python3-neovim-remote) weakremover(python3-net-snmp) weakremover(python3-netCDF4) weakremover(python3-netgen) weakremover(python3-netifaces) weakremover(python3-newt) weakremover(python3-nftables) weakremover(python3-nghttp2) weakremover(python3-nlopt) weakremover(python3-nose) weakremover(python3-nose-cov) weakremover(python3-nose-cover3) weakremover(python3-nose-doc) weakremover(python3-nose-exclude) weakremover(python3-nose-progressive) weakremover(python3-nose-random) weakremover(python3-nose-timer) weakremover(python3-nose2pytest) weakremover(python3-nose_warnings_filters) weakremover(python3-nosexcover) weakremover(python3-notcurses) weakremover(python3-notmuch) weakremover(python3-nss) weakremover(python3-ntlm-auth) weakremover(python3-ntp) weakremover(python3-numba) weakremover(python3-numba-devel) weakremover(python3-numcodecs) weakremover(python3-numexpr) weakremover(python3-numpy) weakremover(python3-numpy-devel) weakremover(python3-numpy-doc) weakremover(python3-numpy-gnu-hpc) weakremover(python3-numpy-gnu-hpc-devel) weakremover(python3-numpy_1_14_0-gnu-hpc) weakremover(python3-numpy_1_14_0-gnu-hpc-devel) weakremover(python3-numpy_1_15_4-gnu-hpc) weakremover(python3-numpy_1_15_4-gnu-hpc-devel) weakremover(python3-numpy_1_16_1-gnu-hpc) weakremover(python3-numpy_1_16_1-gnu-hpc-devel) weakremover(python3-numpy_1_16_2-gnu-hpc) weakremover(python3-numpy_1_16_2-gnu-hpc-devel) weakremover(python3-numpy_1_16_3-gnu-hpc) weakremover(python3-numpy_1_16_3-gnu-hpc-devel) weakremover(python3-numpy_1_16_4-gnu-hpc) weakremover(python3-numpy_1_16_4-gnu-hpc-devel) weakremover(python3-numpy_1_17_0-gnu-hpc) weakremover(python3-numpy_1_17_0-gnu-hpc-devel) weakremover(python3-numpy_1_17_1-gnu-hpc) weakremover(python3-numpy_1_17_1-gnu-hpc-devel) weakremover(python3-numpy_1_17_3-gnu-hpc) weakremover(python3-numpy_1_17_3-gnu-hpc-devel) weakremover(python3-numpy_1_18_1-gnu-hpc) weakremover(python3-numpy_1_18_1-gnu-hpc-devel) weakremover(python3-numpy_1_19_0-gnu-hpc) weakremover(python3-numpy_1_19_0-gnu-hpc-devel) weakremover(python3-numpy_1_19_2-gnu-hpc) weakremover(python3-numpy_1_19_2-gnu-hpc-devel) weakremover(python3-numpy_1_19_5-gnu-hpc) weakremover(python3-numpy_1_19_5-gnu-hpc-devel) weakremover(python3-oauth2client) weakremover(python3-oauth2client-django) weakremover(python3-oauth2client-flask) weakremover(python3-oauth2client-gce) weakremover(python3-obexftp) weakremover(python3-odict) weakremover(python3-onionshare) weakremover(python3-onnx) weakremover(python3-onnx-devel) weakremover(python3-openbabel) weakremover(python3-opencv) weakremover(python3-opencv-qt5) weakremover(python3-opencv3) weakremover(python3-opengl-accelerate) weakremover(python3-openmesh) weakremover(python3-openshot) weakremover(python3-openstack.nose_plugin) weakremover(python3-openvswitch) weakremover(python3-openvswitch-test) weakremover(python3-openwsman) weakremover(python3-ortools) weakremover(python3-os-api-ref) weakremover(python3-os-testr) weakremover(python3-os-win) weakremover(python3-osdlyrics) weakremover(python3-oslo.db) weakremover(python3-oslosphinx) weakremover(python3-otb) weakremover(python3-ovirt-engine-sdk) weakremover(python3-ovs) weakremover(python3-pampy) weakremover(python3-pandas) weakremover(python3-pandas-doc) weakremover(python3-pandas-ext) weakremover(python3-parted) weakremover(python3-partio) weakremover(python3-pass_python_keyring) weakremover(python3-passa) weakremover(python3-pastream) weakremover(python3-pathlib) weakremover(python3-pathlib2) weakremover(python3-patiencediff) weakremover(python3-pbr-test) weakremover(python3-pcp) weakremover(python3-pdfkit) weakremover(python3-peewee) weakremover(python3-pendulum) weakremover(python3-perfume-bench) weakremover(python3-persistent) weakremover(python3-persistent-devel) weakremover(python3-persistent-doc) weakremover(python3-pgmagick) weakremover(python3-photutils) weakremover(python3-piexif) weakremover(python3-pikepdf) weakremover(python3-pipenv) weakremover(python3-piston-mini-client) weakremover(python3-pivy) weakremover(python3-plist) weakremover(python3-plplot) weakremover(python3-ply-doc) weakremover(python3-plyvel) weakremover(python3-pocketsphinx) weakremover(python3-pocketsphinx-python) weakremover(python3-pocketsphinx5) weakremover(python3-polib-doc) weakremover(python3-pomegranate) weakremover(python3-pomegranate-devel) weakremover(python3-pontos) weakremover(python3-poppler-qt5) weakremover(python3-poppler-qt5-devel) weakremover(python3-positional) weakremover(python3-posix_ipc) weakremover(python3-presage) weakremover(python3-prewikka) weakremover(python3-proboscis) weakremover(python3-proliantutils) weakremover(python3-prompt_toolkit1) weakremover(python3-protobuf) weakremover(python3-psautohint) weakremover(python3-psutil) weakremover(python3-psychtoolbox) weakremover(python3-psycopg2) weakremover(python3-psycopg2-doc) weakremover(python3-psycopg2cffi) weakremover(python3-pwquality) weakremover(python3-py-doc) weakremover(python3-py-radix) weakremover(python3-py-ubjson) weakremover(python3-pyFFTW) weakremover(python3-pyIOSXR) weakremover(python3-pyOpenSSL-doc) weakremover(python3-pyPEG2) weakremover(python3-pyRXP) weakremover(python3-pyScss) weakremover(python3-pyalsaaudio) weakremover(python3-pyblake2) weakremover(python3-pybluez) weakremover(python3-pycairo) weakremover(python3-pycairo-devel) weakremover(python3-pycallgraph) weakremover(python3-pycares) weakremover(python3-pycdio) weakremover(python3-pychm) weakremover(python3-pyclipper) weakremover(python3-pycocotools) weakremover(python3-pycrypto) weakremover(python3-pycryptodome) weakremover(python3-pycryptodomex) weakremover(python3-pycups) weakremover(python3-pycurl) weakremover(python3-pycurl-doc) weakremover(python3-pycurl-test) weakremover(python3-pydle) weakremover(python3-pyeantic) weakremover(python3-pyemd) weakremover(python3-pyerfa) weakremover(python3-pyexmdb) weakremover(python3-pyfg) weakremover(python3-pyfuse3) weakremover(python3-pygame) weakremover(python3-pygame-devel) weakremover(python3-pygame-doc) weakremover(python3-pyginac) weakremover(python3-pyginac-devel) weakremover(python3-pygit2) weakremover(python3-pygraphviz) weakremover(python3-pyinotify) weakremover(python3-pyinsane2) weakremover(python3-pyjnius) weakremover(python3-pykafka) weakremover(python3-pykerberos) weakremover(python3-pylibacl) weakremover(python3-pylibiio) weakremover(python3-pyliblo) weakremover(python3-pyliblo-doc) weakremover(python3-pylibmc) weakremover(python3-pyls-black) weakremover(python3-pylzma) weakremover(python3-pymad) weakremover(python3-pymavlink) weakremover(python3-pymilter) weakremover(python3-pymol) weakremover(python3-pymongo) weakremover(python3-pympv) weakremover(python3-pymssql) weakremover(python3-pynest2d) weakremover(python3-pyo) weakremover(python3-pyodbc) weakremover(python3-pyotherside) weakremover(python3-pypandoc) weakremover(python3-pyparsing-doc) weakremover(python3-pyparsing-test) weakremover(python3-pypipegraph) weakremover(python3-pyppeteer) weakremover(python3-pyproj) weakremover(python3-pyreadstat) weakremover(python3-pyroomacoustics) weakremover(python3-pyrsistent) weakremover(python3-pysaml2) weakremover(python3-pyscard) weakremover(python3-pysearpc) weakremover(python3-pysendfile) weakremover(python3-pysha3) weakremover(python3-pyside) weakremover(python3-pyside-devel) weakremover(python3-pyside-shiboken) weakremover(python3-pyside-shiboken-doc) weakremover(python3-pyside2) weakremover(python3-pyside2-devel) weakremover(python3-pyside6) weakremover(python3-pyside6-devel) weakremover(python3-pysmbc) weakremover(python3-pysndfile) weakremover(python3-pysvn) weakremover(python3-pytaglib) weakremover(python3-pytest-aiofiles) weakremover(python3-pytest-cache) weakremover(python3-pytest-faulthandler) weakremover(python3-pytest-flake8) weakremover(python3-pytest-flake8dir) weakremover(python3-pytest-ordering) weakremover(python3-pytest-parallel) weakremover(python3-pytest-pythonpath) weakremover(python3-pytest-random-order) weakremover(python3-pytest-repeat) weakremover(python3-pytest-reqs) weakremover(python3-pytest-runner) weakremover(python3-pytest-subtesthack) weakremover(python3-pytest-test) weakremover(python3-pytest-travis-fold) weakremover(python3-pytest3) weakremover(python3-pytest4) weakremover(python3-pytest5) weakremover(python3-python-afl) weakremover(python3-python-cjson) weakremover(python3-python-crfsuite) weakremover(python3-python-fileinspector) weakremover(python3-python-gammu) weakremover(python3-python-jsonrpc-server) weakremover(python3-python-language-server) weakremover(python3-python-lzo) weakremover(python3-python-poppler) weakremover(python3-python-prctl) weakremover(python3-python-ptrace) weakremover(python3-python-qnotifications) weakremover(python3-python-qpid-proton) weakremover(python3-python-rapidjson) weakremover(python3-python-rtmidi) weakremover(python3-python-snappy) weakremover(python3-pytricia) weakremover(python3-pytzdata) weakremover(python3-pyuv) weakremover(python3-pyverbs) weakremover(python3-pyx-doc) weakremover(python3-pyxattr) weakremover(python3-pyxb) weakremover(python3-pyzmq) weakremover(python3-pyzmq-devel) weakremover(python3-qscintilla) weakremover(python3-qscintilla-qt4) weakremover(python3-qscintilla-qt5) weakremover(python3-qscintilla-qt5-sip) weakremover(python3-qt3d-qt5) weakremover(python3-qt3d-qt5-api) weakremover(python3-qt3d-qt5-sip) weakremover(python3-qt4) weakremover(python3-qt4-devel) weakremover(python3-qt5) weakremover(python3-qt5-devel) weakremover(python3-qt5-quick3d) weakremover(python3-qt5-quick3d-devel) weakremover(python3-qt5-remoteobjects) weakremover(python3-qt5-remoteobjects-devel) weakremover(python3-qt5-sip) weakremover(python3-qtcharts-qt5) weakremover(python3-qtcharts-qt5-api) weakremover(python3-qtcharts-qt5-sip) weakremover(python3-qtdatavis3d-qt5) weakremover(python3-qtdatavis3d-qt5-api) weakremover(python3-qtdatavis3d-qt5-sip) weakremover(python3-qtwebengine-qt5) weakremover(python3-qtwebengine-qt5-api) weakremover(python3-qtwebengine-qt5-sip) weakremover(python3-quicktions) weakremover(python3-quimb) weakremover(python3-rados) weakremover(python3-raet) weakremover(python3-ravello-sdk) weakremover(python3-raven) weakremover(python3-raven-aiohttp) weakremover(python3-rbd) weakremover(python3-rcssmin) weakremover(python3-rdflib-doc) weakremover(python3-rednose) weakremover(python3-regex) weakremover(python3-releases-test) weakremover(python3-rencode) weakremover(python3-repex) weakremover(python3-reportlab) weakremover(python3-requests-html) weakremover(python3-requests-test) weakremover(python3-requirementslib) weakremover(python3-rgw) weakremover(python3-rise) weakremover(python3-rjsmin) weakremover(python3-rpm) weakremover(python3-rpmdeplint) weakremover(python3-rpmfluff) weakremover(python3-rrdtool) weakremover(python3-ruamel.std.argparse) weakremover(python3-ruamel.yaml.clib) weakremover(python3-ruamel.yaml.cmd) weakremover(python3-rustcfg) weakremover(python3-ryu) weakremover(python3-s3fs) weakremover(python3-salt) weakremover(python3-sane) weakremover(python3-sanlock) weakremover(python3-sasl) weakremover(python3-scandir) weakremover(python3-scikit-image) weakremover(python3-scikit-learn) weakremover(python3-scikit-sparse) weakremover(python3-scikits.example) weakremover(python3-scipy) weakremover(python3-scipy-gnu-hpc) weakremover(python3-scipy_1_2_0-gnu-hpc) weakremover(python3-scipy_1_2_1-gnu-hpc) weakremover(python3-scipy_1_3_0-gnu-hpc) weakremover(python3-scipy_1_3_1-gnu-hpc) weakremover(python3-scipy_1_4_1-gnu-hpc) weakremover(python3-scipy_1_5_2-gnu-hpc) weakremover(python3-scipy_1_5_4-gnu-hpc) weakremover(python3-scrypt) weakremover(python3-seccomp) weakremover(python3-selectors2) weakremover(python3-selenium) weakremover(python3-selinux) weakremover(python3-semanage) weakremover(python3-serpy) weakremover(python3-setools) weakremover(python3-setproctitle) weakremover(python3-setupmeta) weakremover(python3-setuptools-test) weakremover(python3-setuptools_scm-test) weakremover(python3-sgp4) weakremover(python3-sherpa) weakremover(python3-shiboken6) weakremover(python3-shiboken6-devel) weakremover(python3-shouldbe) weakremover(python3-simpleaudio) weakremover(python3-simplejson) weakremover(python3-simplejson-test) weakremover(python3-sip) weakremover(python3-sip4) weakremover(python3-sip4-devel) weakremover(python3-siphashc) weakremover(python3-six-doc) weakremover(python3-six-test) weakremover(python3-sleekxmpp) weakremover(python3-slixmpp) weakremover(python3-slumber) weakremover(python3-slycot) weakremover(python3-smbc) weakremover(python3-smbus) weakremover(python3-smmap2) weakremover(python3-snimpy) weakremover(python3-socketIO-client-nexus) weakremover(python3-softlayer) weakremover(python3-solv) weakremover(python3-soundcloud) weakremover(python3-spec) weakremover(python3-spec_tools) weakremover(python3-speechd) weakremover(python3-spglib) weakremover(python3-sphinx-testing) weakremover(python3-sphinxbase) weakremover(python3-sphinxbase5) weakremover(python3-sphinxcontrib) weakremover(python3-sphinxcontrib-actdiag) weakremover(python3-spidev) weakremover(python3-splinter) weakremover(python3-spyder-notebook) weakremover(python3-spyder-unittest) weakremover(python3-sqlsoup) weakremover(python3-ssdeep) weakremover(python3-sss-murmur) weakremover(python3-sss_nss_idmap) weakremover(python3-sssd-config) weakremover(python3-statsmodels) weakremover(python3-subunit) weakremover(python3-sunpy) weakremover(python3-susepubliccloudinfo-amazon) weakremover(python3-systemd) weakremover(python3-tables) weakremover(python3-tables-doc) weakremover(python3-tagpy) weakremover(python3-talloc) weakremover(python3-talloc-devel) weakremover(python3-tbb) weakremover(python3-tdb) weakremover(python3-tensorboard) weakremover(python3-tensorboard-cmd) weakremover(python3-tensorflow-estimator) weakremover(python3-tesserocr) weakremover(python3-test-server) weakremover(python3-testsuite) weakremover(python3-testtools-doc) weakremover(python3-tevent) weakremover(python3-textile) weakremover(python3-thrift) weakremover(python3-thriftpy) weakremover(python3-thriftpy2) weakremover(python3-tinyarray) weakremover(python3-tk) weakremover(python3-tomate) weakremover(python3-tools) weakremover(python3-torch) weakremover(python3-torch-devel) weakremover(python3-torchvision) weakremover(python3-tornado4) weakremover(python3-tornado5) weakremover(python3-tornado6) weakremover(python3-toro) weakremover(python3-tox-doc) weakremover(python3-tox-travis) weakremover(python3-tpm2-pytss) weakremover(python3-traits) weakremover(python3-trello) weakremover(python3-tri.struct) weakremover(python3-tsk) weakremover(python3-tvm) weakremover(python3-tvm-nnvm) weakremover(python3-tvm-topi) weakremover(python3-tvtk) weakremover(python3-tvtk-doc) weakremover(python3-twitter.common.finagle-thrift) weakremover(python3-twitter.common.lang) weakremover(python3-twitter.common.rpc) weakremover(python3-twodict) weakremover(python3-typed-ast) weakremover(python3-typing) weakremover(python3-uamqp) weakremover(python3-ucsmsdk) weakremover(python3-uhd) weakremover(python3-ujson) weakremover(python3-unbound) weakremover(python3-uncompyle6) weakremover(python3-unicodedata2) weakremover(python3-units) weakremover(python3-unittest2) weakremover(python3-upm) weakremover(python3-urllib3-test) weakremover(python3-urwid) weakremover(python3-usbsdmux) weakremover(python3-uvloop) weakremover(python3-vapoursynth) weakremover(python3-vatnumber) weakremover(python3-veusz) weakremover(python3-virtkey) weakremover(python3-virtualbmc) weakremover(python3-virtualenv-doc) weakremover(python3-vispy) weakremover(python3-voila) weakremover(python3-vtk) weakremover(python3-vtk-openmpi) weakremover(python3-vtk-openmpi1) weakremover(python3-vtk-openmpi2) weakremover(python3-vtk-openmpi3) weakremover(python3-vtk-openmpi4) weakremover(python3-vtk-qt) weakremover(python3-watchgod) weakremover(python3-watchman) weakremover(python3-websockets) weakremover(python3-wrapt) weakremover(python3-wsaccel) weakremover(python3-wxPython) weakremover(python3-wxPython-lang) weakremover(python3-xapian) weakremover(python3-xattr) weakremover(python3-xcaplib) weakremover(python3-xcb-proto-devel) weakremover(python3-xmlsec) weakremover(python3-xrootd) weakremover(python3-xsge_tmx) weakremover(python3-xxhash) weakremover(python3-xyzpy) weakremover(python3-yang) weakremover(python3-yappi) weakremover(python3-yara) weakremover(python3-yarb) weakremover(python3-yarl) weakremover(python3-yt) weakremover(python3-yubico) weakremover(python3-yui) weakremover(python3-zake) weakremover(python3-zaqarclient) weakremover(python3-zarafa) weakremover(python3-zbar) weakremover(python3-zeroconf) weakremover(python3-zetup) weakremover(python3-zodbpickle) weakremover(python3-zope-proxy) weakremover(python3-zope.component) weakremover(python3-zope.hookable) weakremover(python3-zope.i18nmessageid) weakremover(python3-zope.interface) weakremover(python3-zope.proxy) weakremover(python3-zope.proxy-devel) weakremover(python3-zope.security) weakremover(python3-zopfli) weakremover(python3-zstandard) weakremover(python3-zstd) weakremover(python3-zypp-plugin) weakremover(python310) weakremover(python310-BTrees) weakremover(python310-BTrees-devel) weakremover(python310-Bottleneck) weakremover(python310-Brotli) weakremover(python310-CCColUtils) weakremover(python310-Cheetah3) weakremover(python310-Cython) weakremover(python310-Cython3) weakremover(python310-Durus) weakremover(python310-Fiona) weakremover(python310-Genshi) weakremover(python310-HepMC) weakremover(python310-JPype1) weakremover(python310-Jinja2) weakremover(python310-Kajiki) weakremover(python310-Kivy) weakremover(python310-Kivy-devel) weakremover(python310-LHAPDF) weakremover(python310-Levenshtein) weakremover(python310-Logbook) weakremover(python310-M2Crypto) weakremover(python310-MarkupSafe) weakremover(python310-Mathics) weakremover(python310-Ming) weakremover(python310-MulticoreTSNE) weakremover(python310-Paver) weakremover(python310-Pillow) weakremover(python310-Pillow-tk) weakremover(python310-PyAudio) weakremover(python310-PyECLib) weakremover(python310-PyICU) weakremover(python310-PyInstaller) weakremover(python310-PyMuPDF) weakremover(python310-PyNaCl) weakremover(python310-PyQt6) weakremover(python310-PyQt6-3D) weakremover(python310-PyQt6-3D-devel) weakremover(python310-PyQt6-Charts) weakremover(python310-PyQt6-Charts-devel) weakremover(python310-PyQt6-DataVisualization) weakremover(python310-PyQt6-DataVisualization-devel) weakremover(python310-PyQt6-NetworkAuth) weakremover(python310-PyQt6-NetworkAuth-devel) weakremover(python310-PyQt6-QScintilla) weakremover(python310-PyQt6-WebEngine) weakremover(python310-PyQt6-WebEngine-devel) weakremover(python310-PyQt6-devel) weakremover(python310-PyQt6-sip) weakremover(python310-PyWavelets) weakremover(python310-PyYAML) weakremover(python310-Pykka) weakremover(python310-QR-Code-generator) weakremover(python310-Qt.py) weakremover(python310-SQLAlchemy) weakremover(python310-Shapely) weakremover(python310-Theano) weakremover(python310-XStatic-jQuery) weakremover(python310-XStatic-term.js) weakremover(python310-abclient) weakremover(python310-acefile) weakremover(python310-acoular) weakremover(python310-adblock) weakremover(python310-aesara) weakremover(python310-afdko) weakremover(python310-aiobotocore) weakremover(python310-aiohttp) weakremover(python310-aioquic) weakremover(python310-aioredis) weakremover(python310-alsa) weakremover(python310-annoy) weakremover(python310-apfel) weakremover(python310-application) weakremover(python310-apsw) weakremover(python310-argon2-cffi) weakremover(python310-argon2-cffi-bindings) weakremover(python310-astropy) weakremover(python310-astropy-healpix) weakremover(python310-astunparse) weakremover(python310-asv) weakremover(python310-asyncpg) weakremover(python310-atom) weakremover(python310-aubio) weakremover(python310-autobahn) weakremover(python310-autodoc) weakremover(python310-av) weakremover(python310-avahi) weakremover(python310-awkward-cpp) weakremover(python310-aws-xray-sdk-aiobotocore) weakremover(python310-awscrt) weakremover(python310-axolotl-curve25519) weakremover(python310-base) weakremover(python310-bcrypt) weakremover(python310-beren) weakremover(python310-biopython) weakremover(python310-bitarray) weakremover(python310-bitstruct) weakremover(python310-bjoern) weakremover(python310-blosc) weakremover(python310-blosc2) weakremover(python310-boost-histogram) weakremover(python310-boto) weakremover(python310-brotlicffi) weakremover(python310-brotlipy) weakremover(python310-bsddb3) weakremover(python310-bsddb3-devel) weakremover(python310-cPyparsing) weakremover(python310-cangjie) weakremover(python310-cassandra-driver) weakremover(python310-cbor) weakremover(python310-cbor2) weakremover(python310-cchardet) weakremover(python310-celerymon) weakremover(python310-cerealizer) weakremover(python310-cffi) weakremover(python310-cftime) weakremover(python310-chart-studio) weakremover(python310-cloud-sptheme) weakremover(python310-cmarkgfm) weakremover(python310-colorlog) weakremover(python310-compizconfig) weakremover(python310-confluent-kafka) weakremover(python310-contextlib2) weakremover(python310-contourpy) weakremover(python310-coverage) weakremover(python310-cracklib) weakremover(python310-cramjam) weakremover(python310-crcmod) weakremover(python310-cryptography) weakremover(python310-ctypescrypto) weakremover(python310-cu2qu) weakremover(python310-curses) weakremover(python310-cwcwidth) weakremover(python310-cx_Freeze) weakremover(python310-cytoolz) weakremover(python310-datrie) weakremover(python310-dbm) weakremover(python310-dbus-python) weakremover(python310-dbus-python-devel) weakremover(python310-deap) weakremover(python310-debugpy) weakremover(python310-devel) weakremover(python310-dist) weakremover(python310-distorm3) weakremover(python310-django-collectd-rest) weakremover(python310-django-webtest) weakremover(python310-djvulibre) weakremover(python310-dmidecode) weakremover(python310-doc) weakremover(python310-doc-devhelp) weakremover(python310-drgn) weakremover(python310-dtaidistance) weakremover(python310-dukpy) weakremover(python310-dukpy-kovidgoyal) weakremover(python310-dulwich) weakremover(python310-e-antic) weakremover(python310-ed25519) weakremover(python310-editdistance) weakremover(python310-editdistance-devel) weakremover(python310-efilter) weakremover(python310-efl) weakremover(python310-eliot) weakremover(python310-enaml) weakremover(python310-ephem) weakremover(python310-espeak) weakremover(python310-ethtool) weakremover(python310-evdev) weakremover(python310-exiv2) weakremover(python310-ezdxf) weakremover(python310-fabio) weakremover(python310-fann2) weakremover(python310-fastbencode) weakremover(python310-fastcluster) weakremover(python310-fastnumbers) weakremover(python310-fastparquet) weakremover(python310-fastremap) weakremover(python310-fasttext) weakremover(python310-fb-re2) weakremover(python310-flask-restplus) weakremover(python310-forbiddenfruit) weakremover(python310-framel) weakremover(python310-frozendict) weakremover(python310-frozenlist) weakremover(python310-fuse) weakremover(python310-gevent) weakremover(python310-geventhttpclient) weakremover(python310-gitdb) weakremover(python310-glucat) weakremover(python310-gmpy) weakremover(python310-gmpy2) weakremover(python310-gobject) weakremover(python310-gobject-Gdk) weakremover(python310-gobject-cairo) weakremover(python310-gobject-devel) weakremover(python310-goobook) weakremover(python310-google-crc32c) weakremover(python310-gpg) weakremover(python310-gpgme) weakremover(python310-gphoto2) weakremover(python310-greenlet) weakremover(python310-grpcio) weakremover(python310-grpcio-status) weakremover(python310-grpcio-tools) weakremover(python310-gssapi) weakremover(python310-gst) weakremover(python310-gsw) weakremover(python310-h5py) weakremover(python310-h5py-openmpi1) weakremover(python310-h5py-openmpi2) weakremover(python310-h5py-openmpi3) weakremover(python310-h5py-openmpi4) weakremover(python310-hdf5storage) weakremover(python310-healpy) weakremover(python310-hiredis) weakremover(python310-hotdoc) weakremover(python310-html5-parser) weakremover(python310-http-parser) weakremover(python310-httptools) weakremover(python310-hug) weakremover(python310-hunter) weakremover(python310-hyper) weakremover(python310-idle) weakremover(python310-ijson) weakremover(python310-imagecodecs) weakremover(python310-imbox) weakremover(python310-iminuit) weakremover(python310-immutables) weakremover(python310-imread) weakremover(python310-inflate64) weakremover(python310-influxdb) weakremover(python310-iptables) weakremover(python310-ipython-iptest) weakremover(python310-itemadapter) weakremover(python310-iwlib) weakremover(python310-jaraco.base) weakremover(python310-jellyfish) weakremover(python310-jgraph) weakremover(python310-jsondate) weakremover(python310-jsonslicer) weakremover(python310-jupyter-jupyterlab-server-openapi) weakremover(python310-jupyter-jupyterlab-server-test) weakremover(python310-jupyter-nbutils) weakremover(python310-jupytext) weakremover(python310-keepalive) weakremover(python310-kerberos) weakremover(python310-keyczar) weakremover(python310-keyring-keyutils) weakremover(python310-kiss-headers) weakremover(python310-kiwisolver) weakremover(python310-kmod) weakremover(python310-kwant) weakremover(python310-lal) weakremover(python310-lalapps) weakremover(python310-lalburst) weakremover(python310-lalframe) weakremover(python310-lalinference) weakremover(python310-lalinspiral) weakremover(python310-lalmetaio) weakremover(python310-lalpulsar) weakremover(python310-lalsimulation) weakremover(python310-lazy-object-proxy) weakremover(python310-ldap) weakremover(python310-ldas-tools-al-swig) weakremover(python310-leglight) weakremover(python310-leveldb) weakremover(python310-lfdfiles) weakremover(python310-lhafile) weakremover(python310-libbde) weakremover(python310-libcaes) weakremover(python310-libcreg) weakremover(python310-libcst) weakremover(python310-libesedb) weakremover(python310-libevt) weakremover(python310-libevtx) weakremover(python310-libewf) weakremover(python310-libexe) weakremover(python310-libfmos) weakremover(python310-libfsapfs) weakremover(python310-libfsext) weakremover(python310-libfsfat) weakremover(python310-libfshfs) weakremover(python310-libfsntfs) weakremover(python310-libfsxfs) weakremover(python310-libfvde) weakremover(python310-libfwnt) weakremover(python310-libfwps) weakremover(python310-libfwsi) weakremover(python310-libkdumpfile) weakremover(python310-liblnk) weakremover(python310-libluksde) weakremover(python310-libmodi) weakremover(python310-libmount) weakremover(python310-libmsiecf) weakremover(python310-libnacl) weakremover(python310-libolecf) weakremover(python310-libpff) weakremover(python310-libpfm) weakremover(python310-libphdi) weakremover(python310-libqcow) weakremover(python310-libregf) weakremover(python310-libsass) weakremover(python310-libscca) weakremover(python310-libsigscan) weakremover(python310-libsmdev) weakremover(python310-libsmraw) weakremover(python310-libvhdi) weakremover(python310-libvirt-python) weakremover(python310-libvmdk) weakremover(python310-libvsapm) weakremover(python310-libvsgpt) weakremover(python310-libvshadow) weakremover(python310-libvslvm) weakremover(python310-libvsmbr) weakremover(python310-libwrc) weakremover(python310-libxml2) weakremover(python310-ligo-lw) weakremover(python310-ligo-segments) weakremover(python310-line_profiler) weakremover(python310-linode-cli) weakremover(python310-linstor) weakremover(python310-linstor-client) weakremover(python310-llfuse) weakremover(python310-llvmlite) weakremover(python310-lmdb) weakremover(python310-lscsoft-glue) weakremover(python310-lupa) weakremover(python310-lws) weakremover(python310-lxml) weakremover(python310-lxml-devel) weakremover(python310-lz4) weakremover(python310-magic) weakremover(python310-mathgl) weakremover(python310-matplotlib) weakremover(python310-matplotlib-cairo) weakremover(python310-matplotlib-gtk-common) weakremover(python310-matplotlib-gtk3) weakremover(python310-matplotlib-gtk4) weakremover(python310-matplotlib-qt5) weakremover(python310-matplotlib-testdata) weakremover(python310-matplotlib-tk) weakremover(python310-matplotlib-web) weakremover(python310-matplotlib-wx) weakremover(python310-maturin) weakremover(python310-maxminddb) weakremover(python310-metamagic.json) weakremover(python310-miniupnpc) weakremover(python310-misaka) weakremover(python310-mitmproxy-wireguard) weakremover(python310-mock) weakremover(python310-mockldap) weakremover(python310-monitoring-plugins-http_json) weakremover(python310-mpi4py) weakremover(python310-mpi4py-devel) weakremover(python310-msgpack) weakremover(python310-multidict) weakremover(python310-mysqlclient) weakremover(python310-nautilus) weakremover(python310-nautilus-devel) weakremover(python310-nbindex-jupyter) weakremover(python310-nbsphinx-link) weakremover(python310-nbxmpp-doc) weakremover(python310-ndindex) weakremover(python310-neovim-remote) weakremover(python310-net-snmp) weakremover(python310-netCDF4) weakremover(python310-netifaces) weakremover(python310-nlopt) weakremover(python310-nose) weakremover(python310-nss) weakremover(python310-ntlm-auth) weakremover(python310-numba) weakremover(python310-numba-devel) weakremover(python310-numcodecs) weakremover(python310-numexpr) weakremover(python310-numpy) weakremover(python310-numpy-devel) weakremover(python310-numpy-gnu-hpc) weakremover(python310-numpy-gnu-hpc-devel) weakremover(python310-numpy_1_21_4-gnu-hpc) weakremover(python310-numpy_1_21_4-gnu-hpc-devel) weakremover(python310-numpy_1_21_6-gnu-hpc) weakremover(python310-numpy_1_21_6-gnu-hpc-devel) weakremover(python310-numpy_1_23_4-gnu-hpc) weakremover(python310-numpy_1_23_4-gnu-hpc-devel) weakremover(python310-numpy_1_24_1-gnu-hpc) weakremover(python310-numpy_1_24_1-gnu-hpc-devel) weakremover(python310-numpy_1_24_2-gnu-hpc) weakremover(python310-numpy_1_24_2-gnu-hpc-devel) weakremover(python310-oauth2client) weakremover(python310-oauth2client-flask) weakremover(python310-oauth2client-gce) weakremover(python310-olm) weakremover(python310-onigurumacffi) weakremover(python310-onnx) weakremover(python310-openTSNE) weakremover(python310-opengl-accelerate) weakremover(python310-openmesh) weakremover(python310-orangebox) weakremover(python310-orjson) weakremover(python310-ovirt-engine-sdk) weakremover(python310-ovs) weakremover(python310-pandas) weakremover(python310-pandas-ext) weakremover(python310-parted) weakremover(python310-pass_python_keyring) weakremover(python310-pastream) weakremover(python310-pathlib) weakremover(python310-pathlib2) weakremover(python310-patiencediff) weakremover(python310-peewee) weakremover(python310-pendulum) weakremover(python310-perfume-bench) weakremover(python310-persistent) weakremover(python310-persistent-devel) weakremover(python310-pgmagick) weakremover(python310-photutils) weakremover(python310-pikepdf) weakremover(python310-pivy) weakremover(python310-plyvel) weakremover(python310-pomegranate) weakremover(python310-pomegranate-devel) weakremover(python310-pontos) weakremover(python310-poppler-qt5) weakremover(python310-poppler-qt5-devel) weakremover(python310-positional) weakremover(python310-prompt_toolkit1) weakremover(python310-protobuf) weakremover(python310-psautohint) weakremover(python310-psutil) weakremover(python310-psychtoolbox) weakremover(python310-psycopg2) weakremover(python310-psycopg2cffi) weakremover(python310-py-radix) weakremover(python310-py-ubjson) weakremover(python310-pyFFTW) weakremover(python310-pyRXP) weakremover(python310-pyScss) weakremover(python310-pyahocorasick) weakremover(python310-pyalsaaudio) weakremover(python310-pyarrow) weakremover(python310-pyarrow-devel) weakremover(python310-pybcj) weakremover(python310-pyblake2) weakremover(python310-pybluez) weakremover(python310-pycairo) weakremover(python310-pycairo-devel) weakremover(python310-pycapnp) weakremover(python310-pycares) weakremover(python310-pycdio) weakremover(python310-pychm) weakremover(python310-pyclipper) weakremover(python310-pycocotools) weakremover(python310-pycryptodome) weakremover(python310-pycryptodomex) weakremover(python310-pycups) weakremover(python310-pycurl) weakremover(python310-pydle) weakremover(python310-pyemd) weakremover(python310-pyerfa) weakremover(python310-pyfuse3) weakremover(python310-pygame) weakremover(python310-pygame-devel) weakremover(python310-pygeos) weakremover(python310-pygit2) weakremover(python310-pygraphviz) weakremover(python310-pyheif) weakremover(python310-pyjnius) weakremover(python310-pykafka) weakremover(python310-pykerberos) weakremover(python310-pylibacl) weakremover(python310-pylibfdt) weakremover(python310-pyliblo) weakremover(python310-pyliblo-doc) weakremover(python310-pylibmc) weakremover(python310-pylsqpack) weakremover(python310-pylzma) weakremover(python310-pymad) weakremover(python310-pymavlink) weakremover(python310-pymilter) weakremover(python310-pymol) weakremover(python310-pymongo) weakremover(python310-pympv) weakremover(python310-pymssql) weakremover(python310-pyo) weakremover(python310-pyodbc) weakremover(python310-pypandoc) weakremover(python310-pypipegraph) weakremover(python310-pyppmd) weakremover(python310-pyproj) weakremover(python310-pyreadstat) weakremover(python310-pyroomacoustics) weakremover(python310-pyrsistent) weakremover(python310-pysaml2) weakremover(python310-pyscard) weakremover(python310-pysendfile) weakremover(python310-pysha3) weakremover(python310-pysmbc) weakremover(python310-pysndfile) weakremover(python310-pysvn) weakremover(python310-pytaglib) weakremover(python310-pytest-flake8) weakremover(python310-pytest-flake8dir) weakremover(python310-pytest-pythonpath) weakremover(python310-pytest-random-order) weakremover(python310-pytest-repeat) weakremover(python310-pytest-subtesthack) weakremover(python310-pytest-travis-fold) weakremover(python310-python-afl) weakremover(python310-python-cjson) weakremover(python310-python-crfsuite) weakremover(python310-python-dmidecode) weakremover(python310-python-gammu) weakremover(python310-python-lzo) weakremover(python310-python-poppler) weakremover(python310-python-prctl) weakremover(python310-python-ptrace) weakremover(python310-python-qpid-proton) weakremover(python310-python-rapidjson) weakremover(python310-python-rtmidi) weakremover(python310-python-snappy) weakremover(python310-pytricia) weakremover(python310-pytzdata) weakremover(python310-pyuv) weakremover(python310-pywayland) weakremover(python310-pywlroots) weakremover(python310-pyxattr) weakremover(python310-pyzmq) weakremover(python310-pyzmq-devel) weakremover(python310-pyzstd) weakremover(python310-qscintilla-qt5) weakremover(python310-qt3d-qt5) weakremover(python310-qt3d-qt5-api) weakremover(python310-qt3d-qt5-devel) weakremover(python310-qt3d-qt5-sip) weakremover(python310-qt5) weakremover(python310-qt5-devel) weakremover(python310-qt5-quick3d) weakremover(python310-qt5-quick3d-devel) weakremover(python310-qt5-remoteobjects) weakremover(python310-qt5-remoteobjects-devel) weakremover(python310-qt5-sip) weakremover(python310-qtcharts-qt5) weakremover(python310-qtcharts-qt5-api) weakremover(python310-qtcharts-qt5-sip) weakremover(python310-qtdatavis3d-qt5) weakremover(python310-qtdatavis3d-qt5-api) weakremover(python310-qtdatavis3d-qt5-devel) weakremover(python310-qtdatavis3d-qt5-sip) weakremover(python310-qtnetworkauth-qt5) weakremover(python310-qtnetworkauth-qt5-devel) weakremover(python310-qtwebengine-qt5) weakremover(python310-qtwebengine-qt5-devel) weakremover(python310-quicktions) weakremover(python310-quimb) weakremover(python310-rapidfuzz) weakremover(python310-ravello-sdk) weakremover(python310-raven) weakremover(python310-rcssmin) weakremover(python310-recordclass) weakremover(python310-regex) weakremover(python310-rencode) weakremover(python310-reportlab) weakremover(python310-reproject) weakremover(python310-rjsmin) weakremover(python310-rpds-py) weakremover(python310-rpm) weakremover(python310-ruamel.yaml.clib) weakremover(python310-rustcfg) weakremover(python310-s3fs) weakremover(python310-sane) weakremover(python310-sanlock) weakremover(python310-sasl) weakremover(python310-scandir) weakremover(python310-scikit-image) weakremover(python310-scikit-learn) weakremover(python310-scikit-sparse) weakremover(python310-scipy) weakremover(python310-scipy-gnu-hpc) weakremover(python310-scipy_1_10_1-gnu-hpc) weakremover(python310-scipy_1_6_0-gnu-hpc) weakremover(python310-scipy_1_7_3-gnu-hpc) weakremover(python310-scipy_1_8_0-gnu-hpc) weakremover(python310-scipy_1_9_1-gnu-hpc) weakremover(python310-scipy_1_9_2-gnu-hpc) weakremover(python310-scipy_1_9_3-gnu-hpc) weakremover(python310-scrypt) weakremover(python310-selenium) weakremover(python310-semanage) weakremover(python310-serpy) weakremover(python310-setools) weakremover(python310-setproctitle) weakremover(python310-setupmeta) weakremover(python310-sgp4) weakremover(python310-sherpa) weakremover(python310-simpleaudio) weakremover(python310-simplejson) weakremover(python310-singledispatch) weakremover(python310-sip4) weakremover(python310-sip4-devel) weakremover(python310-sip5-devel) weakremover(python310-sip6-devel) weakremover(python310-siphashc) weakremover(python310-slixmpp) weakremover(python310-slycot) weakremover(python310-snimpy) weakremover(python310-softlayer) weakremover(python310-soxr) weakremover(python310-sphinx-testing) weakremover(python310-sphinxcontrib-actdiag) weakremover(python310-spidev) weakremover(python310-ssdeep) weakremover(python310-statsmodels) weakremover(python310-subliminal) weakremover(python310-sunpy) weakremover(python310-systemd) weakremover(python310-tables) weakremover(python310-tbb) weakremover(python310-tesserocr) weakremover(python310-testsuite) weakremover(python310-textile) weakremover(python310-thewalrus) weakremover(python310-thrift) weakremover(python310-thriftpy2) weakremover(python310-time-machine) weakremover(python310-tinyarray) weakremover(python310-tk) weakremover(python310-tools) weakremover(python310-torch) weakremover(python310-torch-devel) weakremover(python310-torchvision) weakremover(python310-tornado6) weakremover(python310-traits) weakremover(python310-tri.struct) weakremover(python310-tsk) weakremover(python310-tvm) weakremover(python310-twitter.common.finagle-thrift) weakremover(python310-twitter.common.lang) weakremover(python310-twitter.common.rpc) weakremover(python310-typed-ast) weakremover(python310-uamqp) weakremover(python310-ujson) weakremover(python310-unicodedata2) weakremover(python310-urwid) weakremover(python310-usbsdmux) weakremover(python310-uvloop) weakremover(python310-uwsgi-python3) weakremover(python310-vatnumber) weakremover(python310-veusz) weakremover(python310-virtkey) weakremover(python310-vispy) weakremover(python310-voila) weakremover(python310-watchfiles) weakremover(python310-watchgod) weakremover(python310-websockets) weakremover(python310-wrapt) weakremover(python310-wsaccel) weakremover(python310-wxPython) weakremover(python310-wxPython-lang) weakremover(python310-xapian) weakremover(python310-xattr) weakremover(python310-xkbcommon) weakremover(python310-xmlsec) weakremover(python310-xrootd) weakremover(python310-xxhash) weakremover(python310-y-py) weakremover(python310-yappi) weakremover(python310-yara) weakremover(python310-yarl) weakremover(python310-yt) weakremover(python310-zake) weakremover(python310-zeroconf) weakremover(python310-zodbpickle) weakremover(python310-zope.component) weakremover(python310-zope.hookable) weakremover(python310-zope.i18nmessageid) weakremover(python310-zope.interface) weakremover(python310-zope.proxy) weakremover(python310-zope.proxy-devel) weakremover(python310-zope.security) weakremover(python310-zopfli) weakremover(python310-zstandard) weakremover(python310-zstd) weakremover(python311) weakremover(python311-BTrees) weakremover(python311-BTrees-devel) weakremover(python311-Bottleneck) weakremover(python311-Brotli) weakremover(python311-CCColUtils) weakremover(python311-Cheetah3) weakremover(python311-Cython) weakremover(python311-Cython3) weakremover(python311-Durus) weakremover(python311-Fiona) weakremover(python311-Genshi) weakremover(python311-HepMC) weakremover(python311-JPype1) weakremover(python311-Jinja2) weakremover(python311-Kajiki) weakremover(python311-Kivy) weakremover(python311-Kivy-devel) weakremover(python311-LHAPDF) weakremover(python311-Levenshtein) weakremover(python311-Logbook) weakremover(python311-M2Crypto) weakremover(python311-MarkupSafe) weakremover(python311-Mathics) weakremover(python311-MulticoreTSNE) weakremover(python311-Pillow) weakremover(python311-Pillow-tk) weakremover(python311-PyAudio) weakremover(python311-PyECLib) weakremover(python311-PyICU) weakremover(python311-PyInstaller) weakremover(python311-PyMuPDF) weakremover(python311-PyNaCl) weakremover(python311-PyQt6) weakremover(python311-PyQt6-3D) weakremover(python311-PyQt6-3D-devel) weakremover(python311-PyQt6-Charts) weakremover(python311-PyQt6-Charts-devel) weakremover(python311-PyQt6-DataVisualization) weakremover(python311-PyQt6-DataVisualization-devel) weakremover(python311-PyQt6-NetworkAuth) weakremover(python311-PyQt6-NetworkAuth-devel) weakremover(python311-PyQt6-QScintilla) weakremover(python311-PyQt6-WebEngine) weakremover(python311-PyQt6-WebEngine-devel) weakremover(python311-PyQt6-devel) weakremover(python311-PyQt6-sip) weakremover(python311-PyWavelets) weakremover(python311-PyYAML) weakremover(python311-QR-Code-generator) weakremover(python311-SQLAlchemy) weakremover(python311-Shapely) weakremover(python311-Theano) weakremover(python311-XStatic-jQuery) weakremover(python311-XStatic-term.js) weakremover(python311-acefile) weakremover(python311-adblock) weakremover(python311-afdko) weakremover(python311-aiohttp) weakremover(python311-aioquic) weakremover(python311-alsa) weakremover(python311-annoy) weakremover(python311-apfel) weakremover(python311-application) weakremover(python311-apsw) weakremover(python311-argon2-cffi) weakremover(python311-argon2-cffi-bindings) weakremover(python311-astropy) weakremover(python311-astropy-healpix) weakremover(python311-astunparse) weakremover(python311-asv) weakremover(python311-asyncpg) weakremover(python311-atom) weakremover(python311-aubio) weakremover(python311-audiomate) weakremover(python311-autobahn) weakremover(python311-av) weakremover(python311-avahi) weakremover(python311-awkward-cpp) weakremover(python311-axolotl-curve25519) weakremover(python311-base) weakremover(python311-bcrypt) weakremover(python311-beren) weakremover(python311-biopython) weakremover(python311-bitarray) weakremover(python311-bitstruct) weakremover(python311-bjoern) weakremover(python311-blosc) weakremover(python311-blosc2) weakremover(python311-boost-histogram) weakremover(python311-brotlicffi) weakremover(python311-brotlipy) weakremover(python311-bsddb3) weakremover(python311-bsddb3-devel) weakremover(python311-cPyparsing) weakremover(python311-cangjie) weakremover(python311-cassandra-driver) weakremover(python311-cbor) weakremover(python311-cbor2) weakremover(python311-cchardet) weakremover(python311-cffi) weakremover(python311-cftime) weakremover(python311-cloud-sptheme) weakremover(python311-cmarkgfm) weakremover(python311-colorlog) weakremover(python311-compizconfig) weakremover(python311-confluent-kafka) weakremover(python311-contourpy) weakremover(python311-coverage) weakremover(python311-cracklib) weakremover(python311-cramjam) weakremover(python311-crcmod) weakremover(python311-cryptography) weakremover(python311-cu2qu) weakremover(python311-curses) weakremover(python311-cwcwidth) weakremover(python311-cx_Freeze) weakremover(python311-cytoolz) weakremover(python311-datashader) weakremover(python311-datrie) weakremover(python311-dbm) weakremover(python311-dbus-python) weakremover(python311-dbus-python-devel) weakremover(python311-deap) weakremover(python311-debugpy) weakremover(python311-devel) weakremover(python311-dist) weakremover(python311-distorm3) weakremover(python311-django-collectd-rest) weakremover(python311-django-webtest) weakremover(python311-djvulibre) weakremover(python311-dmidecode) weakremover(python311-doc) weakremover(python311-doc-devhelp) weakremover(python311-drgn) weakremover(python311-dtaidistance) weakremover(python311-dukpy) weakremover(python311-dukpy-kovidgoyal) weakremover(python311-dulwich) weakremover(python311-e-antic) weakremover(python311-ed25519) weakremover(python311-editdistance) weakremover(python311-editdistance-devel) weakremover(python311-enaml) weakremover(python311-ephem) weakremover(python311-espeak) weakremover(python311-ethtool) weakremover(python311-evdev) weakremover(python311-exiv2) weakremover(python311-ezdxf) weakremover(python311-fabio) weakremover(python311-fann2) weakremover(python311-fastbencode) weakremover(python311-fastcluster) weakremover(python311-fastnumbers) weakremover(python311-fastparquet) weakremover(python311-fastremap) weakremover(python311-fasttext) weakremover(python311-fb-re2) weakremover(python311-forbiddenfruit) weakremover(python311-framel) weakremover(python311-frozendict) weakremover(python311-frozenlist) weakremover(python311-fuse) weakremover(python311-gevent) weakremover(python311-geventhttpclient) weakremover(python311-gitdb) weakremover(python311-glucat) weakremover(python311-gmpy2) weakremover(python311-gobject) weakremover(python311-gobject-Gdk) weakremover(python311-gobject-cairo) weakremover(python311-gobject-devel) weakremover(python311-google-crc32c) weakremover(python311-gpg) weakremover(python311-gphoto2) weakremover(python311-greenlet) weakremover(python311-grpcio) weakremover(python311-grpcio-status) weakremover(python311-grpcio-tools) weakremover(python311-gssapi) weakremover(python311-gst) weakremover(python311-gsw) weakremover(python311-h5py) weakremover(python311-h5py-openmpi1) weakremover(python311-h5py-openmpi2) weakremover(python311-h5py-openmpi3) weakremover(python311-h5py-openmpi4) weakremover(python311-hdf5storage) weakremover(python311-healpy) weakremover(python311-hiredis) weakremover(python311-hotdoc) weakremover(python311-html5-parser) weakremover(python311-http-parser) weakremover(python311-httptools) weakremover(python311-hunter) weakremover(python311-idle) weakremover(python311-ijson) weakremover(python311-imagecodecs) weakremover(python311-imbox) weakremover(python311-immutables) weakremover(python311-imread) weakremover(python311-inflate64) weakremover(python311-influxdb) weakremover(python311-iptables) weakremover(python311-itemadapter) weakremover(python311-iwlib) weakremover(python311-jellyfish) weakremover(python311-jsonslicer) weakremover(python311-kerberos) weakremover(python311-keyring-keyutils) weakremover(python311-kiss-headers) weakremover(python311-kiwisolver) weakremover(python311-kmod) weakremover(python311-kwant) weakremover(python311-lazy-object-proxy) weakremover(python311-ldap) weakremover(python311-ldas-tools-al-swig) weakremover(python311-leglight) weakremover(python311-leveldb) weakremover(python311-lfdfiles) weakremover(python311-lhafile) weakremover(python311-libbde) weakremover(python311-libcaes) weakremover(python311-libcreg) weakremover(python311-libcst) weakremover(python311-libesedb) weakremover(python311-libevt) weakremover(python311-libevtx) weakremover(python311-libewf) weakremover(python311-libexe) weakremover(python311-libfmos) weakremover(python311-libfsapfs) weakremover(python311-libfsext) weakremover(python311-libfsfat) weakremover(python311-libfshfs) weakremover(python311-libfsntfs) weakremover(python311-libfsxfs) weakremover(python311-libfvde) weakremover(python311-libfwnt) weakremover(python311-libfwps) weakremover(python311-libfwsi) weakremover(python311-libkdumpfile) weakremover(python311-liblnk) weakremover(python311-libluksde) weakremover(python311-libmodi) weakremover(python311-libmount) weakremover(python311-libmsiecf) weakremover(python311-libnacl) weakremover(python311-libolecf) weakremover(python311-libpff) weakremover(python311-libpfm) weakremover(python311-libphdi) weakremover(python311-libqcow) weakremover(python311-libregf) weakremover(python311-libsass) weakremover(python311-libscca) weakremover(python311-libsigscan) weakremover(python311-libsmdev) weakremover(python311-libsmraw) weakremover(python311-libvhdi) weakremover(python311-libvirt-python) weakremover(python311-libvmdk) weakremover(python311-libvsapm) weakremover(python311-libvsgpt) weakremover(python311-libvshadow) weakremover(python311-libvslvm) weakremover(python311-libvsmbr) weakremover(python311-libwrc) weakremover(python311-libxml2) weakremover(python311-ligo-lw) weakremover(python311-line_profiler) weakremover(python311-linode-cli) weakremover(python311-linstor) weakremover(python311-linstor-client) weakremover(python311-llfuse) weakremover(python311-llvmlite) weakremover(python311-lmdb) weakremover(python311-lscsoft-glue) weakremover(python311-lupa) weakremover(python311-lxml) weakremover(python311-lxml-devel) weakremover(python311-lz4) weakremover(python311-magic) weakremover(python311-mathgl) weakremover(python311-matplotlib) weakremover(python311-matplotlib-cairo) weakremover(python311-matplotlib-gtk-common) weakremover(python311-matplotlib-gtk3) weakremover(python311-matplotlib-gtk4) weakremover(python311-matplotlib-qt5) weakremover(python311-matplotlib-testdata) weakremover(python311-matplotlib-tk) weakremover(python311-matplotlib-web) weakremover(python311-matplotlib-wx) weakremover(python311-maturin) weakremover(python311-maxminddb) weakremover(python311-metamagic.json) weakremover(python311-miniupnpc) weakremover(python311-misaka) weakremover(python311-mitmproxy-wireguard) weakremover(python311-mpi4py) weakremover(python311-mpi4py-devel) weakremover(python311-msgpack) weakremover(python311-multidict) weakremover(python311-mysqlclient) weakremover(python311-nautilus) weakremover(python311-nautilus-devel) weakremover(python311-ndindex) weakremover(python311-net-snmp) weakremover(python311-netCDF4) weakremover(python311-netifaces) weakremover(python311-nlopt) weakremover(python311-nss) weakremover(python311-numcodecs) weakremover(python311-numexpr) weakremover(python311-numpy) weakremover(python311-numpy-devel) weakremover(python311-numpy-gnu-hpc) weakremover(python311-numpy-gnu-hpc-devel) weakremover(python311-numpy_1_24_1-gnu-hpc) weakremover(python311-numpy_1_24_1-gnu-hpc-devel) weakremover(python311-numpy_1_24_2-gnu-hpc) weakremover(python311-numpy_1_24_2-gnu-hpc-devel) weakremover(python311-olm) weakremover(python311-onigurumacffi) weakremover(python311-onnx) weakremover(python311-openTSNE) weakremover(python311-opengl-accelerate) weakremover(python311-openmesh) weakremover(python311-orangebox) weakremover(python311-orjson) weakremover(python311-ovirt-engine-sdk) weakremover(python311-ovs) weakremover(python311-pandas) weakremover(python311-parted) weakremover(python311-pastream) weakremover(python311-patiencediff) weakremover(python311-peewee) weakremover(python311-pendulum) weakremover(python311-persistent) weakremover(python311-persistent-devel) weakremover(python311-pgmagick) weakremover(python311-photutils) weakremover(python311-pikepdf) weakremover(python311-pivy) weakremover(python311-plyvel) weakremover(python311-pomegranate) weakremover(python311-pomegranate-devel) weakremover(python311-poppler-qt5) weakremover(python311-poppler-qt5-devel) weakremover(python311-prompt_toolkit1) weakremover(python311-protobuf) weakremover(python311-psautohint) weakremover(python311-psutil) weakremover(python311-psychtoolbox) weakremover(python311-psycopg2) weakremover(python311-psycopg2cffi) weakremover(python311-py-radix) weakremover(python311-py-ubjson) weakremover(python311-pyFFTW) weakremover(python311-pyRXP) weakremover(python311-pyScss) weakremover(python311-pyahocorasick) weakremover(python311-pyalsaaudio) weakremover(python311-pyarrow) weakremover(python311-pyarrow-devel) weakremover(python311-pybcj) weakremover(python311-pybluez) weakremover(python311-pycairo) weakremover(python311-pycairo-devel) weakremover(python311-pycapnp) weakremover(python311-pycares) weakremover(python311-pycdio) weakremover(python311-pychm) weakremover(python311-pyclipper) weakremover(python311-pycocotools) weakremover(python311-pycryptodome) weakremover(python311-pycryptodomex) weakremover(python311-pycups) weakremover(python311-pycurl) weakremover(python311-pyemd) weakremover(python311-pyerfa) weakremover(python311-pyfuse3) weakremover(python311-pygame) weakremover(python311-pygame-devel) weakremover(python311-pygeos) weakremover(python311-pygit2) weakremover(python311-pygraphviz) weakremover(python311-pyheif) weakremover(python311-pyjnius) weakremover(python311-pykafka) weakremover(python311-pykerberos) weakremover(python311-pylibacl) weakremover(python311-pylibfdt) weakremover(python311-pyliblo) weakremover(python311-pyliblo-doc) weakremover(python311-pylibmc) weakremover(python311-pylsqpack) weakremover(python311-pylzma) weakremover(python311-pymad) weakremover(python311-pymavlink) weakremover(python311-pymilter) weakremover(python311-pymol) weakremover(python311-pymongo) weakremover(python311-pymssql) weakremover(python311-pyo) weakremover(python311-pyodbc) weakremover(python311-pypandoc) weakremover(python311-pyppmd) weakremover(python311-pyproj) weakremover(python311-pyreadstat) weakremover(python311-pyroomacoustics) weakremover(python311-pyrsistent) weakremover(python311-pysaml2) weakremover(python311-pyscard) weakremover(python311-pysendfile) weakremover(python311-pysmbc) weakremover(python311-pysndfile) weakremover(python311-pysvn) weakremover(python311-pytaglib) weakremover(python311-pytest-flake8dir) weakremover(python311-pytest-random-order) weakremover(python311-pytest-repeat) weakremover(python311-pytest-subtesthack) weakremover(python311-python-afl) weakremover(python311-python-cjson) weakremover(python311-python-crfsuite) weakremover(python311-python-gammu) weakremover(python311-python-lzo) weakremover(python311-python-poppler) weakremover(python311-python-prctl) weakremover(python311-python-ptrace) weakremover(python311-python-qpid-proton) weakremover(python311-python-rapidjson) weakremover(python311-python-snappy) weakremover(python311-pytricia) weakremover(python311-pytzdata) weakremover(python311-pywayland) weakremover(python311-pywlroots) weakremover(python311-pyxattr) weakremover(python311-pyzmq) weakremover(python311-pyzmq-devel) weakremover(python311-pyzstd) weakremover(python311-qscintilla-qt5) weakremover(python311-qt3d-qt5) weakremover(python311-qt3d-qt5-devel) weakremover(python311-qt5) weakremover(python311-qt5-devel) weakremover(python311-qt5-quick3d) weakremover(python311-qt5-quick3d-devel) weakremover(python311-qt5-remoteobjects) weakremover(python311-qt5-remoteobjects-devel) weakremover(python311-qt5-sip) weakremover(python311-qtcharts-qt5) weakremover(python311-qtcharts-qt5-api) weakremover(python311-qtcharts-qt5-sip) weakremover(python311-qtdatavis3d-qt5) weakremover(python311-qtdatavis3d-qt5-devel) weakremover(python311-qtnetworkauth-qt5) weakremover(python311-qtnetworkauth-qt5-devel) weakremover(python311-qtwebengine-qt5) weakremover(python311-qtwebengine-qt5-devel) weakremover(python311-quicktions) weakremover(python311-rapidfuzz) weakremover(python311-rcssmin) weakremover(python311-recordclass) weakremover(python311-regex) weakremover(python311-rencode) weakremover(python311-reportlab) weakremover(python311-reproject) weakremover(python311-rjsmin) weakremover(python311-rpds-py) weakremover(python311-rpm) weakremover(python311-ruamel.yaml.clib) weakremover(python311-sane) weakremover(python311-sanlock) weakremover(python311-sasl) weakremover(python311-scandir) weakremover(python311-scikit-image) weakremover(python311-scikit-learn) weakremover(python311-scikit-sparse) weakremover(python311-scipy) weakremover(python311-scipy-gnu-hpc) weakremover(python311-scipy_1_10_1-gnu-hpc) weakremover(python311-scrypt) weakremover(python311-selenium) weakremover(python311-semanage) weakremover(python311-serpy) weakremover(python311-setproctitle) weakremover(python311-sgp4) weakremover(python311-simpleaudio) weakremover(python311-simplejson) weakremover(python311-sip6-devel) weakremover(python311-siphashc) weakremover(python311-slixmpp) weakremover(python311-slycot) weakremover(python311-snimpy) weakremover(python311-softlayer) weakremover(python311-soxr) weakremover(python311-spidev) weakremover(python311-ssdeep) weakremover(python311-statsmodels) weakremover(python311-sunpy) weakremover(python311-swifter) weakremover(python311-systemd) weakremover(python311-tables) weakremover(python311-tbb) weakremover(python311-tesserocr) weakremover(python311-testsuite) weakremover(python311-textile) weakremover(python311-thrift) weakremover(python311-thriftpy2) weakremover(python311-time-machine) weakremover(python311-tinyarray) weakremover(python311-tk) weakremover(python311-tools) weakremover(python311-tornado6) weakremover(python311-traits) weakremover(python311-tri.struct) weakremover(python311-tsk) weakremover(python311-tvm) weakremover(python311-twitter.common.finagle-thrift) weakremover(python311-twitter.common.lang) weakremover(python311-twitter.common.rpc) weakremover(python311-typed-ast) weakremover(python311-uamqp) weakremover(python311-ujson) weakremover(python311-unicodedata2) weakremover(python311-urwid) weakremover(python311-usbsdmux) weakremover(python311-uvloop) weakremover(python311-uwsgi-python3) weakremover(python311-veusz) weakremover(python311-virtkey) weakremover(python311-vispy) weakremover(python311-watchfiles) weakremover(python311-websockets) weakremover(python311-wrapt) weakremover(python311-wsaccel) weakremover(python311-wxPython) weakremover(python311-xapian) weakremover(python311-xattr) weakremover(python311-xkbcommon) weakremover(python311-xmlsec) weakremover(python311-xrootd) weakremover(python311-xxhash) weakremover(python311-y-py) weakremover(python311-yappi) weakremover(python311-yara) weakremover(python311-yarl) weakremover(python311-yt) weakremover(python311-zake) weakremover(python311-zeroconf) weakremover(python311-zodbpickle) weakremover(python311-zope.component) weakremover(python311-zope.hookable) weakremover(python311-zope.i18nmessageid) weakremover(python311-zope.interface) weakremover(python311-zope.proxy) weakremover(python311-zope.proxy-devel) weakremover(python311-zope.security) weakremover(python311-zopfli) weakremover(python311-zstandard) weakremover(python311-zstd) weakremover(python312) weakremover(python312-base) weakremover(python312-curses) weakremover(python312-dbm) weakremover(python312-devel) weakremover(python312-doc) weakremover(python312-doc-devhelp) weakremover(python312-idle) weakremover(python312-testsuite) weakremover(python312-tk) weakremover(python312-tools) weakremover(python36) weakremover(python36-APScheduler) weakremover(python36-AnyQt) weakremover(python36-Arpeggio) weakremover(python36-Authlib) weakremover(python36-Automat) weakremover(python36-BTrees) weakremover(python36-BTrees-devel) weakremover(python36-Babel) weakremover(python36-Beaker) weakremover(python36-BitVector) weakremover(python36-Bottleneck) weakremover(python36-Brotli) weakremover(python36-CCColUtils) weakremover(python36-CacheControl) weakremover(python36-CairoSVG) weakremover(python36-Cerberus) weakremover(python36-Chameleon) weakremover(python36-Cheetah3) weakremover(python36-CherryPy) weakremover(python36-CommonMark) weakremover(python36-ConfigArgParse) weakremover(python36-Cycler) weakremover(python36-Cython) weakremover(python36-DataProperty) weakremover(python36-DataShape) weakremover(python36-DateTime) weakremover(python36-Delorean) weakremover(python36-Deprecated) weakremover(python36-Django) weakremover(python36-Durus) weakremover(python36-EasyProcess) weakremover(python36-EditorConfig) weakremover(python36-ExifRead) weakremover(python36-Fabric) weakremover(python36-Faker) weakremover(python36-Flask) weakremover(python36-Flask-Admin) weakremover(python36-Flask-Babel) weakremover(python36-Flask-BabelEx) weakremover(python36-Flask-Bootstrap) weakremover(python36-Flask-Caching) weakremover(python36-Flask-Compress) weakremover(python36-Flask-Cors) weakremover(python36-Flask-Gravatar) weakremover(python36-Flask-HTMLmin) weakremover(python36-Flask-HTTPAuth) weakremover(python36-Flask-Login) weakremover(python36-Flask-Mail) weakremover(python36-Flask-Migrate) weakremover(python36-Flask-Paranoid) weakremover(python36-Flask-Principal) weakremover(python36-Flask-RESTful) weakremover(python36-Flask-RSTPages) weakremover(python36-Flask-SQLAlchemy) weakremover(python36-Flask-Script) weakremover(python36-Flask-Security-Too) weakremover(python36-Flask-SocketIO) weakremover(python36-Flask-Testing) weakremover(python36-Flask-WTF) weakremover(python36-Flask-doc) weakremover(python36-FontTools) weakremover(python36-FormEncode) weakremover(python36-Genshi) weakremover(python36-GitPython) weakremover(python36-Glances) weakremover(python36-Gloo) weakremover(python36-GooCalendar) weakremover(python36-GooseMPL) weakremover(python36-GridDataFormats) weakremover(python36-HTTPolice) weakremover(python36-HeapDict) weakremover(python36-IMAPClient) weakremover(python36-IMDbPY) weakremover(python36-JPype1) weakremover(python36-Jinja2) weakremover(python36-Js2Py) weakremover(python36-JsonWeb) weakremover(python36-Kajiki) weakremover(python36-Keras-Applications) weakremover(python36-Keras-Preprocessing) weakremover(python36-Kivy) weakremover(python36-Kivy-devel) weakremover(python36-LHAPDF) weakremover(python36-LTTL) weakremover(python36-Lektor) weakremover(python36-Levenshtein) weakremover(python36-Logbook) weakremover(python36-M2Crypto) weakremover(python36-Mako) weakremover(python36-Markdown) weakremover(python36-MarkupPy) weakremover(python36-MarkupSafe) weakremover(python36-Markups) weakremover(python36-Mathics) weakremover(python36-MechanicalSoup) weakremover(python36-Ming) weakremover(python36-MiniMock) weakremover(python36-Morfessor) weakremover(python36-MouseInfo) weakremover(python36-MulticoreTSNE) weakremover(python36-Nuitka) weakremover(python36-OWSLib) weakremover(python36-PGet) weakremover(python36-PTable) weakremover(python36-Parsley) weakremover(python36-Paste) weakremover(python36-PasteDeploy) weakremover(python36-Paver) weakremover(python36-PeakUtils) weakremover(python36-Pebble) weakremover(python36-Pillow) weakremover(python36-Pillow-tk) weakremover(python36-Pint) weakremover(python36-PrettyTable) weakremover(python36-Protego) weakremover(python36-PsyLab) weakremover(python36-PubChemPy) weakremover(python36-Pweave) weakremover(python36-PyAudio) weakremover(python36-PyAutoGUI) weakremover(python36-PyBindGen) weakremover(python36-PyBrowserID) weakremover(python36-PyChart) weakremover(python36-PyChromecast) weakremover(python36-PyCondor) weakremover(python36-PyDispatcher) weakremover(python36-PyECLib) weakremover(python36-PyFxA) weakremover(python36-PyGetWindow) weakremover(python36-PyGithub) weakremover(python36-PyHamcrest) weakremover(python36-PyICU) weakremover(python36-PyInstaller) weakremover(python36-PyJWT) weakremover(python36-PyKMIP) weakremover(python36-PyLaTeX) weakremover(python36-PyMeeus) weakremover(python36-PyMeta3) weakremover(python36-PyMsgBox) weakremover(python36-PyMuPDF) weakremover(python36-PyMySQL) weakremover(python36-PyNaCl) weakremover(python36-PyNamecheap) weakremover(python36-PyOgg) weakremover(python36-PyOpenAL) weakremover(python36-PyPDF2) weakremover(python36-PyPrind) weakremover(python36-PyPrint) weakremover(python36-PyQRCode) weakremover(python36-PyQt6) weakremover(python36-PyQt6-3D) weakremover(python36-PyQt6-3D-devel) weakremover(python36-PyQt6-Charts) weakremover(python36-PyQt6-Charts-devel) weakremover(python36-PyQt6-DataVisualization) weakremover(python36-PyQt6-DataVisualization-devel) weakremover(python36-PyQt6-NetworkAuth) weakremover(python36-PyQt6-NetworkAuth-devel) weakremover(python36-PyQt6-QScintilla) weakremover(python36-PyQt6-devel) weakremover(python36-PyQt6-doc) weakremover(python36-PyQt6-sip) weakremover(python36-PyRIC) weakremover(python36-PyRSS2Gen) weakremover(python36-PyRect) weakremover(python36-PySDL2) weakremover(python36-PyScreeze) weakremover(python36-PySocks) weakremover(python36-PyTrie) weakremover(python36-PyTweening) weakremover(python36-PyVirtualDisplay) weakremover(python36-PyWavelets) weakremover(python36-PyWebDAV3) weakremover(python36-PyWebDAV3-GNUHealth) weakremover(python36-PyX) weakremover(python36-PyYAML) weakremover(python36-Pydap) weakremover(python36-Pygments) weakremover(python36-Pykka) weakremover(python36-Pympler) weakremover(python36-Pyphen) weakremover(python36-Pyro4) weakremover(python36-QDarkStyle) weakremover(python36-QR-Code-generator) weakremover(python36-Qt.py) weakremover(python36-QtAwesome) weakremover(python36-QtPy) weakremover(python36-RegexOrder) weakremover(python36-Routes) weakremover(python36-SPARQLWrapper) weakremover(python36-SQLAlchemy) weakremover(python36-SQLAlchemy-Utils) weakremover(python36-Scrapy) weakremover(python36-SecretStorage) weakremover(python36-Send2Trash) weakremover(python36-Shapely) weakremover(python36-SimpleWebSocketServer) weakremover(python36-SoundCard) weakremover(python36-SoundFile) weakremover(python36-SpeechRecognition) weakremover(python36-Sphinx) weakremover(python36-Sphinx-latex) weakremover(python36-Sphinx2) weakremover(python36-Sphinx2-latex) weakremover(python36-TagStats) weakremover(python36-Telethon) weakremover(python36-Tempita) weakremover(python36-TermRecord) weakremover(python36-Theano) weakremover(python36-Transplant) weakremover(python36-Trolly) weakremover(python36-Trololio) weakremover(python36-Twisted) weakremover(python36-TxSNI) weakremover(python36-URLObject) weakremover(python36-UkPostcodeParser) weakremover(python36-Unidecode) weakremover(python36-VyattaConfParser) weakremover(python36-WSGIProxy2) weakremover(python36-WSME) weakremover(python36-WTForms) weakremover(python36-WTForms-lang) weakremover(python36-Wand) weakremover(python36-WeasyPrint) weakremover(python36-WebOb) weakremover(python36-WebTest) weakremover(python36-Werkzeug) weakremover(python36-Whoosh) weakremover(python36-XStatic) weakremover(python36-XStatic-Angular-Schema-Form) weakremover(python36-XStatic-jQuery) weakremover(python36-XStatic-jquery-ui) weakremover(python36-XStatic-objectpath) weakremover(python36-XStatic-term.js) weakremover(python36-XStatic-tv4) weakremover(python36-XlsxWriter) weakremover(python36-Yapsy) weakremover(python36-ZConfig) weakremover(python36-ZConfig-doc) weakremover(python36-ZEO) weakremover(python36-ZODB) weakremover(python36-abclient) weakremover(python36-abimap) weakremover(python36-abimap-doc) weakremover(python36-abseil) weakremover(python36-acefile) weakremover(python36-acitoolkit) weakremover(python36-acme) weakremover(python36-acoular) weakremover(python36-actdiag) weakremover(python36-adal) weakremover(python36-adapt-parser) weakremover(python36-adblock) weakremover(python36-addict) weakremover(python36-aeidon) weakremover(python36-aenum) weakremover(python36-aexpect) weakremover(python36-afdko) weakremover(python36-affine) weakremover(python36-agate) weakremover(python36-agate-dbf) weakremover(python36-agate-excel) weakremover(python36-agate-lookup) weakremover(python36-agate-remote) weakremover(python36-agate-sql) weakremover(python36-agate-stats) weakremover(python36-aina) weakremover(python36-aiobotocore) weakremover(python36-aiocontextvars) weakremover(python36-aiodataloader) weakremover(python36-aiodns) weakremover(python36-aioeventlet) weakremover(python36-aiofiles) weakremover(python36-aioftp) weakremover(python36-aiohttp) weakremover(python36-aiohttp-jinja2) weakremover(python36-aiohttp-socks) weakremover(python36-aiohttp-theme) weakremover(python36-aiohttp_cors) weakremover(python36-aioitertools) weakremover(python36-aioquic) weakremover(python36-aioredis) weakremover(python36-aioresponses) weakremover(python36-aiorpcX) weakremover(python36-aiosignal) weakremover(python36-aiosmtpd) weakremover(python36-aiosmtplib) weakremover(python36-aiosqlite) weakremover(python36-aiounittest) weakremover(python36-ajsonrpc) weakremover(python36-akismet) weakremover(python36-alabaster) weakremover(python36-aldjemy) weakremover(python36-alembic) weakremover(python36-allpairspy) weakremover(python36-alsa) weakremover(python36-altair) weakremover(python36-altair-widgets) weakremover(python36-altgraph) weakremover(python36-amqp) weakremover(python36-amqpstorm) weakremover(python36-ana) weakremover(python36-aniso8601) weakremover(python36-annoy) weakremover(python36-ansel) weakremover(python36-ansi2html) weakremover(python36-ansicolor) weakremover(python36-ansicolors) weakremover(python36-ansiwrap) weakremover(python36-antlr4-python3-runtime) weakremover(python36-anyio) weakremover(python36-anyjson) weakremover(python36-anymarkup-core) weakremover(python36-apache-libcloud) weakremover(python36-apipkg) weakremover(python36-apiron) weakremover(python36-apns2) weakremover(python36-appdirs) weakremover(python36-application) weakremover(python36-applicationinsights) weakremover(python36-apptools) weakremover(python36-apsw) weakremover(python36-ara) weakremover(python36-arabic-reshaper) weakremover(python36-archmage) weakremover(python36-arf) weakremover(python36-argcomplete) weakremover(python36-argh) weakremover(python36-argon2-cffi) weakremover(python36-argparse-manpage) weakremover(python36-args) weakremover(python36-arrow) weakremover(python36-asciimatics) weakremover(python36-asciitree) weakremover(python36-asgiref) weakremover(python36-asn1crypto) weakremover(python36-aspectlib) weakremover(python36-aspy.yaml) weakremover(python36-asteval) weakremover(python36-astor) weakremover(python36-astral) weakremover(python36-astroid) weakremover(python36-astropy-helpers) weakremover(python36-asttokens) weakremover(python36-astunparse) weakremover(python36-asv) weakremover(python36-async_generator) weakremover(python36-async_timeout) weakremover(python36-asyncpg) weakremover(python36-asyncssh) weakremover(python36-asynctest) weakremover(python36-atlassian-python-api) weakremover(python36-atom) weakremover(python36-atomicwrites) weakremover(python36-atpublic) weakremover(python36-atspi) weakremover(python36-attr) weakremover(python36-attrs) weakremover(python36-aubio) weakremover(python36-audio-degrader) weakremover(python36-audiogrep) weakremover(python36-audiomate) weakremover(python36-audioread) weakremover(python36-augeas) weakremover(python36-authheaders) weakremover(python36-authres) weakremover(python36-autobahn) weakremover(python36-autodoc) weakremover(python36-autodocsumm) weakremover(python36-autoflake) weakremover(python36-autopage) weakremover(python36-autopep8) weakremover(python36-autoray) weakremover(python36-autoupgrade-ng) weakremover(python36-av) weakremover(python36-avahi) weakremover(python36-avocado-plugins-vt) weakremover(python36-avro) weakremover(python36-awkward) weakremover(python36-awpa) weakremover(python36-aws-sam-translator) weakremover(python36-aws-xray-sdk) weakremover(python36-aws-xray-sdk-Django) weakremover(python36-aws-xray-sdk-Flask-SQLAlchemy) weakremover(python36-aws-xray-sdk-SQLAlchemy) weakremover(python36-aws-xray-sdk-aiobotocore) weakremover(python36-aws-xray-sdk-aiohttp) weakremover(python36-aws-xray-sdk-all) weakremover(python36-aws-xray-sdk-mysql-connector) weakremover(python36-aws-xray-sdk-psycopg2) weakremover(python36-aws-xray-sdk-pymongo) weakremover(python36-aws-xray-sdk-pynamodb) weakremover(python36-aws-xray-sdk-requests) weakremover(python36-axolotl) weakremover(python36-axolotl-curve25519) weakremover(python36-azure-agrifood-farming) weakremover(python36-azure-agrifood-nspkg) weakremover(python36-azure-ai-anomalydetector) weakremover(python36-azure-ai-formrecognizer) weakremover(python36-azure-ai-language-nspkg) weakremover(python36-azure-ai-language-questionanswering) weakremover(python36-azure-ai-metricsadvisor) weakremover(python36-azure-ai-nspkg) weakremover(python36-azure-ai-textanalytics) weakremover(python36-azure-ai-translation-document) weakremover(python36-azure-ai-translation-nspkg) weakremover(python36-azure-appconfiguration) weakremover(python36-azure-applicationinsights) weakremover(python36-azure-batch) weakremover(python36-azure-cognitiveservices-anomalydetector) weakremover(python36-azure-cognitiveservices-formrecognizer) weakremover(python36-azure-cognitiveservices-inkrecognizer) weakremover(python36-azure-cognitiveservices-knowledge-nspkg) weakremover(python36-azure-cognitiveservices-knowledge-qnamaker) weakremover(python36-azure-cognitiveservices-language-luis) weakremover(python36-azure-cognitiveservices-language-nspkg) weakremover(python36-azure-cognitiveservices-language-spellcheck) weakremover(python36-azure-cognitiveservices-language-textanalytics) weakremover(python36-azure-cognitiveservices-nspkg) weakremover(python36-azure-cognitiveservices-personalizer) weakremover(python36-azure-cognitiveservices-search-autosuggest) weakremover(python36-azure-cognitiveservices-search-customimagesearch) weakremover(python36-azure-cognitiveservices-search-customsearch) weakremover(python36-azure-cognitiveservices-search-entitysearch) weakremover(python36-azure-cognitiveservices-search-imagesearch) weakremover(python36-azure-cognitiveservices-search-newssearch) weakremover(python36-azure-cognitiveservices-search-nspkg) weakremover(python36-azure-cognitiveservices-search-videosearch) weakremover(python36-azure-cognitiveservices-search-visualsearch) weakremover(python36-azure-cognitiveservices-search-websearch) weakremover(python36-azure-cognitiveservices-vision-computervision) weakremover(python36-azure-cognitiveservices-vision-contentmoderator) weakremover(python36-azure-cognitiveservices-vision-customvision) weakremover(python36-azure-cognitiveservices-vision-face) weakremover(python36-azure-cognitiveservices-vision-nspkg) weakremover(python36-azure-common) weakremover(python36-azure-communication-administration) weakremover(python36-azure-communication-chat) weakremover(python36-azure-communication-identity) weakremover(python36-azure-communication-networktraversal) weakremover(python36-azure-communication-nspkg) weakremover(python36-azure-communication-phonenumbers) weakremover(python36-azure-communication-sms) weakremover(python36-azure-confidentialledger) weakremover(python36-azure-containerregistry) weakremover(python36-azure-core) weakremover(python36-azure-core-tracing-opencensus) weakremover(python36-azure-core-tracing-opentelemetry) weakremover(python36-azure-cosmos) weakremover(python36-azure-data-nspkg) weakremover(python36-azure-data-tables) weakremover(python36-azure-datalake-store) weakremover(python36-azure-devops) weakremover(python36-azure-digitaltwins-core) weakremover(python36-azure-digitaltwins-nspkg) weakremover(python36-azure-eventgrid) weakremover(python36-azure-eventhub) weakremover(python36-azure-eventhub-checkpointstoreblob) weakremover(python36-azure-eventhub-checkpointstoreblob-aio) weakremover(python36-azure-functions-devops-build) weakremover(python36-azure-graphrbac) weakremover(python36-azure-identity) weakremover(python36-azure-keyvault) weakremover(python36-azure-keyvault-administration) weakremover(python36-azure-keyvault-certificates) weakremover(python36-azure-keyvault-keys) weakremover(python36-azure-keyvault-nspkg) weakremover(python36-azure-keyvault-secrets) weakremover(python36-azure-loganalytics) weakremover(python36-azure-media-nspkg) weakremover(python36-azure-media-videoanalyzer-edge) weakremover(python36-azure-messaging-nspkg) weakremover(python36-azure-messaging-webpubsubservice) weakremover(python36-azure-mgmt) weakremover(python36-azure-mgmt-advisor) weakremover(python36-azure-mgmt-agfood) weakremover(python36-azure-mgmt-agrifood) weakremover(python36-azure-mgmt-alertsmanagement) weakremover(python36-azure-mgmt-apimanagement) weakremover(python36-azure-mgmt-appconfiguration) weakremover(python36-azure-mgmt-applicationinsights) weakremover(python36-azure-mgmt-appplatform) weakremover(python36-azure-mgmt-attestation) weakremover(python36-azure-mgmt-authorization) weakremover(python36-azure-mgmt-automanage) weakremover(python36-azure-mgmt-automation) weakremover(python36-azure-mgmt-avs) weakremover(python36-azure-mgmt-azureadb2c) weakremover(python36-azure-mgmt-azurestack) weakremover(python36-azure-mgmt-azurestackhci) weakremover(python36-azure-mgmt-baremetalinfrastructure) weakremover(python36-azure-mgmt-batch) weakremover(python36-azure-mgmt-batchai) weakremover(python36-azure-mgmt-billing) weakremover(python36-azure-mgmt-botservice) weakremover(python36-azure-mgmt-cdn) weakremover(python36-azure-mgmt-chaos) weakremover(python36-azure-mgmt-cognitiveservices) weakremover(python36-azure-mgmt-commerce) weakremover(python36-azure-mgmt-communication) weakremover(python36-azure-mgmt-compute) weakremover(python36-azure-mgmt-confluent) weakremover(python36-azure-mgmt-connectedvmware) weakremover(python36-azure-mgmt-consumption) weakremover(python36-azure-mgmt-containerinstance) weakremover(python36-azure-mgmt-containerregistry) weakremover(python36-azure-mgmt-containerservice) weakremover(python36-azure-mgmt-core) weakremover(python36-azure-mgmt-cosmosdb) weakremover(python36-azure-mgmt-costmanagement) weakremover(python36-azure-mgmt-customproviders) weakremover(python36-azure-mgmt-databox) weakremover(python36-azure-mgmt-databoxedge) weakremover(python36-azure-mgmt-databricks) weakremover(python36-azure-mgmt-datadog) weakremover(python36-azure-mgmt-datafactory) weakremover(python36-azure-mgmt-datalake-analytics) weakremover(python36-azure-mgmt-datalake-nspkg) weakremover(python36-azure-mgmt-datalake-store) weakremover(python36-azure-mgmt-datamigration) weakremover(python36-azure-mgmt-dataprotection) weakremover(python36-azure-mgmt-datashare) weakremover(python36-azure-mgmt-deploymentmanager) weakremover(python36-azure-mgmt-deviceupdate) weakremover(python36-azure-mgmt-devspaces) weakremover(python36-azure-mgmt-devtestlabs) weakremover(python36-azure-mgmt-digitaltwins) weakremover(python36-azure-mgmt-dns) weakremover(python36-azure-mgmt-documentdb) weakremover(python36-azure-mgmt-edgegateway) weakremover(python36-azure-mgmt-edgeorder) weakremover(python36-azure-mgmt-elastic) weakremover(python36-azure-mgmt-eventgrid) weakremover(python36-azure-mgmt-eventhub) weakremover(python36-azure-mgmt-extendedlocation) weakremover(python36-azure-mgmt-fluidrelay) weakremover(python36-azure-mgmt-frontdoor) weakremover(python36-azure-mgmt-guestconfig) weakremover(python36-azure-mgmt-hanaonazure) weakremover(python36-azure-mgmt-hdinsight) weakremover(python36-azure-mgmt-healthcareapis) weakremover(python36-azure-mgmt-hybridcompute) weakremover(python36-azure-mgmt-hybridkubernetes) weakremover(python36-azure-mgmt-hybridnetwork) weakremover(python36-azure-mgmt-imagebuilder) weakremover(python36-azure-mgmt-iotcentral) weakremover(python36-azure-mgmt-iothub) weakremover(python36-azure-mgmt-iothubprovisioningservices) weakremover(python36-azure-mgmt-keyvault) weakremover(python36-azure-mgmt-kubernetesconfiguration) weakremover(python36-azure-mgmt-kusto) weakremover(python36-azure-mgmt-labservices) weakremover(python36-azure-mgmt-loadtestservice) weakremover(python36-azure-mgmt-loganalytics) weakremover(python36-azure-mgmt-logic) weakremover(python36-azure-mgmt-logz) weakremover(python36-azure-mgmt-machinelearningcompute) weakremover(python36-azure-mgmt-machinelearningservices) weakremover(python36-azure-mgmt-maintenance) weakremover(python36-azure-mgmt-managedservices) weakremover(python36-azure-mgmt-managementgroups) weakremover(python36-azure-mgmt-managementpartner) weakremover(python36-azure-mgmt-maps) weakremover(python36-azure-mgmt-marketplaceordering) weakremover(python36-azure-mgmt-media) weakremover(python36-azure-mgmt-mixedreality) weakremover(python36-azure-mgmt-monitor) weakremover(python36-azure-mgmt-msi) weakremover(python36-azure-mgmt-netapp) weakremover(python36-azure-mgmt-network) weakremover(python36-azure-mgmt-notificationhubs) weakremover(python36-azure-mgmt-nspkg) weakremover(python36-azure-mgmt-orbital) weakremover(python36-azure-mgmt-peering) weakremover(python36-azure-mgmt-policyinsights) weakremover(python36-azure-mgmt-portal) weakremover(python36-azure-mgmt-powerbidedicated) weakremover(python36-azure-mgmt-powerbiembedded) weakremover(python36-azure-mgmt-privatedns) weakremover(python36-azure-mgmt-purview) weakremover(python36-azure-mgmt-quantum) weakremover(python36-azure-mgmt-quota) weakremover(python36-azure-mgmt-rdbms) weakremover(python36-azure-mgmt-recoveryservices) weakremover(python36-azure-mgmt-recoveryservicesbackup) weakremover(python36-azure-mgmt-recoveryservicessiterecovery) weakremover(python36-azure-mgmt-redhatopenshift) weakremover(python36-azure-mgmt-redis) weakremover(python36-azure-mgmt-regionmove) weakremover(python36-azure-mgmt-relay) weakremover(python36-azure-mgmt-reservations) weakremover(python36-azure-mgmt-resource) weakremover(python36-azure-mgmt-resourceconnector) weakremover(python36-azure-mgmt-resourcegraph) weakremover(python36-azure-mgmt-resourcehealth) weakremover(python36-azure-mgmt-resourcemover) weakremover(python36-azure-mgmt-scheduler) weakremover(python36-azure-mgmt-search) weakremover(python36-azure-mgmt-security) weakremover(python36-azure-mgmt-serialconsole) weakremover(python36-azure-mgmt-servermanager) weakremover(python36-azure-mgmt-servicebus) weakremover(python36-azure-mgmt-servicefabric) weakremover(python36-azure-mgmt-servicefabricmanagedclusters) weakremover(python36-azure-mgmt-servicelinker) weakremover(python36-azure-mgmt-signalr) weakremover(python36-azure-mgmt-sql) weakremover(python36-azure-mgmt-sqlvirtualmachine) weakremover(python36-azure-mgmt-storage) weakremover(python36-azure-mgmt-storagecache) weakremover(python36-azure-mgmt-storageimportexport) weakremover(python36-azure-mgmt-storagepool) weakremover(python36-azure-mgmt-storagesync) weakremover(python36-azure-mgmt-streamanalytics) weakremover(python36-azure-mgmt-subscription) weakremover(python36-azure-mgmt-support) weakremover(python36-azure-mgmt-synapse) weakremover(python36-azure-mgmt-testbase) weakremover(python36-azure-mgmt-timeseriesinsights) weakremover(python36-azure-mgmt-trafficmanager) weakremover(python36-azure-mgmt-videoanalyzer) weakremover(python36-azure-mgmt-vmwarecloudsimple) weakremover(python36-azure-mgmt-web) weakremover(python36-azure-mgmt-webpubsub) weakremover(python36-azure-mixedreality-authentication) weakremover(python36-azure-mixedreality-nspkg) weakremover(python36-azure-monitor) weakremover(python36-azure-monitor-nspkg) weakremover(python36-azure-monitor-query) weakremover(python36-azure-multiapi-storage) weakremover(python36-azure-nspkg) weakremover(python36-azure-purview-account) weakremover(python36-azure-purview-administration) weakremover(python36-azure-purview-catalog) weakremover(python36-azure-purview-nspkg) weakremover(python36-azure-purview-scanning) weakremover(python36-azure-schemaregistry) weakremover(python36-azure-schemaregistry-avroserializer) weakremover(python36-azure-sdk) weakremover(python36-azure-search-documents) weakremover(python36-azure-search-nspkg) weakremover(python36-azure-security-attestation) weakremover(python36-azure-security-nspkg) weakremover(python36-azure-servicebus) weakremover(python36-azure-servicefabric) weakremover(python36-azure-servicemanagement-legacy) weakremover(python36-azure-storage) weakremover(python36-azure-storage-blob) weakremover(python36-azure-storage-common) weakremover(python36-azure-storage-file) weakremover(python36-azure-storage-file-datalake) weakremover(python36-azure-storage-file-share) weakremover(python36-azure-storage-nspkg) weakremover(python36-azure-storage-queue) weakremover(python36-azure-synapse-accesscontrol) weakremover(python36-azure-synapse-artifacts) weakremover(python36-azure-synapse-managedprivateendpoints) weakremover(python36-azure-synapse-monitoring) weakremover(python36-azure-synapse-nspkg) weakremover(python36-azure-synapse-spark) weakremover(python36-azure-template) weakremover(python36-babelfish) weakremover(python36-backcall) weakremover(python36-backoff) weakremover(python36-backports.entry_points_selectable) weakremover(python36-backports.zoneinfo) weakremover(python36-baron) weakremover(python36-base) weakremover(python36-base58) weakremover(python36-bashate) weakremover(python36-basictracer) weakremover(python36-bcolz) weakremover(python36-bcrypt) weakremover(python36-beautifulsoup4) weakremover(python36-before-after) weakremover(python36-behave) weakremover(python36-bencode) weakremover(python36-beniget) weakremover(python36-beren) weakremover(python36-betamax) weakremover(python36-betamax-matchers) weakremover(python36-bibtexparser) weakremover(python36-bidict) weakremover(python36-billiard) weakremover(python36-binary) weakremover(python36-binaryornot) weakremover(python36-bindep) weakremover(python36-biopython) weakremover(python36-biplist) weakremover(python36-bitarray) weakremover(python36-bitstring) weakremover(python36-bitstruct) weakremover(python36-bjoern) weakremover(python36-black) weakremover(python36-bleach) weakremover(python36-blessed) weakremover(python36-blessings) weakremover(python36-blindspin) weakremover(python36-blinker) weakremover(python36-blist) weakremover(python36-blockdiag) weakremover(python36-blosc) weakremover(python36-bloscpack) weakremover(python36-blue) weakremover(python36-blurb) weakremover(python36-bmap-tools) weakremover(python36-bobo) weakremover(python36-bobodoctestumentation) weakremover(python36-bokcolmaps) weakremover(python36-bokeh) weakremover(python36-boltons) weakremover(python36-boolean.py) weakremover(python36-booleanOperations) weakremover(python36-boto) weakremover(python36-boto3) weakremover(python36-botocore) weakremover(python36-bottle) weakremover(python36-bowler) weakremover(python36-bpython) weakremover(python36-bqplot) weakremover(python36-branca) weakremover(python36-breathe) weakremover(python36-brewer2mpl) weakremover(python36-brotlicffi) weakremover(python36-brotlipy) weakremover(python36-bsddb3) weakremover(python36-bsddb3-devel) weakremover(python36-bson) weakremover(python36-bugzilla) weakremover(python36-bugzillatools) weakremover(python36-build) weakremover(python36-bump2version) weakremover(python36-buttplug) weakremover(python36-bytecode) weakremover(python36-cPyparsing) weakremover(python36-cached-property) weakremover(python36-cachelib) weakremover(python36-cachetools) weakremover(python36-cachey) weakremover(python36-cachy) weakremover(python36-cairocffi) weakremover(python36-cairocffi-pixbuf) weakremover(python36-caldav) weakremover(python36-calmjs) weakremover(python36-calmjs.parse) weakremover(python36-calmjs.types) weakremover(python36-calysto) weakremover(python36-cangjie) weakremover(python36-canonicaljson) weakremover(python36-capturer) weakremover(python36-casacore) weakremover(python36-case) weakremover(python36-cassandra-driver) weakremover(python36-cassowary) weakremover(python36-casttube) weakremover(python36-catkin-pkg) weakremover(python36-cauldron-notebook) weakremover(python36-cbor) weakremover(python36-cbor2) weakremover(python36-cchardet) weakremover(python36-celery) weakremover(python36-celery-batches) weakremover(python36-celerymon) weakremover(python36-cerealizer) weakremover(python36-certbot) weakremover(python36-certbot-apache) weakremover(python36-certbot-dns-cloudflare) weakremover(python36-certbot-dns-cloudxns) weakremover(python36-certbot-dns-digitalocean) weakremover(python36-certbot-dns-dnsimple) weakremover(python36-certbot-dns-dnsmadeeasy) weakremover(python36-certbot-dns-google) weakremover(python36-certbot-dns-linode) weakremover(python36-certbot-dns-luadns) weakremover(python36-certbot-dns-nsone) weakremover(python36-certbot-dns-rfc2136) weakremover(python36-certbot-dns-route53) weakremover(python36-certbot-nginx) weakremover(python36-certifi) weakremover(python36-certipy) weakremover(python36-certstream) weakremover(python36-cffi) weakremover(python36-cfgdiff) weakremover(python36-cfgv) weakremover(python36-cfn-lint) weakremover(python36-cfscrape) weakremover(python36-cftime) weakremover(python36-chai) weakremover(python36-chainmap) weakremover(python36-chardet) weakremover(python36-charset-normalizer) weakremover(python36-chart-studio) weakremover(python36-chartify) weakremover(python36-check-manifest) weakremover(python36-checkdmarc) weakremover(python36-cheroot) weakremover(python36-chest) weakremover(python36-circuitbreaker) weakremover(python36-ciscoconfparse) weakremover(python36-cl) weakremover(python36-cleo) weakremover(python36-cli-helpers) weakremover(python36-click) weakremover(python36-click-aliases) weakremover(python36-click-completion) weakremover(python36-click-default-group) weakremover(python36-click-didyoumean) weakremover(python36-click-help-colors) weakremover(python36-click-log) weakremover(python36-click-man) weakremover(python36-click-plugins) weakremover(python36-click-repl) weakremover(python36-click-spinner) weakremover(python36-click-threading) weakremover(python36-cligj) weakremover(python36-clikit) weakremover(python36-clint) weakremover(python36-cloud-init-seed) weakremover(python36-cloud-sptheme) weakremover(python36-cloudflare) weakremover(python36-cloudpickle) weakremover(python36-cloudscraper) weakremover(python36-cluster) weakremover(python36-cluster-preflight-check) weakremover(python36-cma) weakremover(python36-cmapfile) weakremover(python36-cmarkgfm) weakremover(python36-cmd2) weakremover(python36-cmdln) weakremover(python36-coards) weakremover(python36-codecov) weakremover(python36-cogapp) weakremover(python36-colander) weakremover(python36-colorama) weakremover(python36-colorcet) weakremover(python36-colorclass) weakremover(python36-coloredlogs) weakremover(python36-colorlog) weakremover(python36-colorlover) weakremover(python36-colormap) weakremover(python36-colorspacious) weakremover(python36-colour) weakremover(python36-combi) weakremover(python36-commentjson) weakremover(python36-compat-patcher-core) weakremover(python36-compileall2) weakremover(python36-compizconfig) weakremover(python36-compressed_rtf) weakremover(python36-concurrentloghandler) weakremover(python36-configargparse) weakremover(python36-configobj) weakremover(python36-configshell-fb) weakremover(python36-confluent-kafka) weakremover(python36-confpy) weakremover(python36-confusable-homoglyphs) weakremover(python36-constantly) weakremover(python36-construct) weakremover(python36-contexter) weakremover(python36-contextlib2) weakremover(python36-contextvars) weakremover(python36-control) weakremover(python36-conu) weakremover(python36-convertdate) weakremover(python36-cookiecutter) weakremover(python36-cookies) weakremover(python36-cooldict) weakremover(python36-copr) weakremover(python36-copr-cli) weakremover(python36-coreapi) weakremover(python36-coreapi-cli) weakremover(python36-coreschema) weakremover(python36-cornice) weakremover(python36-cov-core) weakremover(python36-covdefaults) weakremover(python36-coverage) weakremover(python36-coverage-config-reload-plugin) weakremover(python36-coverage-env-plugin) weakremover(python36-coveralls) weakremover(python36-coveralls-check) weakremover(python36-cppclean) weakremover(python36-cpplint) weakremover(python36-cppy) weakremover(python36-cracklib) weakremover(python36-crashtest) weakremover(python36-crayons) weakremover(python36-crcmod) weakremover(python36-crochet) weakremover(python36-cron-descriptor) weakremover(python36-croniter) weakremover(python36-crontab) weakremover(python36-crumbs) weakremover(python36-cryptography) weakremover(python36-cryptography-vectors) weakremover(python36-css-html-js-minify) weakremover(python36-css-parser) weakremover(python36-csscompressor) weakremover(python36-cssselect) weakremover(python36-cssselect2) weakremover(python36-cssutils) weakremover(python36-cstruct) weakremover(python36-csv23) weakremover(python36-csvkit) weakremover(python36-ctypescrypto) weakremover(python36-cu2qu) weakremover(python36-cufflinks) weakremover(python36-curio) weakremover(python36-curlylint) weakremover(python36-curses) weakremover(python36-curtsies) weakremover(python36-cwcwidth) weakremover(python36-cx_Freeze) weakremover(python36-cymruwhois) weakremover(python36-cytoolz) weakremover(python36-czifile) weakremover(python36-d2to1) weakremover(python36-daemonize) weakremover(python36-daiquiri) weakremover(python36-dasbus) weakremover(python36-dash) weakremover(python36-dash-core-components) weakremover(python36-dash-html-components) weakremover(python36-dash-renderer) weakremover(python36-dash-table) weakremover(python36-dask) weakremover(python36-dask-all) weakremover(python36-dask-array) weakremover(python36-dask-bag) weakremover(python36-dask-dataframe) weakremover(python36-dask-distributed) weakremover(python36-dask-dot) weakremover(python36-dask-multiprocessing) weakremover(python36-databases) weakremover(python36-dataclasses) weakremover(python36-datadiff) weakremover(python36-datashader) weakremover(python36-dateparser) weakremover(python36-dateutils) weakremover(python36-datrie) weakremover(python36-dbf) weakremover(python36-dbfread) weakremover(python36-dbm) weakremover(python36-dbus-deviation) weakremover(python36-dbus-python) weakremover(python36-dbus-python-devel) weakremover(python36-dbus_next) weakremover(python36-ddg3) weakremover(python36-ddt) weakremover(python36-deap) weakremover(python36-debian) weakremover(python36-decorator) weakremover(python36-deepdiff) weakremover(python36-deepmerge) weakremover(python36-defcon) weakremover(python36-defusedxml) weakremover(python36-delegator) weakremover(python36-delegator.py) weakremover(python36-demjson) weakremover(python36-dennis) weakremover(python36-dephell) weakremover(python36-dephell-archive) weakremover(python36-dephell-argparse) weakremover(python36-dephell-discover) weakremover(python36-dephell-licenses) weakremover(python36-dephell-links) weakremover(python36-dephell-markers) weakremover(python36-dephell-pythons) weakremover(python36-dephell-setuptools) weakremover(python36-dephell-shells) weakremover(python36-dephell-specifier) weakremover(python36-dephell-venvs) weakremover(python36-dephell-versioning) weakremover(python36-dephell_changelogs) weakremover(python36-deprecation) weakremover(python36-derpconf) weakremover(python36-devel) weakremover(python36-devpi-client) weakremover(python36-devpi-common) weakremover(python36-devpi-server) weakremover(python36-dfdatetime) weakremover(python36-dfwinreg) weakremover(python36-dialite) weakremover(python36-dictdiffer) weakremover(python36-dictknife) weakremover(python36-dictpath) weakremover(python36-dicttoxml) weakremover(python36-diff-match-patch) weakremover(python36-diffimg) weakremover(python36-digitalocean) weakremover(python36-dill) weakremover(python36-dirtyjson) weakremover(python36-discid) weakremover(python36-discogs-client) weakremover(python36-diskcache) weakremover(python36-dist) weakremover(python36-distlib) weakremover(python36-distob) weakremover(python36-distorm3) weakremover(python36-distributed) weakremover(python36-distro) weakremover(python36-distroinfo) weakremover(python36-distutils-extra) weakremover(python36-dj-database-url) weakremover(python36-django-action-framework) weakremover(python36-django-allauth) weakremover(python36-django-appconf) weakremover(python36-django-args) weakremover(python36-django-assets) weakremover(python36-django-attachments) weakremover(python36-django-auth-ldap) weakremover(python36-django-avatar) weakremover(python36-django-axes) weakremover(python36-django-bootstrap3) weakremover(python36-django-bootstrap4) weakremover(python36-django-braces) weakremover(python36-django-cacheops) weakremover(python36-django-ckeditor) weakremover(python36-django-classy-tags) weakremover(python36-django-codemod) weakremover(python36-django-collectd-rest) weakremover(python36-django-compressor) weakremover(python36-django-contrib-comments) weakremover(python36-django-cors-headers) weakremover(python36-django-countries) weakremover(python36-django-coverage-plugin) weakremover(python36-django-crispy-forms) weakremover(python36-django-debreach) weakremover(python36-django-debug-toolbar) weakremover(python36-django-dj-inmemorystorage) weakremover(python36-django-dynamic-fixture) weakremover(python36-django-environ) weakremover(python36-django-eremaea2) weakremover(python36-django-extensions) weakremover(python36-django-extra-views) weakremover(python36-django-filter) weakremover(python36-django-formtools) weakremover(python36-django-geoposition) weakremover(python36-django-grappelli) weakremover(python36-django-gravatar2) weakremover(python36-django-guardian) weakremover(python36-django-haystack) weakremover(python36-django-health-check) weakremover(python36-django-import-export) weakremover(python36-django-invitations) weakremover(python36-django-ipware) weakremover(python36-django-jinja) weakremover(python36-django-js-asset) weakremover(python36-django-json-widget) weakremover(python36-django-jsonfield) weakremover(python36-django-localflavor) weakremover(python36-django-mailer) weakremover(python36-django-mathfilters) weakremover(python36-django-minio-storage) weakremover(python36-django-model-utils) weakremover(python36-django-money) weakremover(python36-django-multiselectfield) weakremover(python36-django-nine) weakremover(python36-django-nose) weakremover(python36-django-oauth-toolkit) weakremover(python36-django-oidc-provider) weakremover(python36-django-oscar) weakremover(python36-django-pandas) weakremover(python36-django-parler) weakremover(python36-django-perf-rec) weakremover(python36-django-pglocks) weakremover(python36-django-phonenumber-field) weakremover(python36-django-picklefield) weakremover(python36-django-pipeline) weakremover(python36-django-polymorphic) weakremover(python36-django-push-notifications) weakremover(python36-django-pyscss) weakremover(python36-django-q) weakremover(python36-django-qsessions) weakremover(python36-django-redis) weakremover(python36-django-registration) weakremover(python36-django-request) weakremover(python36-django-rest-framework-braces) weakremover(python36-django-rest-framework-client) weakremover(python36-django-rest-framework-social-oauth2) weakremover(python36-django-rest-invitations) weakremover(python36-django-rest-knox) weakremover(python36-django-reversion) weakremover(python36-django-rosetta) weakremover(python36-django-seed) weakremover(python36-django-sekizai) weakremover(python36-django-settings-toml) weakremover(python36-django-silk) weakremover(python36-django-sortedm2m) weakremover(python36-django-storages) weakremover(python36-django-tables2) weakremover(python36-django-tagging) weakremover(python36-django-tastypie) weakremover(python36-django-threadedcomments) weakremover(python36-django-timezone-field) weakremover(python36-django-treebeard) weakremover(python36-django-user-agents) weakremover(python36-django-utils-six) weakremover(python36-django-webpack-loader) weakremover(python36-django-webtest) weakremover(python36-django-widget-tweaks) weakremover(python36-djangorestframework) weakremover(python36-djangorestframework-camel-case) weakremover(python36-djangorestframework-simplejwt) weakremover(python36-djet) weakremover(python36-djvulibre) weakremover(python36-dkimpy) weakremover(python36-dns-lexicon) weakremover(python36-dnslib) weakremover(python36-dnspython) weakremover(python36-doc) weakremover(python36-doc-devhelp) weakremover(python36-docformatter) weakremover(python36-docker) weakremover(python36-docker-compose) weakremover(python36-docker-pycreds) weakremover(python36-dockerpty) weakremover(python36-docopt) weakremover(python36-docrepr) weakremover(python36-docutils) weakremover(python36-docutils-ast-writer) weakremover(python36-dogslow) weakremover(python36-dominate) weakremover(python36-dotmap) weakremover(python36-dparse) weakremover(python36-dpcontracts) weakremover(python36-dpkt) weakremover(python36-dragonmapper) weakremover(python36-drms) weakremover(python36-dropbox) weakremover(python36-dtaidistance) weakremover(python36-dtaidistance-devel) weakremover(python36-dtfabric) weakremover(python36-duckduckgo2) weakremover(python36-dukpy) weakremover(python36-dukpy-kovidgoyal) weakremover(python36-dulwich) weakremover(python36-dynaconf) weakremover(python36-easy-thumbnails) weakremover(python36-easydev) weakremover(python36-easygui) weakremover(python36-easypysmb) weakremover(python36-easywatch) weakremover(python36-ebcdic) weakremover(python36-ecdsa) weakremover(python36-ed25519) weakremover(python36-edgegrid-python) weakremover(python36-editdistance) weakremover(python36-editdistance-devel) weakremover(python36-efilter) weakremover(python36-efl) weakremover(python36-elasticsearch) weakremover(python36-elasticsearch-dsl) weakremover(python36-elementpath) weakremover(python36-eliot) weakremover(python36-email-reply-parser) weakremover(python36-email_validator) weakremover(python36-emcee) weakremover(python36-emoji) weakremover(python36-empy) weakremover(python36-enaml) weakremover(python36-encore) weakremover(python36-entrypoint2) weakremover(python36-entrypoints) weakremover(python36-environ-config) weakremover(python36-environmental-override) weakremover(python36-envisage) weakremover(python36-enzyme) weakremover(python36-ephem) weakremover(python36-epubmerge) weakremover(python36-eradicate) weakremover(python36-espeak) weakremover(python36-esptool) weakremover(python36-et_xmlfile) weakremover(python36-etcd) weakremover(python36-ethtool) weakremover(python36-evdev) weakremover(python36-eventlet) weakremover(python36-evilunit) weakremover(python36-evtx) weakremover(python36-exam) weakremover(python36-execnet) weakremover(python36-executing) weakremover(python36-exiv2) weakremover(python36-expects) weakremover(python36-expiringdict) weakremover(python36-exrex) weakremover(python36-extension-helpers) weakremover(python36-extras) weakremover(python36-extratools) weakremover(python36-ez_setup) weakremover(python36-fabio) weakremover(python36-factory_boy) weakremover(python36-fake-useragent) weakremover(python36-fakeredis) weakremover(python36-falcon) weakremover(python36-fanficfare) weakremover(python36-fann2) weakremover(python36-fastTSNE) weakremover(python36-fastcluster) weakremover(python36-fasteners) weakremover(python36-fastimport) weakremover(python36-fastnumbers) weakremover(python36-fastparquet) weakremover(python36-fastremap) weakremover(python36-fb-re2) weakremover(python36-featureflow) weakremover(python36-fedmsg) weakremover(python36-fedmsg-tests) weakremover(python36-fedora-messaging) weakremover(python36-feedgen) weakremover(python36-feedgenerator) weakremover(python36-feedparser) weakremover(python36-ffmpeg-python) weakremover(python36-fido2) weakremover(python36-fields) weakremover(python36-filelock) weakremover(python36-filetype) weakremover(python36-finance_enums) weakremover(python36-fire) weakremover(python36-first) weakremover(python36-fissix) weakremover(python36-fixtures) weakremover(python36-flake8) weakremover(python36-flake8-blind-except) weakremover(python36-flake8-bugbear) weakremover(python36-flake8-builtins) weakremover(python36-flake8-class-newline) weakremover(python36-flake8-comprehensions) weakremover(python36-flake8-debugger) weakremover(python36-flake8-deprecated) weakremover(python36-flake8-docstrings) weakremover(python36-flake8-import-order) weakremover(python36-flake8-imports) weakremover(python36-flake8-isort) weakremover(python36-flake8-pep3101) weakremover(python36-flake8-polyfill) weakremover(python36-flake8-pyi) weakremover(python36-flake8-quotes) weakremover(python36-flaky) weakremover(python36-flasgger) weakremover(python36-flask-jwt-extended) weakremover(python36-flask-oidc) weakremover(python36-flask-peewee) weakremover(python36-flask-restplus) weakremover(python36-flask-restx) weakremover(python36-flatbuffers) weakremover(python36-flatdict) weakremover(python36-fleming) weakremover(python36-flex) weakremover(python36-flexmock) weakremover(python36-flexx) weakremover(python36-flickrapi) weakremover(python36-flit) weakremover(python36-flit-core) weakremover(python36-flower) weakremover(python36-fluent) weakremover(python36-flufl.bounce) weakremover(python36-flufl.i18n) weakremover(python36-flufl.lock) weakremover(python36-flufl.testing) weakremover(python36-fluidity-sm) weakremover(python36-flup) weakremover(python36-folium) weakremover(python36-fontMath) weakremover(python36-fontParts) weakremover(python36-fontPens) weakremover(python36-forbiddenfruit) weakremover(python36-formats) weakremover(python36-freeipa) weakremover(python36-freetype-py) weakremover(python36-freezegun) weakremover(python36-fritzconnection) weakremover(python36-frozendict) weakremover(python36-frozenlist) weakremover(python36-fs) weakremover(python36-fsspec) weakremover(python36-ftfy) weakremover(python36-ftputil) weakremover(python36-fudge) weakremover(python36-funcparserlib) weakremover(python36-funcy) weakremover(python36-furl) weakremover(python36-fuse) weakremover(python36-fusepy) weakremover(python36-future) weakremover(python36-fuzzywuzzy) weakremover(python36-fysom) weakremover(python36-gTTS) weakremover(python36-gTTS-token) weakremover(python36-gast) weakremover(python36-gcsfs) weakremover(python36-gcsfs-fuse) weakremover(python36-gear) weakremover(python36-ged4py) weakremover(python36-genfire) weakremover(python36-genson) weakremover(python36-genty) weakremover(python36-geographiclib) weakremover(python36-geoip2) weakremover(python36-geojson) weakremover(python36-geolib) weakremover(python36-geolinks) weakremover(python36-geomdl) weakremover(python36-geomet) weakremover(python36-geopy) weakremover(python36-getmac) weakremover(python36-gevent) weakremover(python36-geventhttpclient) weakremover(python36-ggplot) weakremover(python36-ghp-import) weakremover(python36-gi-docgen) weakremover(python36-girder-client) weakremover(python36-git-pw) weakremover(python36-git-url-parse) weakremover(python36-gitdb) weakremover(python36-github3.py) weakremover(python36-gitlint) weakremover(python36-glean) weakremover(python36-glfw) weakremover(python36-glob2) weakremover(python36-gmpy) weakremover(python36-gmpy2) weakremover(python36-gns3fy) weakremover(python36-gobject) weakremover(python36-gobject-Gdk) weakremover(python36-gobject-cairo) weakremover(python36-gobject-devel) weakremover(python36-goobook) weakremover(python36-google-api-core) weakremover(python36-google-api-python-client) weakremover(python36-google-auth) weakremover(python36-google-auth-httplib2) weakremover(python36-google-auth-oauthlib) weakremover(python36-google-cloud-core) weakremover(python36-google-cloud-kms) weakremover(python36-google-cloud-speech) weakremover(python36-google-cloud-storage) weakremover(python36-google-cloud-translate) weakremover(python36-google-crc32c) weakremover(python36-google-filesystem) weakremover(python36-google-pasta) weakremover(python36-google-resumable-media) weakremover(python36-googleapis-common-protos) weakremover(python36-googlemaps) weakremover(python36-gpg) weakremover(python36-gpgme) weakremover(python36-gphoto2) weakremover(python36-gprof2dot) weakremover(python36-gps3) weakremover(python36-gpxpy) weakremover(python36-grab) weakremover(python36-graphene) weakremover(python36-graphene-django) weakremover(python36-graphql-core) weakremover(python36-graphql-relay) weakremover(python36-graphviz) weakremover(python36-greenlet) weakremover(python36-greenlet-devel) weakremover(python36-grpc-google-iam-v1) weakremover(python36-grpcio) weakremover(python36-grpcio-gcp) weakremover(python36-grpcio-tools) weakremover(python36-gscholar) weakremover(python36-gsm0338) weakremover(python36-gspread) weakremover(python36-gssapi) weakremover(python36-gst) weakremover(python36-gsw) weakremover(python36-guessit) weakremover(python36-gunicorn) weakremover(python36-guzzle_sphinx_theme) weakremover(python36-gvm-tools) weakremover(python36-gwdatafind) weakremover(python36-gwosc) weakremover(python36-gwyfile) weakremover(python36-gyp) weakremover(python36-h11) weakremover(python36-h2) weakremover(python36-h5py) weakremover(python36-h5py-openmpi1) weakremover(python36-h5py-openmpi2) weakremover(python36-h5py-openmpi3) weakremover(python36-h5py-openmpi4) weakremover(python36-hammett) weakremover(python36-hankel) weakremover(python36-hanzidentifier) weakremover(python36-happybase) weakremover(python36-haproxyctl) weakremover(python36-hashids) weakremover(python36-hatch) weakremover(python36-hawkauthlib) weakremover(python36-hcloud) weakremover(python36-helpdev) weakremover(python36-hepunits) weakremover(python36-hetzner) weakremover(python36-hetznercloud) weakremover(python36-hexdump) weakremover(python36-hide-code) weakremover(python36-hijri-converter) weakremover(python36-hiredis) weakremover(python36-hkdf) weakremover(python36-hl7apy) weakremover(python36-holidays) weakremover(python36-holoviews) weakremover(python36-hotdoc) weakremover(python36-hpack) weakremover(python36-hstspreload) weakremover(python36-html2text) weakremover(python36-html5-parser) weakremover(python36-html5lib) weakremover(python36-htmlmin) weakremover(python36-httmock) weakremover(python36-http-ece) weakremover(python36-http-parser) weakremover(python36-httpbin) weakremover(python36-httplib2) weakremover(python36-httpretty) weakremover(python36-httpsig_cffi) weakremover(python36-httptools) weakremover(python36-humanfriendly) weakremover(python36-humanhash3) weakremover(python36-humanize) weakremover(python36-humanreadable) weakremover(python36-hunter) weakremover(python36-hupper) weakremover(python36-husl) weakremover(python36-hvac) weakremover(python36-hvplot) weakremover(python36-hyper) weakremover(python36-hyperframe) weakremover(python36-hyperlink) weakremover(python36-hypothesis) weakremover(python36-hypothesis-auto) weakremover(python36-hypothesis-fspaths) weakremover(python36-hypothesmith) weakremover(python36-i3ipc) weakremover(python36-icalendar) weakremover(python36-identify) weakremover(python36-idle) weakremover(python36-idna) weakremover(python36-idna_ssl) weakremover(python36-ifaddr) weakremover(python36-ifconfig-parser) weakremover(python36-ijson) weakremover(python36-imagecodecs) weakremover(python36-imageio) weakremover(python36-imageio-ffmpeg) weakremover(python36-imagesize) weakremover(python36-imbox) weakremover(python36-img2pdf) weakremover(python36-iminuit) weakremover(python36-immutables) weakremover(python36-impacket) weakremover(python36-importlab) weakremover(python36-importlib-metadata) weakremover(python36-importlib-resources) weakremover(python36-imread) weakremover(python36-imreg) weakremover(python36-incremental) weakremover(python36-infinity) weakremover(python36-inflect) weakremover(python36-inflection) weakremover(python36-iniconfig) weakremover(python36-inifile) weakremover(python36-iniparse) weakremover(python36-injector) weakremover(python36-intake) weakremover(python36-interrogate) weakremover(python36-intervals) weakremover(python36-intervaltree) weakremover(python36-invocations) weakremover(python36-invoke) weakremover(python36-iocapture) weakremover(python36-ipaddr) weakremover(python36-ipdb) weakremover(python36-iptables) weakremover(python36-ipy) weakremover(python36-ipydatawidgets) weakremover(python36-ipyevents) weakremover(python36-ipykernel) weakremover(python36-ipykernel5) weakremover(python36-ipyleaflet) weakremover(python36-ipympl) weakremover(python36-ipyparallel) weakremover(python36-ipyscales) weakremover(python36-ipysheet) weakremover(python36-ipython715) weakremover(python36-ipython715-iptest) weakremover(python36-ipython_genutils) weakremover(python36-ipyvolume) weakremover(python36-ipywebrtc) weakremover(python36-ipywidgets) weakremover(python36-irc) weakremover(python36-isc_dhcp_leases) weakremover(python36-iso3166) weakremover(python36-iso8601) weakremover(python36-isodate) weakremover(python36-isort) weakremover(python36-itemadapter) weakremover(python36-itemloaders) weakremover(python36-itsdangerous) weakremover(python36-itypes) weakremover(python36-iwlib) weakremover(python36-j2gen) weakremover(python36-jaraco.base) weakremover(python36-jaraco.classes) weakremover(python36-jaraco.collections) weakremover(python36-jaraco.context) weakremover(python36-jaraco.envs) weakremover(python36-jaraco.functools) weakremover(python36-jaraco.itertools) weakremover(python36-jaraco.logging) weakremover(python36-jaraco.packaging) weakremover(python36-jaraco.path) weakremover(python36-jaraco.stream) weakremover(python36-jaraco.text) weakremover(python36-javapackages) weakremover(python36-javaproperties) weakremover(python36-jdatetime) weakremover(python36-jdcal) weakremover(python36-jedi) weakremover(python36-jedihttp) weakremover(python36-jeepney) weakremover(python36-jellyfish) weakremover(python36-jenkinsapi) weakremover(python36-jfscripts) weakremover(python36-jgraph) weakremover(python36-jinja2-fsloader) weakremover(python36-jinja2-pluralize) weakremover(python36-jinja2-time) weakremover(python36-jira) weakremover(python36-jirafs) weakremover(python36-jmespath) weakremover(python36-joblib) weakremover(python36-josepy) weakremover(python36-jplephem) weakremover(python36-jsbeautifier) weakremover(python36-jsmin) weakremover(python36-json-rpc) weakremover(python36-json5) weakremover(python36-json_tricks) weakremover(python36-jsondate) weakremover(python36-jsondiff) weakremover(python36-jsonextended) weakremover(python36-jsonlib-python3) weakremover(python36-jsonlines) weakremover(python36-jsonpatch) weakremover(python36-jsonpath-ng) weakremover(python36-jsonpath-rw) weakremover(python36-jsonpickle) weakremover(python36-jsonpointer) weakremover(python36-jsonref) weakremover(python36-jsonrpclib-pelix) weakremover(python36-jsonschema) weakremover(python36-jsonslicer) weakremover(python36-jsonxs) weakremover(python36-junit-xml) weakremover(python36-junitxml) weakremover(python36-junos-eznc) weakremover(python36-jupyter) weakremover(python36-jupyter-client) weakremover(python36-jupyter-contrib-nbextensions) weakremover(python36-jupyter-core) weakremover(python36-jupyter-datatables) weakremover(python36-jupyter-jupyterlab-server) weakremover(python36-jupyter-jupyterlab-server-test) weakremover(python36-jupyter-nbutils) weakremover(python36-jupyter-packaging) weakremover(python36-jupyter-protocol) weakremover(python36-jupyter-require) weakremover(python36-jupyter-server) weakremover(python36-jupyter-server-mathjax) weakremover(python36-jupyter-server-test) weakremover(python36-jupyter-sphinx) weakremover(python36-jupyter-telemetry) weakremover(python36-jupyter_console) weakremover(python36-jupyter_contrib_core) weakremover(python36-jupyter_highlight_selected_word) weakremover(python36-jupyter_kernel_test) weakremover(python36-jupyter_latex_envs) weakremover(python36-jupyter_nbextensions_configurator) weakremover(python36-jupyterlab) weakremover(python36-jupyterlab-pygments) weakremover(python36-jupyterlab-templates) weakremover(python36-jupyterlab-widgets) weakremover(python36-jupytext) weakremover(python36-jwcrypto) weakremover(python36-k5test) weakremover(python36-kafka-python) weakremover(python36-kaitaistruct) weakremover(python36-kazoo) weakremover(python36-keepalive) weakremover(python36-kerberos) weakremover(python36-keyczar) weakremover(python36-keylime) weakremover(python36-keyring) weakremover(python36-keyring-keyutils) weakremover(python36-keyrings.alt) weakremover(python36-kismet-rest) weakremover(python36-kismetdb) weakremover(python36-kiss-headers) weakremover(python36-kitchen) weakremover(python36-kiwisolver) weakremover(python36-kmatch) weakremover(python36-kmod) weakremover(python36-knack) weakremover(python36-kombu) weakremover(python36-korean-lunar-calendar) weakremover(python36-kubernetes) weakremover(python36-kwant) weakremover(python36-l20n) weakremover(python36-labelImg) weakremover(python36-labels) weakremover(python36-lal) weakremover(python36-lalframe) weakremover(python36-lancet-ioam) weakremover(python36-langdetect) weakremover(python36-langtable) weakremover(python36-language-check) weakremover(python36-lark-parser) weakremover(python36-latexcodec) weakremover(python36-lazr.config) weakremover(python36-lazr.delegates) weakremover(python36-lazr.uri) weakremover(python36-lazy) weakremover(python36-lazy-object-proxy) weakremover(python36-lazyarray) weakremover(python36-ldap) weakremover(python36-ldap3) weakremover(python36-ldapdomaindump) weakremover(python36-ldappool) weakremover(python36-ldaptor) weakremover(python36-ldas-tools-al-swig) weakremover(python36-leather) weakremover(python36-lesscpy) weakremover(python36-leveldb) weakremover(python36-lexicon) weakremover(python36-lfdfiles) weakremover(python36-lhafile) weakremover(python36-lib3to6) weakremover(python36-libarchive) weakremover(python36-libarchive-c) weakremover(python36-libcst) weakremover(python36-libevdev) weakremover(python36-libkdumpfile) weakremover(python36-liblarch) weakremover(python36-liblarch-gtk) weakremover(python36-libnacl) weakremover(python36-libpfm) weakremover(python36-librosa) weakremover(python36-librouteros) weakremover(python36-libsass) weakremover(python36-libusb1) weakremover(python36-libvirt-python) weakremover(python36-libxml2) weakremover(python36-license-expression) weakremover(python36-ligo-segments) weakremover(python36-ligotimegps) weakremover(python36-limnoria) weakremover(python36-line_profiler) weakremover(python36-linecache2) weakremover(python36-lineup-widget) weakremover(python36-link-traits) weakremover(python36-linstor) weakremover(python36-linstor-client) weakremover(python36-linux-procfs) weakremover(python36-lit) weakremover(python36-livereload) weakremover(python36-llfuse) weakremover(python36-llvmlite) weakremover(python36-lmdb) weakremover(python36-lmfit) weakremover(python36-lml) weakremover(python36-localzone) weakremover(python36-locket) weakremover(python36-lockfile) weakremover(python36-logilab-common) weakremover(python36-loguru) weakremover(python36-logutils) weakremover(python36-logzero) weakremover(python36-lscsoft-glue) weakremover(python36-lupa) weakremover(python36-lws) weakremover(python36-lxml) weakremover(python36-lxml-devel) weakremover(python36-lz4) weakremover(python36-lzmaffi) weakremover(python36-m2r) weakremover(python36-macholib) weakremover(python36-magic) weakremover(python36-magic-wormhole) weakremover(python36-magic-wormhole-mailbox-server) weakremover(python36-magic-wormhole-transit-relay) weakremover(python36-magicalimport) weakremover(python36-mailman3-fedmsg-plugin) weakremover(python36-main-wrapper) weakremover(python36-makefun) weakremover(python36-managesieve) weakremover(python36-mando) weakremover(python36-manuel) weakremover(python36-manuel-doc) weakremover(python36-marathon) weakremover(python36-markdown-math) weakremover(python36-markdown2) weakremover(python36-marshmallow) weakremover(python36-marshmallow-enum) weakremover(python36-matplotlib) weakremover(python36-matplotlib-cairo) weakremover(python36-matplotlib-gtk3) weakremover(python36-matplotlib-latex) weakremover(python36-matplotlib-qt5) weakremover(python36-matplotlib-testdata) weakremover(python36-matplotlib-tk) weakremover(python36-matplotlib-web) weakremover(python36-matplotlib-wx) weakremover(python36-maturin) weakremover(python36-mautrix) weakremover(python36-maxminddb) weakremover(python36-mbstrdecoder) weakremover(python36-mccabe) weakremover(python36-md2workflow) weakremover(python36-md2workflow-plugins-jira) weakremover(python36-md2workflow-plugins-redmine) weakremover(python36-mechanize) weakremover(python36-meld3) weakremover(python36-memory_profiler) weakremover(python36-mergedeep) weakremover(python36-metaextract) weakremover(python36-metakernel) weakremover(python36-metamagic.json) weakremover(python36-methodtools) weakremover(python36-mimesis) weakremover(python36-minidb) weakremover(python36-minio) weakremover(python36-miniupnpc) weakremover(python36-misaka) weakremover(python36-missingno) weakremover(python36-mistune) weakremover(python36-mkdocs) weakremover(python36-mkdocs-bootstrap) weakremover(python36-moban) weakremover(python36-moban-ansible) weakremover(python36-mobi) weakremover(python36-mock) weakremover(python36-mock-open) weakremover(python36-mocket) weakremover(python36-mockito) weakremover(python36-mockldap) weakremover(python36-model-bakery) weakremover(python36-modernize) weakremover(python36-mohawk) weakremover(python36-moksha-common) weakremover(python36-moksha-hub) weakremover(python36-mongoengine) weakremover(python36-monotonic) weakremover(python36-more-itertools) weakremover(python36-moreorless) weakremover(python36-moretools) weakremover(python36-moto) weakremover(python36-moto-all) weakremover(python36-moto-server) weakremover(python36-mpi4py) weakremover(python36-mpi4py-devel) weakremover(python36-mplcursors) weakremover(python36-mpmath) weakremover(python36-mrcz) weakremover(python36-mrkd) weakremover(python36-msal) weakremover(python36-msal-extensions) weakremover(python36-msgpack) weakremover(python36-msgpack-numpy) weakremover(python36-msk) weakremover(python36-msm) weakremover(python36-msoffcrypto-tool) weakremover(python36-msrest) weakremover(python36-msrestazure) weakremover(python36-mss) weakremover(python36-mujson) weakremover(python36-mulpyplexer) weakremover(python36-multi_key_dict) weakremover(python36-multidict) weakremover(python36-multipledispatch) weakremover(python36-munch) weakremover(python36-munkres) weakremover(python36-musicbrainzngs) weakremover(python36-mutagen) weakremover(python36-mutatorMath) weakremover(python36-mutt-ics) weakremover(python36-mygpoclient) weakremover(python36-mypy) weakremover(python36-mypy_extensions) weakremover(python36-mysql-connector-python) weakremover(python36-mysql-to-sqlite3) weakremover(python36-mysqlclient) weakremover(python36-nagiosplugin) weakremover(python36-napalm) weakremover(python36-napalm-arubaos-switch) weakremover(python36-napalm-asa) weakremover(python36-napalm-digineo-procurve) weakremover(python36-napalm-procurve) weakremover(python36-natsort) weakremover(python36-nautilus) weakremover(python36-nautilus-devel) weakremover(python36-nbclassic) weakremover(python36-nbclient) weakremover(python36-nbconvert) weakremover(python36-nbdime) weakremover(python36-nbformat) weakremover(python36-nbindex-jupyter) weakremover(python36-nbinteract) weakremover(python36-nbsmoke) weakremover(python36-nbsphinx) weakremover(python36-nbsphinx-link) weakremover(python36-nbval) weakremover(python36-nbxmpp) weakremover(python36-nbxmpp-doc) weakremover(python36-ncclient) weakremover(python36-ndg-httpsclient) weakremover(python36-neovim) weakremover(python36-neovim-remote) weakremover(python36-nest-asyncio) weakremover(python36-nested-lookup) weakremover(python36-net-snmp) weakremover(python36-netCDF4) weakremover(python36-netaddr) weakremover(python36-netifaces) weakremover(python36-netmiko) weakremover(python36-netpbmfile) weakremover(python36-networkx) weakremover(python36-nibabel) weakremover(python36-nilearn) weakremover(python36-nine) weakremover(python36-nltk) weakremover(python36-nocasedict) weakremover(python36-nocaselist) weakremover(python36-node-semver) weakremover(python36-nodeenv) weakremover(python36-nornir) weakremover(python36-nose) weakremover(python36-nose-cov) weakremover(python36-nose-cover3) weakremover(python36-nose-exclude) weakremover(python36-nose-progressive) weakremover(python36-nose-timer) weakremover(python36-nose2) weakremover(python36-nose_warnings_filters) weakremover(python36-nosexcover) weakremover(python36-notebook) weakremover(python36-notebook-lang) weakremover(python36-notify2) weakremover(python36-nox) weakremover(python36-npTDMS) weakremover(python36-nss) weakremover(python36-ntc-templates) weakremover(python36-ntfy) weakremover(python36-ntlm-auth) weakremover(python36-ntplib) weakremover(python36-num2words) weakremover(python36-numba) weakremover(python36-numba-devel) weakremover(python36-numcodecs) weakremover(python36-numericalunits) weakremover(python36-numexpr) weakremover(python36-numpy) weakremover(python36-numpy-devel) weakremover(python36-numpy-gnu-hpc) weakremover(python36-numpy-gnu-hpc-devel) weakremover(python36-numpy_1_19_5-gnu-hpc) weakremover(python36-numpy_1_19_5-gnu-hpc-devel) weakremover(python36-numpydoc) weakremover(python36-nwdiag) weakremover(python36-nxapi-plumbing) weakremover(python36-o2sclpy) weakremover(python36-oauth2) weakremover(python36-oauth2client) weakremover(python36-oauth2client-flask) weakremover(python36-oauth2client-gce) weakremover(python36-oauthlib) weakremover(python36-objgraph) weakremover(python36-oci-sdk) weakremover(python36-oct2py) weakremover(python36-octave-kernel) weakremover(python36-odfpy) weakremover(python36-odorik) weakremover(python36-ogr) weakremover(python36-oic) weakremover(python36-oiffile) weakremover(python36-oktaloginwrapper) weakremover(python36-olefile) weakremover(python36-oletools) weakremover(python36-olm) weakremover(python36-opcodes) weakremover(python36-openapi-codec) weakremover(python36-openapi-core) weakremover(python36-openapi-schema-validator) weakremover(python36-openapi-spec-validator) weakremover(python36-opencensus) weakremover(python36-opencensus-context) weakremover(python36-opencensus-ext-azure) weakremover(python36-opencensus-ext-threading) weakremover(python36-opengl) weakremover(python36-opengl-accelerate) weakremover(python36-openidc-client) weakremover(python36-openmesh) weakremover(python36-openpyxl) weakremover(python36-openqa_client) weakremover(python36-openqa_review) weakremover(python36-openstack.nose_plugin) weakremover(python36-opentelemetry-api) weakremover(python36-opentracing) weakremover(python36-openwrt-luci-rpc) weakremover(python36-opt-einsum) weakremover(python36-orange-canvas-core) weakremover(python36-orange-widget-base) weakremover(python36-ordered-namespace) weakremover(python36-ordered-set) weakremover(python36-orderedmultidict) weakremover(python36-osc-tiny) weakremover(python36-oscrypto) weakremover(python36-osmviz) weakremover(python36-ospd) weakremover(python36-ospd-openvas) weakremover(python36-outcome) weakremover(python36-ovirt-engine-sdk) weakremover(python36-pa-ringbuffer) weakremover(python36-packaging) weakremover(python36-padaos) weakremover(python36-padatious) weakremover(python36-paho-mqtt) weakremover(python36-pako) weakremover(python36-palettable) weakremover(python36-pamela) weakremover(python36-pampy) weakremover(python36-pamqp) weakremover(python36-pan-python) weakremover(python36-pandas) weakremover(python36-pandas-datareader) weakremover(python36-pandas-ext) weakremover(python36-pandocfilters) weakremover(python36-panel) weakremover(python36-panflute) weakremover(python36-papermill) weakremover(python36-parallax) weakremover(python36-param) weakremover(python36-parameterized) weakremover(python36-paramiko) weakremover(python36-paramiko-expect) weakremover(python36-parfive) weakremover(python36-parse) weakremover(python36-parse_type) weakremover(python36-parsedatetime) weakremover(python36-parsel) weakremover(python36-parsimonious) weakremover(python36-parso) weakremover(python36-parsy) weakremover(python36-partd) weakremover(python36-parted) weakremover(python36-particle) weakremover(python36-parver) weakremover(python36-pass_python_keyring) weakremover(python36-passa) weakremover(python36-passivetotal) weakremover(python36-passlib) weakremover(python36-pastel) weakremover(python36-pastream) weakremover(python36-patatt) weakremover(python36-patchy) weakremover(python36-path) weakremover(python36-pathlib) weakremover(python36-pathlib2) weakremover(python36-pathspec) weakremover(python36-pathtools) weakremover(python36-pathvalidate) weakremover(python36-patiencediff) weakremover(python36-patsy) weakremover(python36-pbkdf2) weakremover(python36-pbr) weakremover(python36-pcodedmp) weakremover(python36-pdd) weakremover(python36-pdfkit) weakremover(python36-pdfminer.six) weakremover(python36-pdfrw) weakremover(python36-pecan) weakremover(python36-peewee) weakremover(python36-pefile) weakremover(python36-pelican) weakremover(python36-pem) weakremover(python36-pendulum) weakremover(python36-pep517) weakremover(python36-pep8-naming) weakremover(python36-peppercorn) weakremover(python36-percy) weakremover(python36-perfume-bench) weakremover(python36-persistent) weakremover(python36-persistent-devel) weakremover(python36-petact) weakremover(python36-pexpect) weakremover(python36-pgmagick) weakremover(python36-phabricator) weakremover(python36-phonenumbers) weakremover(python36-phply) weakremover(python36-phue) weakremover(python36-physt) weakremover(python36-pick) weakremover(python36-pickleshare) weakremover(python36-pifpaf) weakremover(python36-pika) weakremover(python36-pika-pool) weakremover(python36-pikepdf) weakremover(python36-pilkit) weakremover(python36-pingparsing) weakremover(python36-pip) weakremover(python36-pip-api) weakremover(python36-pip-licenses) weakremover(python36-pip-shims) weakremover(python36-pip-test) weakremover(python36-pip-tools) weakremover(python36-pip-wheel) weakremover(python36-pipdeptree) weakremover(python36-pipreqs) weakremover(python36-pipx) weakremover(python36-pivy) weakremover(python36-pkgconfig) weakremover(python36-pkginfo) weakremover(python36-pkgutil-resolve-name) weakremover(python36-plaster) weakremover(python36-plaster-pastedeploy) weakremover(python36-platformdirs) weakremover(python36-platformio) weakremover(python36-plette) weakremover(python36-plotly) weakremover(python36-plotly-jupyter) weakremover(python36-pluggy) weakremover(python36-pluginbase) weakremover(python36-plumbum) weakremover(python36-ply) weakremover(python36-plyvel) weakremover(python36-pmw) weakremover(python36-pname) weakremover(python36-podcastparser) weakremover(python36-podman) weakremover(python36-poetry) weakremover(python36-poetry-core) weakremover(python36-polib) weakremover(python36-pomegranate) weakremover(python36-pomegranate-devel) weakremover(python36-pontos) weakremover(python36-pony) weakremover(python36-pooch) weakremover(python36-pook) weakremover(python36-poppler-qt5) weakremover(python36-poppler-qt5-devel) weakremover(python36-port-for) weakremover(python36-portalocker) weakremover(python36-portend) weakremover(python36-portpicker) weakremover(python36-positional) weakremover(python36-power) weakremover(python36-poyo) weakremover(python36-pprintpp) weakremover(python36-pproxy) weakremover(python36-praatio) weakremover(python36-pre-commit) weakremover(python36-precis-i18n) weakremover(python36-precise-runner) weakremover(python36-preggy) weakremover(python36-premailer) weakremover(python36-prestring) weakremover(python36-pretend) weakremover(python36-prettytable) weakremover(python36-proboscis) weakremover(python36-process-tests) weakremover(python36-proglog) weakremover(python36-progress) weakremover(python36-progressbar) weakremover(python36-progressbar2) weakremover(python36-prometheus-client) weakremover(python36-prometheus_client) weakremover(python36-promise) weakremover(python36-prompt_toolkit) weakremover(python36-prompt_toolkit1) weakremover(python36-proselint) weakremover(python36-proto-plus) weakremover(python36-protobuf) weakremover(python36-proton-client) weakremover(python36-protonvpn-nm-lib) weakremover(python36-proxy.py) weakremover(python36-psautohint) weakremover(python36-pscript) weakremover(python36-psutil) weakremover(python36-psychtoolbox) weakremover(python36-psycopg2) weakremover(python36-psycopg2cffi) weakremover(python36-ptpython) weakremover(python36-ptpython-ptipython) weakremover(python36-ptr) weakremover(python36-ptyprocess) weakremover(python36-publicsuffix) weakremover(python36-publicsuffix2) weakremover(python36-publicsuffixlist) weakremover(python36-pudb) weakremover(python36-pulsectl) weakremover(python36-pure-sasl) weakremover(python36-purl) weakremover(python36-py) weakremover(python36-py-cpuinfo) weakremover(python36-py-espeak-ng) weakremover(python36-py-moneyed) weakremover(python36-py-multihash) weakremover(python36-py-radix) weakremover(python36-py-ubjson) weakremover(python36-py-vapid) weakremover(python36-py2pack) weakremover(python36-py3c) weakremover(python36-py3dns) weakremover(python36-py3status) weakremover(python36-py7zr) weakremover(python36-pyDOE2) weakremover(python36-pyFFTW) weakremover(python36-pyLibravatar) weakremover(python36-pyModis) weakremover(python36-pyOCD) weakremover(python36-pyOpenSSL) weakremover(python36-pyPEG2) weakremover(python36-pyRFC3339) weakremover(python36-pyRXP) weakremover(python36-pyScss) weakremover(python36-pyVows) weakremover(python36-pyacoustid) weakremover(python36-pyaes) weakremover(python36-pyahocorasick) weakremover(python36-pyalsaaudio) weakremover(python36-pyaml) weakremover(python36-pyannotate) weakremover(python36-pyasn1) weakremover(python36-pyasn1-modules) weakremover(python36-pybars3) weakremover(python36-pybeam) weakremover(python36-pybind11) weakremover(python36-pybind11-devel) weakremover(python36-pyblake2) weakremover(python36-pybluez) weakremover(python36-pybtex) weakremover(python36-pybugz) weakremover(python36-pycairo) weakremover(python36-pycairo-devel) weakremover(python36-pycapnp) weakremover(python36-pycares) weakremover(python36-pycdio) weakremover(python36-pycha) weakremover(python36-pychm) weakremover(python36-pyclipper) weakremover(python36-pycocotools) weakremover(python36-pycodestyle) weakremover(python36-pycountry) weakremover(python36-pycparser) weakremover(python36-pycryptodome) weakremover(python36-pycryptodomex) weakremover(python36-pycsw) weakremover(python36-pyct) weakremover(python36-pycups) weakremover(python36-pycurl) weakremover(python36-pycxx) weakremover(python36-pycxx-devel) weakremover(python36-pydantic) weakremover(python36-pydash) weakremover(python36-pydata-google-auth) weakremover(python36-pydbus) weakremover(python36-pydenticon) weakremover(python36-pydicom) weakremover(python36-pydle) weakremover(python36-pydocstyle) weakremover(python36-pydocumentdb) weakremover(python36-pydot) weakremover(python36-pydot3) weakremover(python36-pydotplus) weakremover(python36-pydrive2) weakremover(python36-pydub) weakremover(python36-pydyf) weakremover(python36-pyeapi) weakremover(python36-pyee) weakremover(python36-pyelftools) weakremover(python36-pyemd) weakremover(python36-pyenchant) weakremover(python36-pyerfa) weakremover(python36-pyface) weakremover(python36-pyfakefs) weakremover(python36-pyfeyn) weakremover(python36-pyfiglet) weakremover(python36-pyflakes) weakremover(python36-pyftpdlib) weakremover(python36-pyfuse3) weakremover(python36-pygal) weakremover(python36-pygaljs) weakremover(python36-pygame) weakremover(python36-pygame-devel) weakremover(python36-pygerrit2) weakremover(python36-pygit2) weakremover(python36-pyglet) weakremover(python36-pygments-ansi-color) weakremover(python36-pygments-pytest) weakremover(python36-pygments-style-railscasts) weakremover(python36-pygn) weakremover(python36-pygraphviz) weakremover(python36-pyhcl) weakremover(python36-pyhibp) weakremover(python36-pyicumessageformat) weakremover(python36-pyinotify) weakremover(python36-pyjavaproperties) weakremover(python36-pyjokes) weakremover(python36-pyjsparser) weakremover(python36-pyjwkest) weakremover(python36-pykafka) weakremover(python36-pykeepass) weakremover(python36-pykerberos) weakremover(python36-pykickstart) weakremover(python36-pykwalify) weakremover(python36-pylama) weakremover(python36-pylast) weakremover(python36-pyleri) weakremover(python36-pylev) weakremover(python36-pylibacl) weakremover(python36-pyliblo) weakremover(python36-pyliblo-doc) weakremover(python36-pylibmc) weakremover(python36-pylineclip) weakremover(python36-pylint) weakremover(python36-pylons-sphinx-themes) weakremover(python36-pylru) weakremover(python36-pyls-black) weakremover(python36-pyls-spyder) weakremover(python36-pylsp-rope) weakremover(python36-pylsqpack) weakremover(python36-pylzma) weakremover(python36-pymacaroons) weakremover(python36-pymacaroons-pynacl) weakremover(python36-pymad) weakremover(python36-pymarc) weakremover(python36-pymavlink) weakremover(python36-pymediainfo) weakremover(python36-pymemcache) weakremover(python36-pymetar) weakremover(python36-pymilter) weakremover(python36-pymisp) weakremover(python36-pymol) weakremover(python36-pymongo) weakremover(python36-pympv) weakremover(python36-pymssql) weakremover(python36-pynamodb) weakremover(python36-pynetbox) weakremover(python36-pyngus) weakremover(python36-pynxos) weakremover(python36-pyo) weakremover(python36-pyocr) weakremover(python36-pyodbc) weakremover(python36-pyosf) weakremover(python36-pyotp) weakremover(python36-pyowm) weakremover(python36-pyp) weakremover(python36-pypandoc) weakremover(python36-pyparallel) weakremover(python36-pyparsing) weakremover(python36-pyperclip) weakremover(python36-pyperf) weakremover(python36-pypet) weakremover(python36-pypi-search) weakremover(python36-pypipegraph) weakremover(python36-pypiserver) weakremover(python36-pypng) weakremover(python36-pyppeteer) weakremover(python36-pyprel) weakremover(python36-pyprimes) weakremover(python36-pyproj) weakremover(python36-pypsexec) weakremover(python36-pypubsub) weakremover(python36-pypuppetdb) weakremover(python36-pyqt-builder) weakremover(python36-pyqtgraph) weakremover(python36-pyquery) weakremover(python36-pyrad) weakremover(python36-pyramid) weakremover(python36-pyramid-chameleon) weakremover(python36-pyramid-debugtoolbar) weakremover(python36-pyramid-mako) weakremover(python36-pyreadstat) weakremover(python36-pyroma) weakremover(python36-pyroomacoustics) weakremover(python36-pyroute2) weakremover(python36-pyrsistent) weakremover(python36-pysaml2) weakremover(python36-pyscard) weakremover(python36-pyscreenshot) weakremover(python36-pysendfile) weakremover(python36-pyserial) weakremover(python36-pysha3) weakremover(python36-pyshark) weakremover(python36-pyshould) weakremover(python36-pyshp) weakremover(python36-pysmb) weakremover(python36-pysmbc) weakremover(python36-pysmi) weakremover(python36-pysndfile) weakremover(python36-pysnmp) weakremover(python36-pysofaconventions) weakremover(python36-pysolr) weakremover(python36-pyspnego) weakremover(python36-pysrt) weakremover(python36-pyssim) weakremover(python36-pystache) weakremover(python36-pysvn) weakremover(python36-pytaglib) weakremover(python36-pyte) weakremover(python36-pytesseract) weakremover(python36-pytest) weakremover(python36-pytest-aiofiles) weakremover(python36-pytest-aiohttp) weakremover(python36-pytest-arraydiff) weakremover(python36-pytest-astropy) weakremover(python36-pytest-astropy-header) weakremover(python36-pytest-asyncio) weakremover(python36-pytest-attrib) weakremover(python36-pytest-base-url) weakremover(python36-pytest-bdd) weakremover(python36-pytest-benchmark) weakremover(python36-pytest-black) weakremover(python36-pytest-check-links) weakremover(python36-pytest-click) weakremover(python36-pytest-console-scripts) weakremover(python36-pytest-cov) weakremover(python36-pytest-curio) weakremover(python36-pytest-datadir) weakremover(python36-pytest-dependency) weakremover(python36-pytest-describe) weakremover(python36-pytest-django) weakremover(python36-pytest-djangoapp) weakremover(python36-pytest-doctestplus) weakremover(python36-pytest-dotenv) weakremover(python36-pytest-echo) weakremover(python36-pytest-env) weakremover(python36-pytest-error-for-skips) weakremover(python36-pytest-expect) weakremover(python36-pytest-filter-subpackage) weakremover(python36-pytest-fixture-config) weakremover(python36-pytest-flake8) weakremover(python36-pytest-flake8dir) weakremover(python36-pytest-flakes) weakremover(python36-pytest-flask) weakremover(python36-pytest-forked) weakremover(python36-pytest-freezegun) weakremover(python36-pytest-git) weakremover(python36-pytest-helpers-namespace) weakremover(python36-pytest-html) weakremover(python36-pytest-httpbin) weakremover(python36-pytest-httpserver) weakremover(python36-pytest-instafail) weakremover(python36-pytest-isort) weakremover(python36-pytest-json-report) weakremover(python36-pytest-lazy-fixture) weakremover(python36-pytest-listener) weakremover(python36-pytest-localserver) weakremover(python36-pytest-metadata) weakremover(python36-pytest-mock) weakremover(python36-pytest-mpi) weakremover(python36-pytest-mpl) weakremover(python36-pytest-mypy) weakremover(python36-pytest-openfiles) weakremover(python36-pytest-order) weakremover(python36-pytest-ordering) weakremover(python36-pytest-parallel) weakremover(python36-pytest-percent) weakremover(python36-pytest-plus) weakremover(python36-pytest-profiling) weakremover(python36-pytest-pycodestyle) weakremover(python36-pytest-pyramid-server) weakremover(python36-pytest-pythonpath) weakremover(python36-pytest-qt) weakremover(python36-pytest-random-order) weakremover(python36-pytest-randomly) weakremover(python36-pytest-relaxed) weakremover(python36-pytest-remotedata) weakremover(python36-pytest-reorder) weakremover(python36-pytest-repeat) weakremover(python36-pytest-rerunfailures) weakremover(python36-pytest-responsemock) weakremover(python36-pytest-runner) weakremover(python36-pytest-server-fixtures) weakremover(python36-pytest-services) weakremover(python36-pytest-shutil) weakremover(python36-pytest-socket) weakremover(python36-pytest-spec) weakremover(python36-pytest-sphinx) weakremover(python36-pytest-subtesthack) weakremover(python36-pytest-subtests) weakremover(python36-pytest-sugar) weakremover(python36-pytest-super-check) weakremover(python36-pytest-svn) weakremover(python36-pytest-testconfig) weakremover(python36-pytest-testinfra) weakremover(python36-pytest-timeout) weakremover(python36-pytest-tldr) weakremover(python36-pytest-toolbox) weakremover(python36-pytest-tornado) weakremover(python36-pytest-tornasync) weakremover(python36-pytest-translations) weakremover(python36-pytest-travis-fold) weakremover(python36-pytest-trio) weakremover(python36-pytest-twisted) weakremover(python36-pytest-vcr) weakremover(python36-pytest-verbose-parametrize) weakremover(python36-pytest-virtualenv) weakremover(python36-pytest-xdist) weakremover(python36-pytest-xprocess) weakremover(python36-pytest-xvfb) weakremover(python36-pytest5) weakremover(python36-python-afl) weakremover(python36-python-aiml) weakremover(python36-python-akismet) weakremover(python36-python-args) weakremover(python36-python-barcode) weakremover(python36-python-bidi) weakremover(python36-python-box) weakremover(python36-python-cjson) weakremover(python36-python-consul) weakremover(python36-python-coveralls) weakremover(python36-python-crfsuite) weakremover(python36-python-crontab) weakremover(python36-python-daemon) weakremover(python36-python-datamatrix) weakremover(python36-python-dateutil) weakremover(python36-python-dbusmock) weakremover(python36-python-docs-theme) weakremover(python36-python-dotenv) weakremover(python36-python-editor) weakremover(python36-python-engineio) weakremover(python36-python-fedora) weakremover(python36-python-for-android) weakremover(python36-python-gammu) weakremover(python36-python-gflags) weakremover(python36-python-gitlab) weakremover(python36-python-gnupg) weakremover(python36-python-gvm) weakremover(python36-python-jenkins) weakremover(python36-python-jose) weakremover(python36-python-json-logger) weakremover(python36-python-jsonrpc-server) weakremover(python36-python-jsonschema-objects) weakremover(python36-python-language-server) weakremover(python36-python-louvain) weakremover(python36-python-lsp-black) weakremover(python36-python-lsp-jsonrpc) weakremover(python36-python-lsp-server) weakremover(python36-python-lzo) weakremover(python36-python-magic) weakremover(python36-python-memcached) weakremover(python36-python-mimeparse) weakremover(python36-python-mpd2) weakremover(python36-python-mpv) weakremover(python36-python-multipart) weakremover(python36-python-nmap) weakremover(python36-python-openid-cla) weakremover(python36-python-openid-teams) weakremover(python36-python-pam) weakremover(python36-python-poppler) weakremover(python36-python-pptx) weakremover(python36-python-prctl) weakremover(python36-python-pseudorandom) weakremover(python36-python-ptrace) weakremover(python36-python-qdatamatrix) weakremover(python36-python-qpid-proton) weakremover(python36-python-qprogedit) weakremover(python36-python-rapidjson) weakremover(python36-python-redis-lock) weakremover(python36-python-redmine) weakremover(python36-python-rpm-spec) weakremover(python36-python-rtmidi) weakremover(python36-python-rtmidi-doc) weakremover(python36-python-slugify) weakremover(python36-python-snappy) weakremover(python36-python-socketio) weakremover(python36-python-socks) weakremover(python36-python-sofa) weakremover(python36-python-sql) weakremover(python36-python-stdnum) weakremover(python36-python-subunit) weakremover(python36-python-ternary) weakremover(python36-python-twitter) weakremover(python36-python-utils) weakremover(python36-python-vlc) weakremover(python36-python-whois) weakremover(python36-python-xlib) weakremover(python36-python-yubico) weakremover(python36-python3-openid) weakremover(python36-python3-saml) weakremover(python36-pythondialog) weakremover(python36-pythonfinder) weakremover(python36-pythonwhois) weakremover(python36-pythreejs) weakremover(python36-pytidylib) weakremover(python36-pytils) weakremover(python36-pytimeparse) weakremover(python36-pytlv) weakremover(python36-pytoml) weakremover(python36-pytools) weakremover(python36-pytricia) weakremover(python36-pytz) weakremover(python36-pytzdata) weakremover(python36-pyu2f) weakremover(python36-pyuca) weakremover(python36-pyudev) weakremover(python36-pyupgrade) weakremover(python36-pyusb) weakremover(python36-pyuv) weakremover(python36-pyux) weakremover(python36-pyvdr) weakremover(python36-pyvips) weakremover(python36-pyviz-comms) weakremover(python36-pyvmomi) weakremover(python36-pywal) weakremover(python36-pywbem) weakremover(python36-pywbemtools) weakremover(python36-pywebpush) weakremover(python36-pywinrm) weakremover(python36-pyxattr) weakremover(python36-pyxdg) weakremover(python36-pyyaml_env_tag) weakremover(python36-pyzmq) weakremover(python36-pyzmq-devel) weakremover(python36-pyzo) weakremover(python36-q) weakremover(python36-qet_tb_generator) weakremover(python36-qgrid) weakremover(python36-qrcode) weakremover(python36-qscintilla-qt5) weakremover(python36-qscintilla-qt5-sip) weakremover(python36-qstylizer) weakremover(python36-qsymm) weakremover(python36-qt3d-qt5) weakremover(python36-qt3d-qt5-api) weakremover(python36-qt3d-qt5-doc) weakremover(python36-qt3d-qt5-sip) weakremover(python36-qt5) weakremover(python36-qt5-devel) weakremover(python36-qt5-doc) weakremover(python36-qt5-quick3d) weakremover(python36-qt5-quick3d-devel) weakremover(python36-qt5-remoteobjects) weakremover(python36-qt5-remoteobjects-devel) weakremover(python36-qt5-sip) weakremover(python36-qtcharts-qt5) weakremover(python36-qtcharts-qt5-api) weakremover(python36-qtcharts-qt5-doc) weakremover(python36-qtcharts-qt5-sip) weakremover(python36-qtconsole) weakremover(python36-qtdatavis3d-qt5) weakremover(python36-qtdatavis3d-qt5-api) weakremover(python36-qtdatavis3d-qt5-doc) weakremover(python36-qtdatavis3d-qt5-sip) weakremover(python36-qtnetworkauth-qt5) weakremover(python36-qtnetworkauth-qt5-devel) weakremover(python36-qtwebengine-qt5) weakremover(python36-qtwebengine-qt5-api) weakremover(python36-qtwebengine-qt5-devel) weakremover(python36-qtwebengine-qt5-sip) weakremover(python36-quantities) weakremover(python36-quantum-blackbird) weakremover(python36-queuelib) weakremover(python36-quicktions) weakremover(python36-quimb) weakremover(python36-radexreader) weakremover(python36-radon) weakremover(python36-railroad-diagrams) weakremover(python36-random2) weakremover(python36-rarfile) weakremover(python36-rarfile-doc) weakremover(python36-ravello-sdk) weakremover(python36-raven) weakremover(python36-raven-aiohttp) weakremover(python36-rawkit) weakremover(python36-rcssmin) weakremover(python36-rdflib) weakremover(python36-re-assert) weakremover(python36-readme_renderer) weakremover(python36-readthedocs-sphinx-ext) weakremover(python36-rebulk) weakremover(python36-recommonmark) weakremover(python36-reconfigure) weakremover(python36-redbaron) weakremover(python36-redfish) weakremover(python36-redis) weakremover(python36-rednose) weakremover(python36-regex) weakremover(python36-relatorio) weakremover(python36-releases) weakremover(python36-remoto) weakremover(python36-rencode) weakremover(python36-reportlab) weakremover(python36-repoze.lru) weakremover(python36-repoze.sphinx.autointerface) weakremover(python36-repoze.who) weakremover(python36-requestbuilder) weakremover(python36-requests) weakremover(python36-requests-aws) weakremover(python36-requests-cache) weakremover(python36-requests-download) weakremover(python36-requests-file) weakremover(python36-requests-ftp) weakremover(python36-requests-futures) weakremover(python36-requests-gssapi) weakremover(python36-requests-hawk) weakremover(python36-requests-html) weakremover(python36-requests-kerberos) weakremover(python36-requests-mock) weakremover(python36-requests-oauthlib) weakremover(python36-requests-toolbelt) weakremover(python36-requests-unixsocket) weakremover(python36-requests_ntlm) weakremover(python36-requestsexceptions) weakremover(python36-requirements-detector) weakremover(python36-requirements-parser) weakremover(python36-requirementslib) weakremover(python36-requre) weakremover(python36-resampy) weakremover(python36-resolvelib) weakremover(python36-responses) weakremover(python36-restructuredtext_lint) weakremover(python36-restview) weakremover(python36-resultsdb_api) weakremover(python36-rethinkdb) weakremover(python36-retry) weakremover(python36-retry_decorator) weakremover(python36-retrying) weakremover(python36-retryrequests) weakremover(python36-rfc3986) weakremover(python36-rfc3987) weakremover(python36-rfc6555) weakremover(python36-rich) weakremover(python36-rise) weakremover(python36-rjsmin) weakremover(python36-rnginline) weakremover(python36-robot-detection) weakremover(python36-robotframework) weakremover(python36-roifile) weakremover(python36-rollbar) weakremover(python36-roman) weakremover(python36-rope) weakremover(python36-rpcq) weakremover(python36-rply) weakremover(python36-rpm) weakremover(python36-rpmfile) weakremover(python36-rpmlb) weakremover(python36-rpy2) weakremover(python36-rpyc) weakremover(python36-rq) weakremover(python36-rsa) weakremover(python36-rss2email) weakremover(python36-rst.linker) weakremover(python36-rstcheck) weakremover(python36-rt) weakremover(python36-rtslib-fb) weakremover(python36-ruamel.base) weakremover(python36-ruamel.std.argparse) weakremover(python36-ruamel.std.pathlib) weakremover(python36-ruamel.yaml) weakremover(python36-ruamel.yaml.clib) weakremover(python36-ruamel.yaml.cmd) weakremover(python36-ruamel.yaml.convert) weakremover(python36-ruffus) weakremover(python36-runthis-sphinxext) weakremover(python36-rustcfg) weakremover(python36-s3fs) weakremover(python36-s3transfer) weakremover(python36-sadisplay) weakremover(python36-samplerate) weakremover(python36-sane) weakremover(python36-sanlock) weakremover(python36-sarge) weakremover(python36-sas7bdat) weakremover(python36-sasl) weakremover(python36-sat-search) weakremover(python36-sat-stac) weakremover(python36-scales) weakremover(python36-scandir) weakremover(python36-schedule) weakremover(python36-schema) weakremover(python36-scikit-build) weakremover(python36-scikit-dsp-comm) weakremover(python36-scikit-hep-testdata) weakremover(python36-scikit-image) weakremover(python36-scikit-learn) weakremover(python36-scikit-sound) weakremover(python36-scikit-sparse) weakremover(python36-scipy) weakremover(python36-scour) weakremover(python36-scp) weakremover(python36-screeninfo) weakremover(python36-screenplain) weakremover(python36-scripttest) weakremover(python36-scrypt) weakremover(python36-scspell3k) weakremover(python36-sdnotify) weakremover(python36-seaborn) weakremover(python36-selection) weakremover(python36-selectors2) weakremover(python36-selenium) weakremover(python36-semanage) weakremover(python36-semantic_version) weakremover(python36-semver) weakremover(python36-sentry-sdk) weakremover(python36-seqdiag) weakremover(python36-serpent) weakremover(python36-serpy) weakremover(python36-serverfiles) weakremover(python36-service_identity) weakremover(python36-setproctitle) weakremover(python36-setupmeta) weakremover(python36-setuptools) weakremover(python36-setuptools-declarative-requirements) weakremover(python36-setuptools-git) weakremover(python36-setuptools-rust) weakremover(python36-setuptools-test) weakremover(python36-setuptools-version-command) weakremover(python36-setuptools-wheel) weakremover(python36-setuptools_scm) weakremover(python36-setuptools_scm_git_archive) weakremover(python36-sfs) weakremover(python36-sge-pygame) weakremover(python36-sgmllib3k) weakremover(python36-sgp4) weakremover(python36-sh) weakremover(python36-shaptools) weakremover(python36-shellingham) weakremover(python36-shijian) weakremover(python36-shinyutils) weakremover(python36-shodan) weakremover(python36-shortuuid) weakremover(python36-sidecar) weakremover(python36-sievelib) weakremover(python36-sigal) weakremover(python36-signedjson) weakremover(python36-simpleaudio) weakremover(python36-simplebayes) weakremover(python36-simpleeval) weakremover(python36-simplegeneric) weakremover(python36-simplejson) weakremover(python36-simplekml) weakremover(python36-single-version) weakremover(python36-singledispatch) weakremover(python36-siosocks) weakremover(python36-sip) weakremover(python36-sip-devel) weakremover(python36-sip4) weakremover(python36-sip4-devel) weakremover(python36-sip5-devel) weakremover(python36-sip6-devel) weakremover(python36-siphashc) weakremover(python36-six) weakremover(python36-sklearn-pandas) weakremover(python36-slackclient) weakremover(python36-sleekxmpp) weakremover(python36-slimit) weakremover(python36-slip) weakremover(python36-slip-dbus) weakremover(python36-slixmpp) weakremover(python36-slumber) weakremover(python36-smartypants) weakremover(python36-smbprotocol) weakremover(python36-smmap) weakremover(python36-smpplib) weakremover(python36-sniffio) weakremover(python36-snimpy) weakremover(python36-snowballstemmer) weakremover(python36-snuggs) weakremover(python36-social-auth-app-django) weakremover(python36-social-auth-core) weakremover(python36-socketIO-client-nexus) weakremover(python36-socketpool) weakremover(python36-softlayer) weakremover(python36-sorl-thumbnail) weakremover(python36-sortedcollections) weakremover(python36-sortedcontainers) weakremover(python36-sortinghat) weakremover(python36-sounddevice) weakremover(python36-soupsieve) weakremover(python36-sox) weakremover(python36-spake2) weakremover(python36-spark_parser) weakremover(python36-sparse) weakremover(python36-speaklater) weakremover(python36-spec) weakremover(python36-sphinx-argparse) weakremover(python36-sphinx-autodoc-typehints) weakremover(python36-sphinx-bootstrap-theme) weakremover(python36-sphinx-feature-classification) weakremover(python36-sphinx-inline-tabs) weakremover(python36-sphinx-issues) weakremover(python36-sphinx-jsonschema) weakremover(python36-sphinx-removed-in) weakremover(python36-sphinx-tabs) weakremover(python36-sphinx-testing) weakremover(python36-sphinx-version-warning) weakremover(python36-sphinx_press_theme) weakremover(python36-sphinx_rtd_theme) weakremover(python36-sphinxcontrib-actdiag) weakremover(python36-sphinxcontrib-apidoc) weakremover(python36-sphinxcontrib-applehelp) weakremover(python36-sphinxcontrib-asyncio) weakremover(python36-sphinxcontrib-autoprogram) weakremover(python36-sphinxcontrib-autoprogram-doc) weakremover(python36-sphinxcontrib-blockdiag) weakremover(python36-sphinxcontrib-copybutton) weakremover(python36-sphinxcontrib-devhelp) weakremover(python36-sphinxcontrib-documentedlist) weakremover(python36-sphinxcontrib-fulltoc) weakremover(python36-sphinxcontrib-github-alt) weakremover(python36-sphinxcontrib-htmlhelp) weakremover(python36-sphinxcontrib-httpdomain) weakremover(python36-sphinxcontrib-issuetracker) weakremover(python36-sphinxcontrib-jsmath) weakremover(python36-sphinxcontrib-newsfeed) weakremover(python36-sphinxcontrib-nwdiag) weakremover(python36-sphinxcontrib-pecanwsme) weakremover(python36-sphinxcontrib-plantuml) weakremover(python36-sphinxcontrib-programoutput) weakremover(python36-sphinxcontrib-qthelp) weakremover(python36-sphinxcontrib-seqdiag) weakremover(python36-sphinxcontrib-serializinghtml) weakremover(python36-sphinxcontrib-svg2pdfconverter) weakremover(python36-sphinxcontrib-trio) weakremover(python36-sphinxcontrib-websupport) weakremover(python36-sphinxext-opengraph) weakremover(python36-sphobjinv) weakremover(python36-spidev) weakremover(python36-spotipy) weakremover(python36-spyder-kernels) weakremover(python36-sqlalchemy-migrate) weakremover(python36-sqlite-fts4) weakremover(python36-sqlite3-to-mysql) weakremover(python36-sqlitedict) weakremover(python36-sqlparse) weakremover(python36-sqlsoup) weakremover(python36-srcinfo) weakremover(python36-ssdeep) weakremover(python36-sshpubkeys) weakremover(python36-sshtunnel) weakremover(python36-starlette) weakremover(python36-statsd) weakremover(python36-statsmodels) weakremover(python36-stem) weakremover(python36-stestr) weakremover(python36-stomp.py) weakremover(python36-stomper) weakremover(python36-straight-plugin) weakremover(python36-streamz) weakremover(python36-strict-rfc3339) weakremover(python36-strictyaml) weakremover(python36-stripe) weakremover(python36-structlog) weakremover(python36-subgrab) weakremover(python36-subliminal) weakremover(python36-subprocrunner) weakremover(python36-subscene-api) weakremover(python36-subst) weakremover(python36-suds-community) weakremover(python36-suds-jurko) weakremover(python36-suntime) weakremover(python36-sure) weakremover(python36-svglib) weakremover(python36-svgpathtools) weakremover(python36-svgwrite) weakremover(python36-svneverever) weakremover(python36-swapper) weakremover(python36-swifter) weakremover(python36-sybil) weakremover(python36-sympy) weakremover(python36-system_hotkey) weakremover(python36-systemd) weakremover(python36-tableauserverclient) weakremover(python36-tableprint) weakremover(python36-tables) weakremover(python36-tablib) weakremover(python36-tabpy) weakremover(python36-tabulate) weakremover(python36-tap.py) weakremover(python36-targetcli-fb) weakremover(python36-tasklib) weakremover(python36-taskw) weakremover(python36-tbb) weakremover(python36-tblib) weakremover(python36-tcolorpy) weakremover(python36-technicolor) weakremover(python36-telepot) weakremover(python36-telethon-session-sqlalchemy) weakremover(python36-template-remover) weakremover(python36-tempora) weakremover(python36-tenacity) weakremover(python36-tensorpac) weakremover(python36-termcolor) weakremover(python36-terminado) weakremover(python36-terminaltables) weakremover(python36-termstyle) weakremover(python36-tesserocr) weakremover(python36-test-server) weakremover(python36-testfixtures) weakremover(python36-testflo) weakremover(python36-testpath) weakremover(python36-testrepository) weakremover(python36-testresources) weakremover(python36-testscenarios) weakremover(python36-testsuite) weakremover(python36-testtools) weakremover(python36-text-unidecode) weakremover(python36-textX) weakremover(python36-textdistance) weakremover(python36-textfsm) weakremover(python36-textile) weakremover(python36-texttable) weakremover(python36-textwrap3) weakremover(python36-thLib) weakremover(python36-thespian) weakremover(python36-threadpoolctl) weakremover(python36-three-merge) weakremover(python36-threevis) weakremover(python36-thrift) weakremover(python36-thriftpy2) weakremover(python36-tifffile) weakremover(python36-time-machine) weakremover(python36-time-travel) weakremover(python36-timeout-decorator) weakremover(python36-tinyarray) weakremover(python36-tinycss2) weakremover(python36-tinydb) weakremover(python36-tinyrecord) weakremover(python36-tinyrpc) weakremover(python36-titlecase) weakremover(python36-tk) weakremover(python36-tkreadonly) weakremover(python36-tld) weakremover(python36-tldextract) weakremover(python36-tmx) weakremover(python36-tokenize-rt) weakremover(python36-toml) weakremover(python36-tomli) weakremover(python36-tomli-w) weakremover(python36-tomlkit) weakremover(python36-tools) weakremover(python36-toolz) weakremover(python36-toposort) weakremover(python36-topy) weakremover(python36-torch) weakremover(python36-torch-devel) weakremover(python36-torchvision) weakremover(python36-tornado) weakremover(python36-tornado4) weakremover(python36-tornado5) weakremover(python36-tornado6) weakremover(python36-toro) weakremover(python36-tortilla) weakremover(python36-towncrier) weakremover(python36-tox) weakremover(python36-tox-no-internet) weakremover(python36-tox-travis) weakremover(python36-tox-wheel) weakremover(python36-tpfd) weakremover(python36-tqdm) weakremover(python36-traceback2) weakremover(python36-traitlets) weakremover(python36-traits) weakremover(python36-traitsui) weakremover(python36-traittypes) weakremover(python36-transaction) weakremover(python36-transip) weakremover(python36-transitions) weakremover(python36-translate-toolkit) weakremover(python36-translation-finder) weakremover(python36-translationstring) weakremover(python36-translitcodec) weakremover(python36-treq) weakremover(python36-tri.declarative) weakremover(python36-tri.struct) weakremover(python36-trio) weakremover(python36-trustme) weakremover(python36-tsk) weakremover(python36-tvm) weakremover(python36-tweepy) weakremover(python36-twine) weakremover(python36-twitter.common.finagle-thrift) weakremover(python36-twitter.common.lang) weakremover(python36-twitter.common.rpc) weakremover(python36-twodict) weakremover(python36-twython) weakremover(python36-txWS) weakremover(python36-txZMQ) weakremover(python36-txaio) weakremover(python36-txt2tags) weakremover(python36-txtorcon) weakremover(python36-typed-ast) weakremover(python36-typedload) weakremover(python36-typeguard) weakremover(python36-typepy) weakremover(python36-typer) weakremover(python36-typing-inspect) weakremover(python36-typing_extensions) weakremover(python36-typogrify) weakremover(python36-tzlocal) weakremover(python36-u-msgpack-python) weakremover(python36-ua-parser) weakremover(python36-uamqp) weakremover(python36-ucsmsdk) weakremover(python36-ufoLib2) weakremover(python36-ufoProcessor) weakremover(python36-ufonormalizer) weakremover(python36-ujson) weakremover(python36-uncertainties) weakremover(python36-uncompyle6) weakremover(python36-unicodecsv) weakremover(python36-unicodedata2) weakremover(python36-unidiff) weakremover(python36-unify) weakremover(python36-uniseg) weakremover(python36-unittest-mixins) weakremover(python36-unittest-xml-reporting) weakremover(python36-unittest2pytest) weakremover(python36-unpaddedbase64) weakremover(python36-unsync) weakremover(python36-untokenize) weakremover(python36-unyt) weakremover(python36-uproot) weakremover(python36-uritemplate) weakremover(python36-uritools) weakremover(python36-url-normalize) weakremover(python36-urlextract) weakremover(python36-urlgrabber) weakremover(python36-urllib3) weakremover(python36-urwid) weakremover(python36-usbsdmux) weakremover(python36-user-agents) weakremover(python36-user_agent) weakremover(python36-userpath) weakremover(python36-uvicorn) weakremover(python36-uvloop) weakremover(python36-validate_email) weakremover(python36-validators) weakremover(python36-varint) weakremover(python36-varlink) weakremover(python36-vatnumber) weakremover(python36-vcrpy) weakremover(python36-vcver) weakremover(python36-vcversioner) weakremover(python36-vdirsyncer) weakremover(python36-vega) weakremover(python36-vega_datasets) weakremover(python36-venusian) weakremover(python36-venusian-doc) weakremover(python36-verboselogs) weakremover(python36-versioneer) weakremover(python36-versiontag) weakremover(python36-versiontools) weakremover(python36-vim-vint) weakremover(python36-vine) weakremover(python36-virtkey) weakremover(python36-virtualenv) weakremover(python36-virtualenv-clone) weakremover(python36-virtualenvwrapper) weakremover(python36-visitor) weakremover(python36-vistir) weakremover(python36-visvis) weakremover(python36-vncdotool) weakremover(python36-vobject) weakremover(python36-voila) weakremover(python36-volatile) weakremover(python36-voluptuous) weakremover(python36-voluptuous-serialize) weakremover(python36-vsts) weakremover(python36-vsts-cd-manager) weakremover(python36-vulkan) weakremover(python36-vulture) weakremover(python36-w3lib) weakremover(python36-wadllib) weakremover(python36-wafw00f) weakremover(python36-waitress) weakremover(python36-waitress-doc) weakremover(python36-wakeonlan) weakremover(python36-warlock) weakremover(python36-watchdog) weakremover(python36-watchdog-doc) weakremover(python36-watchgod) weakremover(python36-watermark) weakremover(python36-wcwidth) weakremover(python36-weasyprint) weakremover(python36-web.py) weakremover(python36-web_cache) weakremover(python36-webassets) weakremover(python36-webcolors) weakremover(python36-webencodings) weakremover(python36-weblate-language-data) weakremover(python36-weblate-schemas) weakremover(python36-weblib) weakremover(python36-webruntime) weakremover(python36-websocket-client) weakremover(python36-websockets) weakremover(python36-websockify) weakremover(python36-wfuzz) weakremover(python36-whatever) weakremover(python36-whatthepatch) weakremover(python36-wheel) weakremover(python36-wheezy.template) weakremover(python36-whichcraft) weakremover(python36-whitenoise) weakremover(python36-whois_similarity_distance) weakremover(python36-widgetsnbextension) weakremover(python36-wikipedia) weakremover(python36-wirerope) weakremover(python36-wiring) weakremover(python36-wmctrl) weakremover(python36-wolframalpha) weakremover(python36-wptools) weakremover(python36-wrapt) weakremover(python36-ws4py) weakremover(python36-wsaccel) weakremover(python36-wsgi_intercept) weakremover(python36-wsproto) weakremover(python36-wstools) weakremover(python36-wtf-peewee) weakremover(python36-wurlitzer) weakremover(python36-wxPython) weakremover(python36-wxPython-lang) weakremover(python36-xapian) weakremover(python36-xapian-haystack) weakremover(python36-xapp) weakremover(python36-xarray) weakremover(python36-xattr) weakremover(python36-xcffib) weakremover(python36-xdg) weakremover(python36-xdis) weakremover(python36-xdoctest) weakremover(python36-xerox) weakremover(python36-xhtml2pdf) weakremover(python36-xkbgroup) weakremover(python36-xkcdpass) weakremover(python36-xlrd) weakremover(python36-xlwt) weakremover(python36-xmldiff) weakremover(python36-xmlschema) weakremover(python36-xmlsec) weakremover(python36-xmltodict) weakremover(python36-xonsh) weakremover(python36-xpybutil) weakremover(python36-xsge_gui) weakremover(python36-xsge_lighting) weakremover(python36-xsge_particle) weakremover(python36-xsge_path) weakremover(python36-xsge_physics) weakremover(python36-xsge_tiled) weakremover(python36-xsge_tmx) weakremover(python36-xvfbwrapper) weakremover(python36-xxhash) weakremover(python36-yacron) weakremover(python36-yafe) weakremover(python36-yamldoc) weakremover(python36-yamllint) weakremover(python36-yamlloader) weakremover(python36-yapf) weakremover(python36-yara) weakremover(python36-yarb) weakremover(python36-yarg) weakremover(python36-yarl) weakremover(python36-yaspin) weakremover(python36-yaswfp) weakremover(python36-yg.lockfile) weakremover(python36-youtube-dl) weakremover(python36-yq) weakremover(python36-yt) weakremover(python36-zake) weakremover(python36-zarr) weakremover(python36-zc.buildout) weakremover(python36-zc.customdoctests) weakremover(python36-zc.lockfile) weakremover(python36-zdaemon) weakremover(python36-zeep) weakremover(python36-zeroconf) weakremover(python36-zetup) weakremover(python36-zhon) weakremover(python36-zict) weakremover(python36-zignal) weakremover(python36-zipp) weakremover(python36-zipstream) weakremover(python36-zodbpickle) weakremover(python36-zope.cachedescriptors) weakremover(python36-zope.component) weakremover(python36-zope.configuration) weakremover(python36-zope.copy) weakremover(python36-zope.deferredimport) weakremover(python36-zope.deprecation) weakremover(python36-zope.event) weakremover(python36-zope.exceptions) weakremover(python36-zope.hookable) weakremover(python36-zope.i18nmessageid) weakremover(python36-zope.interface) weakremover(python36-zope.location) weakremover(python36-zope.proxy) weakremover(python36-zope.proxy-devel) weakremover(python36-zope.schema) weakremover(python36-zope.security) weakremover(python36-zope.testbrowser) weakremover(python36-zope.testbrowser-test) weakremover(python36-zope.testing) weakremover(python36-zope.testrunner) weakremover(python36-zopfli) weakremover(python36-zstandard) weakremover(python36-zstd) weakremover(python36-zxcvbn) weakremover(python36-zypp-plugin) weakremover(python38) weakremover(python38-APScheduler) weakremover(python38-AnyQt) weakremover(python38-Arpeggio) weakremover(python38-Authlib) weakremover(python38-Automat) weakremover(python38-BTrees) weakremover(python38-BTrees-devel) weakremover(python38-Babel) weakremover(python38-Beaker) weakremover(python38-BitVector) weakremover(python38-Bottleneck) weakremover(python38-Brotli) weakremover(python38-CCColUtils) weakremover(python38-CacheControl) weakremover(python38-CairoSVG) weakremover(python38-Cerberus) weakremover(python38-Chameleon) weakremover(python38-Cheetah3) weakremover(python38-CherryPy) weakremover(python38-CommonMark) weakremover(python38-ConfigArgParse) weakremover(python38-ConfigUpdater) weakremover(python38-Cycler) weakremover(python38-Cython) weakremover(python38-Cython3) weakremover(python38-DataProperty) weakremover(python38-DataShape) weakremover(python38-DateTime) weakremover(python38-Delorean) weakremover(python38-Deprecated) weakremover(python38-Django) weakremover(python38-Dumper) weakremover(python38-Durus) weakremover(python38-EasyProcess) weakremover(python38-EditorConfig) weakremover(python38-ExifRead) weakremover(python38-Fabric) weakremover(python38-Faker) weakremover(python38-Fiona) weakremover(python38-Flask) weakremover(python38-Flask-Admin) weakremover(python38-Flask-Babel) weakremover(python38-Flask-BabelEx) weakremover(python38-Flask-Bootstrap) weakremover(python38-Flask-Caching) weakremover(python38-Flask-Compress) weakremover(python38-Flask-Cors) weakremover(python38-Flask-Gravatar) weakremover(python38-Flask-HTMLmin) weakremover(python38-Flask-HTTPAuth) weakremover(python38-Flask-Login) weakremover(python38-Flask-Mail) weakremover(python38-Flask-Mailman) weakremover(python38-Flask-Migrate) weakremover(python38-Flask-Paranoid) weakremover(python38-Flask-Principal) weakremover(python38-Flask-RESTful) weakremover(python38-Flask-RSTPages) weakremover(python38-Flask-SQLAlchemy) weakremover(python38-Flask-Script) weakremover(python38-Flask-Security-Too) weakremover(python38-Flask-SocketIO) weakremover(python38-Flask-Testing) weakremover(python38-Flask-WTF) weakremover(python38-Flask-doc) weakremover(python38-FontTools) weakremover(python38-FormEncode) weakremover(python38-Genshi) weakremover(python38-GitPython) weakremover(python38-Glances) weakremover(python38-Gloo) weakremover(python38-Glymur) weakremover(python38-GooCalendar) weakremover(python38-GooseMPL) weakremover(python38-GridDataFormats) weakremover(python38-HTTPolice) weakremover(python38-HeapDict) weakremover(python38-HepMC) weakremover(python38-HyperKitty) weakremover(python38-IMAPClient) weakremover(python38-IMDbPY) weakremover(python38-JPype1) weakremover(python38-Jinja2) weakremover(python38-Js2Py) weakremover(python38-JsonWeb) weakremover(python38-Kajiki) weakremover(python38-Keras-Applications) weakremover(python38-Keras-Preprocessing) weakremover(python38-Kivy) weakremover(python38-Kivy-devel) weakremover(python38-LHAPDF) weakremover(python38-LTTL) weakremover(python38-Lektor) weakremover(python38-Levenshtein) weakremover(python38-Logbook) weakremover(python38-M2Crypto) weakremover(python38-Mako) weakremover(python38-Markdown) weakremover(python38-MarkupPy) weakremover(python38-MarkupSafe) weakremover(python38-Markups) weakremover(python38-Mathics) weakremover(python38-Mathics-Scanner) weakremover(python38-MechanicalSoup) weakremover(python38-Ming) weakremover(python38-MiniMock) weakremover(python38-Morfessor) weakremover(python38-MouseInfo) weakremover(python38-MulticoreTSNE) weakremover(python38-Nuitka) weakremover(python38-OSMPythonTools) weakremover(python38-OWSLib) weakremover(python38-PGet) weakremover(python38-PTable) weakremover(python38-Pallets-Sphinx-Themes) weakremover(python38-Parsley) weakremover(python38-Paste) weakremover(python38-PasteDeploy) weakremover(python38-Paver) weakremover(python38-PeakUtils) weakremover(python38-Pebble) weakremover(python38-Pillow) weakremover(python38-Pillow-tk) weakremover(python38-Pint) weakremover(python38-PrettyTable) weakremover(python38-Protego) weakremover(python38-PsyLab) weakremover(python38-PubChemPy) weakremover(python38-Pweave) weakremover(python38-PyAudio) weakremover(python38-PyAutoGUI) weakremover(python38-PyBindGen) weakremover(python38-PyBrowserID) weakremover(python38-PyChart) weakremover(python38-PyChromecast) weakremover(python38-PyCondor) weakremover(python38-PyDispatcher) weakremover(python38-PyECLib) weakremover(python38-PyFxA) weakremover(python38-PyGetWindow) weakremover(python38-PyGithub) weakremover(python38-PyHamcrest) weakremover(python38-PyICU) weakremover(python38-PyInstaller) weakremover(python38-PyJWT) weakremover(python38-PyKMIP) weakremover(python38-PyLaTeX) weakremover(python38-PyMeeus) weakremover(python38-PyMeta3) weakremover(python38-PyMsgBox) weakremover(python38-PyMuPDF) weakremover(python38-PyMySQL) weakremover(python38-PyNaCl) weakremover(python38-PyNamecheap) weakremover(python38-PyOgg) weakremover(python38-PyOpenAL) weakremover(python38-PyPDF2) weakremover(python38-PyPDF3) weakremover(python38-PyPrind) weakremover(python38-PyPrint) weakremover(python38-PyQRCode) weakremover(python38-PyQt6) weakremover(python38-PyQt6-3D) weakremover(python38-PyQt6-3D-devel) weakremover(python38-PyQt6-Charts) weakremover(python38-PyQt6-Charts-devel) weakremover(python38-PyQt6-DataVisualization) weakremover(python38-PyQt6-DataVisualization-devel) weakremover(python38-PyQt6-NetworkAuth) weakremover(python38-PyQt6-NetworkAuth-devel) weakremover(python38-PyQt6-QScintilla) weakremover(python38-PyQt6-WebEngine) weakremover(python38-PyQt6-WebEngine-devel) weakremover(python38-PyQt6-devel) weakremover(python38-PyQt6-doc) weakremover(python38-PyQt6-sip) weakremover(python38-PyRIC) weakremover(python38-PyRSS2Gen) weakremover(python38-PyRect) weakremover(python38-PySDL2) weakremover(python38-PyScreeze) weakremover(python38-PySocks) weakremover(python38-PyTrie) weakremover(python38-PyTweening) weakremover(python38-PyVirtualDisplay) weakremover(python38-PyWavelets) weakremover(python38-PyWebDAV3) weakremover(python38-PyWebDAV3-GNUHealth) weakremover(python38-PyX) weakremover(python38-PyYAML) weakremover(python38-Pydap) weakremover(python38-Pygments) weakremover(python38-Pykka) weakremover(python38-Pympler) weakremover(python38-Pyphen) weakremover(python38-Pyro4) weakremover(python38-Pyro5) weakremover(python38-QDarkStyle) weakremover(python38-QR-Code-generator) weakremover(python38-Qt.py) weakremover(python38-QtAwesome) weakremover(python38-QtPy) weakremover(python38-QtPy-test) weakremover(python38-RegexOrder) weakremover(python38-Routes) weakremover(python38-Rtree) weakremover(python38-SPARQLWrapper) weakremover(python38-SQLAlchemy) weakremover(python38-SQLAlchemy-Utils) weakremover(python38-Scrapy) weakremover(python38-SecretStorage) weakremover(python38-Send2Trash) weakremover(python38-Shapely) weakremover(python38-SimpleWebSocketServer) weakremover(python38-SoundCard) weakremover(python38-SoundFile) weakremover(python38-SpeechRecognition) weakremover(python38-Sphinx) weakremover(python38-Sphinx-latex) weakremover(python38-Sphinx2) weakremover(python38-Sphinx2-latex) weakremover(python38-TagStats) weakremover(python38-Telethon) weakremover(python38-Tempita) weakremover(python38-TermRecord) weakremover(python38-Theano) weakremover(python38-Transplant) weakremover(python38-Trolly) weakremover(python38-Trololio) weakremover(python38-Twisted) weakremover(python38-Twisted-all_non_platform) weakremover(python38-Twisted-conch) weakremover(python38-Twisted-conch_nacl) weakremover(python38-Twisted-contextvars) weakremover(python38-Twisted-http2) weakremover(python38-Twisted-serial) weakremover(python38-Twisted-tls) weakremover(python38-TxSNI) weakremover(python38-URLObject) weakremover(python38-UkPostcodeParser) weakremover(python38-Unidecode) weakremover(python38-VyattaConfParser) weakremover(python38-WSGIProxy2) weakremover(python38-WSME) weakremover(python38-WTForms) weakremover(python38-WTForms-lang) weakremover(python38-Wand) weakremover(python38-WeasyPrint) weakremover(python38-WebOb) weakremover(python38-WebTest) weakremover(python38-Werkzeug) weakremover(python38-Whoosh) weakremover(python38-XStatic) weakremover(python38-XStatic-Angular-Schema-Form) weakremover(python38-XStatic-jQuery) weakremover(python38-XStatic-jquery-ui) weakremover(python38-XStatic-objectpath) weakremover(python38-XStatic-term.js) weakremover(python38-XStatic-tv4) weakremover(python38-XlsxWriter) weakremover(python38-Yapsy) weakremover(python38-ZConfig) weakremover(python38-ZConfig-doc) weakremover(python38-ZEO) weakremover(python38-ZODB) weakremover(python38-abclient) weakremover(python38-abimap) weakremover(python38-abimap-doc) weakremover(python38-abseil) weakremover(python38-accessible-pygments) weakremover(python38-acefile) weakremover(python38-acitoolkit) weakremover(python38-acme) weakremover(python38-acoular) weakremover(python38-actdiag) weakremover(python38-adal) weakremover(python38-adapt-parser) weakremover(python38-adblock) weakremover(python38-addict) weakremover(python38-aeidon) weakremover(python38-aenum) weakremover(python38-aesara) weakremover(python38-aexpect) weakremover(python38-afdko) weakremover(python38-affine) weakremover(python38-agate) weakremover(python38-agate-dbf) weakremover(python38-agate-excel) weakremover(python38-agate-lookup) weakremover(python38-agate-remote) weakremover(python38-agate-sql) weakremover(python38-agate-stats) weakremover(python38-aina) weakremover(python38-aiobotocore) weakremover(python38-aiodataloader) weakremover(python38-aiodns) weakremover(python38-aioeventlet) weakremover(python38-aiofiles) weakremover(python38-aioftp) weakremover(python38-aiohttp) weakremover(python38-aiohttp-jinja2) weakremover(python38-aiohttp-socks) weakremover(python38-aiohttp-theme) weakremover(python38-aiohttp_cors) weakremover(python38-aioitertools) weakremover(python38-aioquic) weakremover(python38-aioredis) weakremover(python38-aioresponses) weakremover(python38-aiorpcX) weakremover(python38-aiosignal) weakremover(python38-aiosmtpd) weakremover(python38-aiosmtplib) weakremover(python38-aiosqlite) weakremover(python38-aiostream) weakremover(python38-aiounittest) weakremover(python38-ajsonrpc) weakremover(python38-akismet) weakremover(python38-alabaster) weakremover(python38-aldjemy) weakremover(python38-alembic) weakremover(python38-allpairspy) weakremover(python38-alsa) weakremover(python38-altair) weakremover(python38-altair-widgets) weakremover(python38-altgraph) weakremover(python38-amqp) weakremover(python38-amqpstorm) weakremover(python38-ana) weakremover(python38-aniso8601) weakremover(python38-annoy) weakremover(python38-ansel) weakremover(python38-ansi2html) weakremover(python38-ansicolor) weakremover(python38-ansicolors) weakremover(python38-ansiwrap) weakremover(python38-antlr4-python3-runtime) weakremover(python38-anyascii) weakremover(python38-anyio) weakremover(python38-anyjson) weakremover(python38-anymarkup-core) weakremover(python38-apache-libcloud) weakremover(python38-apfel) weakremover(python38-apipkg) weakremover(python38-apiron) weakremover(python38-apns2) weakremover(python38-appdirs) weakremover(python38-application) weakremover(python38-applicationinsights) weakremover(python38-apptools) weakremover(python38-apsw) weakremover(python38-ara) weakremover(python38-arabic-reshaper) weakremover(python38-archmage) weakremover(python38-arf) weakremover(python38-argcomplete) weakremover(python38-argh) weakremover(python38-argon2-cffi) weakremover(python38-argon2-cffi-bindings) weakremover(python38-argparse-manpage) weakremover(python38-args) weakremover(python38-arrow) weakremover(python38-arviz) weakremover(python38-asciimatics) weakremover(python38-asciitree) weakremover(python38-asdf) weakremover(python38-asdf-astropy) weakremover(python38-asdf-coordinates-schemas) weakremover(python38-asdf-standard) weakremover(python38-asdf-transform-schemas) weakremover(python38-asdf-wcs-schemas) weakremover(python38-ase) weakremover(python38-asgiref) weakremover(python38-asn1crypto) weakremover(python38-aspectlib) weakremover(python38-aspy.yaml) weakremover(python38-ast-decompiler) weakremover(python38-asteval) weakremover(python38-astor) weakremover(python38-astral) weakremover(python38-astroid) weakremover(python38-astropy) weakremover(python38-astropy-healpix) weakremover(python38-astropy-helpers) weakremover(python38-asttokens) weakremover(python38-astunparse) weakremover(python38-asv) weakremover(python38-async_generator) weakremover(python38-async_timeout) weakremover(python38-asyncclick) weakremover(python38-asyncpg) weakremover(python38-asyncssh) weakremover(python38-atlassian-python-api) weakremover(python38-atom) weakremover(python38-atomicwrites) weakremover(python38-atpublic) weakremover(python38-atspi) weakremover(python38-attr) weakremover(python38-attrs) weakremover(python38-aubio) weakremover(python38-audio-degrader) weakremover(python38-audiogrep) weakremover(python38-audiomate) weakremover(python38-audioread) weakremover(python38-augeas) weakremover(python38-authheaders) weakremover(python38-authres) weakremover(python38-autobahn) weakremover(python38-autocommand) weakremover(python38-autodoc) weakremover(python38-autodocsumm) weakremover(python38-autoflake) weakremover(python38-autopage) weakremover(python38-autopep8) weakremover(python38-autoray) weakremover(python38-autoupgrade-ng) weakremover(python38-av) weakremover(python38-avahi) weakremover(python38-avocado-plugins-vt) weakremover(python38-avro) weakremover(python38-awkward) weakremover(python38-awkward-cpp) weakremover(python38-awpa) weakremover(python38-aws-sam-translator) weakremover(python38-aws-xray-sdk) weakremover(python38-aws-xray-sdk-Django) weakremover(python38-aws-xray-sdk-Flask-SQLAlchemy) weakremover(python38-aws-xray-sdk-SQLAlchemy) weakremover(python38-aws-xray-sdk-aiobotocore) weakremover(python38-aws-xray-sdk-aiohttp) weakremover(python38-aws-xray-sdk-all) weakremover(python38-aws-xray-sdk-bottle) weakremover(python38-aws-xray-sdk-mysql-connector) weakremover(python38-aws-xray-sdk-psycopg2) weakremover(python38-aws-xray-sdk-pymongo) weakremover(python38-aws-xray-sdk-pynamodb) weakremover(python38-aws-xray-sdk-requests) weakremover(python38-awscrt) weakremover(python38-axolotl) weakremover(python38-axolotl-curve25519) weakremover(python38-azure-agrifood-farming) weakremover(python38-azure-agrifood-nspkg) weakremover(python38-azure-ai-anomalydetector) weakremover(python38-azure-ai-formrecognizer) weakremover(python38-azure-ai-language-conversations) weakremover(python38-azure-ai-language-questionanswering) weakremover(python38-azure-ai-metricsadvisor) weakremover(python38-azure-ai-ml) weakremover(python38-azure-ai-textanalytics) weakremover(python38-azure-ai-translation-document) weakremover(python38-azure-appconfiguration) weakremover(python38-azure-applicationinsights) weakremover(python38-azure-batch) weakremover(python38-azure-cognitiveservices-anomalydetector) weakremover(python38-azure-cognitiveservices-formrecognizer) weakremover(python38-azure-cognitiveservices-inkrecognizer) weakremover(python38-azure-cognitiveservices-knowledge-qnamaker) weakremover(python38-azure-cognitiveservices-language-luis) weakremover(python38-azure-cognitiveservices-language-spellcheck) weakremover(python38-azure-cognitiveservices-language-textanalytics) weakremover(python38-azure-cognitiveservices-personalizer) weakremover(python38-azure-cognitiveservices-search-autosuggest) weakremover(python38-azure-cognitiveservices-search-customimagesearch) weakremover(python38-azure-cognitiveservices-search-customsearch) weakremover(python38-azure-cognitiveservices-search-entitysearch) weakremover(python38-azure-cognitiveservices-search-imagesearch) weakremover(python38-azure-cognitiveservices-search-newssearch) weakremover(python38-azure-cognitiveservices-search-videosearch) weakremover(python38-azure-cognitiveservices-search-visualsearch) weakremover(python38-azure-cognitiveservices-search-websearch) weakremover(python38-azure-cognitiveservices-vision-computervision) weakremover(python38-azure-cognitiveservices-vision-contentmoderator) weakremover(python38-azure-cognitiveservices-vision-customvision) weakremover(python38-azure-cognitiveservices-vision-face) weakremover(python38-azure-common) weakremover(python38-azure-communication-administration) weakremover(python38-azure-communication-chat) weakremover(python38-azure-communication-email) weakremover(python38-azure-communication-identity) weakremover(python38-azure-communication-networktraversal) weakremover(python38-azure-communication-nspkg) weakremover(python38-azure-communication-phonenumbers) weakremover(python38-azure-communication-sms) weakremover(python38-azure-confidentialledger) weakremover(python38-azure-containerregistry) weakremover(python38-azure-core) weakremover(python38-azure-core-tracing-opencensus) weakremover(python38-azure-core-tracing-opentelemetry) weakremover(python38-azure-cosmos) weakremover(python38-azure-data-nspkg) weakremover(python38-azure-data-tables) weakremover(python38-azure-datalake-store) weakremover(python38-azure-developer-loadtesting) weakremover(python38-azure-devops) weakremover(python38-azure-digitaltwins-core) weakremover(python38-azure-digitaltwins-nspkg) weakremover(python38-azure-eventgrid) weakremover(python38-azure-eventhub) weakremover(python38-azure-eventhub-checkpointstoreblob) weakremover(python38-azure-eventhub-checkpointstoreblob-aio) weakremover(python38-azure-functions-devops-build) weakremover(python38-azure-graphrbac) weakremover(python38-azure-identity) weakremover(python38-azure-iot-deviceupdate) weakremover(python38-azure-keyvault) weakremover(python38-azure-keyvault-administration) weakremover(python38-azure-keyvault-certificates) weakremover(python38-azure-keyvault-keys) weakremover(python38-azure-keyvault-nspkg) weakremover(python38-azure-keyvault-secrets) weakremover(python38-azure-loganalytics) weakremover(python38-azure-maps-route) weakremover(python38-azure-media-nspkg) weakremover(python38-azure-media-videoanalyzer-edge) weakremover(python38-azure-messaging-webpubsubservice) weakremover(python38-azure-mgmt) weakremover(python38-azure-mgmt-advisor) weakremover(python38-azure-mgmt-agfood) weakremover(python38-azure-mgmt-agrifood) weakremover(python38-azure-mgmt-alertsmanagement) weakremover(python38-azure-mgmt-apimanagement) weakremover(python38-azure-mgmt-app) weakremover(python38-azure-mgmt-appcomplianceautomation) weakremover(python38-azure-mgmt-appconfiguration) weakremover(python38-azure-mgmt-appcontainers) weakremover(python38-azure-mgmt-applicationinsights) weakremover(python38-azure-mgmt-appplatform) weakremover(python38-azure-mgmt-attestation) weakremover(python38-azure-mgmt-authorization) weakremover(python38-azure-mgmt-automanage) weakremover(python38-azure-mgmt-automation) weakremover(python38-azure-mgmt-avs) weakremover(python38-azure-mgmt-azureadb2c) weakremover(python38-azure-mgmt-azurearcdata) weakremover(python38-azure-mgmt-azurestack) weakremover(python38-azure-mgmt-azurestackhci) weakremover(python38-azure-mgmt-baremetalinfrastructure) weakremover(python38-azure-mgmt-batch) weakremover(python38-azure-mgmt-batchai) weakremover(python38-azure-mgmt-billing) weakremover(python38-azure-mgmt-botservice) weakremover(python38-azure-mgmt-cdn) weakremover(python38-azure-mgmt-chaos) weakremover(python38-azure-mgmt-cognitiveservices) weakremover(python38-azure-mgmt-commerce) weakremover(python38-azure-mgmt-communication) weakremover(python38-azure-mgmt-compute) weakremover(python38-azure-mgmt-confidentialledger) weakremover(python38-azure-mgmt-confluent) weakremover(python38-azure-mgmt-connectedvmware) weakremover(python38-azure-mgmt-consumption) weakremover(python38-azure-mgmt-containerinstance) weakremover(python38-azure-mgmt-containerregistry) weakremover(python38-azure-mgmt-containerservice) weakremover(python38-azure-mgmt-core) weakremover(python38-azure-mgmt-cosmosdb) weakremover(python38-azure-mgmt-costmanagement) weakremover(python38-azure-mgmt-customproviders) weakremover(python38-azure-mgmt-dashboard) weakremover(python38-azure-mgmt-databox) weakremover(python38-azure-mgmt-databoxedge) weakremover(python38-azure-mgmt-databricks) weakremover(python38-azure-mgmt-datadog) weakremover(python38-azure-mgmt-datafactory) weakremover(python38-azure-mgmt-datalake-analytics) weakremover(python38-azure-mgmt-datalake-store) weakremover(python38-azure-mgmt-datamigration) weakremover(python38-azure-mgmt-dataprotection) weakremover(python38-azure-mgmt-datashare) weakremover(python38-azure-mgmt-defendereasm) weakremover(python38-azure-mgmt-deploymentmanager) weakremover(python38-azure-mgmt-desktopvirtualization) weakremover(python38-azure-mgmt-devcenter) weakremover(python38-azure-mgmt-deviceupdate) weakremover(python38-azure-mgmt-devspaces) weakremover(python38-azure-mgmt-devtestlabs) weakremover(python38-azure-mgmt-digitaltwins) weakremover(python38-azure-mgmt-dns) weakremover(python38-azure-mgmt-dnsresolver) weakremover(python38-azure-mgmt-documentdb) weakremover(python38-azure-mgmt-dynatrace) weakremover(python38-azure-mgmt-edgegateway) weakremover(python38-azure-mgmt-edgeorder) weakremover(python38-azure-mgmt-education) weakremover(python38-azure-mgmt-elastic) weakremover(python38-azure-mgmt-elasticsan) weakremover(python38-azure-mgmt-eventgrid) weakremover(python38-azure-mgmt-eventhub) weakremover(python38-azure-mgmt-extendedlocation) weakremover(python38-azure-mgmt-fluidrelay) weakremover(python38-azure-mgmt-frontdoor) weakremover(python38-azure-mgmt-graphservices) weakremover(python38-azure-mgmt-guestconfig) weakremover(python38-azure-mgmt-hanaonazure) weakremover(python38-azure-mgmt-hdinsight) weakremover(python38-azure-mgmt-healthcareapis) weakremover(python38-azure-mgmt-hybridcompute) weakremover(python38-azure-mgmt-hybridkubernetes) weakremover(python38-azure-mgmt-hybridnetwork) weakremover(python38-azure-mgmt-imagebuilder) weakremover(python38-azure-mgmt-iotcentral) weakremover(python38-azure-mgmt-iothub) weakremover(python38-azure-mgmt-iothubprovisioningservices) weakremover(python38-azure-mgmt-keyvault) weakremover(python38-azure-mgmt-kubernetesconfiguration) weakremover(python38-azure-mgmt-kusto) weakremover(python38-azure-mgmt-labservices) weakremover(python38-azure-mgmt-loadtesting) weakremover(python38-azure-mgmt-loadtestservice) weakremover(python38-azure-mgmt-loganalytics) weakremover(python38-azure-mgmt-logic) weakremover(python38-azure-mgmt-logz) weakremover(python38-azure-mgmt-machinelearningcompute) weakremover(python38-azure-mgmt-machinelearningservices) weakremover(python38-azure-mgmt-maintenance) weakremover(python38-azure-mgmt-managedservices) weakremover(python38-azure-mgmt-managementgroups) weakremover(python38-azure-mgmt-managementpartner) weakremover(python38-azure-mgmt-maps) weakremover(python38-azure-mgmt-marketplaceordering) weakremover(python38-azure-mgmt-media) weakremover(python38-azure-mgmt-mixedreality) weakremover(python38-azure-mgmt-mobilenetwork) weakremover(python38-azure-mgmt-monitor) weakremover(python38-azure-mgmt-msi) weakremover(python38-azure-mgmt-netapp) weakremover(python38-azure-mgmt-network) weakremover(python38-azure-mgmt-networkfunction) weakremover(python38-azure-mgmt-newrelicobservability) weakremover(python38-azure-mgmt-nginx) weakremover(python38-azure-mgmt-notificationhubs) weakremover(python38-azure-mgmt-oep) weakremover(python38-azure-mgmt-orbital) weakremover(python38-azure-mgmt-peering) weakremover(python38-azure-mgmt-policyinsights) weakremover(python38-azure-mgmt-portal) weakremover(python38-azure-mgmt-powerbidedicated) weakremover(python38-azure-mgmt-powerbiembedded) weakremover(python38-azure-mgmt-privatedns) weakremover(python38-azure-mgmt-purview) weakremover(python38-azure-mgmt-quantum) weakremover(python38-azure-mgmt-quota) weakremover(python38-azure-mgmt-rdbms) weakremover(python38-azure-mgmt-recoveryservices) weakremover(python38-azure-mgmt-recoveryservicesbackup) weakremover(python38-azure-mgmt-recoveryservicessiterecovery) weakremover(python38-azure-mgmt-redhatopenshift) weakremover(python38-azure-mgmt-redis) weakremover(python38-azure-mgmt-redisenterprise) weakremover(python38-azure-mgmt-regionmove) weakremover(python38-azure-mgmt-relay) weakremover(python38-azure-mgmt-reservations) weakremover(python38-azure-mgmt-resource) weakremover(python38-azure-mgmt-resourceconnector) weakremover(python38-azure-mgmt-resourcegraph) weakremover(python38-azure-mgmt-resourcehealth) weakremover(python38-azure-mgmt-resourcemover) weakremover(python38-azure-mgmt-scheduler) weakremover(python38-azure-mgmt-scvmm) weakremover(python38-azure-mgmt-search) weakremover(python38-azure-mgmt-security) weakremover(python38-azure-mgmt-securitydevops) weakremover(python38-azure-mgmt-securityinsight) weakremover(python38-azure-mgmt-serialconsole) weakremover(python38-azure-mgmt-servermanager) weakremover(python38-azure-mgmt-servicebus) weakremover(python38-azure-mgmt-servicefabric) weakremover(python38-azure-mgmt-servicefabricmanagedclusters) weakremover(python38-azure-mgmt-servicelinker) weakremover(python38-azure-mgmt-servicenetworking) weakremover(python38-azure-mgmt-signalr) weakremover(python38-azure-mgmt-sql) weakremover(python38-azure-mgmt-sqlvirtualmachine) weakremover(python38-azure-mgmt-storage) weakremover(python38-azure-mgmt-storagecache) weakremover(python38-azure-mgmt-storageimportexport) weakremover(python38-azure-mgmt-storagemover) weakremover(python38-azure-mgmt-storagepool) weakremover(python38-azure-mgmt-storagesync) weakremover(python38-azure-mgmt-streamanalytics) weakremover(python38-azure-mgmt-subscription) weakremover(python38-azure-mgmt-support) weakremover(python38-azure-mgmt-synapse) weakremover(python38-azure-mgmt-testbase) weakremover(python38-azure-mgmt-timeseriesinsights) weakremover(python38-azure-mgmt-trafficmanager) weakremover(python38-azure-mgmt-videoanalyzer) weakremover(python38-azure-mgmt-vmwarecloudsimple) weakremover(python38-azure-mgmt-voiceservices) weakremover(python38-azure-mgmt-web) weakremover(python38-azure-mgmt-webpubsub) weakremover(python38-azure-mgmt-workloadmonitor) weakremover(python38-azure-mgmt-workloads) weakremover(python38-azure-mixedreality-authentication) weakremover(python38-azure-mixedreality-nspkg) weakremover(python38-azure-monitor) weakremover(python38-azure-monitor-ingestion) weakremover(python38-azure-monitor-query) weakremover(python38-azure-multiapi-storage) weakremover(python38-azure-purview-account) weakremover(python38-azure-purview-administration) weakremover(python38-azure-purview-catalog) weakremover(python38-azure-purview-nspkg) weakremover(python38-azure-purview-scanning) weakremover(python38-azure-purview-sharing) weakremover(python38-azure-schemaregistry) weakremover(python38-azure-schemaregistry-avroencoder) weakremover(python38-azure-schemaregistry-avroserializer) weakremover(python38-azure-sdk) weakremover(python38-azure-search-documents) weakremover(python38-azure-security-attestation) weakremover(python38-azure-security-nspkg) weakremover(python38-azure-servicebus) weakremover(python38-azure-servicefabric) weakremover(python38-azure-servicemanagement-legacy) weakremover(python38-azure-storage) weakremover(python38-azure-storage-blob) weakremover(python38-azure-storage-common) weakremover(python38-azure-storage-file) weakremover(python38-azure-storage-file-datalake) weakremover(python38-azure-storage-file-share) weakremover(python38-azure-storage-nspkg) weakremover(python38-azure-storage-queue) weakremover(python38-azure-synapse-accesscontrol) weakremover(python38-azure-synapse-artifacts) weakremover(python38-azure-synapse-managedprivateendpoints) weakremover(python38-azure-synapse-monitoring) weakremover(python38-azure-synapse-nspkg) weakremover(python38-azure-synapse-spark) weakremover(python38-azure-template) weakremover(python38-babelfish) weakremover(python38-backcall) weakremover(python38-backoff) weakremover(python38-backports.entry_points_selectable) weakremover(python38-backports.zoneinfo) weakremover(python38-baron) weakremover(python38-base) weakremover(python38-base58) weakremover(python38-bashate) weakremover(python38-basictracer) weakremover(python38-bcolz) weakremover(python38-bcrypt) weakremover(python38-beartype) weakremover(python38-beautifulsoup4) weakremover(python38-before-after) weakremover(python38-behave) weakremover(python38-bencode) weakremover(python38-beniget) weakremover(python38-beren) weakremover(python38-betamax) weakremover(python38-betamax-matchers) weakremover(python38-bibtexparser) weakremover(python38-bidict) weakremover(python38-billiard) weakremover(python38-binary) weakremover(python38-binaryornot) weakremover(python38-bindep) weakremover(python38-biopython) weakremover(python38-biplist) weakremover(python38-bitarray) weakremover(python38-bitstring) weakremover(python38-bitstruct) weakremover(python38-bjoern) weakremover(python38-black) weakremover(python38-bleach) weakremover(python38-blessed) weakremover(python38-blessings) weakremover(python38-blindspin) weakremover(python38-blinker) weakremover(python38-blist) weakremover(python38-blockdiag) weakremover(python38-blosc) weakremover(python38-blosc2) weakremover(python38-bloscpack) weakremover(python38-blue) weakremover(python38-blurb) weakremover(python38-bmap-tools) weakremover(python38-bobo) weakremover(python38-bobodoctestumentation) weakremover(python38-bokcolmaps) weakremover(python38-bokeh) weakremover(python38-bokeh2) weakremover(python38-boltons) weakremover(python38-boolean.py) weakremover(python38-booleanOperations) weakremover(python38-boost-histogram) weakremover(python38-boto) weakremover(python38-boto3) weakremover(python38-botocore) weakremover(python38-bottle) weakremover(python38-bowler) weakremover(python38-bpython) weakremover(python38-bqplot) weakremover(python38-bracex) weakremover(python38-branca) weakremover(python38-breathe) weakremover(python38-brewer2mpl) weakremover(python38-brotlicffi) weakremover(python38-brotlipy) weakremover(python38-bsddb3) weakremover(python38-bsddb3-devel) weakremover(python38-bson) weakremover(python38-bugzilla) weakremover(python38-bugzillatools) weakremover(python38-build) weakremover(python38-bump2version) weakremover(python38-buttplug) weakremover(python38-bytecode) weakremover(python38-cPyparsing) weakremover(python38-cached-property) weakremover(python38-cachelib) weakremover(python38-cachetools) weakremover(python38-cachey) weakremover(python38-cachy) weakremover(python38-cairocffi) weakremover(python38-cairocffi-pixbuf) weakremover(python38-caldav) weakremover(python38-calmjs) weakremover(python38-calmjs.parse) weakremover(python38-calmjs.types) weakremover(python38-calver) weakremover(python38-calysto) weakremover(python38-cangjie) weakremover(python38-canonicaljson) weakremover(python38-capturer) weakremover(python38-casacore) weakremover(python38-case) weakremover(python38-cassandra-driver) weakremover(python38-cassowary) weakremover(python38-casttube) weakremover(python38-catkin-pkg) weakremover(python38-cattrs) weakremover(python38-cauldron-notebook) weakremover(python38-cbor) weakremover(python38-cbor2) weakremover(python38-cchardet) weakremover(python38-cdflib) weakremover(python38-celery) weakremover(python38-celery-batches) weakremover(python38-celerymon) weakremover(python38-cepa) weakremover(python38-cerealizer) weakremover(python38-certbot) weakremover(python38-certbot-apache) weakremover(python38-certbot-dns-cloudflare) weakremover(python38-certbot-dns-cloudxns) weakremover(python38-certbot-dns-digitalocean) weakremover(python38-certbot-dns-dnsimple) weakremover(python38-certbot-dns-dnsmadeeasy) weakremover(python38-certbot-dns-google) weakremover(python38-certbot-dns-linode) weakremover(python38-certbot-dns-luadns) weakremover(python38-certbot-dns-nsone) weakremover(python38-certbot-dns-rfc2136) weakremover(python38-certbot-dns-route53) weakremover(python38-certbot-nginx) weakremover(python38-certifi) weakremover(python38-certipy) weakremover(python38-certstream) weakremover(python38-cffi) weakremover(python38-cfgdiff) weakremover(python38-cfgv) weakremover(python38-cfn-lint) weakremover(python38-cfscrape) weakremover(python38-cftime) weakremover(python38-chai) weakremover(python38-chainmap) weakremover(python38-chardet) weakremover(python38-charset-normalizer) weakremover(python38-chart-studio) weakremover(python38-chartify) weakremover(python38-check-manifest) weakremover(python38-checkdmarc) weakremover(python38-cheroot) weakremover(python38-chest) weakremover(python38-circuitbreaker) weakremover(python38-ciscoconfparse) weakremover(python38-cl) weakremover(python38-cleo) weakremover(python38-cli-helpers) weakremover(python38-click) weakremover(python38-click-aliases) weakremover(python38-click-completion) weakremover(python38-click-default-group) weakremover(python38-click-didyoumean) weakremover(python38-click-help-colors) weakremover(python38-click-log) weakremover(python38-click-man) weakremover(python38-click-plugins) weakremover(python38-click-repl) weakremover(python38-click-spinner) weakremover(python38-click-threading) weakremover(python38-cligj) weakremover(python38-clikit) weakremover(python38-clint) weakremover(python38-cloud-init-seed) weakremover(python38-cloud-sptheme) weakremover(python38-cloudflare) weakremover(python38-cloudpickle) weakremover(python38-cloudscraper) weakremover(python38-cloup) weakremover(python38-cluster) weakremover(python38-cluster-preflight-check) weakremover(python38-cma) weakremover(python38-cmapfile) weakremover(python38-cmarkgfm) weakremover(python38-cmd2) weakremover(python38-cmdln) weakremover(python38-coards) weakremover(python38-codecov) weakremover(python38-cogapp) weakremover(python38-colander) weakremover(python38-colorama) weakremover(python38-colorcet) weakremover(python38-colorclass) weakremover(python38-coloredlogs) weakremover(python38-colorful) weakremover(python38-colorlog) weakremover(python38-colorlover) weakremover(python38-colormap) weakremover(python38-colorspacious) weakremover(python38-colour) weakremover(python38-columnize) weakremover(python38-combi) weakremover(python38-comm) weakremover(python38-commentjson) weakremover(python38-compat-patcher-core) weakremover(python38-compileall2) weakremover(python38-compizconfig) weakremover(python38-compressed_rtf) weakremover(python38-concurrentloghandler) weakremover(python38-configargparse) weakremover(python38-configobj) weakremover(python38-configshell-fb) weakremover(python38-confluent-kafka) weakremover(python38-confpy) weakremover(python38-confusable-homoglyphs) weakremover(python38-confuse) weakremover(python38-constantly) weakremover(python38-construct) weakremover(python38-contexter) weakremover(python38-contextlib2) weakremover(python38-contextvars) weakremover(python38-contourpy) weakremover(python38-conu) weakremover(python38-convertdate) weakremover(python38-cookiecutter) weakremover(python38-cookies) weakremover(python38-cooldict) weakremover(python38-copr) weakremover(python38-copr-cli) weakremover(python38-coreapi) weakremover(python38-coreapi-cli) weakremover(python38-coreschema) weakremover(python38-cornice) weakremover(python38-cov-core) weakremover(python38-covdefaults) weakremover(python38-coverage) weakremover(python38-coverage-config-reload-plugin) weakremover(python38-coverage-env-plugin) weakremover(python38-coveralls) weakremover(python38-coveralls-check) weakremover(python38-cppclean) weakremover(python38-cpplint) weakremover(python38-cppy) weakremover(python38-cracklib) weakremover(python38-cramjam) weakremover(python38-crashtest) weakremover(python38-crayons) weakremover(python38-crcmod) weakremover(python38-crochet) weakremover(python38-cron-descriptor) weakremover(python38-croniter) weakremover(python38-crontab) weakremover(python38-crumbs) weakremover(python38-cryptography) weakremover(python38-cryptography-vectors) weakremover(python38-css-html-js-minify) weakremover(python38-css-parser) weakremover(python38-csscompressor) weakremover(python38-cssmin) weakremover(python38-cssselect) weakremover(python38-cssselect2) weakremover(python38-cssutils) weakremover(python38-cstruct) weakremover(python38-csv23) weakremover(python38-csvkit) weakremover(python38-ctypescrypto) weakremover(python38-ctypeslib2) weakremover(python38-cu2qu) weakremover(python38-cufflinks) weakremover(python38-curio) weakremover(python38-curlylint) weakremover(python38-curses) weakremover(python38-curtsies) weakremover(python38-cwcwidth) weakremover(python38-cx_Freeze) weakremover(python38-cymruwhois) weakremover(python38-cytoolz) weakremover(python38-czifile) weakremover(python38-d2to1) weakremover(python38-daemonize) weakremover(python38-daiquiri) weakremover(python38-dasbus) weakremover(python38-dash) weakremover(python38-dash-core-components) weakremover(python38-dash-html-components) weakremover(python38-dash-renderer) weakremover(python38-dash-table) weakremover(python38-dask) weakremover(python38-dask-all) weakremover(python38-dask-array) weakremover(python38-dask-bag) weakremover(python38-dask-complete) weakremover(python38-dask-dataframe) weakremover(python38-dask-delayed) weakremover(python38-dask-diagnostics) weakremover(python38-dask-distributed) weakremover(python38-dask-dot) weakremover(python38-dask-multiprocessing) weakremover(python38-dask-test) weakremover(python38-databases) weakremover(python38-datadiff) weakremover(python38-datashader) weakremover(python38-dateparser) weakremover(python38-dateutils) weakremover(python38-datrie) weakremover(python38-dbf) weakremover(python38-dbfread) weakremover(python38-dbm) weakremover(python38-dbus-deviation) weakremover(python38-dbus-python) weakremover(python38-dbus-python-devel) weakremover(python38-dbus_next) weakremover(python38-ddg3) weakremover(python38-ddt) weakremover(python38-deap) weakremover(python38-debian) weakremover(python38-debugpy) weakremover(python38-decorator) weakremover(python38-deepdiff) weakremover(python38-deepmerge) weakremover(python38-defcon) weakremover(python38-defusedxml) weakremover(python38-delegator) weakremover(python38-delegator.py) weakremover(python38-demjson) weakremover(python38-dennis) weakremover(python38-dephell) weakremover(python38-dephell-archive) weakremover(python38-dephell-argparse) weakremover(python38-dephell-discover) weakremover(python38-dephell-licenses) weakremover(python38-dephell-links) weakremover(python38-dephell-markers) weakremover(python38-dephell-pythons) weakremover(python38-dephell-setuptools) weakremover(python38-dephell-shells) weakremover(python38-dephell-specifier) weakremover(python38-dephell-venvs) weakremover(python38-dephell-versioning) weakremover(python38-dephell_changelogs) weakremover(python38-deprecation) weakremover(python38-derpconf) weakremover(python38-devel) weakremover(python38-devpi-client) weakremover(python38-devpi-common) weakremover(python38-devpi-server) weakremover(python38-dfVFS) weakremover(python38-dfdatetime) weakremover(python38-dfwinreg) weakremover(python38-dialite) weakremover(python38-dictdiffer) weakremover(python38-dictknife) weakremover(python38-dictpath) weakremover(python38-dicttoxml) weakremover(python38-diff-match-patch) weakremover(python38-diffimg) weakremover(python38-digitalocean) weakremover(python38-dill) weakremover(python38-dirty-equals) weakremover(python38-dirtyjson) weakremover(python38-discid) weakremover(python38-discogs-client) weakremover(python38-diskcache) weakremover(python38-dist) weakremover(python38-distlib) weakremover(python38-distob) weakremover(python38-distorm3) weakremover(python38-distributed) weakremover(python38-distro) weakremover(python38-distroinfo) weakremover(python38-distutils-extra) weakremover(python38-dj-database-url) weakremover(python38-django-action-framework) weakremover(python38-django-allauth) weakremover(python38-django-appconf) weakremover(python38-django-args) weakremover(python38-django-assets) weakremover(python38-django-attachments) weakremover(python38-django-auth-ldap) weakremover(python38-django-avatar) weakremover(python38-django-axes) weakremover(python38-django-bootstrap3) weakremover(python38-django-bootstrap4) weakremover(python38-django-braces) weakremover(python38-django-cacheops) weakremover(python38-django-ckeditor) weakremover(python38-django-classy-tags) weakremover(python38-django-codemod) weakremover(python38-django-collectd-rest) weakremover(python38-django-compressor) weakremover(python38-django-contrib-comments) weakremover(python38-django-cors-headers) weakremover(python38-django-countries) weakremover(python38-django-coverage-plugin) weakremover(python38-django-crispy-forms) weakremover(python38-django-debreach) weakremover(python38-django-debug-toolbar) weakremover(python38-django-dj-inmemorystorage) weakremover(python38-django-dynamic-fixture) weakremover(python38-django-environ) weakremover(python38-django-eremaea2) weakremover(python38-django-extensions) weakremover(python38-django-extra-views) weakremover(python38-django-filter) weakremover(python38-django-formtools) weakremover(python38-django-geoposition) weakremover(python38-django-grappelli) weakremover(python38-django-gravatar2) weakremover(python38-django-guardian) weakremover(python38-django-haystack) weakremover(python38-django-health-check) weakremover(python38-django-import-export) weakremover(python38-django-invitations) weakremover(python38-django-ipware) weakremover(python38-django-jinja) weakremover(python38-django-js-asset) weakremover(python38-django-json-widget) weakremover(python38-django-jsonfield) weakremover(python38-django-localflavor) weakremover(python38-django-mailer) weakremover(python38-django-mailman3) weakremover(python38-django-mathfilters) weakremover(python38-django-minio-storage) weakremover(python38-django-model-utils) weakremover(python38-django-money) weakremover(python38-django-mptt) weakremover(python38-django-multiselectfield) weakremover(python38-django-nine) weakremover(python38-django-nose) weakremover(python38-django-oauth-toolkit) weakremover(python38-django-oidc-provider) weakremover(python38-django-opentracing) weakremover(python38-django-pandas) weakremover(python38-django-parler) weakremover(python38-django-perf-rec) weakremover(python38-django-pglocks) weakremover(python38-django-phonenumber-field) weakremover(python38-django-picklefield) weakremover(python38-django-pipeline) weakremover(python38-django-polymorphic) weakremover(python38-django-push-notifications) weakremover(python38-django-pyscss) weakremover(python38-django-q) weakremover(python38-django-qsessions) weakremover(python38-django-redis) weakremover(python38-django-registration) weakremover(python38-django-request) weakremover(python38-django-requests-debug-toolbar) weakremover(python38-django-rest-framework-braces) weakremover(python38-django-rest-framework-client) weakremover(python38-django-rest-framework-social-oauth2) weakremover(python38-django-rest-invitations) weakremover(python38-django-rest-knox) weakremover(python38-django-reversion) weakremover(python38-django-rosetta) weakremover(python38-django-rq) weakremover(python38-django-seed) weakremover(python38-django-sekizai) weakremover(python38-django-settings-toml) weakremover(python38-django-silk) weakremover(python38-django-sortedm2m) weakremover(python38-django-storages) weakremover(python38-django-tables2) weakremover(python38-django-tagging) weakremover(python38-django-taggit) weakremover(python38-django-tagulous) weakremover(python38-django-tastypie) weakremover(python38-django-threadedcomments) weakremover(python38-django-timezone-field) weakremover(python38-django-treebeard) weakremover(python38-django-upgrade) weakremover(python38-django-user-agents) weakremover(python38-django-utils-six) weakremover(python38-django-webpack-loader) weakremover(python38-django-webtest) weakremover(python38-django-widget-tweaks) weakremover(python38-djangorestframework) weakremover(python38-djangorestframework-camel-case) weakremover(python38-djangorestframework-simplejwt) weakremover(python38-djet) weakremover(python38-djvulibre) weakremover(python38-dkimpy) weakremover(python38-dmidecode) weakremover(python38-dns-lexicon) weakremover(python38-dnslib) weakremover(python38-dnspython) weakremover(python38-doc) weakremover(python38-doc-devhelp) weakremover(python38-docformatter) weakremover(python38-docker) weakremover(python38-docker-compose) weakremover(python38-docker-pycreds) weakremover(python38-dockerpty) weakremover(python38-docopt) weakremover(python38-docrepr) weakremover(python38-docstring-to-markdown) weakremover(python38-docutils) weakremover(python38-docutils-ast-writer) weakremover(python38-dogpile.cache) weakremover(python38-dogslow) weakremover(python38-dominate) weakremover(python38-dotmap) weakremover(python38-dparse) weakremover(python38-dpcontracts) weakremover(python38-dpkt) weakremover(python38-dragonmapper) weakremover(python38-drgn) weakremover(python38-drms) weakremover(python38-dropbox) weakremover(python38-dtaidistance) weakremover(python38-dtaidistance-devel) weakremover(python38-dtfabric) weakremover(python38-duckduckgo2) weakremover(python38-duet) weakremover(python38-dukpy) weakremover(python38-dukpy-kovidgoyal) weakremover(python38-dulwich) weakremover(python38-dynaconf) weakremover(python38-e-antic) weakremover(python38-easy-thumbnails) weakremover(python38-easydev) weakremover(python38-easygui) weakremover(python38-easypysmb) weakremover(python38-easywatch) weakremover(python38-ebcdic) weakremover(python38-ecdsa) weakremover(python38-ed25519) weakremover(python38-edgegrid-python) weakremover(python38-editables) weakremover(python38-editdistance) weakremover(python38-editdistance-devel) weakremover(python38-edk2toolext) weakremover(python38-edk2toollib) weakremover(python38-efilter) weakremover(python38-efl) weakremover(python38-elastic-transport) weakremover(python38-elasticsearch) weakremover(python38-elasticsearch-dsl) weakremover(python38-elementpath) weakremover(python38-eliot) weakremover(python38-email-reply-parser) weakremover(python38-email-validator) weakremover(python38-email_validator) weakremover(python38-emcee) weakremover(python38-emoji) weakremover(python38-empy) weakremover(python38-enaml) weakremover(python38-encore) weakremover(python38-enrich) weakremover(python38-entrypoint2) weakremover(python38-entrypoints) weakremover(python38-environ-config) weakremover(python38-environmental-override) weakremover(python38-envisage) weakremover(python38-enzyme) weakremover(python38-ephem) weakremover(python38-ephemeral-port-reserve) weakremover(python38-epubmerge) weakremover(python38-eradicate) weakremover(python38-espeak) weakremover(python38-esptool) weakremover(python38-et_xmlfile) weakremover(python38-etcd) weakremover(python38-ethtool) weakremover(python38-evdev) weakremover(python38-eventlet) weakremover(python38-evilunit) weakremover(python38-evtx) weakremover(python38-exam) weakremover(python38-exceptiongroup) weakremover(python38-execnet) weakremover(python38-executing) weakremover(python38-exiv2) weakremover(python38-expects) weakremover(python38-expiringdict) weakremover(python38-exrex) weakremover(python38-extension-helpers) weakremover(python38-extras) weakremover(python38-extratools) weakremover(python38-ez_setup) weakremover(python38-ezdxf) weakremover(python38-fabio) weakremover(python38-factory_boy) weakremover(python38-fake-useragent) weakremover(python38-fakeredis) weakremover(python38-falcon) weakremover(python38-fanficfare) weakremover(python38-fann2) weakremover(python38-fastTSNE) weakremover(python38-fastapi) weakremover(python38-fastbencode) weakremover(python38-fastcluster) weakremover(python38-fasteners) weakremover(python38-fastimport) weakremover(python38-fastjsonschema) weakremover(python38-fastnumbers) weakremover(python38-fastparquet) weakremover(python38-fastremap) weakremover(python38-fasttext) weakremover(python38-fb-re2) weakremover(python38-featureflow) weakremover(python38-fedmsg) weakremover(python38-fedmsg-tests) weakremover(python38-fedora-messaging) weakremover(python38-feedgen) weakremover(python38-feedgenerator) weakremover(python38-feedparser) weakremover(python38-ffmpeg-python) weakremover(python38-fido2) weakremover(python38-fields) weakremover(python38-filelock) weakremover(python38-filetype) weakremover(python38-finance_enums) weakremover(python38-findpython) weakremover(python38-fire) weakremover(python38-first) weakremover(python38-fissix) weakremover(python38-fixtures) weakremover(python38-flake8) weakremover(python38-flake8-blind-except) weakremover(python38-flake8-bugbear) weakremover(python38-flake8-builtins) weakremover(python38-flake8-class-newline) weakremover(python38-flake8-comprehensions) weakremover(python38-flake8-debugger) weakremover(python38-flake8-deprecated) weakremover(python38-flake8-docstrings) weakremover(python38-flake8-import-order) weakremover(python38-flake8-imports) weakremover(python38-flake8-isort) weakremover(python38-flake8-pep3101) weakremover(python38-flake8-polyfill) weakremover(python38-flake8-pyi) weakremover(python38-flake8-quotes) weakremover(python38-flaky) weakremover(python38-flasgger) weakremover(python38-flask-jwt-extended) weakremover(python38-flask-oidc) weakremover(python38-flask-peewee) weakremover(python38-flask-restplus) weakremover(python38-flask-restx) weakremover(python38-flatbuffers) weakremover(python38-flatdict) weakremover(python38-fleming) weakremover(python38-flex) weakremover(python38-flexmock) weakremover(python38-flexx) weakremover(python38-flickrapi) weakremover(python38-flit) weakremover(python38-flit-core) weakremover(python38-flit-scm) weakremover(python38-flower) weakremover(python38-fluent) weakremover(python38-flufl.bounce) weakremover(python38-flufl.i18n) weakremover(python38-flufl.lock) weakremover(python38-flufl.testing) weakremover(python38-fluidity-sm) weakremover(python38-flup) weakremover(python38-flynt) weakremover(python38-folium) weakremover(python38-fontMath) weakremover(python38-fontParts) weakremover(python38-fontPens) weakremover(python38-forbiddenfruit) weakremover(python38-formats) weakremover(python38-fqdn) weakremover(python38-framel) weakremover(python38-freeipa) weakremover(python38-freetype-py) weakremover(python38-freezegun) weakremover(python38-fritzconnection) weakremover(python38-frozendict) weakremover(python38-frozenlist) weakremover(python38-fs) weakremover(python38-fsspec) weakremover(python38-ftfy) weakremover(python38-ftputil) weakremover(python38-fudge) weakremover(python38-funcparserlib) weakremover(python38-funcy) weakremover(python38-furl) weakremover(python38-fuse) weakremover(python38-fusepy) weakremover(python38-future) weakremover(python38-fuzzywuzzy) weakremover(python38-fysom) weakremover(python38-gTTS) weakremover(python38-gTTS-token) weakremover(python38-gast) weakremover(python38-gcsfs) weakremover(python38-gcsfs-fuse) weakremover(python38-gear) weakremover(python38-ged4py) weakremover(python38-genfire) weakremover(python38-genson) weakremover(python38-genty) weakremover(python38-geographiclib) weakremover(python38-geoip2) weakremover(python38-geojson) weakremover(python38-geolib) weakremover(python38-geolinks) weakremover(python38-geomdl) weakremover(python38-geomet) weakremover(python38-geopandas) weakremover(python38-geopy) weakremover(python38-getmac) weakremover(python38-gevent) weakremover(python38-gevent-websocket) weakremover(python38-geventhttpclient) weakremover(python38-ggplot) weakremover(python38-ghp-import) weakremover(python38-girder-client) weakremover(python38-git-pw) weakremover(python38-git-url-parse) weakremover(python38-gitdb) weakremover(python38-github3.py) weakremover(python38-gitlint) weakremover(python38-glad2) weakremover(python38-glean) weakremover(python38-glean-parser) weakremover(python38-glfw) weakremover(python38-glob2) weakremover(python38-glucat) weakremover(python38-gmpy) weakremover(python38-gmpy2) weakremover(python38-gns3fy) weakremover(python38-gobject) weakremover(python38-gobject-Gdk) weakremover(python38-gobject-cairo) weakremover(python38-gobject-devel) weakremover(python38-goobook) weakremover(python38-google-api-core) weakremover(python38-google-api-python-client) weakremover(python38-google-auth) weakremover(python38-google-auth-httplib2) weakremover(python38-google-auth-oauthlib) weakremover(python38-google-cloud-core) weakremover(python38-google-cloud-kms) weakremover(python38-google-cloud-speech) weakremover(python38-google-cloud-storage) weakremover(python38-google-cloud-translate) weakremover(python38-google-crc32c) weakremover(python38-google-filesystem) weakremover(python38-google-pasta) weakremover(python38-google-resumable-media) weakremover(python38-googleapis-common-protos) weakremover(python38-googlemaps) weakremover(python38-gpg) weakremover(python38-gpgme) weakremover(python38-gphoto2) weakremover(python38-gprof2dot) weakremover(python38-gps3) weakremover(python38-gpstime) weakremover(python38-gpxpy) weakremover(python38-grab) weakremover(python38-graphene) weakremover(python38-graphene-django) weakremover(python38-graphql-core) weakremover(python38-graphql-relay) weakremover(python38-graphviz) weakremover(python38-greenlet) weakremover(python38-greenlet-devel) weakremover(python38-grpc-google-iam-v1) weakremover(python38-grpcio) weakremover(python38-grpcio-gcp) weakremover(python38-grpcio-status) weakremover(python38-grpcio-tools) weakremover(python38-gscholar) weakremover(python38-gsm0338) weakremover(python38-gspread) weakremover(python38-gssapi) weakremover(python38-gst) weakremover(python38-gsw) weakremover(python38-guessit) weakremover(python38-gunicorn) weakremover(python38-guzzle_sphinx_theme) weakremover(python38-gvm-tools) weakremover(python38-gwcs) weakremover(python38-gwosc) weakremover(python38-gwyfile) weakremover(python38-gyp) weakremover(python38-h11) weakremover(python38-h2) weakremover(python38-h5netcdf) weakremover(python38-h5py) weakremover(python38-h5py-openmpi1) weakremover(python38-h5py-openmpi2) weakremover(python38-h5py-openmpi3) weakremover(python38-h5py-openmpi4) weakremover(python38-habanero) weakremover(python38-hammett) weakremover(python38-hankel) weakremover(python38-hanzidentifier) weakremover(python38-happybase) weakremover(python38-haproxyctl) weakremover(python38-hashids) weakremover(python38-hatch) weakremover(python38-hatch-fancy-pypi-readme) weakremover(python38-hatch-jupyter-builder) weakremover(python38-hatch_nodejs_version) weakremover(python38-hatch_vcs) weakremover(python38-hatchling) weakremover(python38-hawkauthlib) weakremover(python38-hcloud) weakremover(python38-hdf5storage) weakremover(python38-healpy) weakremover(python38-helpdev) weakremover(python38-hepunits) weakremover(python38-hetzner) weakremover(python38-hetznercloud) weakremover(python38-hexdump) weakremover(python38-hid-parser) weakremover(python38-hide-code) weakremover(python38-hijri-converter) weakremover(python38-hiredis) weakremover(python38-hkdf) weakremover(python38-hl7apy) weakremover(python38-holidays) weakremover(python38-holoviews) weakremover(python38-hotdoc) weakremover(python38-hpack) weakremover(python38-hsluv) weakremover(python38-hstspreload) weakremover(python38-html2text) weakremover(python38-html5-parser) weakremover(python38-html5lib) weakremover(python38-htmlmin) weakremover(python38-httmock) weakremover(python38-http-ece) weakremover(python38-http-parser) weakremover(python38-httpbin) weakremover(python38-httpcore) weakremover(python38-httplib2) weakremover(python38-httpretty) weakremover(python38-httpsig_cffi) weakremover(python38-httptools) weakremover(python38-httpx) weakremover(python38-hug) weakremover(python38-humanfriendly) weakremover(python38-humanhash3) weakremover(python38-humanize) weakremover(python38-humanreadable) weakremover(python38-hunter) weakremover(python38-hupper) weakremover(python38-husl) weakremover(python38-hvac) weakremover(python38-hvplot) weakremover(python38-hyper) weakremover(python38-hyperframe) weakremover(python38-hyperlink) weakremover(python38-hypothesis) weakremover(python38-hypothesis-auto) weakremover(python38-hypothesis-fspaths) weakremover(python38-hypothesmith) weakremover(python38-i3ipc) weakremover(python38-icalendar) weakremover(python38-icoextract) weakremover(python38-identify) weakremover(python38-idle) weakremover(python38-idna) weakremover(python38-idna_ssl) weakremover(python38-ifaddr) weakremover(python38-ifconfig-parser) weakremover(python38-igwn-auth-utils) weakremover(python38-igwn-auth-utils-requests) weakremover(python38-ijson) weakremover(python38-imagecodecs) weakremover(python38-imageio) weakremover(python38-imageio-ffmpeg) weakremover(python38-imagesize) weakremover(python38-imbox) weakremover(python38-img2pdf) weakremover(python38-iminuit) weakremover(python38-immutables) weakremover(python38-impacket) weakremover(python38-importlab) weakremover(python38-importlib-metadata) weakremover(python38-importlib-resources) weakremover(python38-imread) weakremover(python38-imreg) weakremover(python38-incremental) weakremover(python38-infinity) weakremover(python38-inflate64) weakremover(python38-inflect) weakremover(python38-inflection) weakremover(python38-influxdb) weakremover(python38-ini2toml) weakremover(python38-ini2toml-all) weakremover(python38-ini2toml-full) weakremover(python38-ini2toml-lite) weakremover(python38-iniconfig) weakremover(python38-inifile) weakremover(python38-iniparse) weakremover(python38-injector) weakremover(python38-installer) weakremover(python38-intake) weakremover(python38-interrogate) weakremover(python38-intervals) weakremover(python38-intervaltree) weakremover(python38-invocations) weakremover(python38-invoke) weakremover(python38-iocapture) weakremover(python38-ipaddr) weakremover(python38-ipdb) weakremover(python38-iptables) weakremover(python38-ipy) weakremover(python38-ipydatawidgets) weakremover(python38-ipyevents) weakremover(python38-ipyfilechooser) weakremover(python38-ipykernel) weakremover(python38-ipyleaflet) weakremover(python38-ipympl) weakremover(python38-ipyparallel) weakremover(python38-ipyscales) weakremover(python38-ipysheet) weakremover(python38-ipython) weakremover(python38-ipython-iptest) weakremover(python38-ipython715) weakremover(python38-ipython715-iptest) weakremover(python38-ipython_genutils) weakremover(python38-ipyvolume) weakremover(python38-ipyvue) weakremover(python38-ipyvuetify) weakremover(python38-ipywebrtc) weakremover(python38-ipywidgets) weakremover(python38-irc) weakremover(python38-isbnlib) weakremover(python38-isc_dhcp_leases) weakremover(python38-iso3166) weakremover(python38-iso8601) weakremover(python38-isodate) weakremover(python38-isoduration) weakremover(python38-isort) weakremover(python38-itemadapter) weakremover(python38-itemloaders) weakremover(python38-itsdangerous) weakremover(python38-itypes) weakremover(python38-iwlib) weakremover(python38-j2gen) weakremover(python38-jaraco.base) weakremover(python38-jaraco.classes) weakremover(python38-jaraco.collections) weakremover(python38-jaraco.context) weakremover(python38-jaraco.envs) weakremover(python38-jaraco.functools) weakremover(python38-jaraco.itertools) weakremover(python38-jaraco.logging) weakremover(python38-jaraco.packaging) weakremover(python38-jaraco.path) weakremover(python38-jaraco.stream) weakremover(python38-jaraco.text) weakremover(python38-jaraco.tidelift) weakremover(python38-javapackages) weakremover(python38-javaproperties) weakremover(python38-jdatetime) weakremover(python38-jdcal) weakremover(python38-jedi) weakremover(python38-jedihttp) weakremover(python38-jeepney) weakremover(python38-jellyfish) weakremover(python38-jenkinsapi) weakremover(python38-jfscripts) weakremover(python38-jgraph) weakremover(python38-jinja2-fsloader) weakremover(python38-jinja2-pluralize) weakremover(python38-jinja2-time) weakremover(python38-jira) weakremover(python38-jirafs) weakremover(python38-jmespath) weakremover(python38-joblib) weakremover(python38-josepy) weakremover(python38-jplephem) weakremover(python38-jsbeautifier) weakremover(python38-jschema-to-python) weakremover(python38-jsmin) weakremover(python38-json-rpc) weakremover(python38-json5) weakremover(python38-json_tricks) weakremover(python38-jsondate) weakremover(python38-jsondiff) weakremover(python38-jsonextended) weakremover(python38-jsonlib-python3) weakremover(python38-jsonlines) weakremover(python38-jsonpatch) weakremover(python38-jsonpath-ng) weakremover(python38-jsonpath-rw) weakremover(python38-jsonpickle) weakremover(python38-jsonpointer) weakremover(python38-jsonref) weakremover(python38-jsonrpclib-pelix) weakremover(python38-jsonschema) weakremover(python38-jsonschema-format) weakremover(python38-jsonschema-format-nongpl) weakremover(python38-jsonschema-spec) weakremover(python38-jsonschema-specifications) weakremover(python38-jsonslicer) weakremover(python38-jsonxs) weakremover(python38-junit-xml) weakremover(python38-junitxml) weakremover(python38-junos-eznc) weakremover(python38-jupyter) weakremover(python38-jupyter-client) weakremover(python38-jupyter-client7) weakremover(python38-jupyter-collaboration) weakremover(python38-jupyter-contrib-nbextensions) weakremover(python38-jupyter-core) weakremover(python38-jupyter-datatables) weakremover(python38-jupyter-events) weakremover(python38-jupyter-jupyterlab-server) weakremover(python38-jupyter-jupyterlab-server-openapi) weakremover(python38-jupyter-jupyterlab-server-test) weakremover(python38-jupyter-kernel-test) weakremover(python38-jupyter-nbutils) weakremover(python38-jupyter-packaging) weakremover(python38-jupyter-protocol) weakremover(python38-jupyter-require) weakremover(python38-jupyter-server) weakremover(python38-jupyter-server-fileid) weakremover(python38-jupyter-server-mathjax) weakremover(python38-jupyter-server-terminals) weakremover(python38-jupyter-server-test) weakremover(python38-jupyter-sphinx) weakremover(python38-jupyter-telemetry) weakremover(python38-jupyter-ydoc) weakremover(python38-jupyter_console) weakremover(python38-jupyter_contrib_core) weakremover(python38-jupyter_highlight_selected_word) weakremover(python38-jupyter_kernel_test) weakremover(python38-jupyter_latex_envs) weakremover(python38-jupyter_nbextensions_configurator) weakremover(python38-jupyterlab) weakremover(python38-jupyterlab-pygments) weakremover(python38-jupyterlab-server) weakremover(python38-jupyterlab-server-openapi) weakremover(python38-jupyterlab-server-test) weakremover(python38-jupyterlab-templates) weakremover(python38-jupyterlab-widgets) weakremover(python38-jupytext) weakremover(python38-jwcrypto) weakremover(python38-k5test) weakremover(python38-kafka-python) weakremover(python38-kaitaistruct) weakremover(python38-kasa) weakremover(python38-kazoo) weakremover(python38-keepalive) weakremover(python38-kerberos) weakremover(python38-keyczar) weakremover(python38-keylime) weakremover(python38-keyring) weakremover(python38-keyring-keyutils) weakremover(python38-keyring-pass) weakremover(python38-keyrings.alt) weakremover(python38-khal) weakremover(python38-kismet-rest) weakremover(python38-kismetdb) weakremover(python38-kiss-headers) weakremover(python38-kitchen) weakremover(python38-kiwisolver) weakremover(python38-kmatch) weakremover(python38-kmod) weakremover(python38-knack) weakremover(python38-kombu) weakremover(python38-korean-lunar-calendar) weakremover(python38-kubernetes) weakremover(python38-kwant) weakremover(python38-l20n) weakremover(python38-labelImg) weakremover(python38-labels) weakremover(python38-lal) weakremover(python38-lalapps) weakremover(python38-lalburst) weakremover(python38-lalframe) weakremover(python38-lalinference) weakremover(python38-lalinspiral) weakremover(python38-lalmetaio) weakremover(python38-lalpulsar) weakremover(python38-lalsimulation) weakremover(python38-lancet-ioam) weakremover(python38-langdetect) weakremover(python38-langtable) weakremover(python38-language-check) weakremover(python38-lark) weakremover(python38-lark-parser) weakremover(python38-latexcodec) weakremover(python38-lazr.config) weakremover(python38-lazr.delegates) weakremover(python38-lazr.uri) weakremover(python38-lazy) weakremover(python38-lazy-loader) weakremover(python38-lazy-object-proxy) weakremover(python38-lazyarray) weakremover(python38-ldap) weakremover(python38-ldap3) weakremover(python38-ldapdomaindump) weakremover(python38-ldappool) weakremover(python38-ldaptor) weakremover(python38-ldas-tools-al-swig) weakremover(python38-leather) weakremover(python38-leglight) weakremover(python38-lesscpy) weakremover(python38-leveldb) weakremover(python38-lexicon) weakremover(python38-lfdfiles) weakremover(python38-lhafile) weakremover(python38-lib3to6) weakremover(python38-libarchive) weakremover(python38-libarchive-c) weakremover(python38-libbde) weakremover(python38-libcaes) weakremover(python38-libcreg) weakremover(python38-libcst) weakremover(python38-libesedb) weakremover(python38-libevdev) weakremover(python38-libevt) weakremover(python38-libevtx) weakremover(python38-libewf) weakremover(python38-libexe) weakremover(python38-libfmos) weakremover(python38-libfsapfs) weakremover(python38-libfsext) weakremover(python38-libfsfat) weakremover(python38-libfshfs) weakremover(python38-libfsntfs) weakremover(python38-libfsxfs) weakremover(python38-libfvde) weakremover(python38-libfwnt) weakremover(python38-libfwps) weakremover(python38-libfwsi) weakremover(python38-libkdumpfile) weakremover(python38-liblarch) weakremover(python38-liblarch-gtk) weakremover(python38-liblnk) weakremover(python38-libluksde) weakremover(python38-libmodi) weakremover(python38-libmount) weakremover(python38-libmsiecf) weakremover(python38-libmsym) weakremover(python38-libnacl) weakremover(python38-libolecf) weakremover(python38-libpff) weakremover(python38-libpfm) weakremover(python38-libphdi) weakremover(python38-libqcow) weakremover(python38-libregf) weakremover(python38-librosa) weakremover(python38-librouteros) weakremover(python38-libsass) weakremover(python38-libscca) weakremover(python38-libsigscan) weakremover(python38-libsmdev) weakremover(python38-libsmraw) weakremover(python38-libusb1) weakremover(python38-libvhdi) weakremover(python38-libvirt-python) weakremover(python38-libvmdk) weakremover(python38-libvsapm) weakremover(python38-libvsgpt) weakremover(python38-libvshadow) weakremover(python38-libvslvm) weakremover(python38-libvsmbr) weakremover(python38-libwrc) weakremover(python38-libxml2) weakremover(python38-license-expression) weakremover(python38-ligo-lw) weakremover(python38-ligo-segments) weakremover(python38-ligotimegps) weakremover(python38-limnoria) weakremover(python38-line_profiler) weakremover(python38-linecache2) weakremover(python38-linetable) weakremover(python38-lineup-widget) weakremover(python38-link-traits) weakremover(python38-linkify-it-py) weakremover(python38-linode-cli) weakremover(python38-linstor) weakremover(python38-linstor-client) weakremover(python38-linux-procfs) weakremover(python38-lit) weakremover(python38-littleutils) weakremover(python38-livereload) weakremover(python38-llfuse) weakremover(python38-llvmlite) weakremover(python38-lmdb) weakremover(python38-lmfit) weakremover(python38-lml) weakremover(python38-localzone) weakremover(python38-locket) weakremover(python38-lockfile) weakremover(python38-logilab-common) weakremover(python38-loguru) weakremover(python38-logutils) weakremover(python38-logzero) weakremover(python38-looseversion) weakremover(python38-lscsoft-glue) weakremover(python38-lupa) weakremover(python38-lws) weakremover(python38-lxml) weakremover(python38-lxml-devel) weakremover(python38-lz4) weakremover(python38-lzmaffi) weakremover(python38-m2r) weakremover(python38-macholib) weakremover(python38-magic) weakremover(python38-magic-wormhole) weakremover(python38-magic-wormhole-mailbox-server) weakremover(python38-magic-wormhole-transit-relay) weakremover(python38-magicalimport) weakremover(python38-mailman) weakremover(python38-mailman3-fedmsg-plugin) weakremover(python38-mailmanclient) weakremover(python38-main-wrapper) weakremover(python38-makefun) weakremover(python38-managesieve) weakremover(python38-mando) weakremover(python38-manuel) weakremover(python38-manuel-doc) weakremover(python38-marathon) weakremover(python38-markdown-it-py) weakremover(python38-markdown-math) weakremover(python38-markdown2) weakremover(python38-marshmallow) weakremover(python38-marshmallow-enum) weakremover(python38-material-color-utilities-python) weakremover(python38-mathgl) weakremover(python38-mathics-pygments) weakremover(python38-matplotlib) weakremover(python38-matplotlib-cairo) weakremover(python38-matplotlib-gtk-common) weakremover(python38-matplotlib-gtk3) weakremover(python38-matplotlib-gtk4) weakremover(python38-matplotlib-inline) weakremover(python38-matplotlib-latex) weakremover(python38-matplotlib-qt5) weakremover(python38-matplotlib-testdata) weakremover(python38-matplotlib-tk) weakremover(python38-matplotlib-web) weakremover(python38-matplotlib-wx) weakremover(python38-matrix-nio) weakremover(python38-matrix_common) weakremover(python38-maturin) weakremover(python38-mautrix) weakremover(python38-maxminddb) weakremover(python38-mbstrdecoder) weakremover(python38-mccabe) weakremover(python38-md2workflow) weakremover(python38-md2workflow-plugins-jira) weakremover(python38-md2workflow-plugins-redmine) weakremover(python38-mdit-py-plugins) weakremover(python38-mdurl) weakremover(python38-mechanize) weakremover(python38-mediafile) weakremover(python38-meld3) weakremover(python38-memory_profiler) weakremover(python38-mercantile) weakremover(python38-merge3) weakremover(python38-mergedeep) weakremover(python38-meson-python) weakremover(python38-metaextract) weakremover(python38-metakernel) weakremover(python38-metamagic.json) weakremover(python38-methodtools) weakremover(python38-micropipenv) weakremover(python38-mimesis) weakremover(python38-minidb) weakremover(python38-minio) weakremover(python38-miniupnpc) weakremover(python38-misaka) weakremover(python38-missingno) weakremover(python38-mistune) weakremover(python38-mitmproxy) weakremover(python38-mitmproxy-wireguard) weakremover(python38-mizani) weakremover(python38-mkdocs) weakremover(python38-mkdocs-bootstrap) weakremover(python38-moban) weakremover(python38-moban-ansible) weakremover(python38-mobi) weakremover(python38-mock) weakremover(python38-mock-open) weakremover(python38-mocket) weakremover(python38-mockito) weakremover(python38-mockldap) weakremover(python38-model-bakery) weakremover(python38-modernize) weakremover(python38-mohawk) weakremover(python38-moksha-common) weakremover(python38-moksha-hub) weakremover(python38-mongoengine) weakremover(python38-monitoring-plugins-http_json) weakremover(python38-monotonic) weakremover(python38-more-itertools) weakremover(python38-moreorless) weakremover(python38-moretools) weakremover(python38-moto) weakremover(python38-moto-all) weakremover(python38-moto-server) weakremover(python38-mpi4py) weakremover(python38-mpi4py-devel) weakremover(python38-mpl-animators) weakremover(python38-mplcursors) weakremover(python38-mpld3) weakremover(python38-mpmath) weakremover(python38-mrcz) weakremover(python38-mrkd) weakremover(python38-msal) weakremover(python38-msal-extensions) weakremover(python38-msgpack) weakremover(python38-msgpack-numpy) weakremover(python38-msk) weakremover(python38-msm) weakremover(python38-msoffcrypto-tool) weakremover(python38-msrest) weakremover(python38-msrestazure) weakremover(python38-mss) weakremover(python38-mujson) weakremover(python38-mulpyplexer) weakremover(python38-multi_key_dict) weakremover(python38-multidict) weakremover(python38-multipledispatch) weakremover(python38-multivolumefile) weakremover(python38-munch) weakremover(python38-munkres) weakremover(python38-musicbrainzngs) weakremover(python38-mutagen) weakremover(python38-mutatorMath) weakremover(python38-mutmut) weakremover(python38-mutt-ics) weakremover(python38-mwclient) weakremover(python38-mycli) weakremover(python38-mygpoclient) weakremover(python38-mypy) weakremover(python38-mypy-protobuf) weakremover(python38-mypy_extensions) weakremover(python38-mysql-connector-python) weakremover(python38-mysql-to-sqlite3) weakremover(python38-mysqlclient) weakremover(python38-myst-parser) weakremover(python38-nagiosplugin) weakremover(python38-napalm) weakremover(python38-napalm-ansible) weakremover(python38-napalm-arubaos-switch) weakremover(python38-napalm-asa) weakremover(python38-napalm-digineo-procurve) weakremover(python38-napalm-procurve) weakremover(python38-natsort) weakremover(python38-nautilus) weakremover(python38-nautilus-devel) weakremover(python38-nbclassic) weakremover(python38-nbclient) weakremover(python38-nbconvert) weakremover(python38-nbdime) weakremover(python38-nbdime-git) weakremover(python38-nbdime-hg) weakremover(python38-nbformat) weakremover(python38-nbindex-jupyter) weakremover(python38-nbinteract) weakremover(python38-nbsmoke) weakremover(python38-nbsphinx) weakremover(python38-nbsphinx-link) weakremover(python38-nbval) weakremover(python38-nbxmpp) weakremover(python38-nbxmpp-doc) weakremover(python38-ncclient) weakremover(python38-ndg-httpsclient) weakremover(python38-ndjson) weakremover(python38-neovim) weakremover(python38-neovim-remote) weakremover(python38-nest-asyncio) weakremover(python38-nested-lookup) weakremover(python38-net-snmp) weakremover(python38-netCDF4) weakremover(python38-netaddr) weakremover(python38-netifaces) weakremover(python38-netmiko) weakremover(python38-netpbmfile) weakremover(python38-netutils) weakremover(python38-networkx) weakremover(python38-nibabel) weakremover(python38-nilearn) weakremover(python38-nine) weakremover(python38-nlopt) weakremover(python38-nltk) weakremover(python38-nocasedict) weakremover(python38-nocaselist) weakremover(python38-node-semver) weakremover(python38-nodeenv) weakremover(python38-nornir) weakremover(python38-nose) weakremover(python38-nose-cov) weakremover(python38-nose-cover3) weakremover(python38-nose-exclude) weakremover(python38-nose-progressive) weakremover(python38-nose-timer) weakremover(python38-nose2) weakremover(python38-nose_warnings_filters) weakremover(python38-nosexcover) weakremover(python38-notebook) weakremover(python38-notebook-lang) weakremover(python38-notebook-shim) weakremover(python38-notify2) weakremover(python38-nox) weakremover(python38-npTDMS) weakremover(python38-nptyping) weakremover(python38-nss) weakremover(python38-ntc-templates) weakremover(python38-ntfy) weakremover(python38-ntlm-auth) weakremover(python38-ntplib) weakremover(python38-num2words) weakremover(python38-numba) weakremover(python38-numba-devel) weakremover(python38-numcodecs) weakremover(python38-numericalunits) weakremover(python38-numexpr) weakremover(python38-numpy) weakremover(python38-numpy-devel) weakremover(python38-numpy-gnu-hpc) weakremover(python38-numpy-gnu-hpc-devel) weakremover(python38-numpy_1_19_5-gnu-hpc) weakremover(python38-numpy_1_19_5-gnu-hpc-devel) weakremover(python38-numpy_1_20_1-gnu-hpc) weakremover(python38-numpy_1_20_1-gnu-hpc-devel) weakremover(python38-numpy_1_20_2-gnu-hpc) weakremover(python38-numpy_1_20_2-gnu-hpc-devel) weakremover(python38-numpy_1_20_3-gnu-hpc) weakremover(python38-numpy_1_20_3-gnu-hpc-devel) weakremover(python38-numpy_1_21_0-gnu-hpc) weakremover(python38-numpy_1_21_0-gnu-hpc-devel) weakremover(python38-numpy_1_21_2-gnu-hpc) weakremover(python38-numpy_1_21_2-gnu-hpc-devel) weakremover(python38-numpy_1_21_4-gnu-hpc) weakremover(python38-numpy_1_21_4-gnu-hpc-devel) weakremover(python38-numpy_1_21_6-gnu-hpc) weakremover(python38-numpy_1_21_6-gnu-hpc-devel) weakremover(python38-numpy_1_23_4-gnu-hpc) weakremover(python38-numpy_1_23_4-gnu-hpc-devel) weakremover(python38-numpy_1_24_1-gnu-hpc) weakremover(python38-numpy_1_24_1-gnu-hpc-devel) weakremover(python38-numpy_1_24_2-gnu-hpc) weakremover(python38-numpy_1_24_2-gnu-hpc-devel) weakremover(python38-numpydoc) weakremover(python38-nwdiag) weakremover(python38-nxapi-plumbing) weakremover(python38-o2sclpy) weakremover(python38-oauth2) weakremover(python38-oauth2client) weakremover(python38-oauth2client-flask) weakremover(python38-oauth2client-gce) weakremover(python38-oauthlib) weakremover(python38-objgraph) weakremover(python38-oci-sdk) weakremover(python38-oct2py) weakremover(python38-octave-kernel) weakremover(python38-odfpy) weakremover(python38-odorik) weakremover(python38-ogr) weakremover(python38-oic) weakremover(python38-oiffile) weakremover(python38-oktaloginwrapper) weakremover(python38-olefile) weakremover(python38-oletools) weakremover(python38-olm) weakremover(python38-onnx) weakremover(python38-onnxconverter-common) weakremover(python38-opcodes) weakremover(python38-openTSNE) weakremover(python38-openai) weakremover(python38-openapi-codec) weakremover(python38-openapi-core) weakremover(python38-openapi-schema-validator) weakremover(python38-openapi-spec-validator) weakremover(python38-opencensus) weakremover(python38-opencensus-context) weakremover(python38-opencensus-ext-azure) weakremover(python38-opencensus-ext-threading) weakremover(python38-opengl) weakremover(python38-opengl-accelerate) weakremover(python38-openidc-client) weakremover(python38-openmesh) weakremover(python38-openpyxl) weakremover(python38-openqa_client) weakremover(python38-openqa_review) weakremover(python38-openstack.nose_plugin) weakremover(python38-opentelemetry-api) weakremover(python38-opentracing) weakremover(python38-openwrt-luci-rpc) weakremover(python38-opt-einsum) weakremover(python38-orange-canvas-core) weakremover(python38-orangebox) weakremover(python38-ordered-namespace) weakremover(python38-ordered-set) weakremover(python38-orderedmultidict) weakremover(python38-orjson) weakremover(python38-osc-tiny) weakremover(python38-oscrypto) weakremover(python38-osmviz) weakremover(python38-ospd) weakremover(python38-ospd-openvas) weakremover(python38-outcome) weakremover(python38-ovirt-engine-sdk) weakremover(python38-ovs) weakremover(python38-pa-ringbuffer) weakremover(python38-packaging) weakremover(python38-padaos) weakremover(python38-padatious) weakremover(python38-paho-mqtt) weakremover(python38-pako) weakremover(python38-palettable) weakremover(python38-pamela) weakremover(python38-pampy) weakremover(python38-pamqp) weakremover(python38-pan-python) weakremover(python38-pandas) weakremover(python38-pandas-datareader) weakremover(python38-pandas-ext) weakremover(python38-pandocfilters) weakremover(python38-panel) weakremover(python38-panflute) weakremover(python38-papermill) weakremover(python38-parallax) weakremover(python38-param) weakremover(python38-parameterized) weakremover(python38-paramiko) weakremover(python38-paramiko-expect) weakremover(python38-parfive) weakremover(python38-parse) weakremover(python38-parse_type) weakremover(python38-parsedatetime) weakremover(python38-parsel) weakremover(python38-parsimonious) weakremover(python38-parso) weakremover(python38-parsy) weakremover(python38-partd) weakremover(python38-parted) weakremover(python38-particle) weakremover(python38-parver) weakremover(python38-pass-git-helper) weakremover(python38-pass_python_keyring) weakremover(python38-passa) weakremover(python38-passivetotal) weakremover(python38-passlib) weakremover(python38-pastel) weakremover(python38-pastream) weakremover(python38-patatt) weakremover(python38-patchy) weakremover(python38-path) weakremover(python38-pathable) weakremover(python38-pathlib) weakremover(python38-pathlib2) weakremover(python38-pathspec) weakremover(python38-pathtools) weakremover(python38-pathvalidate) weakremover(python38-patiencediff) weakremover(python38-patsy) weakremover(python38-pbkdf2) weakremover(python38-pbr) weakremover(python38-pcodedmp) weakremover(python38-pdd) weakremover(python38-pdfkit) weakremover(python38-pdfminer.six) weakremover(python38-pdfrw) weakremover(python38-pdm) weakremover(python38-pdm-pep517) weakremover(python38-pecan) weakremover(python38-peewee) weakremover(python38-pefile) weakremover(python38-pegasus-wms.api) weakremover(python38-pegasus-wms.common) weakremover(python38-pegen) weakremover(python38-pelican) weakremover(python38-pem) weakremover(python38-pendulum) weakremover(python38-pep440) weakremover(python38-pep517) weakremover(python38-pep8-naming) weakremover(python38-peppercorn) weakremover(python38-percy) weakremover(python38-perfume-bench) weakremover(python38-perky) weakremover(python38-persistent) weakremover(python38-persistent-devel) weakremover(python38-petact) weakremover(python38-pexpect) weakremover(python38-pgmagick) weakremover(python38-phabricator) weakremover(python38-phonenumbers) weakremover(python38-photutils) weakremover(python38-phply) weakremover(python38-phue) weakremover(python38-physt) weakremover(python38-pick) weakremover(python38-pickleshare) weakremover(python38-pifpaf) weakremover(python38-pika) weakremover(python38-pika-pool) weakremover(python38-pikepdf) weakremover(python38-pilkit) weakremover(python38-pingparsing) weakremover(python38-pip) weakremover(python38-pip-api) weakremover(python38-pip-licenses) weakremover(python38-pip-run) weakremover(python38-pip-shims) weakremover(python38-pip-test) weakremover(python38-pip-tools) weakremover(python38-pip-wheel) weakremover(python38-pipdeptree) weakremover(python38-pipreqs) weakremover(python38-pipx) weakremover(python38-pivy) weakremover(python38-pkgconfig) weakremover(python38-pkginfo) weakremover(python38-pkgutil-resolve-name) weakremover(python38-plaster) weakremover(python38-plaster-pastedeploy) weakremover(python38-platformdirs) weakremover(python38-platformio) weakremover(python38-plette) weakremover(python38-plotly) weakremover(python38-plotly-jupyter) weakremover(python38-pluggy) weakremover(python38-pluginbase) weakremover(python38-plumbum) weakremover(python38-ply) weakremover(python38-plyvel) weakremover(python38-pmw) weakremover(python38-pname) weakremover(python38-podcastparser) weakremover(python38-podman) weakremover(python38-podman-compose) weakremover(python38-poetry) weakremover(python38-poetry-core) weakremover(python38-poetry-plugin-export) weakremover(python38-polib) weakremover(python38-pomegranate) weakremover(python38-pomegranate-devel) weakremover(python38-pontos) weakremover(python38-pony) weakremover(python38-pooch) weakremover(python38-pook) weakremover(python38-poppler-qt5) weakremover(python38-poppler-qt5-devel) weakremover(python38-port-for) weakremover(python38-portalocker) weakremover(python38-portend) weakremover(python38-portpicker) weakremover(python38-positional) weakremover(python38-postorius) weakremover(python38-power) weakremover(python38-poyo) weakremover(python38-pprintpp) weakremover(python38-pproxy) weakremover(python38-praatio) weakremover(python38-pre-commit) weakremover(python38-precis-i18n) weakremover(python38-precise-runner) weakremover(python38-preggy) weakremover(python38-premailer) weakremover(python38-prestring) weakremover(python38-pretend) weakremover(python38-prettytable) weakremover(python38-priority) weakremover(python38-proboscis) weakremover(python38-process-tests) weakremover(python38-proglog) weakremover(python38-progress) weakremover(python38-progressbar) weakremover(python38-progressbar2) weakremover(python38-prometheus-client) weakremover(python38-prometheus_client) weakremover(python38-promise) weakremover(python38-prompt_toolkit) weakremover(python38-prompt_toolkit1) weakremover(python38-proselint) weakremover(python38-proto-plus) weakremover(python38-protobuf) weakremover(python38-proton-client) weakremover(python38-protonvpn-nm-lib) weakremover(python38-proxmoxer) weakremover(python38-proxy.py) weakremover(python38-psautohint) weakremover(python38-pscript) weakremover(python38-psutil) weakremover(python38-psychtoolbox) weakremover(python38-psycopg2) weakremover(python38-psycopg2cffi) weakremover(python38-ptpython) weakremover(python38-ptpython-ptipython) weakremover(python38-ptr) weakremover(python38-ptyprocess) weakremover(python38-publicsuffix) weakremover(python38-publicsuffix2) weakremover(python38-publicsuffixlist) weakremover(python38-pudb) weakremover(python38-pulsectl) weakremover(python38-pure-eval) weakremover(python38-pure-sasl) weakremover(python38-purl) weakremover(python38-py) weakremover(python38-py-cpuinfo) weakremover(python38-py-espeak-ng) weakremover(python38-py-moneyed) weakremover(python38-py-multihash) weakremover(python38-py-radix) weakremover(python38-py-ubjson) weakremover(python38-py-vapid) weakremover(python38-py2pack) weakremover(python38-py3dns) weakremover(python38-py3status) weakremover(python38-py7zr) weakremover(python38-pyDOE2) weakremover(python38-pyFFTW) weakremover(python38-pyLibravatar) weakremover(python38-pyModis) weakremover(python38-pyOCD) weakremover(python38-pyOpenSSL) weakremover(python38-pyPEG2) weakremover(python38-pyRFC3339) weakremover(python38-pyRXP) weakremover(python38-pyScss) weakremover(python38-pyUSID) weakremover(python38-pyVows) weakremover(python38-pyacoustid) weakremover(python38-pyaes) weakremover(python38-pyahocorasick) weakremover(python38-pyalsaaudio) weakremover(python38-pyaml) weakremover(python38-pyannotate) weakremover(python38-pyarrow) weakremover(python38-pyarrow-devel) weakremover(python38-pyasn1) weakremover(python38-pyasn1-modules) weakremover(python38-pybars3) weakremover(python38-pybcj) weakremover(python38-pybeam) weakremover(python38-pybind11) weakremover(python38-pybind11-devel) weakremover(python38-pybind11-stubgen) weakremover(python38-pyblake2) weakremover(python38-pybluez) weakremover(python38-pybtex) weakremover(python38-pybugz) weakremover(python38-pycairo) weakremover(python38-pycairo-devel) weakremover(python38-pycapnp) weakremover(python38-pycares) weakremover(python38-pycdio) weakremover(python38-pycdlib) weakremover(python38-pycha) weakremover(python38-pychm) weakremover(python38-pyclipper) weakremover(python38-pycocotools) weakremover(python38-pycodestyle) weakremover(python38-pycountry) weakremover(python38-pycparser) weakremover(python38-pycryptodome) weakremover(python38-pycryptodomex) weakremover(python38-pycsw) weakremover(python38-pyct) weakremover(python38-pycups) weakremover(python38-pycurl) weakremover(python38-pycxx) weakremover(python38-pycxx-devel) weakremover(python38-pydantic) weakremover(python38-pydash) weakremover(python38-pydata-google-auth) weakremover(python38-pydata-sphinx-theme) weakremover(python38-pydbus) weakremover(python38-pydenticon) weakremover(python38-pydicom) weakremover(python38-pydicom-data) weakremover(python38-pydle) weakremover(python38-pydocstyle) weakremover(python38-pydocumentdb) weakremover(python38-pydot) weakremover(python38-pydot3) weakremover(python38-pydotplus) weakremover(python38-pydrive2) weakremover(python38-pydub) weakremover(python38-pydyf) weakremover(python38-pyeapi) weakremover(python38-pyee) weakremover(python38-pyelftools) weakremover(python38-pyemd) weakremover(python38-pyenchant) weakremover(python38-pyerfa) weakremover(python38-pyface) weakremover(python38-pyfakefs) weakremover(python38-pyfeyn) weakremover(python38-pyfiglet) weakremover(python38-pyflakes) weakremover(python38-pyftpdlib) weakremover(python38-pyfuse3) weakremover(python38-pygal) weakremover(python38-pygaljs) weakremover(python38-pygame) weakremover(python38-pygame-devel) weakremover(python38-pygeos) weakremover(python38-pygerrit2) weakremover(python38-pygit2) weakremover(python38-pyglet) weakremover(python38-pygments-ansi-color) weakremover(python38-pygments-pytest) weakremover(python38-pygments-style-railscasts) weakremover(python38-pygn) weakremover(python38-pygraphviz) weakremover(python38-pyhcl) weakremover(python38-pyheif) weakremover(python38-pyhibp) weakremover(python38-pyicumessageformat) weakremover(python38-pyinotify) weakremover(python38-pyinstaller-hooks-contrib) weakremover(python38-pyipp) weakremover(python38-pyjavaproperties) weakremover(python38-pyjnius) weakremover(python38-pyjokes) weakremover(python38-pyjsparser) weakremover(python38-pyjwkest) weakremover(python38-pykafka) weakremover(python38-pykeepass) weakremover(python38-pykerberos) weakremover(python38-pykickstart) weakremover(python38-pykka) weakremover(python38-pykwalify) weakremover(python38-pylama) weakremover(python38-pylast) weakremover(python38-pyleri) weakremover(python38-pylev) weakremover(python38-pylibacl) weakremover(python38-pylibfdt) weakremover(python38-pyliblo) weakremover(python38-pyliblo-doc) weakremover(python38-pylibmc) weakremover(python38-pylineclip) weakremover(python38-pylint) weakremover(python38-pylint-ignore) weakremover(python38-pylint-venv) weakremover(python38-pylons-sphinx-themes) weakremover(python38-pylru) weakremover(python38-pyls-black) weakremover(python38-pyls-spyder) weakremover(python38-pylsp-rope) weakremover(python38-pylsqpack) weakremover(python38-pylzma) weakremover(python38-pymacaroons) weakremover(python38-pymacaroons-pynacl) weakremover(python38-pymad) weakremover(python38-pymarc) weakremover(python38-pymavlink) weakremover(python38-pymediainfo) weakremover(python38-pymemcache) weakremover(python38-pymetar) weakremover(python38-pymilter) weakremover(python38-pymisp) weakremover(python38-pymol) weakremover(python38-pymongo) weakremover(python38-pympv) weakremover(python38-pymssql) weakremover(python38-pynamodb) weakremover(python38-pynetbox) weakremover(python38-pyngus) weakremover(python38-pynxos) weakremover(python38-pyo) weakremover(python38-pyocr) weakremover(python38-pyodbc) weakremover(python38-pyosf) weakremover(python38-pyotp) weakremover(python38-pyowm) weakremover(python38-pyp) weakremover(python38-pypandoc) weakremover(python38-pyparallel) weakremover(python38-pyparsing) weakremover(python38-pyperclip) weakremover(python38-pyperf) weakremover(python38-pypet) weakremover(python38-pypi-search) weakremover(python38-pypipegraph) weakremover(python38-pypiserver) weakremover(python38-pypng) weakremover(python38-pyppeteer) weakremover(python38-pyppmd) weakremover(python38-pyprel) weakremover(python38-pyprimes) weakremover(python38-pyproj) weakremover(python38-pyproject-hooks) weakremover(python38-pyproject-metadata) weakremover(python38-pypsexec) weakremover(python38-pypubsub) weakremover(python38-pypuppetdb) weakremover(python38-pyqt-builder) weakremover(python38-pyquery) weakremover(python38-pyquil) weakremover(python38-pyrad) weakremover(python38-pyramid) weakremover(python38-pyramid-chameleon) weakremover(python38-pyramid-debugtoolbar) weakremover(python38-pyramid-mako) weakremover(python38-pyreadstat) weakremover(python38-pyroma) weakremover(python38-pyroomacoustics) weakremover(python38-pyroute2) weakremover(python38-pyroute2.core) weakremover(python38-pyroute2.ethtool) weakremover(python38-pyroute2.ipdb) weakremover(python38-pyroute2.ipset) weakremover(python38-pyroute2.ndb) weakremover(python38-pyroute2.nftables) weakremover(python38-pyroute2.nslink) weakremover(python38-pyrsistent) weakremover(python38-pysaml2) weakremover(python38-pyscard) weakremover(python38-pyscreenshot) weakremover(python38-pysendfile) weakremover(python38-pyserial) weakremover(python38-pysha3) weakremover(python38-pyshark) weakremover(python38-pyshould) weakremover(python38-pyshp) weakremover(python38-pysmb) weakremover(python38-pysmbc) weakremover(python38-pysmi) weakremover(python38-pysndfile) weakremover(python38-pysnmp) weakremover(python38-pysofaconventions) weakremover(python38-pysolr) weakremover(python38-pyspnego) weakremover(python38-pysrt) weakremover(python38-pyssim) weakremover(python38-pystache) weakremover(python38-pysvn) weakremover(python38-pytaglib) weakremover(python38-pyte) weakremover(python38-pytesseract) weakremover(python38-pytest) weakremover(python38-pytest-aiofiles) weakremover(python38-pytest-aiohttp) weakremover(python38-pytest-arraydiff) weakremover(python38-pytest-astropy) weakremover(python38-pytest-astropy-header) weakremover(python38-pytest-asyncio) weakremover(python38-pytest-attrib) weakremover(python38-pytest-base-url) weakremover(python38-pytest-bdd) weakremover(python38-pytest-benchmark) weakremover(python38-pytest-black) weakremover(python38-pytest-check) weakremover(python38-pytest-check-links) weakremover(python38-pytest-click) weakremover(python38-pytest-console-scripts) weakremover(python38-pytest-cookies) weakremover(python38-pytest-cov) weakremover(python38-pytest-curio) weakremover(python38-pytest-datadir) weakremover(python38-pytest-dependency) weakremover(python38-pytest-describe) weakremover(python38-pytest-django) weakremover(python38-pytest-djangoapp) weakremover(python38-pytest-doctestplus) weakremover(python38-pytest-dotenv) weakremover(python38-pytest-echo) weakremover(python38-pytest-env) weakremover(python38-pytest-error-for-skips) weakremover(python38-pytest-expect) weakremover(python38-pytest-filter-subpackage) weakremover(python38-pytest-fixture-config) weakremover(python38-pytest-flake8) weakremover(python38-pytest-flake8-path) weakremover(python38-pytest-flake8dir) weakremover(python38-pytest-flakes) weakremover(python38-pytest-flask) weakremover(python38-pytest-forked) weakremover(python38-pytest-freezegun) weakremover(python38-pytest-git) weakremover(python38-pytest-helpers-namespace) weakremover(python38-pytest-html) weakremover(python38-pytest-httpbin) weakremover(python38-pytest-httpserver) weakremover(python38-pytest-httpx) weakremover(python38-pytest-instafail) weakremover(python38-pytest-isort) weakremover(python38-pytest-json-report) weakremover(python38-pytest-jupyter) weakremover(python38-pytest-jupyter-client) weakremover(python38-pytest-jupyter-server) weakremover(python38-pytest-lazy-fixture) weakremover(python38-pytest-listener) weakremover(python38-pytest-localserver) weakremover(python38-pytest-metadata) weakremover(python38-pytest-mock) weakremover(python38-pytest-mockito) weakremover(python38-pytest-mpi) weakremover(python38-pytest-mpl) weakremover(python38-pytest-mypy) weakremover(python38-pytest-openfiles) weakremover(python38-pytest-order) weakremover(python38-pytest-ordering) weakremover(python38-pytest-parallel) weakremover(python38-pytest-percent) weakremover(python38-pytest-plus) weakremover(python38-pytest-profiling) weakremover(python38-pytest-pycodestyle) weakremover(python38-pytest-pyramid-server) weakremover(python38-pytest-pythonpath) weakremover(python38-pytest-qt) weakremover(python38-pytest-random-order) weakremover(python38-pytest-randomly) weakremover(python38-pytest-regressions) weakremover(python38-pytest-relaxed) weakremover(python38-pytest-remotedata) weakremover(python38-pytest-reorder) weakremover(python38-pytest-repeat) weakremover(python38-pytest-rerunfailures) weakremover(python38-pytest-responsemock) weakremover(python38-pytest-runner) weakremover(python38-pytest-server-fixtures) weakremover(python38-pytest-services) weakremover(python38-pytest-shutil) weakremover(python38-pytest-socket) weakremover(python38-pytest-spec) weakremover(python38-pytest-sphinx) weakremover(python38-pytest-subprocess) weakremover(python38-pytest-subtesthack) weakremover(python38-pytest-subtests) weakremover(python38-pytest-sugar) weakremover(python38-pytest-super-check) weakremover(python38-pytest-svn) weakremover(python38-pytest-testconfig) weakremover(python38-pytest-testinfra) weakremover(python38-pytest-timeout) weakremover(python38-pytest-tldr) weakremover(python38-pytest-toolbox) weakremover(python38-pytest-tornado) weakremover(python38-pytest-tornasync) weakremover(python38-pytest-translations) weakremover(python38-pytest-travis-fold) weakremover(python38-pytest-trio) weakremover(python38-pytest-twisted) weakremover(python38-pytest-vcr) weakremover(python38-pytest-verbose-parametrize) weakremover(python38-pytest-virtualenv) weakremover(python38-pytest-xdist) weakremover(python38-pytest-xprocess) weakremover(python38-pytest-xvfb) weakremover(python38-pytest5) weakremover(python38-python-afl) weakremover(python38-python-aiml) weakremover(python38-python-akismet) weakremover(python38-python-args) weakremover(python38-python-barcode) weakremover(python38-python-bidi) weakremover(python38-python-binary-memcached) weakremover(python38-python-box) weakremover(python38-python-cjson) weakremover(python38-python-consul) weakremover(python38-python-coveralls) weakremover(python38-python-crfsuite) weakremover(python38-python-crontab) weakremover(python38-python-daemon) weakremover(python38-python-datamatrix) weakremover(python38-python-dateutil) weakremover(python38-python-dbusmock) weakremover(python38-python-debian) weakremover(python38-python-dmidecode) weakremover(python38-python-docs-theme) weakremover(python38-python-doi) weakremover(python38-python-dotenv) weakremover(python38-python-editor) weakremover(python38-python-engineio) weakremover(python38-python-fedora) weakremover(python38-python-for-android) weakremover(python38-python-gammu) weakremover(python38-python-gflags) weakremover(python38-python-gitlab) weakremover(python38-python-gnupg) weakremover(python38-python-gvm) weakremover(python38-python-jenkins) weakremover(python38-python-jose) weakremover(python38-python-jose-cryptography) weakremover(python38-python-json-logger) weakremover(python38-python-jsonrpc-server) weakremover(python38-python-jsonschema-objects) weakremover(python38-python-keycloak) weakremover(python38-python-language-server) weakremover(python38-python-louvain) weakremover(python38-python-lsp-black) weakremover(python38-python-lsp-jsonrpc) weakremover(python38-python-lsp-server) weakremover(python38-python-lzo) weakremover(python38-python-magic) weakremover(python38-python-memcached) weakremover(python38-python-mimeparse) weakremover(python38-python-mpd2) weakremover(python38-python-mpv) weakremover(python38-python-multipart) weakremover(python38-python-nmap) weakremover(python38-python-openid-cla) weakremover(python38-python-openid-teams) weakremover(python38-python-pam) weakremover(python38-python-poppler) weakremover(python38-python-pptx) weakremover(python38-python-prctl) weakremover(python38-python-pseudorandom) weakremover(python38-python-ptrace) weakremover(python38-python-qdatamatrix) weakremover(python38-python-qpid-proton) weakremover(python38-python-qprogedit) weakremover(python38-python-rapidjson) weakremover(python38-python-redis-lock) weakremover(python38-python-redmine) weakremover(python38-python-rpm-spec) weakremover(python38-python-rtmidi) weakremover(python38-python-rtmidi-doc) weakremover(python38-python-slugify) weakremover(python38-python-snappy) weakremover(python38-python-socketio) weakremover(python38-python-socks) weakremover(python38-python-sofa) weakremover(python38-python-sql) weakremover(python38-python-stdnum) weakremover(python38-python-subunit) weakremover(python38-python-ternary) weakremover(python38-python-twitter) weakremover(python38-python-utils) weakremover(python38-python-vlc) weakremover(python38-python-whois) weakremover(python38-python-xlib) weakremover(python38-python-yubico) weakremover(python38-python3-openid) weakremover(python38-python3-saml) weakremover(python38-pythondialog) weakremover(python38-pythonfinder) weakremover(python38-pythonwhois) weakremover(python38-pythran) weakremover(python38-pythreejs) weakremover(python38-pytidylib) weakremover(python38-pytils) weakremover(python38-pytimeparse) weakremover(python38-pytlv) weakremover(python38-pytoml) weakremover(python38-pytoolconfig) weakremover(python38-pytoolconfig-global) weakremover(python38-pytoolconfig-validation) weakremover(python38-pytools) weakremover(python38-pytricia) weakremover(python38-pytz) weakremover(python38-pytz-deprecation-shim) weakremover(python38-pytzdata) weakremover(python38-pyu2f) weakremover(python38-pyuca) weakremover(python38-pyudev) weakremover(python38-pyupgrade) weakremover(python38-pyusb) weakremover(python38-pyuv) weakremover(python38-pyux) weakremover(python38-pyvdr) weakremover(python38-pyvips) weakremover(python38-pyviz-comms) weakremover(python38-pyvmomi) weakremover(python38-pywal) weakremover(python38-pywayland) weakremover(python38-pywbem) weakremover(python38-pywbemtools) weakremover(python38-pywebpush) weakremover(python38-pywinrm) weakremover(python38-pywlroots) weakremover(python38-pyxattr) weakremover(python38-pyxdg) weakremover(python38-pyyaml_env_tag) weakremover(python38-pyzmq) weakremover(python38-pyzmq-devel) weakremover(python38-pyzo) weakremover(python38-pyzstd) weakremover(python38-q) weakremover(python38-qcs-api-client) weakremover(python38-qet_tb_generator) weakremover(python38-qgrid) weakremover(python38-qpageview) weakremover(python38-qrcode) weakremover(python38-qscintilla-qt5) weakremover(python38-qscintilla-qt5-sip) weakremover(python38-qstylizer) weakremover(python38-qsymm) weakremover(python38-qt3d-qt5) weakremover(python38-qt3d-qt5-api) weakremover(python38-qt3d-qt5-devel) weakremover(python38-qt3d-qt5-doc) weakremover(python38-qt3d-qt5-sip) weakremover(python38-qt5) weakremover(python38-qt5-devel) weakremover(python38-qt5-doc) weakremover(python38-qt5-quick3d) weakremover(python38-qt5-quick3d-devel) weakremover(python38-qt5-remoteobjects) weakremover(python38-qt5-remoteobjects-devel) weakremover(python38-qt5-sip) weakremover(python38-qtcharts-qt5) weakremover(python38-qtcharts-qt5-api) weakremover(python38-qtcharts-qt5-doc) weakremover(python38-qtcharts-qt5-sip) weakremover(python38-qtconsole) weakremover(python38-qtdatavis3d-qt5) weakremover(python38-qtdatavis3d-qt5-api) weakremover(python38-qtdatavis3d-qt5-devel) weakremover(python38-qtdatavis3d-qt5-doc) weakremover(python38-qtdatavis3d-qt5-sip) weakremover(python38-qtnetworkauth-qt5) weakremover(python38-qtnetworkauth-qt5-devel) weakremover(python38-qtwebengine-qt5) weakremover(python38-qtwebengine-qt5-api) weakremover(python38-qtwebengine-qt5-devel) weakremover(python38-qtwebengine-qt5-sip) weakremover(python38-quantities) weakremover(python38-quantum-blackbird) weakremover(python38-queuelib) weakremover(python38-quicktions) weakremover(python38-quimb) weakremover(python38-radexreader) weakremover(python38-radon) weakremover(python38-railroad-diagrams) weakremover(python38-random2) weakremover(python38-rapidfuzz) weakremover(python38-rarfile) weakremover(python38-rarfile-doc) weakremover(python38-ravello-sdk) weakremover(python38-raven) weakremover(python38-raven-aiohttp) weakremover(python38-rawkit) weakremover(python38-rcssmin) weakremover(python38-rdflib) weakremover(python38-re-assert) weakremover(python38-readme_renderer) weakremover(python38-readthedocs-sphinx-ext) weakremover(python38-rebulk) weakremover(python38-recommonmark) weakremover(python38-reconfigure) weakremover(python38-recordclass) weakremover(python38-redbaron) weakremover(python38-redfish) weakremover(python38-redis) weakremover(python38-rednose) weakremover(python38-reedsolo) weakremover(python38-referencing) weakremover(python38-regex) weakremover(python38-relatorio) weakremover(python38-releases) weakremover(python38-remoto) weakremover(python38-rencode) weakremover(python38-reportlab) weakremover(python38-repoze.lru) weakremover(python38-repoze.sphinx.autointerface) weakremover(python38-repoze.who) weakremover(python38-reproject) weakremover(python38-requestbuilder) weakremover(python38-requests) weakremover(python38-requests-aws) weakremover(python38-requests-cache) weakremover(python38-requests-download) weakremover(python38-requests-file) weakremover(python38-requests-ftp) weakremover(python38-requests-futures) weakremover(python38-requests-gssapi) weakremover(python38-requests-hawk) weakremover(python38-requests-html) weakremover(python38-requests-kerberos) weakremover(python38-requests-mock) weakremover(python38-requests-oauthlib) weakremover(python38-requests-toolbelt) weakremover(python38-requests-unixsocket) weakremover(python38-requests-wsgi-adapter) weakremover(python38-requests_ntlm) weakremover(python38-requestsexceptions) weakremover(python38-requirements-detector) weakremover(python38-requirements-parser) weakremover(python38-requirementslib) weakremover(python38-requre) weakremover(python38-resampy) weakremover(python38-resolvelib) weakremover(python38-responses) weakremover(python38-respx) weakremover(python38-restructuredtext_lint) weakremover(python38-restview) weakremover(python38-resultsdb_api) weakremover(python38-rethinkdb) weakremover(python38-retry) weakremover(python38-retry_decorator) weakremover(python38-retrying) weakremover(python38-retryrequests) weakremover(python38-rfc3339-validator) weakremover(python38-rfc3986) weakremover(python38-rfc3986-validator) weakremover(python38-rfc3987) weakremover(python38-rfc6555) weakremover(python38-rich) weakremover(python38-rich-click) weakremover(python38-rise) weakremover(python38-rjsmin) weakremover(python38-rnc2rng) weakremover(python38-rnginline) weakremover(python38-robot-detection) weakremover(python38-robotframework) weakremover(python38-roifile) weakremover(python38-rollbar) weakremover(python38-roman) weakremover(python38-rope) weakremover(python38-rpcq) weakremover(python38-rpds-py) weakremover(python38-rply) weakremover(python38-rpm) weakremover(python38-rpmfile) weakremover(python38-rpmlb) weakremover(python38-rpy2) weakremover(python38-rpyc) weakremover(python38-rq) weakremover(python38-rsa) weakremover(python38-rss2email) weakremover(python38-rst.linker) weakremover(python38-rstcheck) weakremover(python38-rt) weakremover(python38-rtslib-fb) weakremover(python38-ruamel.base) weakremover(python38-ruamel.std.argparse) weakremover(python38-ruamel.std.pathlib) weakremover(python38-ruamel.yaml) weakremover(python38-ruamel.yaml.clib) weakremover(python38-ruamel.yaml.cmd) weakremover(python38-ruamel.yaml.convert) weakremover(python38-ruffus) weakremover(python38-runthis-sphinxext) weakremover(python38-rustcfg) weakremover(python38-s3fs) weakremover(python38-s3transfer) weakremover(python38-sadisplay) weakremover(python38-safe-netrc) weakremover(python38-sambacc) weakremover(python38-samplerate) weakremover(python38-sane) weakremover(python38-sanlock) weakremover(python38-sarge) weakremover(python38-sarif-om) weakremover(python38-sas7bdat) weakremover(python38-sasl) weakremover(python38-sat-search) weakremover(python38-sat-stac) weakremover(python38-scales) weakremover(python38-scandir) weakremover(python38-schedule) weakremover(python38-schema) weakremover(python38-scikit-build) weakremover(python38-scikit-build-core) weakremover(python38-scikit-build-core-pyproject) weakremover(python38-scikit-dsp-comm) weakremover(python38-scikit-hep-testdata) weakremover(python38-scikit-image) weakremover(python38-scikit-learn) weakremover(python38-scikit-sound) weakremover(python38-scikit-sparse) weakremover(python38-scipy) weakremover(python38-scipy-gnu-hpc) weakremover(python38-scipy_1_10_1-gnu-hpc) weakremover(python38-scipy_1_6_0-gnu-hpc) weakremover(python38-scipy_1_7_3-gnu-hpc) weakremover(python38-scipy_1_8_0-gnu-hpc) weakremover(python38-scipy_1_9_1-gnu-hpc) weakremover(python38-scipy_1_9_2-gnu-hpc) weakremover(python38-scipy_1_9_3-gnu-hpc) weakremover(python38-scitokens) weakremover(python38-scour) weakremover(python38-scp) weakremover(python38-screeninfo) weakremover(python38-screenplain) weakremover(python38-scripttest) weakremover(python38-scrypt) weakremover(python38-scspell3k) weakremover(python38-sdnotify) weakremover(python38-seaborn) weakremover(python38-securesystemslib) weakremover(python38-selection) weakremover(python38-selectors2) weakremover(python38-selenium) weakremover(python38-semanage) weakremover(python38-semantic_version) weakremover(python38-semver) weakremover(python38-sentry-sdk) weakremover(python38-seqdiag) weakremover(python38-serpent) weakremover(python38-serpy) weakremover(python38-serverfiles) weakremover(python38-service_identity) weakremover(python38-setools) weakremover(python38-setproctitle) weakremover(python38-setupmeta) weakremover(python38-setuptools) weakremover(python38-setuptools-declarative-requirements) weakremover(python38-setuptools-gettext) weakremover(python38-setuptools-git) weakremover(python38-setuptools-git-versioning) weakremover(python38-setuptools-rust) weakremover(python38-setuptools-test) weakremover(python38-setuptools-version-command) weakremover(python38-setuptools-wheel) weakremover(python38-setuptools_scm) weakremover(python38-setuptools_scm_git_archive) weakremover(python38-sfs) weakremover(python38-sge-pygame) weakremover(python38-sgmllib3k) weakremover(python38-sgp4) weakremover(python38-sh) weakremover(python38-shaptools) weakremover(python38-shellingham) weakremover(python38-sherpa) weakremover(python38-shijian) weakremover(python38-shinyutils) weakremover(python38-shodan) weakremover(python38-shortuuid) weakremover(python38-show-in-file-manager) weakremover(python38-sidecar) weakremover(python38-sidpy) weakremover(python38-sievelib) weakremover(python38-sigal) weakremover(python38-signedjson) weakremover(python38-simpleaudio) weakremover(python38-simplebayes) weakremover(python38-simpleeval) weakremover(python38-simplegeneric) weakremover(python38-simplejson) weakremover(python38-simplekml) weakremover(python38-single-version) weakremover(python38-singledispatch) weakremover(python38-siosocks) weakremover(python38-sip) weakremover(python38-sip-devel) weakremover(python38-sip4) weakremover(python38-sip4-devel) weakremover(python38-sip5-devel) weakremover(python38-sip6-devel) weakremover(python38-siphashc) weakremover(python38-six) weakremover(python38-sklearn-pandas) weakremover(python38-skyfield) weakremover(python38-slack-sdk) weakremover(python38-slackclient) weakremover(python38-sleekxmpp) weakremover(python38-slimit) weakremover(python38-slip) weakremover(python38-slip-dbus) weakremover(python38-slixmpp) weakremover(python38-slumber) weakremover(python38-slycot) weakremover(python38-smart-open) weakremover(python38-smartypants) weakremover(python38-smbprotocol) weakremover(python38-smmap) weakremover(python38-smpplib) weakremover(python38-sniffio) weakremover(python38-snimpy) weakremover(python38-snowballstemmer) weakremover(python38-snuggs) weakremover(python38-social-auth-app-django) weakremover(python38-social-auth-core) weakremover(python38-socketIO-client-nexus) weakremover(python38-socketpool) weakremover(python38-softlayer) weakremover(python38-softlayer-zeep) weakremover(python38-sorl-thumbnail) weakremover(python38-sortedcollections) weakremover(python38-sortedcontainers) weakremover(python38-sortinghat) weakremover(python38-sounddevice) weakremover(python38-soupsieve) weakremover(python38-sox) weakremover(python38-soxr) weakremover(python38-spake2) weakremover(python38-spark_parser) weakremover(python38-sparse) weakremover(python38-speaklater) weakremover(python38-spec) weakremover(python38-sphinx-argparse) weakremover(python38-sphinx-autobuild) weakremover(python38-sphinx-autodoc-typehints) weakremover(python38-sphinx-book-theme) weakremover(python38-sphinx-bootstrap-theme) weakremover(python38-sphinx-click) weakremover(python38-sphinx-feature-classification) weakremover(python38-sphinx-inline-tabs) weakremover(python38-sphinx-issues) weakremover(python38-sphinx-jsonschema) weakremover(python38-sphinx-qt-documentation) weakremover(python38-sphinx-removed-in) weakremover(python38-sphinx-tabs) weakremover(python38-sphinx-testing) weakremover(python38-sphinx-theme-builder) weakremover(python38-sphinx-version-warning) weakremover(python38-sphinx_mdinclude) weakremover(python38-sphinx_press_theme) weakremover(python38-sphinx_rtd_theme) weakremover(python38-sphinxcontrib-actdiag) weakremover(python38-sphinxcontrib-apidoc) weakremover(python38-sphinxcontrib-applehelp) weakremover(python38-sphinxcontrib-asyncio) weakremover(python38-sphinxcontrib-autoprogram) weakremover(python38-sphinxcontrib-autoprogram-doc) weakremover(python38-sphinxcontrib-blockdiag) weakremover(python38-sphinxcontrib-copybutton) weakremover(python38-sphinxcontrib-devhelp) weakremover(python38-sphinxcontrib-documentedlist) weakremover(python38-sphinxcontrib-fulltoc) weakremover(python38-sphinxcontrib-github-alt) weakremover(python38-sphinxcontrib-htmlhelp) weakremover(python38-sphinxcontrib-httpdomain) weakremover(python38-sphinxcontrib-issuetracker) weakremover(python38-sphinxcontrib-jsmath) weakremover(python38-sphinxcontrib-newsfeed) weakremover(python38-sphinxcontrib-nwdiag) weakremover(python38-sphinxcontrib-pecanwsme) weakremover(python38-sphinxcontrib-plantuml) weakremover(python38-sphinxcontrib-programoutput) weakremover(python38-sphinxcontrib-qthelp) weakremover(python38-sphinxcontrib-seqdiag) weakremover(python38-sphinxcontrib-serializinghtml) weakremover(python38-sphinxcontrib-svg2pdfconverter) weakremover(python38-sphinxcontrib-towncrier) weakremover(python38-sphinxcontrib-trio) weakremover(python38-sphinxcontrib-websupport) weakremover(python38-sphinxext-opengraph) weakremover(python38-sphobjinv) weakremover(python38-spidev) weakremover(python38-spotipy) weakremover(python38-spur) weakremover(python38-spyder-kernels) weakremover(python38-sqlalchemy-migrate) weakremover(python38-sqlglot) weakremover(python38-sqlite-fts4) weakremover(python38-sqlite-utils) weakremover(python38-sqlite3-to-mysql) weakremover(python38-sqlitedict) weakremover(python38-sqlparse) weakremover(python38-sqlsoup) weakremover(python38-srcinfo) weakremover(python38-ssdeep) weakremover(python38-sshpubkeys) weakremover(python38-sshtunnel) weakremover(python38-stack-data) weakremover(python38-starlette) weakremover(python38-statsd) weakremover(python38-statsmodels) weakremover(python38-stdeb) weakremover(python38-stem) weakremover(python38-stestr) weakremover(python38-stomp.py) weakremover(python38-stomper) weakremover(python38-straight-plugin) weakremover(python38-streamz) weakremover(python38-strict-rfc3339) weakremover(python38-strictyaml) weakremover(python38-stripe) weakremover(python38-structlog) weakremover(python38-subgrab) weakremover(python38-subliminal) weakremover(python38-subprocess-tee) weakremover(python38-subprocrunner) weakremover(python38-subscene-api) weakremover(python38-subst) weakremover(python38-suds) weakremover(python38-suds-community) weakremover(python38-suds-jurko) weakremover(python38-sunpy) weakremover(python38-suntime) weakremover(python38-sure) weakremover(python38-surer) weakremover(python38-svglib) weakremover(python38-svgpathtools) weakremover(python38-svgwrite) weakremover(python38-svm) weakremover(python38-svneverever) weakremover(python38-swagger-spec-validator) weakremover(python38-swapper) weakremover(python38-swifter) weakremover(python38-sybil) weakremover(python38-sympy) weakremover(python38-synr) weakremover(python38-system-hotkey310) weakremover(python38-system_hotkey) weakremover(python38-systemd) weakremover(python38-tableauserverclient) weakremover(python38-tableprint) weakremover(python38-tables) weakremover(python38-tablib) weakremover(python38-tabpy) weakremover(python38-tabulate) weakremover(python38-tap.py) weakremover(python38-targetcli-fb) weakremover(python38-tasklib) weakremover(python38-taskw) weakremover(python38-tbb) weakremover(python38-tblib) weakremover(python38-tcolorpy) weakremover(python38-technicolor) weakremover(python38-telepot) weakremover(python38-telethon-session-sqlalchemy) weakremover(python38-template-remover) weakremover(python38-tempora) weakremover(python38-tenacity) weakremover(python38-tensorpac) weakremover(python38-term-background) weakremover(python38-termcolor) weakremover(python38-terminado) weakremover(python38-terminaltables) weakremover(python38-termstyle) weakremover(python38-tesserocr) weakremover(python38-test-server) weakremover(python38-testfixtures) weakremover(python38-testflo) weakremover(python38-testpath) weakremover(python38-testrepository) weakremover(python38-testresources) weakremover(python38-testscenarios) weakremover(python38-testsuite) weakremover(python38-testtools) weakremover(python38-text-unidecode) weakremover(python38-textX) weakremover(python38-textdistance) weakremover(python38-textfsm) weakremover(python38-textile) weakremover(python38-texttable) weakremover(python38-textwrap3) weakremover(python38-thLib) weakremover(python38-thespian) weakremover(python38-thewalrus) weakremover(python38-threadpoolctl) weakremover(python38-three-merge) weakremover(python38-threevis) weakremover(python38-thrift) weakremover(python38-thriftpy2) weakremover(python38-tifffile) weakremover(python38-time-machine) weakremover(python38-time-travel) weakremover(python38-timeout-decorator) weakremover(python38-tinyarray) weakremover(python38-tinycss2) weakremover(python38-tinydb) weakremover(python38-tinyrecord) weakremover(python38-tinyrpc) weakremover(python38-titlecase) weakremover(python38-tk) weakremover(python38-tkreadonly) weakremover(python38-tld) weakremover(python38-tldextract) weakremover(python38-tmx) weakremover(python38-tokenize-rt) weakremover(python38-toml) weakremover(python38-tomli) weakremover(python38-tomli-w) weakremover(python38-tomlkit) weakremover(python38-tools) weakremover(python38-toolz) weakremover(python38-toposort) weakremover(python38-topy) weakremover(python38-torch) weakremover(python38-torch-devel) weakremover(python38-torchvision) weakremover(python38-tornado) weakremover(python38-tornado4) weakremover(python38-tornado5) weakremover(python38-tornado6) weakremover(python38-toro) weakremover(python38-tortilla) weakremover(python38-towncrier) weakremover(python38-tox) weakremover(python38-tox-no-internet) weakremover(python38-tox-travis) weakremover(python38-tox-wheel) weakremover(python38-tpfd) weakremover(python38-tqdm) weakremover(python38-traceback2) weakremover(python38-traitlets) weakremover(python38-traits) weakremover(python38-traitsui) weakremover(python38-traittypes) weakremover(python38-transaction) weakremover(python38-transip) weakremover(python38-transitions) weakremover(python38-translate-toolkit) weakremover(python38-translation-finder) weakremover(python38-translationstring) weakremover(python38-translitcodec) weakremover(python38-treq) weakremover(python38-tri.declarative) weakremover(python38-tri.struct) weakremover(python38-trio) weakremover(python38-trove-classifiers) weakremover(python38-trustme) weakremover(python38-tsk) weakremover(python38-ttp) weakremover(python38-ttp-templates) weakremover(python38-tvm) weakremover(python38-tweepy) weakremover(python38-twine) weakremover(python38-twitter) weakremover(python38-twitter.common.finagle-thrift) weakremover(python38-twitter.common.lang) weakremover(python38-twitter.common.rpc) weakremover(python38-twodict) weakremover(python38-twython) weakremover(python38-txWS) weakremover(python38-txZMQ) weakremover(python38-txaio) weakremover(python38-txt2tags) weakremover(python38-txtorcon) weakremover(python38-typed-ast) weakremover(python38-typedload) weakremover(python38-typeguard) weakremover(python38-typepy) weakremover(python38-typer) weakremover(python38-typing-inspect) weakremover(python38-typing_extensions) weakremover(python38-typogrify) weakremover(python38-tzlocal) weakremover(python38-u-msgpack-python) weakremover(python38-ua-parser) weakremover(python38-uamqp) weakremover(python38-uc-micro-py) weakremover(python38-ucsmsdk) weakremover(python38-ufoLib2) weakremover(python38-ufoProcessor) weakremover(python38-ufonormalizer) weakremover(python38-uhashring) weakremover(python38-ujson) weakremover(python38-uncertainties) weakremover(python38-uncompyle6) weakremover(python38-unearth) weakremover(python38-unicodecsv) weakremover(python38-unicodedata2) weakremover(python38-unidiff) weakremover(python38-unify) weakremover(python38-uniseg) weakremover(python38-unittest-mixins) weakremover(python38-unittest-xml-reporting) weakremover(python38-unittest2pytest) weakremover(python38-unpaddedbase64) weakremover(python38-unsync) weakremover(python38-untokenize) weakremover(python38-unyt) weakremover(python38-uproot) weakremover(python38-uri-template) weakremover(python38-uritemplate) weakremover(python38-uritools) weakremover(python38-url-normalize) weakremover(python38-urlextract) weakremover(python38-urlgrabber) weakremover(python38-urllib3) weakremover(python38-urwid) weakremover(python38-usbsdmux) weakremover(python38-user-agents) weakremover(python38-user_agent) weakremover(python38-userpath) weakremover(python38-usfm2osis) weakremover(python38-uvicorn) weakremover(python38-uvloop) weakremover(python38-uwsgi-python3) weakremover(python38-validate-pyproject) weakremover(python38-validate_email) weakremover(python38-validators) weakremover(python38-varint) weakremover(python38-varlink) weakremover(python38-vatnumber) weakremover(python38-vcrpy) weakremover(python38-vcver) weakremover(python38-vcversioner) weakremover(python38-vdirsyncer) weakremover(python38-vega) weakremover(python38-vega_datasets) weakremover(python38-venusian) weakremover(python38-venusian-doc) weakremover(python38-verboselogs) weakremover(python38-versioneer) weakremover(python38-versioningit) weakremover(python38-versiontag) weakremover(python38-versiontools) weakremover(python38-veusz) weakremover(python38-vim-vint) weakremover(python38-vine) weakremover(python38-virtkey) weakremover(python38-virtualenv) weakremover(python38-virtualenv-clone) weakremover(python38-virtualenvwrapper) weakremover(python38-virtue) weakremover(python38-visitor) weakremover(python38-vispy) weakremover(python38-vistir) weakremover(python38-visvis) weakremover(python38-vncdotool) weakremover(python38-vobject) weakremover(python38-voila) weakremover(python38-volatile) weakremover(python38-voluptuous) weakremover(python38-voluptuous-serialize) weakremover(python38-vsts) weakremover(python38-vsts-cd-manager) weakremover(python38-vulkan) weakremover(python38-vulture) weakremover(python38-w3lib) weakremover(python38-wadllib) weakremover(python38-wafw00f) weakremover(python38-waitress) weakremover(python38-waitress-doc) weakremover(python38-wakeonlan) weakremover(python38-warlock) weakremover(python38-watchdog) weakremover(python38-watchdog-doc) weakremover(python38-watchfiles) weakremover(python38-watchgod) weakremover(python38-watermark) weakremover(python38-wcag-contrast-ratio) weakremover(python38-wcmatch) weakremover(python38-wcwidth) weakremover(python38-weasyprint) weakremover(python38-web.py) weakremover(python38-web_cache) weakremover(python38-webassets) weakremover(python38-webcolors) weakremover(python38-webencodings) weakremover(python38-weblate-language-data) weakremover(python38-weblate-schemas) weakremover(python38-weblib) weakremover(python38-webruntime) weakremover(python38-websocket-client) weakremover(python38-websockets) weakremover(python38-websockify) weakremover(python38-wfuzz) weakremover(python38-whatever) weakremover(python38-whatthepatch) weakremover(python38-wheel) weakremover(python38-wheezy.template) weakremover(python38-whichcraft) weakremover(python38-whitenoise) weakremover(python38-whois_similarity_distance) weakremover(python38-widgetsnbextension) weakremover(python38-wikipedia) weakremover(python38-wirerope) weakremover(python38-wiring) weakremover(python38-wmctrl) weakremover(python38-wolframalpha) weakremover(python38-wptools) weakremover(python38-wrapt) weakremover(python38-ws4py) weakremover(python38-wsaccel) weakremover(python38-wsgi_intercept) weakremover(python38-wsproto) weakremover(python38-wstools) weakremover(python38-wtf-peewee) weakremover(python38-wurlitzer) weakremover(python38-wxPython) weakremover(python38-wxPython-lang) weakremover(python38-xapian) weakremover(python38-xapian-haystack) weakremover(python38-xapp) weakremover(python38-xarray) weakremover(python38-xarray-einstats) weakremover(python38-xattr) weakremover(python38-xcffib) weakremover(python38-xdg) weakremover(python38-xdis) weakremover(python38-xdoctest) weakremover(python38-xerox) weakremover(python38-xhtml2pdf) weakremover(python38-xkbcommon) weakremover(python38-xkbgroup) weakremover(python38-xkcdpass) weakremover(python38-xlrd) weakremover(python38-xlwt) weakremover(python38-xmldiff) weakremover(python38-xmlschema) weakremover(python38-xmlsec) weakremover(python38-xmltodict) weakremover(python38-xonsh) weakremover(python38-xpybutil) weakremover(python38-xrootd) weakremover(python38-xsge_gui) weakremover(python38-xsge_lighting) weakremover(python38-xsge_particle) weakremover(python38-xsge_path) weakremover(python38-xsge_physics) weakremover(python38-xsge_tiled) weakremover(python38-xsge_tmx) weakremover(python38-xvfbwrapper) weakremover(python38-xxhash) weakremover(python38-xyzservices) weakremover(python38-y-py) weakremover(python38-yacron) weakremover(python38-yafe) weakremover(python38-yamale) weakremover(python38-yamldoc) weakremover(python38-yamllint) weakremover(python38-yamlloader) weakremover(python38-yapf) weakremover(python38-yappi) weakremover(python38-yara) weakremover(python38-yarb) weakremover(python38-yarg) weakremover(python38-yarl) weakremover(python38-yaspin) weakremover(python38-yaswfp) weakremover(python38-yg.lockfile) weakremover(python38-youtube-dl) weakremover(python38-ypy-websocket) weakremover(python38-yq) weakremover(python38-yt) weakremover(python38-zake) weakremover(python38-zarr) weakremover(python38-zc.buildout) weakremover(python38-zc.customdoctests) weakremover(python38-zc.lockfile) weakremover(python38-zdaemon) weakremover(python38-zeep) weakremover(python38-zeroconf) weakremover(python38-zetup) weakremover(python38-zhon) weakremover(python38-zict) weakremover(python38-zignal) weakremover(python38-zipp) weakremover(python38-zipstream) weakremover(python38-zodbpickle) weakremover(python38-zope.cachedescriptors) weakremover(python38-zope.component) weakremover(python38-zope.configuration) weakremover(python38-zope.copy) weakremover(python38-zope.deferredimport) weakremover(python38-zope.deprecation) weakremover(python38-zope.event) weakremover(python38-zope.exceptions) weakremover(python38-zope.hookable) weakremover(python38-zope.i18nmessageid) weakremover(python38-zope.interface) weakremover(python38-zope.location) weakremover(python38-zope.proxy) weakremover(python38-zope.proxy-devel) weakremover(python38-zope.schema) weakremover(python38-zope.security) weakremover(python38-zope.testbrowser) weakremover(python38-zope.testbrowser-test) weakremover(python38-zope.testing) weakremover(python38-zope.testrunner) weakremover(python38-zopfli) weakremover(python38-zstandard) weakremover(python38-zstd) weakremover(python38-zxcvbn) weakremover(python38-zypp-plugin) weakremover(python39) weakremover(python39-BTrees) weakremover(python39-BTrees-devel) weakremover(python39-Bottleneck) weakremover(python39-Brotli) weakremover(python39-CCColUtils) weakremover(python39-Cheetah3) weakremover(python39-Cython) weakremover(python39-Cython3) weakremover(python39-Durus) weakremover(python39-Fiona) weakremover(python39-Flask-Script) weakremover(python39-Genshi) weakremover(python39-HepMC) weakremover(python39-JPype1) weakremover(python39-Jinja2) weakremover(python39-Kajiki) weakremover(python39-Keras-Applications) weakremover(python39-Kivy) weakremover(python39-Kivy-devel) weakremover(python39-LHAPDF) weakremover(python39-Levenshtein) weakremover(python39-Logbook) weakremover(python39-M2Crypto) weakremover(python39-MarkupSafe) weakremover(python39-Mathics) weakremover(python39-Ming) weakremover(python39-MulticoreTSNE) weakremover(python39-Paver) weakremover(python39-Pillow) weakremover(python39-Pillow-tk) weakremover(python39-PyAudio) weakremover(python39-PyECLib) weakremover(python39-PyICU) weakremover(python39-PyInstaller) weakremover(python39-PyMuPDF) weakremover(python39-PyNaCl) weakremover(python39-PyPrint) weakremover(python39-PyQt6) weakremover(python39-PyQt6-3D) weakremover(python39-PyQt6-3D-devel) weakremover(python39-PyQt6-Charts) weakremover(python39-PyQt6-Charts-devel) weakremover(python39-PyQt6-DataVisualization) weakremover(python39-PyQt6-DataVisualization-devel) weakremover(python39-PyQt6-NetworkAuth) weakremover(python39-PyQt6-NetworkAuth-devel) weakremover(python39-PyQt6-QScintilla) weakremover(python39-PyQt6-WebEngine) weakremover(python39-PyQt6-WebEngine-devel) weakremover(python39-PyQt6-devel) weakremover(python39-PyQt6-sip) weakremover(python39-PyWavelets) weakremover(python39-PyYAML) weakremover(python39-Pydap) weakremover(python39-Pykka) weakremover(python39-QR-Code-generator) weakremover(python39-Qt.py) weakremover(python39-SQLAlchemy) weakremover(python39-Shapely) weakremover(python39-Theano) weakremover(python39-XStatic-jQuery) weakremover(python39-XStatic-term.js) weakremover(python39-abclient) weakremover(python39-acefile) weakremover(python39-acoular) weakremover(python39-adblock) weakremover(python39-aesara) weakremover(python39-afdko) weakremover(python39-aiobotocore) weakremover(python39-aiohttp) weakremover(python39-aioquic) weakremover(python39-aioredis) weakremover(python39-alsa) weakremover(python39-annoy) weakremover(python39-apfel) weakremover(python39-application) weakremover(python39-apsw) weakremover(python39-argon2-cffi) weakremover(python39-argon2-cffi-bindings) weakremover(python39-astropy) weakremover(python39-astropy-healpix) weakremover(python39-astropy-helpers) weakremover(python39-astunparse) weakremover(python39-asv) weakremover(python39-asyncpg) weakremover(python39-atom) weakremover(python39-aubio) weakremover(python39-autobahn) weakremover(python39-autodoc) weakremover(python39-av) weakremover(python39-avahi) weakremover(python39-avocado-plugins-vt) weakremover(python39-awkward-cpp) weakremover(python39-aws-xray-sdk-aiobotocore) weakremover(python39-awscrt) weakremover(python39-axolotl-curve25519) weakremover(python39-backports.zoneinfo) weakremover(python39-base) weakremover(python39-bcrypt) weakremover(python39-beren) weakremover(python39-biopython) weakremover(python39-bitarray) weakremover(python39-bitstruct) weakremover(python39-bjoern) weakremover(python39-blindspin) weakremover(python39-blist) weakremover(python39-blosc) weakremover(python39-blosc2) weakremover(python39-boost-histogram) weakremover(python39-boto) weakremover(python39-brotlicffi) weakremover(python39-brotlipy) weakremover(python39-bsddb3) weakremover(python39-bsddb3-devel) weakremover(python39-cPyparsing) weakremover(python39-cangjie) weakremover(python39-casacore) weakremover(python39-cassandra-driver) weakremover(python39-cbor) weakremover(python39-cbor2) weakremover(python39-cchardet) weakremover(python39-celerymon) weakremover(python39-cerealizer) weakremover(python39-cffi) weakremover(python39-cftime) weakremover(python39-chainmap) weakremover(python39-cloud-sptheme) weakremover(python39-cmarkgfm) weakremover(python39-colorlog) weakremover(python39-combi) weakremover(python39-compizconfig) weakremover(python39-confluent-kafka) weakremover(python39-contextlib2) weakremover(python39-contourpy) weakremover(python39-coverage) weakremover(python39-coverage-config-reload-plugin) weakremover(python39-coverage-env-plugin) weakremover(python39-coveralls) weakremover(python39-cracklib) weakremover(python39-cramjam) weakremover(python39-crcmod) weakremover(python39-cryptography) weakremover(python39-ctypescrypto) weakremover(python39-cu2qu) weakremover(python39-curses) weakremover(python39-cwcwidth) weakremover(python39-cx_Freeze) weakremover(python39-cytoolz) weakremover(python39-datrie) weakremover(python39-dbm) weakremover(python39-dbus-python) weakremover(python39-dbus-python-devel) weakremover(python39-deap) weakremover(python39-debugpy) weakremover(python39-demjson) weakremover(python39-dephell) weakremover(python39-dephell-archive) weakremover(python39-dephell-argparse) weakremover(python39-dephell-discover) weakremover(python39-dephell-licenses) weakremover(python39-dephell-links) weakremover(python39-dephell-markers) weakremover(python39-dephell-pythons) weakremover(python39-dephell-setuptools) weakremover(python39-dephell-shells) weakremover(python39-dephell-specifier) weakremover(python39-dephell-venvs) weakremover(python39-dephell-versioning) weakremover(python39-dephell_changelogs) weakremover(python39-devel) weakremover(python39-dist) weakremover(python39-distorm3) weakremover(python39-django-action-framework) weakremover(python39-django-args) weakremover(python39-django-collectd-rest) weakremover(python39-django-dynamic-fixture) weakremover(python39-django-multiselectfield) weakremover(python39-django-nose) weakremover(python39-django-pyscss) weakremover(python39-django-threadedcomments) weakremover(python39-django-webtest) weakremover(python39-djvulibre) weakremover(python39-dmidecode) weakremover(python39-doc) weakremover(python39-doc-devhelp) weakremover(python39-drgn) weakremover(python39-dtaidistance) weakremover(python39-dukpy) weakremover(python39-dukpy-kovidgoyal) weakremover(python39-dulwich) weakremover(python39-e-antic) weakremover(python39-ed25519) weakremover(python39-editdistance) weakremover(python39-editdistance-devel) weakremover(python39-efilter) weakremover(python39-efl) weakremover(python39-eliot) weakremover(python39-enaml) weakremover(python39-ephem) weakremover(python39-espeak) weakremover(python39-ethtool) weakremover(python39-evdev) weakremover(python39-exiv2) weakremover(python39-ezdxf) weakremover(python39-fabio) weakremover(python39-fann2) weakremover(python39-fastbencode) weakremover(python39-fastcluster) weakremover(python39-fastnumbers) weakremover(python39-fastparquet) weakremover(python39-fastremap) weakremover(python39-fasttext) weakremover(python39-fb-re2) weakremover(python39-flask-restplus) weakremover(python39-forbiddenfruit) weakremover(python39-framel) weakremover(python39-frozendict) weakremover(python39-frozenlist) weakremover(python39-fuse) weakremover(python39-fysom) weakremover(python39-gevent) weakremover(python39-geventhttpclient) weakremover(python39-gi-docgen) weakremover(python39-gitdb) weakremover(python39-gitlint) weakremover(python39-glucat) weakremover(python39-gmpy) weakremover(python39-gmpy2) weakremover(python39-gobject) weakremover(python39-gobject-Gdk) weakremover(python39-gobject-cairo) weakremover(python39-gobject-devel) weakremover(python39-goobook) weakremover(python39-google-crc32c) weakremover(python39-google-filesystem) weakremover(python39-google-pasta) weakremover(python39-gpg) weakremover(python39-gpgme) weakremover(python39-gphoto2) weakremover(python39-greenlet) weakremover(python39-grpcio) weakremover(python39-grpcio-status) weakremover(python39-grpcio-tools) weakremover(python39-gssapi) weakremover(python39-gst) weakremover(python39-gsw) weakremover(python39-gvm-tools) weakremover(python39-h5py) weakremover(python39-h5py-openmpi1) weakremover(python39-h5py-openmpi2) weakremover(python39-h5py-openmpi3) weakremover(python39-h5py-openmpi4) weakremover(python39-hdf5storage) weakremover(python39-healpy) weakremover(python39-hide-code) weakremover(python39-hiredis) weakremover(python39-hotdoc) weakremover(python39-html5-parser) weakremover(python39-http-parser) weakremover(python39-httptools) weakremover(python39-hug) weakremover(python39-hunter) weakremover(python39-hyper) weakremover(python39-hypothesis-auto) weakremover(python39-idle) weakremover(python39-ijson) weakremover(python39-imagecodecs) weakremover(python39-imbox) weakremover(python39-iminuit) weakremover(python39-immutables) weakremover(python39-imread) weakremover(python39-inflate64) weakremover(python39-influxdb) weakremover(python39-iptables) weakremover(python39-ipython-iptest) weakremover(python39-ipython715) weakremover(python39-ipython715-iptest) weakremover(python39-itemadapter) weakremover(python39-iwlib) weakremover(python39-jaraco.base) weakremover(python39-jellyfish) weakremover(python39-jgraph) weakremover(python39-jsondate) weakremover(python39-jsonextended) weakremover(python39-jsonlib-python3) weakremover(python39-jsonslicer) weakremover(python39-jupyter-jupyterlab-server-openapi) weakremover(python39-jupyter-jupyterlab-server-test) weakremover(python39-jupyter-nbutils) weakremover(python39-jupyter-protocol) weakremover(python39-jupytext) weakremover(python39-keepalive) weakremover(python39-kerberos) weakremover(python39-keyczar) weakremover(python39-keyring-keyutils) weakremover(python39-kiss-headers) weakremover(python39-kiwisolver) weakremover(python39-kmod) weakremover(python39-kwant) weakremover(python39-labelImg) weakremover(python39-lal) weakremover(python39-lalapps) weakremover(python39-lalburst) weakremover(python39-lalframe) weakremover(python39-lalinference) weakremover(python39-lalinspiral) weakremover(python39-lalmetaio) weakremover(python39-lalpulsar) weakremover(python39-lalsimulation) weakremover(python39-lazy-object-proxy) weakremover(python39-ldap) weakremover(python39-ldas-tools-al-swig) weakremover(python39-leglight) weakremover(python39-leveldb) weakremover(python39-lfdfiles) weakremover(python39-lhafile) weakremover(python39-libbde) weakremover(python39-libcaes) weakremover(python39-libcreg) weakremover(python39-libcst) weakremover(python39-libesedb) weakremover(python39-libevt) weakremover(python39-libevtx) weakremover(python39-libewf) weakremover(python39-libexe) weakremover(python39-libfmos) weakremover(python39-libfsapfs) weakremover(python39-libfsext) weakremover(python39-libfsfat) weakremover(python39-libfshfs) weakremover(python39-libfsntfs) weakremover(python39-libfsxfs) weakremover(python39-libfvde) weakremover(python39-libfwnt) weakremover(python39-libfwps) weakremover(python39-libfwsi) weakremover(python39-libkdumpfile) weakremover(python39-liblnk) weakremover(python39-libluksde) weakremover(python39-libmodi) weakremover(python39-libmount) weakremover(python39-libmsiecf) weakremover(python39-libnacl) weakremover(python39-libolecf) weakremover(python39-libpff) weakremover(python39-libpfm) weakremover(python39-libphdi) weakremover(python39-libqcow) weakremover(python39-libregf) weakremover(python39-libsass) weakremover(python39-libscca) weakremover(python39-libsigscan) weakremover(python39-libsmdev) weakremover(python39-libsmraw) weakremover(python39-libvhdi) weakremover(python39-libvirt-python) weakremover(python39-libvmdk) weakremover(python39-libvsapm) weakremover(python39-libvsgpt) weakremover(python39-libvshadow) weakremover(python39-libvslvm) weakremover(python39-libvsmbr) weakremover(python39-libwrc) weakremover(python39-libxml2) weakremover(python39-ligo-lw) weakremover(python39-ligo-segments) weakremover(python39-line_profiler) weakremover(python39-linode-cli) weakremover(python39-linstor) weakremover(python39-linstor-client) weakremover(python39-llfuse) weakremover(python39-llvmlite) weakremover(python39-lmdb) weakremover(python39-lscsoft-glue) weakremover(python39-lupa) weakremover(python39-lws) weakremover(python39-lxml) weakremover(python39-lxml-devel) weakremover(python39-lz4) weakremover(python39-lzmaffi) weakremover(python39-m2r) weakremover(python39-magic) weakremover(python39-mathgl) weakremover(python39-matplotlib) weakremover(python39-matplotlib-cairo) weakremover(python39-matplotlib-gtk-common) weakremover(python39-matplotlib-gtk3) weakremover(python39-matplotlib-gtk4) weakremover(python39-matplotlib-qt5) weakremover(python39-matplotlib-testdata) weakremover(python39-matplotlib-tk) weakremover(python39-matplotlib-web) weakremover(python39-matplotlib-wx) weakremover(python39-maturin) weakremover(python39-maxminddb) weakremover(python39-metamagic.json) weakremover(python39-miniupnpc) weakremover(python39-misaka) weakremover(python39-mitmproxy-wireguard) weakremover(python39-mock) weakremover(python39-mockldap) weakremover(python39-moksha-common) weakremover(python39-moretools) weakremover(python39-mpi4py) weakremover(python39-mpi4py-devel) weakremover(python39-mrkd) weakremover(python39-msgpack) weakremover(python39-multidict) weakremover(python39-mysqlclient) weakremover(python39-nautilus) weakremover(python39-nautilus-devel) weakremover(python39-nbindex-jupyter) weakremover(python39-nbinteract) weakremover(python39-nbsphinx-link) weakremover(python39-nbxmpp) weakremover(python39-nbxmpp-doc) weakremover(python39-ndindex) weakremover(python39-neovim-remote) weakremover(python39-net-snmp) weakremover(python39-netCDF4) weakremover(python39-netifaces) weakremover(python39-nlopt) weakremover(python39-nose) weakremover(python39-nose-cov) weakremover(python39-nose-cover3) weakremover(python39-nose-exclude) weakremover(python39-nose-progressive) weakremover(python39-nose-timer) weakremover(python39-nose_warnings_filters) weakremover(python39-nosexcover) weakremover(python39-nss) weakremover(python39-ntlm-auth) weakremover(python39-numba) weakremover(python39-numba-devel) weakremover(python39-numcodecs) weakremover(python39-numexpr) weakremover(python39-numpy) weakremover(python39-numpy-devel) weakremover(python39-numpy-gnu-hpc) weakremover(python39-numpy-gnu-hpc-devel) weakremover(python39-numpy_1_20_1-gnu-hpc) weakremover(python39-numpy_1_20_1-gnu-hpc-devel) weakremover(python39-numpy_1_20_2-gnu-hpc) weakremover(python39-numpy_1_20_2-gnu-hpc-devel) weakremover(python39-numpy_1_20_3-gnu-hpc) weakremover(python39-numpy_1_20_3-gnu-hpc-devel) weakremover(python39-numpy_1_21_0-gnu-hpc) weakremover(python39-numpy_1_21_0-gnu-hpc-devel) weakremover(python39-numpy_1_21_2-gnu-hpc) weakremover(python39-numpy_1_21_2-gnu-hpc-devel) weakremover(python39-numpy_1_21_4-gnu-hpc) weakremover(python39-numpy_1_21_4-gnu-hpc-devel) weakremover(python39-numpy_1_21_6-gnu-hpc) weakremover(python39-numpy_1_21_6-gnu-hpc-devel) weakremover(python39-numpy_1_23_4-gnu-hpc) weakremover(python39-numpy_1_23_4-gnu-hpc-devel) weakremover(python39-numpy_1_24_1-gnu-hpc) weakremover(python39-numpy_1_24_1-gnu-hpc-devel) weakremover(python39-numpy_1_24_2-gnu-hpc) weakremover(python39-numpy_1_24_2-gnu-hpc-devel) weakremover(python39-oauth2client) weakremover(python39-oauth2client-flask) weakremover(python39-oauth2client-gce) weakremover(python39-olm) weakremover(python39-onigurumacffi) weakremover(python39-onnx) weakremover(python39-openTSNE) weakremover(python39-opengl-accelerate) weakremover(python39-openmesh) weakremover(python39-openqa_review) weakremover(python39-orangebox) weakremover(python39-orjson) weakremover(python39-ovirt-engine-sdk) weakremover(python39-ovs) weakremover(python39-pampy) weakremover(python39-pandas) weakremover(python39-pandas-ext) weakremover(python39-parted) weakremover(python39-pass_python_keyring) weakremover(python39-pastream) weakremover(python39-pathlib) weakremover(python39-pathlib2) weakremover(python39-patiencediff) weakremover(python39-pdfkit) weakremover(python39-peewee) weakremover(python39-pendulum) weakremover(python39-perfume-bench) weakremover(python39-persistent) weakremover(python39-persistent-devel) weakremover(python39-pgmagick) weakremover(python39-photutils) weakremover(python39-pikepdf) weakremover(python39-pivy) weakremover(python39-plyvel) weakremover(python39-pomegranate) weakremover(python39-pomegranate-devel) weakremover(python39-pontos) weakremover(python39-poppler-qt5) weakremover(python39-poppler-qt5-devel) weakremover(python39-positional) weakremover(python39-proboscis) weakremover(python39-prompt_toolkit1) weakremover(python39-protobuf) weakremover(python39-psautohint) weakremover(python39-psutil) weakremover(python39-psychtoolbox) weakremover(python39-psycopg2) weakremover(python39-psycopg2cffi) weakremover(python39-py-radix) weakremover(python39-py-ubjson) weakremover(python39-pyFFTW) weakremover(python39-pyRXP) weakremover(python39-pyScss) weakremover(python39-pyahocorasick) weakremover(python39-pyalsaaudio) weakremover(python39-pyarrow) weakremover(python39-pyarrow-devel) weakremover(python39-pybcj) weakremover(python39-pyblake2) weakremover(python39-pybluez) weakremover(python39-pycairo) weakremover(python39-pycairo-devel) weakremover(python39-pycapnp) weakremover(python39-pycares) weakremover(python39-pycdio) weakremover(python39-pychm) weakremover(python39-pyclipper) weakremover(python39-pycocotools) weakremover(python39-pycryptodome) weakremover(python39-pycryptodomex) weakremover(python39-pycups) weakremover(python39-pycurl) weakremover(python39-pyemd) weakremover(python39-pyerfa) weakremover(python39-pyfuse3) weakremover(python39-pygame) weakremover(python39-pygame-devel) weakremover(python39-pygeos) weakremover(python39-pygit2) weakremover(python39-pygraphviz) weakremover(python39-pyheif) weakremover(python39-pyjnius) weakremover(python39-pykafka) weakremover(python39-pykerberos) weakremover(python39-pylibacl) weakremover(python39-pylibfdt) weakremover(python39-pyliblo) weakremover(python39-pyliblo-doc) weakremover(python39-pylibmc) weakremover(python39-pyls-black) weakremover(python39-pylsqpack) weakremover(python39-pylzma) weakremover(python39-pymad) weakremover(python39-pymavlink) weakremover(python39-pymilter) weakremover(python39-pymol) weakremover(python39-pymongo) weakremover(python39-pympv) weakremover(python39-pymssql) weakremover(python39-pyo) weakremover(python39-pyodbc) weakremover(python39-pypandoc) weakremover(python39-pypipegraph) weakremover(python39-pyppeteer) weakremover(python39-pyppmd) weakremover(python39-pyproj) weakremover(python39-pyreadstat) weakremover(python39-pyroomacoustics) weakremover(python39-pyrsistent) weakremover(python39-pysaml2) weakremover(python39-pyscard) weakremover(python39-pysendfile) weakremover(python39-pysha3) weakremover(python39-pysmbc) weakremover(python39-pysndfile) weakremover(python39-pysvn) weakremover(python39-pytaglib) weakremover(python39-pytest-aiofiles) weakremover(python39-pytest-flake8) weakremover(python39-pytest-flake8dir) weakremover(python39-pytest-parallel) weakremover(python39-pytest-pythonpath) weakremover(python39-pytest-random-order) weakremover(python39-pytest-repeat) weakremover(python39-pytest-runner) weakremover(python39-pytest-subtesthack) weakremover(python39-pytest-travis-fold) weakremover(python39-pytest5) weakremover(python39-python-afl) weakremover(python39-python-cjson) weakremover(python39-python-crfsuite) weakremover(python39-python-dmidecode) weakremover(python39-python-gammu) weakremover(python39-python-gvm) weakremover(python39-python-jsonrpc-server) weakremover(python39-python-language-server) weakremover(python39-python-lzo) weakremover(python39-python-poppler) weakremover(python39-python-prctl) weakremover(python39-python-ptrace) weakremover(python39-python-qpid-proton) weakremover(python39-python-rapidjson) weakremover(python39-python-rtmidi) weakremover(python39-python-snappy) weakremover(python39-pytricia) weakremover(python39-pytzdata) weakremover(python39-pyuv) weakremover(python39-pywayland) weakremover(python39-pywlroots) weakremover(python39-pyxattr) weakremover(python39-pyzmq) weakremover(python39-pyzmq-devel) weakremover(python39-pyzstd) weakremover(python39-qscintilla-qt5) weakremover(python39-qscintilla-qt5-sip) weakremover(python39-qt3d-qt5) weakremover(python39-qt3d-qt5-api) weakremover(python39-qt3d-qt5-devel) weakremover(python39-qt3d-qt5-sip) weakremover(python39-qt5) weakremover(python39-qt5-devel) weakremover(python39-qt5-quick3d) weakremover(python39-qt5-quick3d-devel) weakremover(python39-qt5-remoteobjects) weakremover(python39-qt5-remoteobjects-devel) weakremover(python39-qt5-sip) weakremover(python39-qtcharts-qt5) weakremover(python39-qtcharts-qt5-api) weakremover(python39-qtcharts-qt5-sip) weakremover(python39-qtdatavis3d-qt5) weakremover(python39-qtdatavis3d-qt5-api) weakremover(python39-qtdatavis3d-qt5-devel) weakremover(python39-qtdatavis3d-qt5-sip) weakremover(python39-qtnetworkauth-qt5) weakremover(python39-qtnetworkauth-qt5-devel) weakremover(python39-qtwebengine-qt5) weakremover(python39-qtwebengine-qt5-api) weakremover(python39-qtwebengine-qt5-devel) weakremover(python39-qtwebengine-qt5-sip) weakremover(python39-quicktions) weakremover(python39-quimb) weakremover(python39-rapidfuzz) weakremover(python39-ravello-sdk) weakremover(python39-raven) weakremover(python39-raven-aiohttp) weakremover(python39-rcssmin) weakremover(python39-recordclass) weakremover(python39-rednose) weakremover(python39-regex) weakremover(python39-rencode) weakremover(python39-reportlab) weakremover(python39-reproject) weakremover(python39-requests-html) weakremover(python39-rise) weakremover(python39-rjsmin) weakremover(python39-rpds-py) weakremover(python39-rpm) weakremover(python39-ruamel.std.argparse) weakremover(python39-ruamel.yaml.clib) weakremover(python39-rustcfg) weakremover(python39-s3fs) weakremover(python39-sane) weakremover(python39-sanlock) weakremover(python39-sasl) weakremover(python39-scandir) weakremover(python39-scikit-image) weakremover(python39-scikit-learn) weakremover(python39-scikit-sparse) weakremover(python39-scipy) weakremover(python39-scipy-gnu-hpc) weakremover(python39-scipy_1_10_1-gnu-hpc) weakremover(python39-scipy_1_6_0-gnu-hpc) weakremover(python39-scipy_1_7_3-gnu-hpc) weakremover(python39-scipy_1_8_0-gnu-hpc) weakremover(python39-scipy_1_9_1-gnu-hpc) weakremover(python39-scipy_1_9_2-gnu-hpc) weakremover(python39-scipy_1_9_3-gnu-hpc) weakremover(python39-scrypt) weakremover(python39-selectors2) weakremover(python39-selenium) weakremover(python39-semanage) weakremover(python39-serpy) weakremover(python39-setproctitle) weakremover(python39-setupmeta) weakremover(python39-setuptools-test) weakremover(python39-sgp4) weakremover(python39-sherpa) weakremover(python39-simpleaudio) weakremover(python39-simplejson) weakremover(python39-singledispatch) weakremover(python39-sip) weakremover(python39-sip4) weakremover(python39-sip4-devel) weakremover(python39-sip5-devel) weakremover(python39-sip6-devel) weakremover(python39-siphashc) weakremover(python39-sleekxmpp) weakremover(python39-slixmpp) weakremover(python39-slumber) weakremover(python39-slycot) weakremover(python39-snimpy) weakremover(python39-socketIO-client-nexus) weakremover(python39-softlayer) weakremover(python39-soxr) weakremover(python39-spec) weakremover(python39-sphinx-testing) weakremover(python39-sphinxcontrib-actdiag) weakremover(python39-spidev) weakremover(python39-sqlsoup) weakremover(python39-ssdeep) weakremover(python39-statsmodels) weakremover(python39-subliminal) weakremover(python39-sunpy) weakremover(python39-systemd) weakremover(python39-tables) weakremover(python39-tbb) weakremover(python39-tesserocr) weakremover(python39-test-server) weakremover(python39-testsuite) weakremover(python39-textile) weakremover(python39-thewalrus) weakremover(python39-thrift) weakremover(python39-thriftpy2) weakremover(python39-time-machine) weakremover(python39-tinyarray) weakremover(python39-tk) weakremover(python39-tools) weakremover(python39-torch) weakremover(python39-torch-devel) weakremover(python39-torchvision) weakremover(python39-tornado5) weakremover(python39-tornado6) weakremover(python39-tox-travis) weakremover(python39-traits) weakremover(python39-tri.struct) weakremover(python39-tsk) weakremover(python39-tvm) weakremover(python39-twitter.common.finagle-thrift) weakremover(python39-twitter.common.lang) weakremover(python39-twitter.common.rpc) weakremover(python39-twodict) weakremover(python39-typed-ast) weakremover(python39-uamqp) weakremover(python39-ucsmsdk) weakremover(python39-ujson) weakremover(python39-unicodedata2) weakremover(python39-urwid) weakremover(python39-usbsdmux) weakremover(python39-uvloop) weakremover(python39-uwsgi-python3) weakremover(python39-veusz) weakremover(python39-virtkey) weakremover(python39-vispy) weakremover(python39-voila) weakremover(python39-watchfiles) weakremover(python39-watchgod) weakremover(python39-websockets) weakremover(python39-wrapt) weakremover(python39-wsaccel) weakremover(python39-wxPython) weakremover(python39-wxPython-lang) weakremover(python39-xapian) weakremover(python39-xattr) weakremover(python39-xkbcommon) weakremover(python39-xmlsec) weakremover(python39-xrootd) weakremover(python39-xsge_tmx) weakremover(python39-xxhash) weakremover(python39-y-py) weakremover(python39-yappi) weakremover(python39-yara) weakremover(python39-yarb) weakremover(python39-yarl) weakremover(python39-yt) weakremover(python39-zake) weakremover(python39-zeroconf) weakremover(python39-zetup) weakremover(python39-zodbpickle) weakremover(python39-zope.component) weakremover(python39-zope.hookable) weakremover(python39-zope.i18nmessageid) weakremover(python39-zope.interface) weakremover(python39-zope.proxy) weakremover(python39-zope.proxy-devel) weakremover(python39-zope.security) weakremover(python39-zopfli) weakremover(python39-zstandard) weakremover(python39-zstd) weakremover(pytorch-converters) weakremover(pytorch-examples) weakremover(pyzy-db-android) weakremover(pyzy-db-open-phrase) weakremover(pyzy-devel) weakremover(q4wine) weakremover(q5go) weakremover(qFlipper) weakremover(qFlipper-cli) weakremover(qFlipper-libflipperproto) weakremover(qactus) weakremover(qalculate) weakremover(qalculate-gtk) weakremover(qalculate-qt) weakremover(qbe) weakremover(qbittorrent) weakremover(qbittorrent-nox) weakremover(qbs) weakremover(qbs-devel) weakremover(qca) weakremover(qca-devel) weakremover(qca-qt5) weakremover(qca-qt5-devel) weakremover(qca-qt5-plugins) weakremover(qca-qt6) weakremover(qca-qt6-devel) weakremover(qca-qt6-plugins) weakremover(qconf) weakremover(qcoro-devel) weakremover(qcoro-qt5-devel) weakremover(qcoro-qt6-devel) weakremover(qcustomplot-devel) weakremover(qd-devel) weakremover(qdevicemonitor) weakremover(qdirstat) weakremover(qdl) weakremover(qdox-repolib) weakremover(qelectrotech) weakremover(qemacs) weakremover(qemu) weakremover(qemu-accel-qtest) weakremover(qemu-accel-tcg-x86) weakremover(qemu-arm) weakremover(qemu-audio-alsa) weakremover(qemu-audio-dbus) weakremover(qemu-audio-jack) weakremover(qemu-audio-oss) weakremover(qemu-audio-pa) weakremover(qemu-audio-sdl) weakremover(qemu-audio-spice) weakremover(qemu-block-curl) weakremover(qemu-block-dmg) weakremover(qemu-block-gluster) weakremover(qemu-block-iscsi) weakremover(qemu-block-nfs) weakremover(qemu-block-rbd) weakremover(qemu-block-ssh) weakremover(qemu-chardev-baum) weakremover(qemu-chardev-spice) weakremover(qemu-extra) weakremover(qemu-guest-agent) weakremover(qemu-hw-display-qxl) weakremover(qemu-hw-display-virtio-gpu) weakremover(qemu-hw-display-virtio-gpu-pci) weakremover(qemu-hw-display-virtio-vga) weakremover(qemu-hw-s390x-virtio-gpu-ccw) weakremover(qemu-hw-usb-host) weakremover(qemu-hw-usb-redirect) weakremover(qemu-hw-usb-smartcard) weakremover(qemu-ivshmem-tools) weakremover(qemu-ksm) weakremover(qemu-lang) weakremover(qemu-linux-user) weakremover(qemu-ovmf-ia32) weakremover(qemu-ppc) weakremover(qemu-s390) weakremover(qemu-s390x) weakremover(qemu-testsuite) weakremover(qemu-tools) weakremover(qemu-ui-curses) weakremover(qemu-ui-dbus) weakremover(qemu-ui-gtk) weakremover(qemu-ui-opengl) weakremover(qemu-ui-sdl) weakremover(qemu-ui-spice-app) weakremover(qemu-ui-spice-core) weakremover(qemu-vhost-user-gpu) weakremover(qemu-x86) weakremover(qgis) weakremover(qgis-devel) weakremover(qgis-plugin-grass) weakremover(qgit) weakremover(qgle) weakremover(qgo) weakremover(qgroundcontrol) weakremover(qhexedit2) weakremover(qhexedit2-devel) weakremover(qhull) weakremover(qhull-devel) weakremover(qhull_r-devel) weakremover(qhullcpp-devel-static) weakremover(qimgv) weakremover(qiv) weakremover(qjackctl) weakremover(qlipper) weakremover(qlogic-rules) weakremover(qloud) weakremover(qlvnictools) weakremover(qm) weakremover(qml-box2d) weakremover(qmlkonsole) weakremover(qmlpluginexports-qt5) weakremover(qmlpluginexports-qt6) weakremover(qmltermwidget) weakremover(qmmp) weakremover(qmodbus) weakremover(qnapi) weakremover(qoauth-devel) weakremover(qoauth-qt5-devel) weakremover(qolibri) weakremover(qore) weakremover(qore-devel) weakremover(qore-json-module) weakremover(qore-linenoise-module) weakremover(qore-linenoise-module-doc) weakremover(qore-mysql-module) weakremover(qore-mysql-module-doc) weakremover(qore-openldap-module) weakremover(qore-openldap-module-doc) weakremover(qore-pgsql-module) weakremover(qore-pgsql-module-doc) weakremover(qore-sqlite3-module) weakremover(qore-ssh2-module) weakremover(qore-ssh2-module-doc) weakremover(qore-stdlib) weakremover(qore-uuid-module) weakremover(qore-uuid-module-doc) weakremover(qore-xml-module) weakremover(qore-xml-module-tools) weakremover(qore-yaml-module) weakremover(qpdf) weakremover(qpdf-devel) weakremover(qpdfview) weakremover(qpdfview-plugin-djvu) weakremover(qpdfview-plugin-image) weakremover(qpdfview-plugin-pdf) weakremover(qpdfview-plugin-ps) weakremover(qperf) weakremover(qphotorec) weakremover(qpid-cpp-client) weakremover(qpid-cpp-client-devel) weakremover(qpid-cpp-client-devel-docs) weakremover(qpid-cpp-server) weakremover(qpid-cpp-server-ha) weakremover(qpid-cpp-server-store) weakremover(qpid-proton-devel) weakremover(qpid-proton-test) weakremover(qpid-qmf) weakremover(qpid-qmf-devel) weakremover(qpid-tests) weakremover(qpid-tools) weakremover(qpress) weakremover(qprint) weakremover(qps) weakremover(qputty-qt5) weakremover(qpwgraph) weakremover(qqc2-breeze-style) weakremover(qqc2-breeze-style-devel) weakremover(qqc2-desktop-style) weakremover(qqc2-desktop-style-devel) weakremover(qqwing) weakremover(qqwing-devel) weakremover(qrencode) weakremover(qrencode-devel) weakremover(qrupdate) weakremover(qrupdate-devel) weakremover(qrupdate-static) weakremover(qsapecng) weakremover(qscintilla-qt5) weakremover(qscintilla-qt5-devel) weakremover(qscintilla-qt6) weakremover(qscintilla-qt6-devel) weakremover(qscintilla2_qt5) weakremover(qsyncthingtray) weakremover(qsynergy) weakremover(qsynth) weakremover(qt-fsarchiver) weakremover(qt-fsarchiver-lang) weakremover(qt3) weakremover(qt3-devel) weakremover(qt3-devel-doc) weakremover(qt3-devel-examples) weakremover(qt3-devel-tools) weakremover(qt3-extensions) weakremover(qt3-man) weakremover(qt3-mysql) weakremover(qt3-postgresql) weakremover(qt3-sqlite) weakremover(qt3-unixODBC) weakremover(qt4-assistant-adp) weakremover(qt4-assistant-adp-devel) weakremover(qt4-qtscript) weakremover(qt4-qtscript-doc) weakremover(qt4-style-fusion) weakremover(qt4-x11-tools) weakremover(qt5-creator) weakremover(qt5-creator-plugin-devel) weakremover(qt5ct) weakremover(qt5integration) weakremover(qt6-3d-docs-html) weakremover(qt6-3d-docs-qch) weakremover(qt6-3d-examples) weakremover(qt6-3d-imports) weakremover(qt6-3danimation-devel) weakremover(qt6-3danimation-private-devel) weakremover(qt6-3dcore-devel) weakremover(qt6-3dcore-private-devel) weakremover(qt6-3dextras-devel) weakremover(qt6-3dextras-private-devel) weakremover(qt6-3dinput-devel) weakremover(qt6-3dinput-private-devel) weakremover(qt6-3dlogic-devel) weakremover(qt6-3dlogic-private-devel) weakremover(qt6-3dquick-devel) weakremover(qt6-3dquick-private-devel) weakremover(qt6-3dquickanimation-devel) weakremover(qt6-3dquickanimation-private-devel) weakremover(qt6-3dquickextras-devel) weakremover(qt6-3dquickextras-private-devel) weakremover(qt6-3dquickinput-devel) weakremover(qt6-3dquickinput-private-devel) weakremover(qt6-3dquickrender-devel) weakremover(qt6-3dquickrender-private-devel) weakremover(qt6-3dquickscene2d-devel) weakremover(qt6-3dquickscene2d-private-devel) weakremover(qt6-3drender-devel) weakremover(qt6-3drender-private-devel) weakremover(qt6-base-common-devel) weakremover(qt6-base-docs-html) weakremover(qt6-base-docs-qch) weakremover(qt6-base-examples) weakremover(qt6-bodymovin-devel) weakremover(qt6-bodymovin-private-devel) weakremover(qt6-bundledembree-devel-static) weakremover(qt6-bundledphysx-devel-static) weakremover(qt6-bundledresonanceaudio-devel-static) weakremover(qt6-charts-devel) weakremover(qt6-charts-docs-html) weakremover(qt6-charts-docs-qch) weakremover(qt6-charts-examples) weakremover(qt6-charts-imports) weakremover(qt6-charts-private-devel) weakremover(qt6-chartsqml-devel) weakremover(qt6-chartsqml-private-devel) weakremover(qt6-coap-devel) weakremover(qt6-coap-docs-html) weakremover(qt6-coap-docs-qch) weakremover(qt6-coap-examples) weakremover(qt6-coap-private-devel) weakremover(qt6-concurrent-devel) weakremover(qt6-connectivity) weakremover(qt6-connectivity-devel) weakremover(qt6-connectivity-docs-html) weakremover(qt6-connectivity-docs-qch) weakremover(qt6-connectivity-examples) weakremover(qt6-connectivity-private-devel) weakremover(qt6-core-devel) weakremover(qt6-core-private-devel) weakremover(qt6-creator) weakremover(qt6-creator-plugin-devel) weakremover(qt6-datavis3d-docs-html) weakremover(qt6-datavis3d-docs-qch) weakremover(qt6-datavis3d-examples) weakremover(qt6-datavisualization-devel) weakremover(qt6-datavisualization-imports) weakremover(qt6-datavisualization-private-devel) weakremover(qt6-datavisualizationqml-devel) weakremover(qt6-datavisualizationqml-private-devel) weakremover(qt6-dbus-devel) weakremover(qt6-dbus-private-devel) weakremover(qt6-declarative-docs-html) weakremover(qt6-declarative-docs-qch) weakremover(qt6-declarative-examples) weakremover(qt6-declarative-imports) weakremover(qt6-declarative-tools) weakremover(qt6-declarativeopcua-private-devel) weakremover(qt6-designer-devel) weakremover(qt6-designer-private-devel) weakremover(qt6-designercomponents-private-devel) weakremover(qt6-grpc-devel) weakremover(qt6-grpc-docs-html) weakremover(qt6-grpc-docs-qch) weakremover(qt6-grpc-examples) weakremover(qt6-grpc-private-devel) weakremover(qt6-gui-devel) weakremover(qt6-gui-private-devel) weakremover(qt6-help-devel) weakremover(qt6-help-private-devel) weakremover(qt6-httpserver-devel) weakremover(qt6-httpserver-docs-html) weakremover(qt6-httpserver-docs-qch) weakremover(qt6-httpserver-examples) weakremover(qt6-httpserver-private-devel) weakremover(qt6-hunspellinputmethod-devel) weakremover(qt6-hunspellinputmethod-private-devel) weakremover(qt6-imageformats) weakremover(qt6-imageformats-devel) weakremover(qt6-imageformats-docs-html) weakremover(qt6-imageformats-docs-qch) weakremover(qt6-jsonrpc-private-devel) weakremover(qt6-kmssupport-devel-static) weakremover(qt6-kmssupport-private-devel) weakremover(qt6-labsanimation-devel) weakremover(qt6-labsanimation-private-devel) weakremover(qt6-labsfolderlistmodel-devel) weakremover(qt6-labsfolderlistmodel-private-devel) weakremover(qt6-labsqmlmodels-devel) weakremover(qt6-labsqmlmodels-private-devel) weakremover(qt6-labssettings-devel) weakremover(qt6-labssettings-private-devel) weakremover(qt6-labssharedimage-devel) weakremover(qt6-labssharedimage-private-devel) weakremover(qt6-labswavefrontmesh-devel) weakremover(qt6-labswavefrontmesh-private-devel) weakremover(qt6-languageserver-private-devel) weakremover(qt6-linguist-devel) weakremover(qt6-location) weakremover(qt6-location-devel) weakremover(qt6-location-docs-html) weakremover(qt6-location-docs-qch) weakremover(qt6-location-examples) weakremover(qt6-location-imports) weakremover(qt6-location-private-devel) weakremover(qt6-lottie-docs-html) weakremover(qt6-lottie-docs-qch) weakremover(qt6-lottie-imports) weakremover(qt6-macros) weakremover(qt6-mqtt-devel) weakremover(qt6-mqtt-docs-html) weakremover(qt6-mqtt-docs-qch) weakremover(qt6-mqtt-examples) weakremover(qt6-mqtt-private-devel) weakremover(qt6-multimedia) weakremover(qt6-multimedia-devel) weakremover(qt6-multimedia-docs-html) weakremover(qt6-multimedia-docs-qch) weakremover(qt6-multimedia-examples) weakremover(qt6-multimedia-imports) weakremover(qt6-multimedia-private-devel) weakremover(qt6-multimediaquick-private-devel) weakremover(qt6-multimediawidgets-devel) weakremover(qt6-multimediawidgets-private-devel) weakremover(qt6-network-devel) weakremover(qt6-network-informationbackends) weakremover(qt6-network-private-devel) weakremover(qt6-network-tls) weakremover(qt6-networkauth-devel) weakremover(qt6-networkauth-docs-html) weakremover(qt6-networkauth-docs-qch) weakremover(qt6-networkauth-examples) weakremover(qt6-networkauth-private-devel) weakremover(qt6-networkinformation-glib) weakremover(qt6-networkinformation-nm) weakremover(qt6-opcua) weakremover(qt6-opcua-devel) weakremover(qt6-opcua-docs-html) weakremover(qt6-opcua-docs-qch) weakremover(qt6-opcua-examples) weakremover(qt6-opcua-imports) weakremover(qt6-opcua-private-devel) weakremover(qt6-opengl-devel) weakremover(qt6-opengl-private-devel) weakremover(qt6-openglwidgets-devel) weakremover(qt6-packetprotocol-devel-static) weakremover(qt6-packetprotocol-private-devel) weakremover(qt6-pdf-devel) weakremover(qt6-pdf-imports) weakremover(qt6-pdf-private-devel) weakremover(qt6-pdfquick-devel) weakremover(qt6-pdfquick-private-devel) weakremover(qt6-pdfwidgets-devel) weakremover(qt6-pdfwidgets-private-devel) weakremover(qt6-platformsupport-devel-static) weakremover(qt6-platformsupport-private-devel) weakremover(qt6-platformtheme-gtk3) weakremover(qt6-platformtheme-xdgdesktopportal) weakremover(qt6-positioning) weakremover(qt6-positioning-devel) weakremover(qt6-positioning-docs-html) weakremover(qt6-positioning-docs-qch) weakremover(qt6-positioning-examples) weakremover(qt6-positioning-imports) weakremover(qt6-positioning-private-devel) weakremover(qt6-positioningquick-devel) weakremover(qt6-positioningquick-private-devel) weakremover(qt6-printsupport-cups) weakremover(qt6-printsupport-devel) weakremover(qt6-printsupport-private-devel) weakremover(qt6-protobuf-devel) weakremover(qt6-protobuf-private-devel) weakremover(qt6-qml-devel) weakremover(qt6-qml-private-devel) weakremover(qt6-qmlcompiler-devel-static) weakremover(qt6-qmlcompiler-private-devel) weakremover(qt6-qmlcore-devel) weakremover(qt6-qmlcore-private-devel) weakremover(qt6-qmldebug-devel-static) weakremover(qt6-qmldebug-private-devel) weakremover(qt6-qmldevtools-devel-static) weakremover(qt6-qmldom-devel-static) weakremover(qt6-qmldom-private-devel) weakremover(qt6-qmllint-devel-static) weakremover(qt6-qmllocalstorage-devel) weakremover(qt6-qmllocalstorage-private-devel) weakremover(qt6-qmlmodels-devel) weakremover(qt6-qmlmodels-private-devel) weakremover(qt6-qmltyperegistrar-devel-static) weakremover(qt6-qmlworkerscript-devel) weakremover(qt6-qmlworkerscript-private-devel) weakremover(qt6-qmlxmllistmodel-devel) weakremover(qt6-qmlxmllistmodel-private-devel) weakremover(qt6-qt5compat-devel) weakremover(qt6-qt5compat-docs-html) weakremover(qt6-qt5compat-docs-qch) weakremover(qt6-qt5compat-imports) weakremover(qt6-qt5compat-private-devel) weakremover(qt6-quick-devel) weakremover(qt6-quick-private-devel) weakremover(qt6-quick3d) weakremover(qt6-quick3d-devel) weakremover(qt6-quick3d-docs-html) weakremover(qt6-quick3d-docs-qch) weakremover(qt6-quick3d-examples) weakremover(qt6-quick3d-imports) weakremover(qt6-quick3d-private-devel) weakremover(qt6-quick3dassetimport-devel) weakremover(qt6-quick3dassetimport-private-devel) weakremover(qt6-quick3dassetutils-devel) weakremover(qt6-quick3dassetutils-private-devel) weakremover(qt6-quick3deffects-devel) weakremover(qt6-quick3dglslparser-private-devel) weakremover(qt6-quick3dhelpers-devel) weakremover(qt6-quick3dhelpers-private-devel) weakremover(qt6-quick3dhelpersimpl-devel) weakremover(qt6-quick3dhelpersimpl-private-devel) weakremover(qt6-quick3diblbaker-devel) weakremover(qt6-quick3diblbaker-private-devel) weakremover(qt6-quick3dparticleeffects-devel) weakremover(qt6-quick3dparticles-devel) weakremover(qt6-quick3dparticles-private-devel) weakremover(qt6-quick3dphysics) weakremover(qt6-quick3dphysics-devel) weakremover(qt6-quick3dphysics-docs-html) weakremover(qt6-quick3dphysics-docs-qch) weakremover(qt6-quick3dphysics-examples) weakremover(qt6-quick3dphysics-imports) weakremover(qt6-quick3dphysics-private-devel) weakremover(qt6-quick3dphysicshelpers-private-devel) weakremover(qt6-quick3druntimerender-devel) weakremover(qt6-quick3druntimerender-private-devel) weakremover(qt6-quick3dspatialaudio-private-devel) weakremover(qt6-quick3dutils-devel) weakremover(qt6-quick3dutils-private-devel) weakremover(qt6-quickcontrols2-devel) weakremover(qt6-quickcontrols2-docs-html) weakremover(qt6-quickcontrols2-docs-qch) weakremover(qt6-quickcontrols2-examples) weakremover(qt6-quickcontrols2-imports) weakremover(qt6-quickcontrols2-private-devel) weakremover(qt6-quickcontrols2impl-devel) weakremover(qt6-quickcontrols2impl-private-devel) weakremover(qt6-quickcontrolstestutils-devel-static) weakremover(qt6-quickdialogs2-devel) weakremover(qt6-quickdialogs2-private-devel) weakremover(qt6-quickdialogs2quickimpl-devel) weakremover(qt6-quickdialogs2quickimpl-private-devel) weakremover(qt6-quickdialogs2utils-devel) weakremover(qt6-quickdialogs2utils-private-devel) weakremover(qt6-quickeffectmaker) weakremover(qt6-quickeffectmaker-docs-html) weakremover(qt6-quickeffectmaker-docs-qch) weakremover(qt6-quickeffectmaker-examples) weakremover(qt6-quickeffects-private-devel) weakremover(qt6-quicklayouts-devel) weakremover(qt6-quicklayouts-private-devel) weakremover(qt6-quickparticles-devel) weakremover(qt6-quickparticles-private-devel) weakremover(qt6-quickshapes-devel) weakremover(qt6-quickshapes-private-devel) weakremover(qt6-quicktemplates2-devel) weakremover(qt6-quicktemplates2-private-devel) weakremover(qt6-quicktest-devel) weakremover(qt6-quicktest-private-devel) weakremover(qt6-quicktestutils-devel-static) weakremover(qt6-quicktimeline-devel) weakremover(qt6-quicktimeline-docs-html) weakremover(qt6-quicktimeline-docs-qch) weakremover(qt6-quicktimeline-imports) weakremover(qt6-quicktimeline-private-devel) weakremover(qt6-quickwidgets-devel) weakremover(qt6-quickwidgets-private-devel) weakremover(qt6-remoteobjects-devel) weakremover(qt6-remoteobjects-docs-html) weakremover(qt6-remoteobjects-docs-qch) weakremover(qt6-remoteobjects-examples) weakremover(qt6-remoteobjects-imports) weakremover(qt6-remoteobjects-private-devel) weakremover(qt6-remoteobjects-tools) weakremover(qt6-remoteobjectsqml-devel) weakremover(qt6-remoteobjectsqml-private-devel) weakremover(qt6-scxml) weakremover(qt6-scxml-devel) weakremover(qt6-scxml-docs-html) weakremover(qt6-scxml-docs-qch) weakremover(qt6-scxml-examples) weakremover(qt6-scxml-imports) weakremover(qt6-scxml-private-devel) weakremover(qt6-scxmlqml-devel) weakremover(qt6-scxmlqml-private-devel) weakremover(qt6-sensors) weakremover(qt6-sensors-devel) weakremover(qt6-sensors-docs-html) weakremover(qt6-sensors-docs-qch) weakremover(qt6-sensors-examples) weakremover(qt6-sensors-imports) weakremover(qt6-sensors-private-devel) weakremover(qt6-sensorsquick-devel) weakremover(qt6-sensorsquick-private-devel) weakremover(qt6-serialbus) weakremover(qt6-serialbus-devel) weakremover(qt6-serialbus-docs-html) weakremover(qt6-serialbus-docs-qch) weakremover(qt6-serialbus-examples) weakremover(qt6-serialbus-private-devel) weakremover(qt6-serialport-devel) weakremover(qt6-serialport-docs-html) weakremover(qt6-serialport-docs-qch) weakremover(qt6-serialport-examples) weakremover(qt6-serialport-private-devel) weakremover(qt6-shadertools) weakremover(qt6-shadertools-devel) weakremover(qt6-shadertools-docs-html) weakremover(qt6-shadertools-docs-qch) weakremover(qt6-shadertools-private-devel) weakremover(qt6-spatialaudio-devel) weakremover(qt6-spatialaudio-private-devel) weakremover(qt6-speech-docs-html) weakremover(qt6-speech-docs-qch) weakremover(qt6-speech-examples) weakremover(qt6-sql-devel) weakremover(qt6-sql-mysql) weakremover(qt6-sql-postgresql) weakremover(qt6-sql-private-devel) weakremover(qt6-sql-sqlite) weakremover(qt6-sql-unixODBC) weakremover(qt6-statemachine-devel) weakremover(qt6-statemachine-private-devel) weakremover(qt6-statemachineqml-devel) weakremover(qt6-statemachineqml-private-devel) weakremover(qt6-svg-devel) weakremover(qt6-svg-docs-html) weakremover(qt6-svg-docs-qch) weakremover(qt6-svg-examples) weakremover(qt6-svg-private-devel) weakremover(qt6-test-devel) weakremover(qt6-test-private-devel) weakremover(qt6-texttospeech) weakremover(qt6-texttospeech-devel) weakremover(qt6-texttospeech-private-devel) weakremover(qt6-tools) weakremover(qt6-tools-assistant) weakremover(qt6-tools-designer) weakremover(qt6-tools-devel) weakremover(qt6-tools-docs-html) weakremover(qt6-tools-docs-qch) weakremover(qt6-tools-examples) weakremover(qt6-tools-helpgenerators) weakremover(qt6-tools-linguist) weakremover(qt6-tools-private-devel) weakremover(qt6-tools-qdbus) weakremover(qt6-tools-qdoc) weakremover(qt6-tools-qtpaths) weakremover(qt6-uitools-devel) weakremover(qt6-uitools-private-devel) weakremover(qt6-virtualkeyboard) weakremover(qt6-virtualkeyboard-devel) weakremover(qt6-virtualkeyboard-docs-html) weakremover(qt6-virtualkeyboard-docs-qch) weakremover(qt6-virtualkeyboard-examples) weakremover(qt6-virtualkeyboard-imports) weakremover(qt6-virtualkeyboard-private-devel) weakremover(qt6-wayland) weakremover(qt6-wayland-devel) weakremover(qt6-wayland-docs-html) weakremover(qt6-wayland-docs-qch) weakremover(qt6-wayland-examples) weakremover(qt6-wayland-imports) weakremover(qt6-waylandclient-devel) weakremover(qt6-waylandclient-private-devel) weakremover(qt6-waylandcompositor-devel) weakremover(qt6-waylandcompositor-private-devel) weakremover(qt6-waylandeglclienthwintegration-private-devel) weakremover(qt6-waylandeglcompositorhwintegration-private-devel) weakremover(qt6-waylandglobal-private-devel) weakremover(qt6-webchannel-devel) weakremover(qt6-webchannel-docs-html) weakremover(qt6-webchannel-docs-qch) weakremover(qt6-webchannel-examples) weakremover(qt6-webchannel-imports) weakremover(qt6-webchannel-private-devel) weakremover(qt6-webengine) weakremover(qt6-webengine-docs-html) weakremover(qt6-webengine-docs-qch) weakremover(qt6-webengine-examples) weakremover(qt6-webengine-imports) weakremover(qt6-webenginecore-devel) weakremover(qt6-webenginecore-private-devel) weakremover(qt6-webenginequick-devel) weakremover(qt6-webenginequick-private-devel) weakremover(qt6-webenginewidgets-devel) weakremover(qt6-webenginewidgets-private-devel) weakremover(qt6-websockets-devel) weakremover(qt6-websockets-docs-html) weakremover(qt6-websockets-docs-qch) weakremover(qt6-websockets-examples) weakremover(qt6-websockets-imports) weakremover(qt6-websockets-private-devel) weakremover(qt6-webview) weakremover(qt6-webview-devel) weakremover(qt6-webview-docs-html) weakremover(qt6-webview-docs-qch) weakremover(qt6-webview-examples) weakremover(qt6-webview-imports) weakremover(qt6-webview-private-devel) weakremover(qt6-webviewquick-devel) weakremover(qt6-webviewquick-private-devel) weakremover(qt6-widgets-devel) weakremover(qt6-widgets-private-devel) weakremover(qt6-wlshellintegration-private-devel) weakremover(qt6-xml-devel) weakremover(qt6-xml-private-devel) weakremover(qt6ct) weakremover(qtc) weakremover(qtcurve-gtk2) weakremover(qtcurve-kde4) weakremover(qtcurve-qt5) weakremover(qtdbusextended-devel) weakremover(qtdeclarative-imports-provides-qt5) weakremover(qtdeclarative-imports-provides-qt6) weakremover(qtel) weakremover(qterm) weakremover(qterminal) weakremover(qtermwidget-lang) weakremover(qtermwidget-qt4-data) weakremover(qtermwidget-qt4-devel) weakremover(qtermwidget-qt5-devel) weakremover(qtfm) weakremover(qtile) weakremover(qtkeychain-devel) weakremover(qtkeychain-lang) weakremover(qtkeychain-qt5-devel) weakremover(qtkeychain-qt6-devel) weakremover(qtmpris) weakremover(qtmpris-devel) weakremover(qtox) weakremover(qtractor) weakremover(qtxdg-tools) weakremover(quadrapassel) weakremover(quagga) weakremover(quagga-devel) weakremover(quakespasm) weakremover(quantum-espresso) weakremover(quantum-espresso-doc) weakremover(quantum-espresso-openmpi) weakremover(quasiquotes) weakremover(quassel-base) weakremover(quassel-client) weakremover(quassel-client-qt5) weakremover(quassel-core) weakremover(quassel-mono) weakremover(quazip-devel) weakremover(quazip-qt5-devel) weakremover(quazip-qt6-devel) weakremover(qucs) weakremover(qucs-devel) weakremover(qucs-lang) weakremover(qucs-s) weakremover(quickbench) weakremover(quickbook_1_58_0) weakremover(quilter) weakremover(quimup) weakremover(quiterss) weakremover(quiterss-lang) weakremover(quota) weakremover(quota-nfs) weakremover(quotatool) weakremover(qupzilla) weakremover(qupzilla-gnome-keyring) weakremover(qupzilla-kwallet) weakremover(qutim) weakremover(qutim-devel) weakremover(qutim-plugin-aspeller) weakremover(qutim-plugin-hunspeller) weakremover(qutim-plugin-kdeintegration) weakremover(qutim-plugin-sdlsound) weakremover(quvi) weakremover(qv4l2) weakremover(qview) weakremover(qwebyast) weakremover(qwt-designer) weakremover(qwt-devel) weakremover(qwt-devel-doc) weakremover(qwt-examples) weakremover(qwt6) weakremover(qwt6-designer) weakremover(qwt6-devel) weakremover(qwt6-devel-doc) weakremover(qwt6-examples) weakremover(qwt6-qt5-designer) weakremover(qwt6-qt5-devel) weakremover(qwt6-qt5-examples) weakremover(qwt6-qt6-designer) weakremover(qwt6-qt6-devel) weakremover(qwt6-qt6-examples) weakremover(qwtplot3d-devel) weakremover(qxmledit) weakremover(qxmledit-devel) weakremover(qxtglobalshortcut-devel) weakremover(rabbitmq-c-tools) weakremover(rabbitmq-server) weakremover(rabbitmq-server-plugins) weakremover(racer) weakremover(racket) weakremover(racket-devel) weakremover(radamsa) weakremover(radare2) weakremover(radare2-devel) weakremover(radare2-iaito) weakremover(radare2-iaito-devel) weakremover(radcli) weakremover(radcli-compat-devel) weakremover(radcli-devel) weakremover(radeontop) weakremover(radiotray) weakremover(radiotray-lang) weakremover(radiotray-ng) weakremover(rados-objclass-devel) weakremover(radvd) weakremover(raft-devel) weakremover(rage) weakremover(rage-encryption) weakremover(ragel) weakremover(ragel-6) weakremover(ragel-devel) weakremover(rakkess) weakremover(rakudo) weakremover(rancher-cli) weakremover(rancher-kim) weakremover(rancher-selinux) weakremover(rang-devel) weakremover(range-v3-devel) weakremover(rapidjson-devel) weakremover(rapidyaml-devel) weakremover(rapport) weakremover(raptor) weakremover(rarian) weakremover(rarian-devel) weakremover(rarian-scrollkeeper-compat) weakremover(rarpd) weakremover(rasdaemon) weakremover(rash) weakremover(rasmol) weakremover(raspberrypi-rpiboot) weakremover(raspberrypi-tools-armstubs) weakremover(rasqal) weakremover(ratbagd) weakremover(ratslap) weakremover(rav1e) weakremover(rav1e-devel) weakremover(raw-thumbnailer) weakremover(rawstudio) weakremover(rawstudio-lang) weakremover(rawtherapee) weakremover(raylib-devel) weakremover(razercfg) weakremover(razor-agents) weakremover(rbac-lookup) weakremover(rbac-manager) weakremover(rbd-fuse) weakremover(rbd-mirror) weakremover(rbd-nbd) weakremover(rbutil) weakremover(rcc-runtime) weakremover(rclone) weakremover(rcs) weakremover(rdate) weakremover(rdesktop) weakremover(rdiff) weakremover(rdiff-backup) weakremover(rdist) weakremover(rdma) weakremover(rdma-core) weakremover(rdma-core-devel) weakremover(rdma-ndd) weakremover(rds-tools) weakremover(rds-tools-devel) weakremover(re-devel) weakremover(re2-devel) weakremover(re2c) weakremover(readcd) weakremover(readline-devel) weakremover(readline-devel-static) weakremover(readline5-devel) weakremover(readline6-devel) weakremover(readrec0) weakremover(reaim) weakremover(realmd) weakremover(rebootmgr) weakremover(recastnavigation-devel) weakremover(recidivm) weakremover(reco) weakremover(recode) weakremover(recode-devel) weakremover(recordmydesktop) weakremover(redeclipse) weakremover(redeclipse-server) weakremover(redis) weakremover(redis++-devel) weakremover(redis-operator) weakremover(redland) weakremover(redland-storage-postgresql) weakremover(redsea) weakremover(redshift) weakremover(redshift-gtk) weakremover(reg) weakremover(rehex) weakremover(reiser4progs) weakremover(reiser4progs-devel) weakremover(reiserfs) weakremover(rekonq) weakremover(rekonq-doc) weakremover(rekonq-lang) weakremover(rekor) weakremover(rem-devel) weakremover(remake) weakremover(remind) weakremover(remmina) weakremover(remmina-devel) weakremover(remmina-kiosk) weakremover(remmina-plugin-exec) weakremover(remmina-plugin-gvnc) weakremover(remmina-plugin-kwallet) weakremover(remmina-plugin-nx) weakremover(remmina-plugin-python-wrapper) weakremover(remmina-plugin-rdp) weakremover(remmina-plugin-secret) weakremover(remmina-plugin-spice) weakremover(remmina-plugin-st) weakremover(remmina-plugin-telepathy) weakremover(remmina-plugin-vnc) weakremover(remmina-plugin-www) weakremover(remmina-plugin-xdmcp) weakremover(remmina-plugins-gnome) weakremover(remontoire) weakremover(renameutils) weakremover(rendercheck) weakremover(renderdoc) weakremover(renderdoc-devel) weakremover(rep-gtk) weakremover(rep-gtk-devel) weakremover(replay-sorcery) weakremover(reprepro) weakremover(reproc-devel) weakremover(reptyr) weakremover(resample) weakremover(resolv_wrapper) weakremover(resolve-trivial-conflicts) weakremover(resource-agents) weakremover(resource-agents-zfs) weakremover(restic) weakremover(restool) weakremover(restorecond) weakremover(restund) weakremover(retro-gtk) weakremover(retro-gtk-devel) weakremover(retroarch) weakremover(retroarch-assets) weakremover(retroarch-joypad-autoconfig) weakremover(reuse) weakremover(reuse-lang) weakremover(reveng) weakremover(rfb) weakremover(rfbplaymacro) weakremover(rfbproxy) weakremover(rfc) weakremover(rfcat) weakremover(rfcat-udev) weakremover(rfkill) weakremover(rgb) weakremover(rhash) weakremover(rhash-devel) weakremover(rhythmbox) weakremover(rhythmbox-devel) weakremover(rime) weakremover(rime-plum) weakremover(rinetd) weakremover(rinstall) weakremover(rio) weakremover(ripgrep) weakremover(rist-tools) weakremover(ristretto) weakremover(ritchie-cli) weakremover(river) weakremover(river-riverctl) weakremover(river-rivertile) weakremover(rk-devel) weakremover(rkdeveloptool) weakremover(rke) weakremover(rke2) weakremover(rke2-selinux) weakremover(rkhunter) weakremover(rkward) weakremover(rls) weakremover(rls1.53) weakremover(rls1.54) weakremover(rls1.55) weakremover(rlwrap) weakremover(rmail) weakremover(rman) weakremover(rmedigicontrol) weakremover(rmt-server) weakremover(rmt-server-config) weakremover(rmt-server-pubcloud) weakremover(rmw) weakremover(rnd_jue) weakremover(rnd_jue-data) weakremover(rng-tools) weakremover(rnnoise-devel) weakremover(rnp) weakremover(rnp-devel) weakremover(robinhood) weakremover(robinhood-tests) weakremover(robinhood-tools) weakremover(robinhood-webgui) weakremover(roccat-arvo) weakremover(roccat-arvo-devel) weakremover(roccat-isku) weakremover(roccat-isku-devel) weakremover(roccat-iskufx) weakremover(roccat-iskufx-devel) weakremover(roccat-kiro) weakremover(roccat-kone) weakremover(roccat-kone-devel) weakremover(roccat-koneplus) weakremover(roccat-koneplus-devel) weakremover(roccat-konepure) weakremover(roccat-konepure-devel) weakremover(roccat-konextd) weakremover(roccat-konextd-devel) weakremover(roccat-kova2016) weakremover(roccat-kovaplus) weakremover(roccat-kovaplus-devel) weakremover(roccat-lua) weakremover(roccat-lua-devel) weakremover(roccat-nyth) weakremover(roccat-nyth-devel) weakremover(roccat-pyra) weakremover(roccat-pyra-devel) weakremover(roccat-ryos) weakremover(roccat-ryos-devel) weakremover(roccat-savu) weakremover(roccat-savu-devel) weakremover(roccat-skeltr) weakremover(roccat-sova) weakremover(roccat-suora) weakremover(roccat-tools) weakremover(roccat-tools-devel) weakremover(roccat-tyon) weakremover(roccat-tyon-devel) weakremover(rockdodger) weakremover(rocksdb-devel) weakremover(rocksdb-tools) weakremover(rocksndiamonds) weakremover(rocs) weakremover(rocs-devel) weakremover(rofi) weakremover(rofi-calc) weakremover(rofi-devel) weakremover(rofi-wayland) weakremover(rofi-wayland-devel) weakremover(rook) weakremover(rook-integration) weakremover(rook-rookflex) weakremover(root-tail) weakremover(rootlesskit) weakremover(rosegarden) weakremover(rott) weakremover(rox-filer) weakremover(rp-pppoe) weakremover(rpcbind) weakremover(rpcgen) weakremover(rpcsvc-proto-devel) weakremover(rpi-imager) weakremover(rpm) weakremover(rpm-build) weakremover(rpm-build-perl) weakremover(rpm-devel) weakremover(rpm-python) weakremover(rpm-repos-openSUSE-Tumbleweed) weakremover(rpm2docserv) weakremover(rpma-devel) weakremover(rpmemd) weakremover(rpmlint-Factory) weakremover(rpmlint-Factory-strict) weakremover(rpmlint-mini) weakremover(rr) weakremover(rrdtool) weakremover(rrdtool-cached) weakremover(rrdtool-devel) weakremover(rrdtool-doc) weakremover(rrep) weakremover(rscsi) weakremover(rsh) weakremover(rsh-server) weakremover(rshim) weakremover(rsibreak) weakremover(rsibreak-doc) weakremover(rsign2) weakremover(rsocket) weakremover(rspamd) weakremover(rss-glx) weakremover(rss2email) weakremover(rssguard) weakremover(rsstail) weakremover(rst2html5) weakremover(rstart) weakremover(rstudio) weakremover(rstudio-desktop) weakremover(rstudio-server) weakremover(rsvg-convert) weakremover(rsvg-view) weakremover(rsvg2-sharp) weakremover(rsvndump) weakremover(rsync) weakremover(rsyslog) weakremover(rsyslog-diag-tools) weakremover(rsyslog-doc) weakremover(rsyslog-module-dbi) weakremover(rsyslog-module-elasticsearch) weakremover(rsyslog-module-gcrypt) weakremover(rsyslog-module-gssapi) weakremover(rsyslog-module-gtls) weakremover(rsyslog-module-guardtime) weakremover(rsyslog-module-kafka) weakremover(rsyslog-module-mmnormalize) weakremover(rsyslog-module-mysql) weakremover(rsyslog-module-omamqp1) weakremover(rsyslog-module-omhttpfs) weakremover(rsyslog-module-omtcl) weakremover(rsyslog-module-ossl) weakremover(rsyslog-module-pgsql) weakremover(rsyslog-module-relp) weakremover(rsyslog-module-snmp) weakremover(rsyslog-module-udpspoof) weakremover(rt-tests) weakremover(rtags) weakremover(rtaudio-devel) weakremover(rtkit) weakremover(rtl-sdr) weakremover(rtl-sdr-devel) weakremover(rtl-sdr-udev) weakremover(rtl8812au) weakremover(rtl8812au-kmp-64kb) weakremover(rtl8812au-kmp-default) weakremover(rtl_433) weakremover(rtl_433-devel) weakremover(rtla) weakremover(rtla-rebuild) weakremover(rtmidi-devel) weakremover(rtorrent) weakremover(rtorrent-vim) weakremover(rtr-tools) weakremover(rtrlib-devel) weakremover(rttr-devel) weakremover(rttr-devel-doc) weakremover(rubberband-cli) weakremover(rubberband-ladspa) weakremover(rubberband-lv2) weakremover(rubberband-vamp) weakremover(ruby) weakremover(ruby-apparmor) weakremover(ruby-camgm) weakremover(ruby-devel) weakremover(ruby-geos) weakremover(ruby-libprelude) weakremover(ruby-marisa) weakremover(ruby-obexftp) weakremover(ruby-qt4) weakremover(ruby-qt4-devel) weakremover(ruby-redland) weakremover(ruby-rrdtool) weakremover(ruby-selinux) weakremover(ruby-solv) weakremover(ruby-xapian) weakremover(ruby-yui) weakremover(ruby-zypp) weakremover(ruby2.1) weakremover(ruby2.1-devel) weakremover(ruby2.1-devel-extra) weakremover(ruby2.1-doc) weakremover(ruby2.1-doc-ri) weakremover(ruby2.1-rubygem-RedCloth) weakremover(ruby2.1-rubygem-RedCloth-doc) weakremover(ruby2.1-rubygem-RedCloth-testsuite) weakremover(ruby2.1-rubygem-abstract) weakremover(ruby2.1-rubygem-abstract-doc) weakremover(ruby2.1-rubygem-abstract-testsuite) weakremover(ruby2.1-rubygem-abstract_method) weakremover(ruby2.1-rubygem-abstract_method-doc) weakremover(ruby2.1-rubygem-actionmailer-4_2) weakremover(ruby2.1-rubygem-actionmailer-doc-4_2) weakremover(ruby2.1-rubygem-actionpack-4_2) weakremover(ruby2.1-rubygem-actionpack-doc-4_2) weakremover(ruby2.1-rubygem-actionview-4_2) weakremover(ruby2.1-rubygem-actionview-doc-4_2) weakremover(ruby2.1-rubygem-activejob-4_2) weakremover(ruby2.1-rubygem-activejob-doc-4_2) weakremover(ruby2.1-rubygem-activemodel-4_2) weakremover(ruby2.1-rubygem-activemodel-doc-4_2) weakremover(ruby2.1-rubygem-activerecord-4_2) weakremover(ruby2.1-rubygem-activerecord-deprecated_finders) weakremover(ruby2.1-rubygem-activerecord-deprecated_finders-doc) weakremover(ruby2.1-rubygem-activerecord-doc-4_2) weakremover(ruby2.1-rubygem-activesupport-4_2) weakremover(ruby2.1-rubygem-activesupport-doc-4_2) weakremover(ruby2.1-rubygem-addressable) weakremover(ruby2.1-rubygem-addressable-doc) weakremover(ruby2.1-rubygem-addressable-testsuite) weakremover(ruby2.1-rubygem-airbrussh) weakremover(ruby2.1-rubygem-airbrussh-doc) weakremover(ruby2.1-rubygem-amqp) weakremover(ruby2.1-rubygem-amqp-doc) weakremover(ruby2.1-rubygem-amqp-testsuite) weakremover(ruby2.1-rubygem-archive-tar-minitar) weakremover(ruby2.1-rubygem-archive-tar-minitar-doc) weakremover(ruby2.1-rubygem-arel) weakremover(ruby2.1-rubygem-arel-3_0) weakremover(ruby2.1-rubygem-arel-7) weakremover(ruby2.1-rubygem-arel-doc) weakremover(ruby2.1-rubygem-arel-doc-3_0) weakremover(ruby2.1-rubygem-arel-doc-7) weakremover(ruby2.1-rubygem-arel-testsuite-3_0) weakremover(ruby2.1-rubygem-atomic) weakremover(ruby2.1-rubygem-atomic-doc) weakremover(ruby2.1-rubygem-atomic-testsuite) weakremover(ruby2.1-rubygem-augeas) weakremover(ruby2.1-rubygem-augeas-doc) weakremover(ruby2.1-rubygem-autoprefixer-rails) weakremover(ruby2.1-rubygem-autoprefixer-rails-doc) weakremover(ruby2.1-rubygem-autoprefixer-rails-testsuite) weakremover(ruby2.1-rubygem-axiom-types) weakremover(ruby2.1-rubygem-axiom-types-doc) weakremover(ruby2.1-rubygem-axiom-types-testsuite) weakremover(ruby2.1-rubygem-bcrypt) weakremover(ruby2.1-rubygem-bcrypt-doc) weakremover(ruby2.1-rubygem-bcrypt-ruby) weakremover(ruby2.1-rubygem-bcrypt-ruby-doc) weakremover(ruby2.1-rubygem-bcrypt-testsuite) weakremover(ruby2.1-rubygem-binding_of_caller) weakremover(ruby2.1-rubygem-binding_of_caller-doc) weakremover(ruby2.1-rubygem-binding_of_caller-testsuite) weakremover(ruby2.1-rubygem-bootstrap-sass) weakremover(ruby2.1-rubygem-bootstrap-sass-doc) weakremover(ruby2.1-rubygem-bootstrap-sass-testsuite) weakremover(ruby2.1-rubygem-buff-ignore) weakremover(ruby2.1-rubygem-buff-ignore-doc) weakremover(ruby2.1-rubygem-buff-ignore-testsuite) weakremover(ruby2.1-rubygem-builder) weakremover(ruby2.1-rubygem-builder-doc) weakremover(ruby2.1-rubygem-builder-testsuite) weakremover(ruby2.1-rubygem-bundler) weakremover(ruby2.1-rubygem-bundler-audit) weakremover(ruby2.1-rubygem-bundler-audit-doc) weakremover(ruby2.1-rubygem-bundler-audit-testsuite) weakremover(ruby2.1-rubygem-bundler-doc) weakremover(ruby2.1-rubygem-bunny) weakremover(ruby2.1-rubygem-bunny-doc) weakremover(ruby2.1-rubygem-bunny-testsuite) weakremover(ruby2.1-rubygem-byebug) weakremover(ruby2.1-rubygem-byebug-doc) weakremover(ruby2.1-rubygem-capistrano) weakremover(ruby2.1-rubygem-capistrano-doc) weakremover(ruby2.1-rubygem-capistrano-harrow) weakremover(ruby2.1-rubygem-capistrano-harrow-doc) weakremover(ruby2.1-rubygem-capistrano-stats) weakremover(ruby2.1-rubygem-capistrano-stats-doc) weakremover(ruby2.1-rubygem-capistrano-testsuite) weakremover(ruby2.1-rubygem-celluloid) weakremover(ruby2.1-rubygem-celluloid-doc) weakremover(ruby2.1-rubygem-celluloid-testsuite) weakremover(ruby2.1-rubygem-cfa) weakremover(ruby2.1-rubygem-cfa-doc) weakremover(ruby2.1-rubygem-cfa_grub2) weakremover(ruby2.1-rubygem-cfa_grub2-doc) weakremover(ruby2.1-rubygem-cheetah) weakremover(ruby2.1-rubygem-cheetah-doc) weakremover(ruby2.1-rubygem-childprocess) weakremover(ruby2.1-rubygem-childprocess-doc) weakremover(ruby2.1-rubygem-childprocess-testsuite) weakremover(ruby2.1-rubygem-ci_reporter) weakremover(ruby2.1-rubygem-ci_reporter-doc) weakremover(ruby2.1-rubygem-ci_reporter-testsuite) weakremover(ruby2.1-rubygem-cleanroom) weakremover(ruby2.1-rubygem-cleanroom-doc) weakremover(ruby2.1-rubygem-cleanroom-testsuite) weakremover(ruby2.1-rubygem-coderay) weakremover(ruby2.1-rubygem-coderay-doc) weakremover(ruby2.1-rubygem-coderay-testsuite) weakremover(ruby2.1-rubygem-coercible) weakremover(ruby2.1-rubygem-coercible-doc) weakremover(ruby2.1-rubygem-coercible-testsuite) weakremover(ruby2.1-rubygem-coffee-rails) weakremover(ruby2.1-rubygem-coffee-rails-doc) weakremover(ruby2.1-rubygem-coffee-rails-testsuite) weakremover(ruby2.1-rubygem-coffee-script) weakremover(ruby2.1-rubygem-coffee-script-doc) weakremover(ruby2.1-rubygem-coffee-script-source) weakremover(ruby2.1-rubygem-coffee-script-source-doc) weakremover(ruby2.1-rubygem-colorator) weakremover(ruby2.1-rubygem-colorator-doc) weakremover(ruby2.1-rubygem-colored) weakremover(ruby2.1-rubygem-colored-doc) weakremover(ruby2.1-rubygem-colored-testsuite) weakremover(ruby2.1-rubygem-colorize) weakremover(ruby2.1-rubygem-colorize-doc) weakremover(ruby2.1-rubygem-colorize-testsuite) weakremover(ruby2.1-rubygem-columnize) weakremover(ruby2.1-rubygem-columnize-doc) weakremover(ruby2.1-rubygem-columnize-testsuite) weakremover(ruby2.1-rubygem-commander) weakremover(ruby2.1-rubygem-commander-doc) weakremover(ruby2.1-rubygem-commander-testsuite) weakremover(ruby2.1-rubygem-concurrent-ruby) weakremover(ruby2.1-rubygem-concurrent-ruby-doc) weakremover(ruby2.1-rubygem-cool.io) weakremover(ruby2.1-rubygem-cool.io-doc) weakremover(ruby2.1-rubygem-cool.io-testsuite) weakremover(ruby2.1-rubygem-cri) weakremover(ruby2.1-rubygem-cri-2_6) weakremover(ruby2.1-rubygem-cri-doc) weakremover(ruby2.1-rubygem-cri-doc-2_6) weakremover(ruby2.1-rubygem-cri-testsuite) weakremover(ruby2.1-rubygem-cri-testsuite-2_6) weakremover(ruby2.1-rubygem-cssmin) weakremover(ruby2.1-rubygem-cssmin-doc) weakremover(ruby2.1-rubygem-daemon_controller) weakremover(ruby2.1-rubygem-daemon_controller-doc) weakremover(ruby2.1-rubygem-daemon_controller-testsuite) weakremover(ruby2.1-rubygem-daemons) weakremover(ruby2.1-rubygem-daemons-doc) weakremover(ruby2.1-rubygem-debug_inspector) weakremover(ruby2.1-rubygem-debug_inspector-doc) weakremover(ruby2.1-rubygem-debugger-linecache) weakremover(ruby2.1-rubygem-debugger-linecache-doc) weakremover(ruby2.1-rubygem-debugger-linecache-testsuite) weakremover(ruby2.1-rubygem-deep_merge) weakremover(ruby2.1-rubygem-deep_merge-doc) weakremover(ruby2.1-rubygem-deep_merge-testsuite) weakremover(ruby2.1-rubygem-delayed_job) weakremover(ruby2.1-rubygem-delayed_job-doc) weakremover(ruby2.1-rubygem-delayed_job-testsuite) weakremover(ruby2.1-rubygem-delayed_job_active_record) weakremover(ruby2.1-rubygem-delayed_job_active_record-doc) weakremover(ruby2.1-rubygem-descendants_tracker) weakremover(ruby2.1-rubygem-descendants_tracker-doc) weakremover(ruby2.1-rubygem-descendants_tracker-testsuite) weakremover(ruby2.1-rubygem-devise) weakremover(ruby2.1-rubygem-devise-doc) weakremover(ruby2.1-rubygem-devise-i18n) weakremover(ruby2.1-rubygem-devise-i18n-doc) weakremover(ruby2.1-rubygem-devise-i18n-testsuite) weakremover(ruby2.1-rubygem-devise-testsuite) weakremover(ruby2.1-rubygem-dice) weakremover(ruby2.1-rubygem-dice-doc) weakremover(ruby2.1-rubygem-diff-lcs) weakremover(ruby2.1-rubygem-diff-lcs-doc) weakremover(ruby2.1-rubygem-diff-lcs-testsuite) weakremover(ruby2.1-rubygem-diffy) weakremover(ruby2.1-rubygem-diffy-doc) weakremover(ruby2.1-rubygem-diffy-testsuite) weakremover(ruby2.1-rubygem-docile) weakremover(ruby2.1-rubygem-docile-doc) weakremover(ruby2.1-rubygem-docile-testsuite) weakremover(ruby2.1-rubygem-docker-api) weakremover(ruby2.1-rubygem-docker-api-doc) weakremover(ruby2.1-rubygem-docker-api-testsuite) weakremover(ruby2.1-rubygem-equalizer) weakremover(ruby2.1-rubygem-equalizer-doc) weakremover(ruby2.1-rubygem-equalizer-testsuite) weakremover(ruby2.1-rubygem-erubis) weakremover(ruby2.1-rubygem-erubis-2_6) weakremover(ruby2.1-rubygem-erubis-doc) weakremover(ruby2.1-rubygem-erubis-doc-2_6) weakremover(ruby2.1-rubygem-erubis-testsuite) weakremover(ruby2.1-rubygem-erubis-testsuite-2_6) weakremover(ruby2.1-rubygem-eventmachine) weakremover(ruby2.1-rubygem-eventmachine-doc) weakremover(ruby2.1-rubygem-exception_notification) weakremover(ruby2.1-rubygem-exception_notification-doc) weakremover(ruby2.1-rubygem-exception_notification-testsuite) weakremover(ruby2.1-rubygem-excon) weakremover(ruby2.1-rubygem-excon-doc) weakremover(ruby2.1-rubygem-excon-testsuite) weakremover(ruby2.1-rubygem-execjs) weakremover(ruby2.1-rubygem-execjs-doc) weakremover(ruby2.1-rubygem-extlib) weakremover(ruby2.1-rubygem-extlib-doc) weakremover(ruby2.1-rubygem-extlib-testsuite) weakremover(ruby2.1-rubygem-facter) weakremover(ruby2.1-rubygem-facter-doc) weakremover(ruby2.1-rubygem-facter-testsuite) weakremover(ruby2.1-rubygem-factory_girl) weakremover(ruby2.1-rubygem-factory_girl-doc) weakremover(ruby2.1-rubygem-factory_girl-testsuite) weakremover(ruby2.1-rubygem-factory_girl_rails) weakremover(ruby2.1-rubygem-factory_girl_rails-doc) weakremover(ruby2.1-rubygem-faraday) weakremover(ruby2.1-rubygem-faraday-doc) weakremover(ruby2.1-rubygem-faraday-testsuite) weakremover(ruby2.1-rubygem-faraday_middleware) weakremover(ruby2.1-rubygem-faraday_middleware-0_9) weakremover(ruby2.1-rubygem-faraday_middleware-doc) weakremover(ruby2.1-rubygem-faraday_middleware-doc-0_9) weakremover(ruby2.1-rubygem-faraday_middleware-multi_json) weakremover(ruby2.1-rubygem-faraday_middleware-multi_json-doc) weakremover(ruby2.1-rubygem-faraday_middleware-multi_json-testsuite) weakremover(ruby2.1-rubygem-fast_gettext) weakremover(ruby2.1-rubygem-fast_gettext-1_1) weakremover(ruby2.1-rubygem-fast_gettext-1_2) weakremover(ruby2.1-rubygem-fast_gettext-doc) weakremover(ruby2.1-rubygem-fast_gettext-doc-1_1) weakremover(ruby2.1-rubygem-fast_gettext-doc-1_2) weakremover(ruby2.1-rubygem-fast_xs) weakremover(ruby2.1-rubygem-fast_xs-doc) weakremover(ruby2.1-rubygem-fast_xs-testsuite) weakremover(ruby2.1-rubygem-fastercsv) weakremover(ruby2.1-rubygem-fastercsv-doc) weakremover(ruby2.1-rubygem-fastercsv-testsuite) weakremover(ruby2.1-rubygem-ffi) weakremover(ruby2.1-rubygem-ffi-doc) weakremover(ruby2.1-rubygem-ffi-testsuite) weakremover(ruby2.1-rubygem-file-tail) weakremover(ruby2.1-rubygem-file-tail-doc) weakremover(ruby2.1-rubygem-flog) weakremover(ruby2.1-rubygem-flog-doc) weakremover(ruby2.1-rubygem-flog-testsuite) weakremover(ruby2.1-rubygem-fluentd) weakremover(ruby2.1-rubygem-fluentd-doc) weakremover(ruby2.1-rubygem-fluentd-testsuite) weakremover(ruby2.1-rubygem-gem2rpm) weakremover(ruby2.1-rubygem-gem2rpm-doc) weakremover(ruby2.1-rubygem-get_process_mem) weakremover(ruby2.1-rubygem-get_process_mem-doc) weakremover(ruby2.1-rubygem-get_process_mem-testsuite) weakremover(ruby2.1-rubygem-gettext) weakremover(ruby2.1-rubygem-gettext-doc) weakremover(ruby2.1-rubygem-gettext-setup) weakremover(ruby2.1-rubygem-gettext-setup-doc) weakremover(ruby2.1-rubygem-gettext-setup-testsuite) weakremover(ruby2.1-rubygem-gettext-testsuite) weakremover(ruby2.1-rubygem-gettext_i18n_rails) weakremover(ruby2.1-rubygem-gettext_i18n_rails-doc) weakremover(ruby2.1-rubygem-gettext_i18n_rails_js) weakremover(ruby2.1-rubygem-gettext_i18n_rails_js-doc) weakremover(ruby2.1-rubygem-gettext_i18n_rails_js-testsuite) weakremover(ruby2.1-rubygem-gli) weakremover(ruby2.1-rubygem-gli-doc) weakremover(ruby2.1-rubygem-gli-testsuite) weakremover(ruby2.1-rubygem-globalid) weakremover(ruby2.1-rubygem-globalid-doc) weakremover(ruby2.1-rubygem-gpgme) weakremover(ruby2.1-rubygem-gpgme-doc) weakremover(ruby2.1-rubygem-gpgme-testsuite) weakremover(ruby2.1-rubygem-haml) weakremover(ruby2.1-rubygem-haml-doc) weakremover(ruby2.1-rubygem-haml-rails) weakremover(ruby2.1-rubygem-haml-rails-doc) weakremover(ruby2.1-rubygem-haml-rails-testsuite) weakremover(ruby2.1-rubygem-haml-testsuite) weakremover(ruby2.1-rubygem-has_mobile_views) weakremover(ruby2.1-rubygem-has_mobile_views-doc) weakremover(ruby2.1-rubygem-has_mobile_views-testsuite) weakremover(ruby2.1-rubygem-hashdiff) weakremover(ruby2.1-rubygem-hashdiff-doc) weakremover(ruby2.1-rubygem-hashdiff-testsuite) weakremover(ruby2.1-rubygem-hashicorp-checkpoint) weakremover(ruby2.1-rubygem-hashicorp-checkpoint-doc) weakremover(ruby2.1-rubygem-hashicorp-checkpoint-testsuite) weakremover(ruby2.1-rubygem-hashie) weakremover(ruby2.1-rubygem-hashie-doc) weakremover(ruby2.1-rubygem-hashie-testsuite) weakremover(ruby2.1-rubygem-hiera) weakremover(ruby2.1-rubygem-hiera-doc) weakremover(ruby2.1-rubygem-hiera-eyaml) weakremover(ruby2.1-rubygem-hiera-eyaml-doc) weakremover(ruby2.1-rubygem-hiera-eyaml-gpg) weakremover(ruby2.1-rubygem-hiera-eyaml-gpg-doc) weakremover(ruby2.1-rubygem-hiera-testsuite) weakremover(ruby2.1-rubygem-highline) weakremover(ruby2.1-rubygem-highline-1_6) weakremover(ruby2.1-rubygem-highline-doc) weakremover(ruby2.1-rubygem-highline-doc-1_6) weakremover(ruby2.1-rubygem-highline-testsuite) weakremover(ruby2.1-rubygem-highline-testsuite-1_6) weakremover(ruby2.1-rubygem-hike) weakremover(ruby2.1-rubygem-hike-1_2) weakremover(ruby2.1-rubygem-hike-doc) weakremover(ruby2.1-rubygem-hike-doc-1_2) weakremover(ruby2.1-rubygem-hitimes) weakremover(ruby2.1-rubygem-hitimes-doc) weakremover(ruby2.1-rubygem-hitimes-testsuite) weakremover(ruby2.1-rubygem-hoe) weakremover(ruby2.1-rubygem-hoe-doc) weakremover(ruby2.1-rubygem-hoe-testsuite) weakremover(ruby2.1-rubygem-html2haml) weakremover(ruby2.1-rubygem-html2haml-doc) weakremover(ruby2.1-rubygem-html2haml-testsuite) weakremover(ruby2.1-rubygem-http_accept_language) weakremover(ruby2.1-rubygem-http_accept_language-doc) weakremover(ruby2.1-rubygem-http_accept_language-testsuite) weakremover(ruby2.1-rubygem-http_parser.rb) weakremover(ruby2.1-rubygem-http_parser.rb-doc) weakremover(ruby2.1-rubygem-http_parser.rb-testsuite) weakremover(ruby2.1-rubygem-httpclient) weakremover(ruby2.1-rubygem-httpclient-doc) weakremover(ruby2.1-rubygem-httpclient-testsuite) weakremover(ruby2.1-rubygem-hub) weakremover(ruby2.1-rubygem-hub-doc) weakremover(ruby2.1-rubygem-i18n) weakremover(ruby2.1-rubygem-i18n-doc) weakremover(ruby2.1-rubygem-i18n-testsuite) weakremover(ruby2.1-rubygem-ice_nine) weakremover(ruby2.1-rubygem-ice_nine-doc) weakremover(ruby2.1-rubygem-ice_nine-testsuite) weakremover(ruby2.1-rubygem-inifile) weakremover(ruby2.1-rubygem-inifile-doc) weakremover(ruby2.1-rubygem-inifile-testsuite) weakremover(ruby2.1-rubygem-ipaddress) weakremover(ruby2.1-rubygem-ipaddress-doc) weakremover(ruby2.1-rubygem-ipaddress-testsuite) weakremover(ruby2.1-rubygem-jbuilder) weakremover(ruby2.1-rubygem-jbuilder-doc) weakremover(ruby2.1-rubygem-jbuilder-testsuite) weakremover(ruby2.1-rubygem-jekyll) weakremover(ruby2.1-rubygem-jekyll-doc) weakremover(ruby2.1-rubygem-jekyll-sass-converter) weakremover(ruby2.1-rubygem-jekyll-sass-converter-doc) weakremover(ruby2.1-rubygem-jekyll-watch) weakremover(ruby2.1-rubygem-jekyll-watch-doc) weakremover(ruby2.1-rubygem-jmespath) weakremover(ruby2.1-rubygem-jmespath-doc) weakremover(ruby2.1-rubygem-journey-1_0) weakremover(ruby2.1-rubygem-journey-doc-1_0) weakremover(ruby2.1-rubygem-journey-testsuite-1_0) weakremover(ruby2.1-rubygem-jquery-rails) weakremover(ruby2.1-rubygem-jquery-rails-doc) weakremover(ruby2.1-rubygem-jquery-rails-testsuite) weakremover(ruby2.1-rubygem-jquery-ui-rails) weakremover(ruby2.1-rubygem-jquery-ui-rails-doc) weakremover(ruby2.1-rubygem-js-routes) weakremover(ruby2.1-rubygem-js-routes-doc) weakremover(ruby2.1-rubygem-js-routes-testsuite) weakremover(ruby2.1-rubygem-json) weakremover(ruby2.1-rubygem-json-doc) weakremover(ruby2.1-rubygem-json-schema) weakremover(ruby2.1-rubygem-json-schema-doc) weakremover(ruby2.1-rubygem-json-schema-testsuite) weakremover(ruby2.1-rubygem-json_pure) weakremover(ruby2.1-rubygem-json_pure-doc) weakremover(ruby2.1-rubygem-kgio) weakremover(ruby2.1-rubygem-kgio-doc) weakremover(ruby2.1-rubygem-kgio-testsuite) weakremover(ruby2.1-rubygem-kramdown) weakremover(ruby2.1-rubygem-kramdown-doc) weakremover(ruby2.1-rubygem-kramdown-testsuite) weakremover(ruby2.1-rubygem-launchy) weakremover(ruby2.1-rubygem-launchy-doc) weakremover(ruby2.1-rubygem-launchy-testsuite) weakremover(ruby2.1-rubygem-levenshtein) weakremover(ruby2.1-rubygem-levenshtein-doc) weakremover(ruby2.1-rubygem-levenshtein-testsuite) weakremover(ruby2.1-rubygem-librarian) weakremover(ruby2.1-rubygem-librarian-doc) weakremover(ruby2.1-rubygem-librarian-testsuite) weakremover(ruby2.1-rubygem-libyui-rake) weakremover(ruby2.1-rubygem-libyui-rake-doc) weakremover(ruby2.1-rubygem-liquid) weakremover(ruby2.1-rubygem-liquid-doc) weakremover(ruby2.1-rubygem-liquid-testsuite) weakremover(ruby2.1-rubygem-listen) weakremover(ruby2.1-rubygem-listen-doc) weakremover(ruby2.1-rubygem-locale) weakremover(ruby2.1-rubygem-locale-doc) weakremover(ruby2.1-rubygem-locale-testsuite) weakremover(ruby2.1-rubygem-log4r) weakremover(ruby2.1-rubygem-log4r-doc) weakremover(ruby2.1-rubygem-lolcat) weakremover(ruby2.1-rubygem-lolcat-doc) weakremover(ruby2.1-rubygem-loofah) weakremover(ruby2.1-rubygem-loofah-doc) weakremover(ruby2.1-rubygem-loofah-testsuite) weakremover(ruby2.1-rubygem-mail) weakremover(ruby2.1-rubygem-mail-2_5) weakremover(ruby2.1-rubygem-mail-doc) weakremover(ruby2.1-rubygem-mail-doc-2_5) weakremover(ruby2.1-rubygem-mcollective) weakremover(ruby2.1-rubygem-mcollective-doc) weakremover(ruby2.1-rubygem-mcollective-testsuite) weakremover(ruby2.1-rubygem-memcache-client) weakremover(ruby2.1-rubygem-memcache-client-doc) weakremover(ruby2.1-rubygem-memcache-client-testsuite) weakremover(ruby2.1-rubygem-mercenary) weakremover(ruby2.1-rubygem-mercenary-doc) weakremover(ruby2.1-rubygem-mercenary-testsuite) weakremover(ruby2.1-rubygem-metaclass) weakremover(ruby2.1-rubygem-metaclass-doc) weakremover(ruby2.1-rubygem-metaclass-testsuite) weakremover(ruby2.1-rubygem-method_source) weakremover(ruby2.1-rubygem-method_source-doc) weakremover(ruby2.1-rubygem-method_source-testsuite) weakremover(ruby2.1-rubygem-mime-types) weakremover(ruby2.1-rubygem-mime-types-1) weakremover(ruby2.1-rubygem-mime-types-data) weakremover(ruby2.1-rubygem-mime-types-data-doc) weakremover(ruby2.1-rubygem-mime-types-doc) weakremover(ruby2.1-rubygem-mime-types-doc-1) weakremover(ruby2.1-rubygem-mime-types-testsuite) weakremover(ruby2.1-rubygem-mime-types-testsuite-1) weakremover(ruby2.1-rubygem-mimemagic) weakremover(ruby2.1-rubygem-mimemagic-doc) weakremover(ruby2.1-rubygem-mimemagic-testsuite) weakremover(ruby2.1-rubygem-mini_magick) weakremover(ruby2.1-rubygem-mini_magick-doc) weakremover(ruby2.1-rubygem-mini_portile) weakremover(ruby2.1-rubygem-mini_portile-doc) weakremover(ruby2.1-rubygem-mini_portile2) weakremover(ruby2.1-rubygem-mini_portile2-doc) weakremover(ruby2.1-rubygem-mini_portile2-testsuite) weakremover(ruby2.1-rubygem-minitar) weakremover(ruby2.1-rubygem-minitar-doc) weakremover(ruby2.1-rubygem-minitest) weakremover(ruby2.1-rubygem-minitest-doc) weakremover(ruby2.1-rubygem-minitest-testsuite) weakremover(ruby2.1-rubygem-mixlib-authentication) weakremover(ruby2.1-rubygem-mixlib-authentication-doc) weakremover(ruby2.1-rubygem-mixlib-authentication-testsuite) weakremover(ruby2.1-rubygem-mixlib-cli) weakremover(ruby2.1-rubygem-mixlib-cli-doc) weakremover(ruby2.1-rubygem-mixlib-cli-testsuite) weakremover(ruby2.1-rubygem-mixlib-config) weakremover(ruby2.1-rubygem-mixlib-config-doc) weakremover(ruby2.1-rubygem-mixlib-config-testsuite) weakremover(ruby2.1-rubygem-mixlib-log) weakremover(ruby2.1-rubygem-mixlib-log-doc) weakremover(ruby2.1-rubygem-mixlib-log-testsuite) weakremover(ruby2.1-rubygem-mixlib-shellout) weakremover(ruby2.1-rubygem-mixlib-shellout-doc) weakremover(ruby2.1-rubygem-mobileesp_converted) weakremover(ruby2.1-rubygem-mobileesp_converted-doc) weakremover(ruby2.1-rubygem-mobileesp_converted-testsuite) weakremover(ruby2.1-rubygem-mocha) weakremover(ruby2.1-rubygem-mocha-doc) weakremover(ruby2.1-rubygem-mocha-testsuite) weakremover(ruby2.1-rubygem-moneta) weakremover(ruby2.1-rubygem-moneta-0_7) weakremover(ruby2.1-rubygem-moneta-doc) weakremover(ruby2.1-rubygem-moneta-doc-0_7) weakremover(ruby2.1-rubygem-moneta-testsuite) weakremover(ruby2.1-rubygem-moneta-testsuite-0_7) weakremover(ruby2.1-rubygem-msgpack) weakremover(ruby2.1-rubygem-msgpack-doc) weakremover(ruby2.1-rubygem-msgpack-testsuite) weakremover(ruby2.1-rubygem-multi_json) weakremover(ruby2.1-rubygem-multi_json-doc) weakremover(ruby2.1-rubygem-multipart-post) weakremover(ruby2.1-rubygem-multipart-post-doc) weakremover(ruby2.1-rubygem-multipart-post-testsuite) weakremover(ruby2.1-rubygem-mustache) weakremover(ruby2.1-rubygem-mustache-doc) weakremover(ruby2.1-rubygem-mustache-testsuite) weakremover(ruby2.1-rubygem-mysql) weakremover(ruby2.1-rubygem-mysql-doc) weakremover(ruby2.1-rubygem-mysql-testsuite) weakremover(ruby2.1-rubygem-mysql2) weakremover(ruby2.1-rubygem-mysql2-doc) weakremover(ruby2.1-rubygem-mysql2-testsuite) weakremover(ruby2.1-rubygem-net-scp) weakremover(ruby2.1-rubygem-net-scp-1_1) weakremover(ruby2.1-rubygem-net-scp-doc) weakremover(ruby2.1-rubygem-net-scp-doc-1_1) weakremover(ruby2.1-rubygem-net-scp-testsuite) weakremover(ruby2.1-rubygem-net-scp-testsuite-1_1) weakremover(ruby2.1-rubygem-net-sftp) weakremover(ruby2.1-rubygem-net-sftp-doc) weakremover(ruby2.1-rubygem-net-sftp-testsuite) weakremover(ruby2.1-rubygem-net-ssh) weakremover(ruby2.1-rubygem-net-ssh-doc) weakremover(ruby2.1-rubygem-net-ssh-gateway) weakremover(ruby2.1-rubygem-net-ssh-gateway-doc) weakremover(ruby2.1-rubygem-net-ssh-gateway-testsuite) weakremover(ruby2.1-rubygem-net-ssh-multi) weakremover(ruby2.1-rubygem-net-ssh-multi-1_1) weakremover(ruby2.1-rubygem-net-ssh-multi-doc) weakremover(ruby2.1-rubygem-net-ssh-multi-doc-1_1) weakremover(ruby2.1-rubygem-net-ssh-multi-testsuite) weakremover(ruby2.1-rubygem-net-ssh-multi-testsuite-1_1) weakremover(ruby2.1-rubygem-net-ssh-testsuite) weakremover(ruby2.1-rubygem-netrc) weakremover(ruby2.1-rubygem-netrc-doc) weakremover(ruby2.1-rubygem-netrc-testsuite) weakremover(ruby2.1-rubygem-nio4r) weakremover(ruby2.1-rubygem-nio4r-doc) weakremover(ruby2.1-rubygem-nio4r-testsuite) weakremover(ruby2.1-rubygem-nokogiri) weakremover(ruby2.1-rubygem-nokogiri-doc) weakremover(ruby2.1-rubygem-nokogiri-testsuite) weakremover(ruby2.1-rubygem-open4) weakremover(ruby2.1-rubygem-open4-doc) weakremover(ruby2.1-rubygem-open4-testsuite) weakremover(ruby2.1-rubygem-owncloud-admin) weakremover(ruby2.1-rubygem-owncloud-admin-doc) weakremover(ruby2.1-rubygem-packaging_rake_tasks) weakremover(ruby2.1-rubygem-packaging_rake_tasks-doc) weakremover(ruby2.1-rubygem-paint) weakremover(ruby2.1-rubygem-paint-doc) weakremover(ruby2.1-rubygem-path_expander) weakremover(ruby2.1-rubygem-path_expander-doc) weakremover(ruby2.1-rubygem-path_expander-testsuite) weakremover(ruby2.1-rubygem-pg) weakremover(ruby2.1-rubygem-pg-doc) weakremover(ruby2.1-rubygem-pg-testsuite) weakremover(ruby2.1-rubygem-pkg-config) weakremover(ruby2.1-rubygem-pkg-config-doc) weakremover(ruby2.1-rubygem-pkg-config-testsuite) weakremover(ruby2.1-rubygem-po_to_json) weakremover(ruby2.1-rubygem-po_to_json-doc) weakremover(ruby2.1-rubygem-po_to_json-testsuite) weakremover(ruby2.1-rubygem-polyglot) weakremover(ruby2.1-rubygem-polyglot-doc) weakremover(ruby2.1-rubygem-power_assert) weakremover(ruby2.1-rubygem-power_assert-doc) weakremover(ruby2.1-rubygem-power_assert-testsuite) weakremover(ruby2.1-rubygem-pry) weakremover(ruby2.1-rubygem-pry-doc) weakremover(ruby2.1-rubygem-pry-doc-doc) weakremover(ruby2.1-rubygem-pry-doc-testsuite) weakremover(ruby2.1-rubygem-pry_debug) weakremover(ruby2.1-rubygem-pry_debug-doc) weakremover(ruby2.1-rubygem-pry_debug-testsuite) weakremover(ruby2.1-rubygem-puma) weakremover(ruby2.1-rubygem-puma-doc) weakremover(ruby2.1-rubygem-puma_worker_killer) weakremover(ruby2.1-rubygem-puma_worker_killer-doc) weakremover(ruby2.1-rubygem-puma_worker_killer-testsuite) weakremover(ruby2.1-rubygem-puppet) weakremover(ruby2.1-rubygem-puppet-doc) weakremover(ruby2.1-rubygem-puppet-lint) weakremover(ruby2.1-rubygem-puppet-lint-doc) weakremover(ruby2.1-rubygem-puppet-lint-testsuite) weakremover(ruby2.1-rubygem-puppet-syntax) weakremover(ruby2.1-rubygem-puppet-syntax-doc) weakremover(ruby2.1-rubygem-puppet-syntax-testsuite) weakremover(ruby2.1-rubygem-puppet-testsuite) weakremover(ruby2.1-rubygem-puppet_forge) weakremover(ruby2.1-rubygem-puppet_forge-doc) weakremover(ruby2.1-rubygem-puppet_forge-testsuite) weakremover(ruby2.1-rubygem-quiet_assets) weakremover(ruby2.1-rubygem-quiet_assets-doc) weakremover(ruby2.1-rubygem-quiet_assets-testsuite) weakremover(ruby2.1-rubygem-quixoten-puppetdb-terminus) weakremover(ruby2.1-rubygem-quixoten-puppetdb-terminus-doc) weakremover(ruby2.1-rubygem-r10k) weakremover(ruby2.1-rubygem-r10k-doc) weakremover(ruby2.1-rubygem-r10k-testsuite) weakremover(ruby2.1-rubygem-ra10ke) weakremover(ruby2.1-rubygem-ra10ke-doc) weakremover(ruby2.1-rubygem-rack) weakremover(ruby2.1-rubygem-rack-1_3) weakremover(ruby2.1-rubygem-rack-1_4) weakremover(ruby2.1-rubygem-rack-1_6) weakremover(ruby2.1-rubygem-rack-cache-1_2) weakremover(ruby2.1-rubygem-rack-cache-doc-1_2) weakremover(ruby2.1-rubygem-rack-cache-testsuite-1_2) weakremover(ruby2.1-rubygem-rack-doc) weakremover(ruby2.1-rubygem-rack-doc-1_3) weakremover(ruby2.1-rubygem-rack-doc-1_4) weakremover(ruby2.1-rubygem-rack-doc-1_6) weakremover(ruby2.1-rubygem-rack-protection) weakremover(ruby2.1-rubygem-rack-protection-doc) weakremover(ruby2.1-rubygem-rack-protection-testsuite) weakremover(ruby2.1-rubygem-rack-ssl) weakremover(ruby2.1-rubygem-rack-ssl-1_3) weakremover(ruby2.1-rubygem-rack-ssl-doc) weakremover(ruby2.1-rubygem-rack-ssl-doc-1_3) weakremover(ruby2.1-rubygem-rack-test-0_6) weakremover(ruby2.1-rubygem-rack-test-doc-0_6) weakremover(ruby2.1-rubygem-rack-test-testsuite-0_6) weakremover(ruby2.1-rubygem-rack-testsuite) weakremover(ruby2.1-rubygem-rack-testsuite-1_3) weakremover(ruby2.1-rubygem-rack-testsuite-1_4) weakremover(ruby2.1-rubygem-rack-testsuite-1_6) weakremover(ruby2.1-rubygem-rails-4_2) weakremover(ruby2.1-rubygem-rails-deprecated_sanitizer) weakremover(ruby2.1-rubygem-rails-deprecated_sanitizer-doc) weakremover(ruby2.1-rubygem-rails-deprecated_sanitizer-testsuite) weakremover(ruby2.1-rubygem-rails-doc-4_2) weakremover(ruby2.1-rubygem-rails-dom-testing) weakremover(ruby2.1-rubygem-rails-dom-testing-doc) weakremover(ruby2.1-rubygem-rails-dom-testing-testsuite) weakremover(ruby2.1-rubygem-rails-html-sanitizer) weakremover(ruby2.1-rubygem-rails-html-sanitizer-doc) weakremover(ruby2.1-rubygem-rails-html-sanitizer-testsuite) weakremover(ruby2.1-rubygem-rails-i18n) weakremover(ruby2.1-rubygem-rails-i18n-doc) weakremover(ruby2.1-rubygem-railties-4_2) weakremover(ruby2.1-rubygem-railties-doc-4_2) weakremover(ruby2.1-rubygem-raindrops) weakremover(ruby2.1-rubygem-raindrops-doc) weakremover(ruby2.1-rubygem-raindrops-testsuite) weakremover(ruby2.1-rubygem-rake) weakremover(ruby2.1-rubygem-rake-compiler) weakremover(ruby2.1-rubygem-rake-compiler-doc) weakremover(ruby2.1-rubygem-rake-compiler-testsuite) weakremover(ruby2.1-rubygem-rake-doc) weakremover(ruby2.1-rubygem-rake-testsuite) weakremover(ruby2.1-rubygem-rb-fsevent) weakremover(ruby2.1-rubygem-rb-fsevent-doc) weakremover(ruby2.1-rubygem-rb-fsevent-testsuite) weakremover(ruby2.1-rubygem-rb-inotify) weakremover(ruby2.1-rubygem-rb-inotify-doc) weakremover(ruby2.1-rubygem-rb-kqueue) weakremover(ruby2.1-rubygem-rb-kqueue-doc) weakremover(ruby2.1-rubygem-rdoc-3) weakremover(ruby2.1-rubygem-rdoc-4) weakremover(ruby2.1-rubygem-rdoc-doc-4) weakremover(ruby2.1-rubygem-rdoc-testsuite-3) weakremover(ruby2.1-rubygem-rdoc-testsuite-4) weakremover(ruby2.1-rubygem-responders) weakremover(ruby2.1-rubygem-responders-doc) weakremover(ruby2.1-rubygem-rest-client) weakremover(ruby2.1-rubygem-rest-client-doc) weakremover(ruby2.1-rubygem-rest-client-testsuite) weakremover(ruby2.1-rubygem-restility) weakremover(ruby2.1-rubygem-restility-doc) weakremover(ruby2.1-rubygem-restility-testsuite) weakremover(ruby2.1-rubygem-rgen) weakremover(ruby2.1-rubygem-rgen-doc) weakremover(ruby2.1-rubygem-rgen-testsuite) weakremover(ruby2.1-rubygem-rhc) weakremover(ruby2.1-rubygem-rhc-doc) weakremover(ruby2.1-rubygem-rhc-testsuite) weakremover(ruby2.1-rubygem-rouge) weakremover(ruby2.1-rubygem-rouge-doc) weakremover(ruby2.1-rubygem-rpm) weakremover(ruby2.1-rubygem-rpm-doc) weakremover(ruby2.1-rubygem-rpm-testsuite) weakremover(ruby2.1-rubygem-rspec) weakremover(ruby2.1-rubygem-rspec-core) weakremover(ruby2.1-rubygem-rspec-core-doc) weakremover(ruby2.1-rubygem-rspec-doc) weakremover(ruby2.1-rubygem-rspec-expectations) weakremover(ruby2.1-rubygem-rspec-expectations-doc) weakremover(ruby2.1-rubygem-rspec-mocks) weakremover(ruby2.1-rubygem-rspec-mocks-doc) weakremover(ruby2.1-rubygem-rspec-puppet) weakremover(ruby2.1-rubygem-rspec-puppet-doc) weakremover(ruby2.1-rubygem-rspec-support) weakremover(ruby2.1-rubygem-rspec-support-doc) weakremover(ruby2.1-rubygem-ruby-augeas) weakremover(ruby2.1-rubygem-ruby-augeas-doc) weakremover(ruby2.1-rubygem-ruby-dbus) weakremover(ruby2.1-rubygem-ruby-dbus-doc) weakremover(ruby2.1-rubygem-ruby-dbus-testsuite) weakremover(ruby2.1-rubygem-ruby-libvirt) weakremover(ruby2.1-rubygem-ruby-libvirt-doc) weakremover(ruby2.1-rubygem-ruby-shadow) weakremover(ruby2.1-rubygem-ruby-shadow-doc) weakremover(ruby2.1-rubygem-ruby_dep) weakremover(ruby2.1-rubygem-ruby_dep-doc) weakremover(ruby2.1-rubygem-ruby_parser) weakremover(ruby2.1-rubygem-ruby_parser-doc) weakremover(ruby2.1-rubygem-ruby_parser-testsuite) weakremover(ruby2.1-rubygem-rubyforge) weakremover(ruby2.1-rubygem-rubyforge-doc) weakremover(ruby2.1-rubygem-rubyforge-testsuite) weakremover(ruby2.1-rubygem-rubyzip) weakremover(ruby2.1-rubygem-rubyzip-doc) weakremover(ruby2.1-rubygem-rubyzip-testsuite) weakremover(ruby2.1-rubygem-safe_yaml) weakremover(ruby2.1-rubygem-safe_yaml-doc) weakremover(ruby2.1-rubygem-safe_yaml-testsuite) weakremover(ruby2.1-rubygem-sass) weakremover(ruby2.1-rubygem-sass-doc) weakremover(ruby2.1-rubygem-sass-rails) weakremover(ruby2.1-rubygem-sass-rails-doc) weakremover(ruby2.1-rubygem-sass-testsuite) weakremover(ruby2.1-rubygem-sdoc) weakremover(ruby2.1-rubygem-sdoc-doc) weakremover(ruby2.1-rubygem-sdoc-testsuite) weakremover(ruby2.1-rubygem-semantic_puppet) weakremover(ruby2.1-rubygem-semantic_puppet-doc) weakremover(ruby2.1-rubygem-semantic_puppet-testsuite) weakremover(ruby2.1-rubygem-serverengine) weakremover(ruby2.1-rubygem-serverengine-doc) weakremover(ruby2.1-rubygem-serverengine-testsuite) weakremover(ruby2.1-rubygem-sexp_processor) weakremover(ruby2.1-rubygem-sexp_processor-doc) weakremover(ruby2.1-rubygem-sexp_processor-testsuite) weakremover(ruby2.1-rubygem-sigdump) weakremover(ruby2.1-rubygem-sigdump-doc) weakremover(ruby2.1-rubygem-simple_oauth) weakremover(ruby2.1-rubygem-simple_oauth-doc) weakremover(ruby2.1-rubygem-simplecov) weakremover(ruby2.1-rubygem-simplecov-doc) weakremover(ruby2.1-rubygem-simplecov-html) weakremover(ruby2.1-rubygem-simplecov-html-doc) weakremover(ruby2.1-rubygem-simplecov-html-testsuite) weakremover(ruby2.1-rubygem-simplecov-testsuite) weakremover(ruby2.1-rubygem-sinatra) weakremover(ruby2.1-rubygem-sinatra-doc) weakremover(ruby2.1-rubygem-sinatra-testsuite) weakremover(ruby2.1-rubygem-slop) weakremover(ruby2.1-rubygem-slop-3) weakremover(ruby2.1-rubygem-slop-3_3) weakremover(ruby2.1-rubygem-slop-doc) weakremover(ruby2.1-rubygem-slop-doc-3) weakremover(ruby2.1-rubygem-slop-doc-3_3) weakremover(ruby2.1-rubygem-slop-testsuite) weakremover(ruby2.1-rubygem-slop-testsuite-3) weakremover(ruby2.1-rubygem-slop-testsuite-3_3) weakremover(ruby2.1-rubygem-spring) weakremover(ruby2.1-rubygem-spring-doc) weakremover(ruby2.1-rubygem-spring-watcher-listen) weakremover(ruby2.1-rubygem-spring-watcher-listen-doc) weakremover(ruby2.1-rubygem-spring-watcher-listen-testsuite) weakremover(ruby2.1-rubygem-sprockets) weakremover(ruby2.1-rubygem-sprockets-2_1) weakremover(ruby2.1-rubygem-sprockets-2_2) weakremover(ruby2.1-rubygem-sprockets-doc) weakremover(ruby2.1-rubygem-sprockets-doc-2_1) weakremover(ruby2.1-rubygem-sprockets-doc-2_2) weakremover(ruby2.1-rubygem-sprockets-helpers) weakremover(ruby2.1-rubygem-sprockets-helpers-doc) weakremover(ruby2.1-rubygem-sprockets-helpers-testsuite) weakremover(ruby2.1-rubygem-sprockets-rails) weakremover(ruby2.1-rubygem-sprockets-rails-doc) weakremover(ruby2.1-rubygem-sqlite3) weakremover(ruby2.1-rubygem-sqlite3-doc) weakremover(ruby2.1-rubygem-sqlite3-testsuite) weakremover(ruby2.1-rubygem-sshkit) weakremover(ruby2.1-rubygem-sshkit-doc) weakremover(ruby2.1-rubygem-sshkit-testsuite) weakremover(ruby2.1-rubygem-stackdeck) weakremover(ruby2.1-rubygem-stackdeck-doc) weakremover(ruby2.1-rubygem-stackdeck-testsuite) weakremover(ruby2.1-rubygem-stomp) weakremover(ruby2.1-rubygem-stomp-doc) weakremover(ruby2.1-rubygem-stomp-testsuite) weakremover(ruby2.1-rubygem-strptime) weakremover(ruby2.1-rubygem-strptime-doc) weakremover(ruby2.1-rubygem-studio_api) weakremover(ruby2.1-rubygem-studio_api-doc) weakremover(ruby2.1-rubygem-studio_api-testsuite) weakremover(ruby2.1-rubygem-systemu) weakremover(ruby2.1-rubygem-systemu-doc) weakremover(ruby2.1-rubygem-systemu-testsuite) weakremover(ruby2.1-rubygem-taskjuggler) weakremover(ruby2.1-rubygem-taskjuggler-doc) weakremover(ruby2.1-rubygem-taskjuggler-testsuite) weakremover(ruby2.1-rubygem-term-ansicolor) weakremover(ruby2.1-rubygem-term-ansicolor-doc) weakremover(ruby2.1-rubygem-test-unit) weakremover(ruby2.1-rubygem-test-unit-doc) weakremover(ruby2.1-rubygem-test-unit-testsuite) weakremover(ruby2.1-rubygem-text) weakremover(ruby2.1-rubygem-text-doc) weakremover(ruby2.1-rubygem-text-hyphen) weakremover(ruby2.1-rubygem-text-hyphen-doc) weakremover(ruby2.1-rubygem-text-hyphen-testsuite) weakremover(ruby2.1-rubygem-text-testsuite) weakremover(ruby2.1-rubygem-thor) weakremover(ruby2.1-rubygem-thor-doc) weakremover(ruby2.1-rubygem-thor-testsuite) weakremover(ruby2.1-rubygem-thread_safe) weakremover(ruby2.1-rubygem-thread_safe-doc) weakremover(ruby2.1-rubygem-thread_safe-testsuite) weakremover(ruby2.1-rubygem-tilt) weakremover(ruby2.1-rubygem-tilt-1_1) weakremover(ruby2.1-rubygem-tilt-1_4) weakremover(ruby2.1-rubygem-tilt-doc) weakremover(ruby2.1-rubygem-tilt-doc-1_1) weakremover(ruby2.1-rubygem-tilt-doc-1_4) weakremover(ruby2.1-rubygem-tilt-testsuite) weakremover(ruby2.1-rubygem-tilt-testsuite-1_1) weakremover(ruby2.1-rubygem-tilt-testsuite-1_4) weakremover(ruby2.1-rubygem-timers) weakremover(ruby2.1-rubygem-timers-doc) weakremover(ruby2.1-rubygem-timers-testsuite) weakremover(ruby2.1-rubygem-tins) weakremover(ruby2.1-rubygem-tins-doc) weakremover(ruby2.1-rubygem-treetop) weakremover(ruby2.1-rubygem-treetop-1_4) weakremover(ruby2.1-rubygem-treetop-doc) weakremover(ruby2.1-rubygem-treetop-doc-1_4) weakremover(ruby2.1-rubygem-treetop-testsuite) weakremover(ruby2.1-rubygem-treetop-testsuite-1_4) weakremover(ruby2.1-rubygem-trollop) weakremover(ruby2.1-rubygem-trollop-doc) weakremover(ruby2.1-rubygem-trollop-testsuite) weakremover(ruby2.1-rubygem-turbolinks) weakremover(ruby2.1-rubygem-turbolinks-doc) weakremover(ruby2.1-rubygem-turbolinks-source) weakremover(ruby2.1-rubygem-turbolinks-source-doc) weakremover(ruby2.1-rubygem-turbolinks-testsuite) weakremover(ruby2.1-rubygem-tzinfo) weakremover(ruby2.1-rubygem-tzinfo-0) weakremover(ruby2.1-rubygem-tzinfo-data) weakremover(ruby2.1-rubygem-tzinfo-data-doc) weakremover(ruby2.1-rubygem-tzinfo-doc) weakremover(ruby2.1-rubygem-tzinfo-doc-0) weakremover(ruby2.1-rubygem-tzinfo-testsuite) weakremover(ruby2.1-rubygem-tzinfo-testsuite-0) weakremover(ruby2.1-rubygem-uglifier) weakremover(ruby2.1-rubygem-uglifier-doc) weakremover(ruby2.1-rubygem-uglifier-testsuite) weakremover(ruby2.1-rubygem-unicorn) weakremover(ruby2.1-rubygem-unicorn-doc) weakremover(ruby2.1-rubygem-unicorn-testsuite) weakremover(ruby2.1-rubygem-virtus) weakremover(ruby2.1-rubygem-virtus-doc) weakremover(ruby2.1-rubygem-virtus-testsuite) weakremover(ruby2.1-rubygem-web-console) weakremover(ruby2.1-rubygem-web-console-2) weakremover(ruby2.1-rubygem-web-console-doc) weakremover(ruby2.1-rubygem-web-console-doc-2) weakremover(ruby2.1-rubygem-websocket) weakremover(ruby2.1-rubygem-websocket-doc) weakremover(ruby2.1-rubygem-websocket-driver) weakremover(ruby2.1-rubygem-websocket-driver-doc) weakremover(ruby2.1-rubygem-websocket-extensions) weakremover(ruby2.1-rubygem-websocket-extensions-doc) weakremover(ruby2.1-rubygem-websocket-testsuite) weakremover(ruby2.1-rubygem-xml-simple) weakremover(ruby2.1-rubygem-xml-simple-doc) weakremover(ruby2.1-rubygem-xmlhash) weakremover(ruby2.1-rubygem-xmlhash-doc) weakremover(ruby2.1-rubygem-xmlhash-testsuite) weakremover(ruby2.1-rubygem-yajl-ruby) weakremover(ruby2.1-rubygem-yajl-ruby-doc) weakremover(ruby2.1-rubygem-yajl-ruby-testsuite) weakremover(ruby2.1-rubygem-yard) weakremover(ruby2.1-rubygem-yard-doc) weakremover(ruby2.1-rubygem-yard-testsuite) weakremover(ruby2.1-rubygem-yast-rake) weakremover(ruby2.1-rubygem-yast-rake-doc) weakremover(ruby2.1-stdlib) weakremover(ruby2.2) weakremover(ruby2.2-devel) weakremover(ruby2.2-devel-extra) weakremover(ruby2.2-doc) weakremover(ruby2.2-doc-ri) weakremover(ruby2.2-rubygem-RedCloth) weakremover(ruby2.2-rubygem-RedCloth-doc) weakremover(ruby2.2-rubygem-RedCloth-testsuite) weakremover(ruby2.2-rubygem-abstract) weakremover(ruby2.2-rubygem-abstract-doc) weakremover(ruby2.2-rubygem-abstract-testsuite) weakremover(ruby2.2-rubygem-abstract_method) weakremover(ruby2.2-rubygem-abstract_method-doc) weakremover(ruby2.2-rubygem-actionmailer-4_2) weakremover(ruby2.2-rubygem-actionmailer-doc-4_2) weakremover(ruby2.2-rubygem-actionpack-4_2) weakremover(ruby2.2-rubygem-actionpack-doc-4_2) weakremover(ruby2.2-rubygem-actionview-4_2) weakremover(ruby2.2-rubygem-actionview-doc-4_2) weakremover(ruby2.2-rubygem-activejob-4_2) weakremover(ruby2.2-rubygem-activejob-doc-4_2) weakremover(ruby2.2-rubygem-activemodel-4_2) weakremover(ruby2.2-rubygem-activemodel-doc-4_2) weakremover(ruby2.2-rubygem-activerecord-4_2) weakremover(ruby2.2-rubygem-activerecord-deprecated_finders) weakremover(ruby2.2-rubygem-activerecord-deprecated_finders-doc) weakremover(ruby2.2-rubygem-activerecord-doc-4_2) weakremover(ruby2.2-rubygem-activesupport-4_2) weakremover(ruby2.2-rubygem-activesupport-doc-4_2) weakremover(ruby2.2-rubygem-addressable) weakremover(ruby2.2-rubygem-addressable-doc) weakremover(ruby2.2-rubygem-addressable-testsuite) weakremover(ruby2.2-rubygem-airbrussh) weakremover(ruby2.2-rubygem-airbrussh-doc) weakremover(ruby2.2-rubygem-amqp) weakremover(ruby2.2-rubygem-amqp-doc) weakremover(ruby2.2-rubygem-amqp-testsuite) weakremover(ruby2.2-rubygem-archive-tar-minitar) weakremover(ruby2.2-rubygem-archive-tar-minitar-doc) weakremover(ruby2.2-rubygem-arel) weakremover(ruby2.2-rubygem-arel-3_0) weakremover(ruby2.2-rubygem-arel-7) weakremover(ruby2.2-rubygem-arel-doc) weakremover(ruby2.2-rubygem-arel-doc-3_0) weakremover(ruby2.2-rubygem-arel-doc-7) weakremover(ruby2.2-rubygem-arel-testsuite-3_0) weakremover(ruby2.2-rubygem-atomic) weakremover(ruby2.2-rubygem-atomic-doc) weakremover(ruby2.2-rubygem-atomic-testsuite) weakremover(ruby2.2-rubygem-augeas) weakremover(ruby2.2-rubygem-augeas-doc) weakremover(ruby2.2-rubygem-autoprefixer-rails) weakremover(ruby2.2-rubygem-autoprefixer-rails-doc) weakremover(ruby2.2-rubygem-autoprefixer-rails-testsuite) weakremover(ruby2.2-rubygem-axiom-types) weakremover(ruby2.2-rubygem-axiom-types-doc) weakremover(ruby2.2-rubygem-axiom-types-testsuite) weakremover(ruby2.2-rubygem-bcrypt) weakremover(ruby2.2-rubygem-bcrypt-doc) weakremover(ruby2.2-rubygem-bcrypt-ruby) weakremover(ruby2.2-rubygem-bcrypt-ruby-doc) weakremover(ruby2.2-rubygem-bcrypt-testsuite) weakremover(ruby2.2-rubygem-binding_of_caller) weakremover(ruby2.2-rubygem-binding_of_caller-doc) weakremover(ruby2.2-rubygem-binding_of_caller-testsuite) weakremover(ruby2.2-rubygem-bootstrap-sass) weakremover(ruby2.2-rubygem-bootstrap-sass-doc) weakremover(ruby2.2-rubygem-bootstrap-sass-testsuite) weakremover(ruby2.2-rubygem-buff-ignore) weakremover(ruby2.2-rubygem-buff-ignore-doc) weakremover(ruby2.2-rubygem-buff-ignore-testsuite) weakremover(ruby2.2-rubygem-builder) weakremover(ruby2.2-rubygem-builder-doc) weakremover(ruby2.2-rubygem-builder-testsuite) weakremover(ruby2.2-rubygem-bundler) weakremover(ruby2.2-rubygem-bundler-audit) weakremover(ruby2.2-rubygem-bundler-audit-doc) weakremover(ruby2.2-rubygem-bundler-audit-testsuite) weakremover(ruby2.2-rubygem-bundler-doc) weakremover(ruby2.2-rubygem-bunny) weakremover(ruby2.2-rubygem-bunny-doc) weakremover(ruby2.2-rubygem-bunny-testsuite) weakremover(ruby2.2-rubygem-byebug) weakremover(ruby2.2-rubygem-byebug-doc) weakremover(ruby2.2-rubygem-capistrano) weakremover(ruby2.2-rubygem-capistrano-doc) weakremover(ruby2.2-rubygem-capistrano-harrow) weakremover(ruby2.2-rubygem-capistrano-harrow-doc) weakremover(ruby2.2-rubygem-capistrano-stats) weakremover(ruby2.2-rubygem-capistrano-stats-doc) weakremover(ruby2.2-rubygem-capistrano-testsuite) weakremover(ruby2.2-rubygem-celluloid) weakremover(ruby2.2-rubygem-celluloid-doc) weakremover(ruby2.2-rubygem-celluloid-testsuite) weakremover(ruby2.2-rubygem-cfa) weakremover(ruby2.2-rubygem-cfa-doc) weakremover(ruby2.2-rubygem-cfa_grub2) weakremover(ruby2.2-rubygem-cfa_grub2-doc) weakremover(ruby2.2-rubygem-cheetah) weakremover(ruby2.2-rubygem-cheetah-doc) weakremover(ruby2.2-rubygem-childprocess) weakremover(ruby2.2-rubygem-childprocess-doc) weakremover(ruby2.2-rubygem-childprocess-testsuite) weakremover(ruby2.2-rubygem-ci_reporter) weakremover(ruby2.2-rubygem-ci_reporter-doc) weakremover(ruby2.2-rubygem-ci_reporter-testsuite) weakremover(ruby2.2-rubygem-cleanroom) weakremover(ruby2.2-rubygem-cleanroom-doc) weakremover(ruby2.2-rubygem-cleanroom-testsuite) weakremover(ruby2.2-rubygem-coderay) weakremover(ruby2.2-rubygem-coderay-doc) weakremover(ruby2.2-rubygem-coderay-testsuite) weakremover(ruby2.2-rubygem-coercible) weakremover(ruby2.2-rubygem-coercible-doc) weakremover(ruby2.2-rubygem-coercible-testsuite) weakremover(ruby2.2-rubygem-coffee-rails) weakremover(ruby2.2-rubygem-coffee-rails-doc) weakremover(ruby2.2-rubygem-coffee-rails-testsuite) weakremover(ruby2.2-rubygem-coffee-script) weakremover(ruby2.2-rubygem-coffee-script-doc) weakremover(ruby2.2-rubygem-coffee-script-source) weakremover(ruby2.2-rubygem-coffee-script-source-doc) weakremover(ruby2.2-rubygem-colorator) weakremover(ruby2.2-rubygem-colorator-doc) weakremover(ruby2.2-rubygem-colorize) weakremover(ruby2.2-rubygem-colorize-doc) weakremover(ruby2.2-rubygem-colorize-testsuite) weakremover(ruby2.2-rubygem-columnize) weakremover(ruby2.2-rubygem-columnize-doc) weakremover(ruby2.2-rubygem-columnize-testsuite) weakremover(ruby2.2-rubygem-commander) weakremover(ruby2.2-rubygem-commander-doc) weakremover(ruby2.2-rubygem-commander-testsuite) weakremover(ruby2.2-rubygem-concurrent-ruby) weakremover(ruby2.2-rubygem-concurrent-ruby-doc) weakremover(ruby2.2-rubygem-cool.io) weakremover(ruby2.2-rubygem-cool.io-doc) weakremover(ruby2.2-rubygem-cool.io-testsuite) weakremover(ruby2.2-rubygem-cri) weakremover(ruby2.2-rubygem-cri-2_6) weakremover(ruby2.2-rubygem-cri-doc) weakremover(ruby2.2-rubygem-cri-doc-2_6) weakremover(ruby2.2-rubygem-cri-testsuite) weakremover(ruby2.2-rubygem-cri-testsuite-2_6) weakremover(ruby2.2-rubygem-cssmin) weakremover(ruby2.2-rubygem-cssmin-doc) weakremover(ruby2.2-rubygem-daemons) weakremover(ruby2.2-rubygem-daemons-doc) weakremover(ruby2.2-rubygem-debug_inspector) weakremover(ruby2.2-rubygem-debug_inspector-doc) weakremover(ruby2.2-rubygem-debugger-linecache) weakremover(ruby2.2-rubygem-debugger-linecache-doc) weakremover(ruby2.2-rubygem-debugger-linecache-testsuite) weakremover(ruby2.2-rubygem-deep_merge) weakremover(ruby2.2-rubygem-deep_merge-doc) weakremover(ruby2.2-rubygem-deep_merge-testsuite) weakremover(ruby2.2-rubygem-delayed_job) weakremover(ruby2.2-rubygem-delayed_job-doc) weakremover(ruby2.2-rubygem-delayed_job-testsuite) weakremover(ruby2.2-rubygem-descendants_tracker) weakremover(ruby2.2-rubygem-descendants_tracker-doc) weakremover(ruby2.2-rubygem-descendants_tracker-testsuite) weakremover(ruby2.2-rubygem-devise) weakremover(ruby2.2-rubygem-devise-doc) weakremover(ruby2.2-rubygem-devise-i18n) weakremover(ruby2.2-rubygem-devise-i18n-doc) weakremover(ruby2.2-rubygem-devise-i18n-testsuite) weakremover(ruby2.2-rubygem-devise-testsuite) weakremover(ruby2.2-rubygem-diff-lcs) weakremover(ruby2.2-rubygem-diff-lcs-doc) weakremover(ruby2.2-rubygem-diff-lcs-testsuite) weakremover(ruby2.2-rubygem-diffy) weakremover(ruby2.2-rubygem-diffy-doc) weakremover(ruby2.2-rubygem-diffy-testsuite) weakremover(ruby2.2-rubygem-docile) weakremover(ruby2.2-rubygem-docile-doc) weakremover(ruby2.2-rubygem-docile-testsuite) weakremover(ruby2.2-rubygem-docker-api) weakremover(ruby2.2-rubygem-docker-api-doc) weakremover(ruby2.2-rubygem-docker-api-testsuite) weakremover(ruby2.2-rubygem-equalizer) weakremover(ruby2.2-rubygem-equalizer-doc) weakremover(ruby2.2-rubygem-equalizer-testsuite) weakremover(ruby2.2-rubygem-erubis) weakremover(ruby2.2-rubygem-erubis-2_6) weakremover(ruby2.2-rubygem-erubis-doc) weakremover(ruby2.2-rubygem-erubis-doc-2_6) weakremover(ruby2.2-rubygem-erubis-testsuite) weakremover(ruby2.2-rubygem-erubis-testsuite-2_6) weakremover(ruby2.2-rubygem-eventmachine) weakremover(ruby2.2-rubygem-eventmachine-doc) weakremover(ruby2.2-rubygem-exception_notification) weakremover(ruby2.2-rubygem-exception_notification-doc) weakremover(ruby2.2-rubygem-exception_notification-testsuite) weakremover(ruby2.2-rubygem-excon) weakremover(ruby2.2-rubygem-excon-doc) weakremover(ruby2.2-rubygem-excon-testsuite) weakremover(ruby2.2-rubygem-execjs) weakremover(ruby2.2-rubygem-execjs-doc) weakremover(ruby2.2-rubygem-extlib) weakremover(ruby2.2-rubygem-extlib-doc) weakremover(ruby2.2-rubygem-extlib-testsuite) weakremover(ruby2.2-rubygem-facter) weakremover(ruby2.2-rubygem-facter-doc) weakremover(ruby2.2-rubygem-facter-testsuite) weakremover(ruby2.2-rubygem-factory_girl) weakremover(ruby2.2-rubygem-factory_girl-doc) weakremover(ruby2.2-rubygem-factory_girl-testsuite) weakremover(ruby2.2-rubygem-factory_girl_rails) weakremover(ruby2.2-rubygem-factory_girl_rails-doc) weakremover(ruby2.2-rubygem-faraday) weakremover(ruby2.2-rubygem-faraday-doc) weakremover(ruby2.2-rubygem-faraday-testsuite) weakremover(ruby2.2-rubygem-faraday_middleware) weakremover(ruby2.2-rubygem-faraday_middleware-0_9) weakremover(ruby2.2-rubygem-faraday_middleware-doc) weakremover(ruby2.2-rubygem-faraday_middleware-doc-0_9) weakremover(ruby2.2-rubygem-faraday_middleware-multi_json) weakremover(ruby2.2-rubygem-faraday_middleware-multi_json-doc) weakremover(ruby2.2-rubygem-faraday_middleware-multi_json-testsuite) weakremover(ruby2.2-rubygem-fast_gettext) weakremover(ruby2.2-rubygem-fast_gettext-1_1) weakremover(ruby2.2-rubygem-fast_gettext-1_2) weakremover(ruby2.2-rubygem-fast_gettext-doc) weakremover(ruby2.2-rubygem-fast_gettext-doc-1_1) weakremover(ruby2.2-rubygem-fast_gettext-doc-1_2) weakremover(ruby2.2-rubygem-fast_xs) weakremover(ruby2.2-rubygem-fast_xs-doc) weakremover(ruby2.2-rubygem-fast_xs-testsuite) weakremover(ruby2.2-rubygem-fastercsv) weakremover(ruby2.2-rubygem-fastercsv-doc) weakremover(ruby2.2-rubygem-fastercsv-testsuite) weakremover(ruby2.2-rubygem-ffi) weakremover(ruby2.2-rubygem-ffi-doc) weakremover(ruby2.2-rubygem-ffi-testsuite) weakremover(ruby2.2-rubygem-file-tail) weakremover(ruby2.2-rubygem-file-tail-doc) weakremover(ruby2.2-rubygem-flog) weakremover(ruby2.2-rubygem-flog-doc) weakremover(ruby2.2-rubygem-flog-testsuite) weakremover(ruby2.2-rubygem-fluentd) weakremover(ruby2.2-rubygem-fluentd-doc) weakremover(ruby2.2-rubygem-fluentd-testsuite) weakremover(ruby2.2-rubygem-gem2rpm) weakremover(ruby2.2-rubygem-gem2rpm-doc) weakremover(ruby2.2-rubygem-get_process_mem) weakremover(ruby2.2-rubygem-get_process_mem-doc) weakremover(ruby2.2-rubygem-get_process_mem-testsuite) weakremover(ruby2.2-rubygem-gettext) weakremover(ruby2.2-rubygem-gettext-doc) weakremover(ruby2.2-rubygem-gettext-setup) weakremover(ruby2.2-rubygem-gettext-setup-doc) weakremover(ruby2.2-rubygem-gettext-setup-testsuite) weakremover(ruby2.2-rubygem-gettext-testsuite) weakremover(ruby2.2-rubygem-gettext_i18n_rails) weakremover(ruby2.2-rubygem-gettext_i18n_rails-doc) weakremover(ruby2.2-rubygem-gettext_i18n_rails_js) weakremover(ruby2.2-rubygem-gettext_i18n_rails_js-doc) weakremover(ruby2.2-rubygem-gettext_i18n_rails_js-testsuite) weakremover(ruby2.2-rubygem-gli) weakremover(ruby2.2-rubygem-gli-doc) weakremover(ruby2.2-rubygem-gli-testsuite) weakremover(ruby2.2-rubygem-globalid) weakremover(ruby2.2-rubygem-globalid-doc) weakremover(ruby2.2-rubygem-gpgme) weakremover(ruby2.2-rubygem-gpgme-doc) weakremover(ruby2.2-rubygem-gpgme-testsuite) weakremover(ruby2.2-rubygem-haml) weakremover(ruby2.2-rubygem-haml-doc) weakremover(ruby2.2-rubygem-haml-rails) weakremover(ruby2.2-rubygem-haml-rails-doc) weakremover(ruby2.2-rubygem-haml-rails-testsuite) weakremover(ruby2.2-rubygem-haml-testsuite) weakremover(ruby2.2-rubygem-has_mobile_views) weakremover(ruby2.2-rubygem-has_mobile_views-doc) weakremover(ruby2.2-rubygem-has_mobile_views-testsuite) weakremover(ruby2.2-rubygem-hashdiff) weakremover(ruby2.2-rubygem-hashdiff-doc) weakremover(ruby2.2-rubygem-hashdiff-testsuite) weakremover(ruby2.2-rubygem-hashicorp-checkpoint) weakremover(ruby2.2-rubygem-hashicorp-checkpoint-doc) weakremover(ruby2.2-rubygem-hashicorp-checkpoint-testsuite) weakremover(ruby2.2-rubygem-hashie) weakremover(ruby2.2-rubygem-hashie-doc) weakremover(ruby2.2-rubygem-hashie-testsuite) weakremover(ruby2.2-rubygem-hiera) weakremover(ruby2.2-rubygem-hiera-doc) weakremover(ruby2.2-rubygem-hiera-eyaml) weakremover(ruby2.2-rubygem-hiera-eyaml-doc) weakremover(ruby2.2-rubygem-hiera-eyaml-gpg) weakremover(ruby2.2-rubygem-hiera-eyaml-gpg-doc) weakremover(ruby2.2-rubygem-hiera-testsuite) weakremover(ruby2.2-rubygem-highline) weakremover(ruby2.2-rubygem-highline-1_6) weakremover(ruby2.2-rubygem-highline-doc) weakremover(ruby2.2-rubygem-highline-doc-1_6) weakremover(ruby2.2-rubygem-highline-testsuite) weakremover(ruby2.2-rubygem-highline-testsuite-1_6) weakremover(ruby2.2-rubygem-hike) weakremover(ruby2.2-rubygem-hike-1_2) weakremover(ruby2.2-rubygem-hike-doc) weakremover(ruby2.2-rubygem-hike-doc-1_2) weakremover(ruby2.2-rubygem-hitimes) weakremover(ruby2.2-rubygem-hitimes-doc) weakremover(ruby2.2-rubygem-hitimes-testsuite) weakremover(ruby2.2-rubygem-hoe) weakremover(ruby2.2-rubygem-hoe-doc) weakremover(ruby2.2-rubygem-hoe-testsuite) weakremover(ruby2.2-rubygem-html2haml) weakremover(ruby2.2-rubygem-html2haml-doc) weakremover(ruby2.2-rubygem-html2haml-testsuite) weakremover(ruby2.2-rubygem-http_accept_language) weakremover(ruby2.2-rubygem-http_accept_language-doc) weakremover(ruby2.2-rubygem-http_accept_language-testsuite) weakremover(ruby2.2-rubygem-http_parser.rb) weakremover(ruby2.2-rubygem-http_parser.rb-doc) weakremover(ruby2.2-rubygem-http_parser.rb-testsuite) weakremover(ruby2.2-rubygem-httpclient) weakremover(ruby2.2-rubygem-httpclient-doc) weakremover(ruby2.2-rubygem-httpclient-testsuite) weakremover(ruby2.2-rubygem-hub) weakremover(ruby2.2-rubygem-hub-doc) weakremover(ruby2.2-rubygem-i18n) weakremover(ruby2.2-rubygem-i18n-doc) weakremover(ruby2.2-rubygem-i18n-testsuite) weakremover(ruby2.2-rubygem-ice_nine) weakremover(ruby2.2-rubygem-ice_nine-doc) weakremover(ruby2.2-rubygem-ice_nine-testsuite) weakremover(ruby2.2-rubygem-inifile) weakremover(ruby2.2-rubygem-inifile-doc) weakremover(ruby2.2-rubygem-inifile-testsuite) weakremover(ruby2.2-rubygem-ipaddress) weakremover(ruby2.2-rubygem-ipaddress-doc) weakremover(ruby2.2-rubygem-ipaddress-testsuite) weakremover(ruby2.2-rubygem-jbuilder) weakremover(ruby2.2-rubygem-jbuilder-doc) weakremover(ruby2.2-rubygem-jbuilder-testsuite) weakremover(ruby2.2-rubygem-jekyll) weakremover(ruby2.2-rubygem-jekyll-doc) weakremover(ruby2.2-rubygem-jekyll-sass-converter) weakremover(ruby2.2-rubygem-jekyll-sass-converter-doc) weakremover(ruby2.2-rubygem-jekyll-watch) weakremover(ruby2.2-rubygem-jekyll-watch-doc) weakremover(ruby2.2-rubygem-jmespath) weakremover(ruby2.2-rubygem-jmespath-doc) weakremover(ruby2.2-rubygem-journey-1_0) weakremover(ruby2.2-rubygem-journey-doc-1_0) weakremover(ruby2.2-rubygem-journey-testsuite-1_0) weakremover(ruby2.2-rubygem-jquery-rails) weakremover(ruby2.2-rubygem-jquery-rails-doc) weakremover(ruby2.2-rubygem-jquery-rails-testsuite) weakremover(ruby2.2-rubygem-jquery-ui-rails) weakremover(ruby2.2-rubygem-jquery-ui-rails-doc) weakremover(ruby2.2-rubygem-js-routes) weakremover(ruby2.2-rubygem-js-routes-doc) weakremover(ruby2.2-rubygem-js-routes-testsuite) weakremover(ruby2.2-rubygem-json) weakremover(ruby2.2-rubygem-json-doc) weakremover(ruby2.2-rubygem-json-schema) weakremover(ruby2.2-rubygem-json-schema-doc) weakremover(ruby2.2-rubygem-json-schema-testsuite) weakremover(ruby2.2-rubygem-json_pure) weakremover(ruby2.2-rubygem-json_pure-doc) weakremover(ruby2.2-rubygem-kgio) weakremover(ruby2.2-rubygem-kgio-doc) weakremover(ruby2.2-rubygem-kgio-testsuite) weakremover(ruby2.2-rubygem-kramdown) weakremover(ruby2.2-rubygem-kramdown-doc) weakremover(ruby2.2-rubygem-kramdown-testsuite) weakremover(ruby2.2-rubygem-launchy) weakremover(ruby2.2-rubygem-launchy-doc) weakremover(ruby2.2-rubygem-launchy-testsuite) weakremover(ruby2.2-rubygem-levenshtein) weakremover(ruby2.2-rubygem-levenshtein-doc) weakremover(ruby2.2-rubygem-levenshtein-testsuite) weakremover(ruby2.2-rubygem-librarian) weakremover(ruby2.2-rubygem-librarian-doc) weakremover(ruby2.2-rubygem-librarian-testsuite) weakremover(ruby2.2-rubygem-libyui-rake) weakremover(ruby2.2-rubygem-libyui-rake-doc) weakremover(ruby2.2-rubygem-liquid) weakremover(ruby2.2-rubygem-liquid-doc) weakremover(ruby2.2-rubygem-liquid-testsuite) weakremover(ruby2.2-rubygem-listen) weakremover(ruby2.2-rubygem-listen-doc) weakremover(ruby2.2-rubygem-locale) weakremover(ruby2.2-rubygem-locale-doc) weakremover(ruby2.2-rubygem-locale-testsuite) weakremover(ruby2.2-rubygem-log4r) weakremover(ruby2.2-rubygem-log4r-doc) weakremover(ruby2.2-rubygem-lolcat) weakremover(ruby2.2-rubygem-lolcat-doc) weakremover(ruby2.2-rubygem-loofah) weakremover(ruby2.2-rubygem-loofah-doc) weakremover(ruby2.2-rubygem-loofah-testsuite) weakremover(ruby2.2-rubygem-mail) weakremover(ruby2.2-rubygem-mail-2_5) weakremover(ruby2.2-rubygem-mail-doc) weakremover(ruby2.2-rubygem-mail-doc-2_5) weakremover(ruby2.2-rubygem-mcollective) weakremover(ruby2.2-rubygem-mcollective-doc) weakremover(ruby2.2-rubygem-mcollective-testsuite) weakremover(ruby2.2-rubygem-mercenary) weakremover(ruby2.2-rubygem-mercenary-doc) weakremover(ruby2.2-rubygem-mercenary-testsuite) weakremover(ruby2.2-rubygem-metaclass) weakremover(ruby2.2-rubygem-metaclass-doc) weakremover(ruby2.2-rubygem-metaclass-testsuite) weakremover(ruby2.2-rubygem-method_source) weakremover(ruby2.2-rubygem-method_source-doc) weakremover(ruby2.2-rubygem-method_source-testsuite) weakremover(ruby2.2-rubygem-mime-types) weakremover(ruby2.2-rubygem-mime-types-1) weakremover(ruby2.2-rubygem-mime-types-data) weakremover(ruby2.2-rubygem-mime-types-data-doc) weakremover(ruby2.2-rubygem-mime-types-doc) weakremover(ruby2.2-rubygem-mime-types-doc-1) weakremover(ruby2.2-rubygem-mime-types-testsuite) weakremover(ruby2.2-rubygem-mime-types-testsuite-1) weakremover(ruby2.2-rubygem-mimemagic) weakremover(ruby2.2-rubygem-mimemagic-doc) weakremover(ruby2.2-rubygem-mimemagic-testsuite) weakremover(ruby2.2-rubygem-mini_magick) weakremover(ruby2.2-rubygem-mini_magick-doc) weakremover(ruby2.2-rubygem-mini_portile) weakremover(ruby2.2-rubygem-mini_portile-doc) weakremover(ruby2.2-rubygem-mini_portile2) weakremover(ruby2.2-rubygem-mini_portile2-doc) weakremover(ruby2.2-rubygem-mini_portile2-testsuite) weakremover(ruby2.2-rubygem-minitar) weakremover(ruby2.2-rubygem-minitar-doc) weakremover(ruby2.2-rubygem-minitest) weakremover(ruby2.2-rubygem-minitest-doc) weakremover(ruby2.2-rubygem-minitest-testsuite) weakremover(ruby2.2-rubygem-mixlib-authentication) weakremover(ruby2.2-rubygem-mixlib-authentication-doc) weakremover(ruby2.2-rubygem-mixlib-authentication-testsuite) weakremover(ruby2.2-rubygem-mixlib-cli) weakremover(ruby2.2-rubygem-mixlib-cli-doc) weakremover(ruby2.2-rubygem-mixlib-cli-testsuite) weakremover(ruby2.2-rubygem-mixlib-config) weakremover(ruby2.2-rubygem-mixlib-config-doc) weakremover(ruby2.2-rubygem-mixlib-config-testsuite) weakremover(ruby2.2-rubygem-mixlib-log) weakremover(ruby2.2-rubygem-mixlib-log-doc) weakremover(ruby2.2-rubygem-mixlib-log-testsuite) weakremover(ruby2.2-rubygem-mixlib-shellout) weakremover(ruby2.2-rubygem-mixlib-shellout-doc) weakremover(ruby2.2-rubygem-mocha) weakremover(ruby2.2-rubygem-mocha-doc) weakremover(ruby2.2-rubygem-mocha-testsuite) weakremover(ruby2.2-rubygem-moneta) weakremover(ruby2.2-rubygem-moneta-0_7) weakremover(ruby2.2-rubygem-moneta-doc) weakremover(ruby2.2-rubygem-moneta-doc-0_7) weakremover(ruby2.2-rubygem-moneta-testsuite) weakremover(ruby2.2-rubygem-moneta-testsuite-0_7) weakremover(ruby2.2-rubygem-msgpack) weakremover(ruby2.2-rubygem-msgpack-doc) weakremover(ruby2.2-rubygem-msgpack-testsuite) weakremover(ruby2.2-rubygem-multi_json) weakremover(ruby2.2-rubygem-multi_json-doc) weakremover(ruby2.2-rubygem-multipart-post) weakremover(ruby2.2-rubygem-multipart-post-doc) weakremover(ruby2.2-rubygem-multipart-post-testsuite) weakremover(ruby2.2-rubygem-mustache) weakremover(ruby2.2-rubygem-mustache-doc) weakremover(ruby2.2-rubygem-mustache-testsuite) weakremover(ruby2.2-rubygem-mysql2) weakremover(ruby2.2-rubygem-mysql2-doc) weakremover(ruby2.2-rubygem-mysql2-testsuite) weakremover(ruby2.2-rubygem-net-scp) weakremover(ruby2.2-rubygem-net-scp-1_1) weakremover(ruby2.2-rubygem-net-scp-doc) weakremover(ruby2.2-rubygem-net-scp-doc-1_1) weakremover(ruby2.2-rubygem-net-scp-testsuite) weakremover(ruby2.2-rubygem-net-scp-testsuite-1_1) weakremover(ruby2.2-rubygem-net-sftp) weakremover(ruby2.2-rubygem-net-sftp-doc) weakremover(ruby2.2-rubygem-net-sftp-testsuite) weakremover(ruby2.2-rubygem-net-ssh) weakremover(ruby2.2-rubygem-net-ssh-doc) weakremover(ruby2.2-rubygem-net-ssh-gateway) weakremover(ruby2.2-rubygem-net-ssh-gateway-doc) weakremover(ruby2.2-rubygem-net-ssh-gateway-testsuite) weakremover(ruby2.2-rubygem-net-ssh-multi) weakremover(ruby2.2-rubygem-net-ssh-multi-1_1) weakremover(ruby2.2-rubygem-net-ssh-multi-doc) weakremover(ruby2.2-rubygem-net-ssh-multi-doc-1_1) weakremover(ruby2.2-rubygem-net-ssh-multi-testsuite) weakremover(ruby2.2-rubygem-net-ssh-multi-testsuite-1_1) weakremover(ruby2.2-rubygem-net-ssh-testsuite) weakremover(ruby2.2-rubygem-netrc) weakremover(ruby2.2-rubygem-netrc-doc) weakremover(ruby2.2-rubygem-netrc-testsuite) weakremover(ruby2.2-rubygem-nio4r) weakremover(ruby2.2-rubygem-nio4r-doc) weakremover(ruby2.2-rubygem-nio4r-testsuite) weakremover(ruby2.2-rubygem-nokogiri) weakremover(ruby2.2-rubygem-nokogiri-doc) weakremover(ruby2.2-rubygem-nokogiri-testsuite) weakremover(ruby2.2-rubygem-open4) weakremover(ruby2.2-rubygem-open4-doc) weakremover(ruby2.2-rubygem-open4-testsuite) weakremover(ruby2.2-rubygem-owncloud-admin) weakremover(ruby2.2-rubygem-owncloud-admin-doc) weakremover(ruby2.2-rubygem-packaging_rake_tasks) weakremover(ruby2.2-rubygem-packaging_rake_tasks-doc) weakremover(ruby2.2-rubygem-paint) weakremover(ruby2.2-rubygem-paint-doc) weakremover(ruby2.2-rubygem-path_expander) weakremover(ruby2.2-rubygem-path_expander-doc) weakremover(ruby2.2-rubygem-path_expander-testsuite) weakremover(ruby2.2-rubygem-pg) weakremover(ruby2.2-rubygem-pg-doc) weakremover(ruby2.2-rubygem-pg-testsuite) weakremover(ruby2.2-rubygem-pkg-config) weakremover(ruby2.2-rubygem-pkg-config-doc) weakremover(ruby2.2-rubygem-pkg-config-testsuite) weakremover(ruby2.2-rubygem-po_to_json) weakremover(ruby2.2-rubygem-po_to_json-doc) weakremover(ruby2.2-rubygem-po_to_json-testsuite) weakremover(ruby2.2-rubygem-polyglot) weakremover(ruby2.2-rubygem-polyglot-doc) weakremover(ruby2.2-rubygem-power_assert) weakremover(ruby2.2-rubygem-power_assert-doc) weakremover(ruby2.2-rubygem-power_assert-testsuite) weakremover(ruby2.2-rubygem-pry) weakremover(ruby2.2-rubygem-pry-doc) weakremover(ruby2.2-rubygem-pry-doc-doc) weakremover(ruby2.2-rubygem-pry-doc-testsuite) weakremover(ruby2.2-rubygem-puma) weakremover(ruby2.2-rubygem-puma-doc) weakremover(ruby2.2-rubygem-puma_worker_killer) weakremover(ruby2.2-rubygem-puma_worker_killer-doc) weakremover(ruby2.2-rubygem-puma_worker_killer-testsuite) weakremover(ruby2.2-rubygem-puppet) weakremover(ruby2.2-rubygem-puppet-doc) weakremover(ruby2.2-rubygem-puppet-lint) weakremover(ruby2.2-rubygem-puppet-lint-doc) weakremover(ruby2.2-rubygem-puppet-lint-testsuite) weakremover(ruby2.2-rubygem-puppet-syntax) weakremover(ruby2.2-rubygem-puppet-syntax-doc) weakremover(ruby2.2-rubygem-puppet-syntax-testsuite) weakremover(ruby2.2-rubygem-puppet-testsuite) weakremover(ruby2.2-rubygem-puppet_forge) weakremover(ruby2.2-rubygem-puppet_forge-doc) weakremover(ruby2.2-rubygem-puppet_forge-testsuite) weakremover(ruby2.2-rubygem-quiet_assets) weakremover(ruby2.2-rubygem-quiet_assets-doc) weakremover(ruby2.2-rubygem-quiet_assets-testsuite) weakremover(ruby2.2-rubygem-quixoten-puppetdb-terminus) weakremover(ruby2.2-rubygem-quixoten-puppetdb-terminus-doc) weakremover(ruby2.2-rubygem-r10k) weakremover(ruby2.2-rubygem-r10k-doc) weakremover(ruby2.2-rubygem-r10k-testsuite) weakremover(ruby2.2-rubygem-ra10ke) weakremover(ruby2.2-rubygem-ra10ke-doc) weakremover(ruby2.2-rubygem-rack) weakremover(ruby2.2-rubygem-rack-1_3) weakremover(ruby2.2-rubygem-rack-1_4) weakremover(ruby2.2-rubygem-rack-1_6) weakremover(ruby2.2-rubygem-rack-cache-1_2) weakremover(ruby2.2-rubygem-rack-cache-doc-1_2) weakremover(ruby2.2-rubygem-rack-cache-testsuite-1_2) weakremover(ruby2.2-rubygem-rack-doc) weakremover(ruby2.2-rubygem-rack-doc-1_3) weakremover(ruby2.2-rubygem-rack-doc-1_4) weakremover(ruby2.2-rubygem-rack-doc-1_6) weakremover(ruby2.2-rubygem-rack-protection) weakremover(ruby2.2-rubygem-rack-protection-doc) weakremover(ruby2.2-rubygem-rack-protection-testsuite) weakremover(ruby2.2-rubygem-rack-ssl-1_3) weakremover(ruby2.2-rubygem-rack-ssl-doc-1_3) weakremover(ruby2.2-rubygem-rack-test-0_6) weakremover(ruby2.2-rubygem-rack-test-doc-0_6) weakremover(ruby2.2-rubygem-rack-test-testsuite-0_6) weakremover(ruby2.2-rubygem-rack-testsuite) weakremover(ruby2.2-rubygem-rack-testsuite-1_3) weakremover(ruby2.2-rubygem-rack-testsuite-1_4) weakremover(ruby2.2-rubygem-rack-testsuite-1_6) weakremover(ruby2.2-rubygem-rails-4_2) weakremover(ruby2.2-rubygem-rails-deprecated_sanitizer) weakremover(ruby2.2-rubygem-rails-deprecated_sanitizer-doc) weakremover(ruby2.2-rubygem-rails-deprecated_sanitizer-testsuite) weakremover(ruby2.2-rubygem-rails-doc-4_2) weakremover(ruby2.2-rubygem-rails-dom-testing) weakremover(ruby2.2-rubygem-rails-dom-testing-doc) weakremover(ruby2.2-rubygem-rails-dom-testing-testsuite) weakremover(ruby2.2-rubygem-rails-html-sanitizer) weakremover(ruby2.2-rubygem-rails-html-sanitizer-doc) weakremover(ruby2.2-rubygem-rails-html-sanitizer-testsuite) weakremover(ruby2.2-rubygem-rails-i18n) weakremover(ruby2.2-rubygem-rails-i18n-doc) weakremover(ruby2.2-rubygem-railties-4_2) weakremover(ruby2.2-rubygem-railties-doc-4_2) weakremover(ruby2.2-rubygem-raindrops) weakremover(ruby2.2-rubygem-raindrops-doc) weakremover(ruby2.2-rubygem-raindrops-testsuite) weakremover(ruby2.2-rubygem-rake) weakremover(ruby2.2-rubygem-rake-compiler) weakremover(ruby2.2-rubygem-rake-compiler-doc) weakremover(ruby2.2-rubygem-rake-compiler-testsuite) weakremover(ruby2.2-rubygem-rake-doc) weakremover(ruby2.2-rubygem-rake-testsuite) weakremover(ruby2.2-rubygem-rb-fsevent) weakremover(ruby2.2-rubygem-rb-fsevent-doc) weakremover(ruby2.2-rubygem-rb-fsevent-testsuite) weakremover(ruby2.2-rubygem-rb-inotify) weakremover(ruby2.2-rubygem-rb-inotify-doc) weakremover(ruby2.2-rubygem-rb-kqueue) weakremover(ruby2.2-rubygem-rb-kqueue-doc) weakremover(ruby2.2-rubygem-rdoc-4) weakremover(ruby2.2-rubygem-rdoc-doc-4) weakremover(ruby2.2-rubygem-rdoc-testsuite-4) weakremover(ruby2.2-rubygem-responders) weakremover(ruby2.2-rubygem-responders-doc) weakremover(ruby2.2-rubygem-rest-client) weakremover(ruby2.2-rubygem-rest-client-doc) weakremover(ruby2.2-rubygem-rest-client-testsuite) weakremover(ruby2.2-rubygem-restility) weakremover(ruby2.2-rubygem-restility-doc) weakremover(ruby2.2-rubygem-restility-testsuite) weakremover(ruby2.2-rubygem-rgen) weakremover(ruby2.2-rubygem-rgen-doc) weakremover(ruby2.2-rubygem-rgen-testsuite) weakremover(ruby2.2-rubygem-rhc) weakremover(ruby2.2-rubygem-rhc-doc) weakremover(ruby2.2-rubygem-rhc-testsuite) weakremover(ruby2.2-rubygem-rouge) weakremover(ruby2.2-rubygem-rouge-doc) weakremover(ruby2.2-rubygem-rpm) weakremover(ruby2.2-rubygem-rpm-doc) weakremover(ruby2.2-rubygem-rpm-testsuite) weakremover(ruby2.2-rubygem-rspec) weakremover(ruby2.2-rubygem-rspec-core) weakremover(ruby2.2-rubygem-rspec-core-doc) weakremover(ruby2.2-rubygem-rspec-doc) weakremover(ruby2.2-rubygem-rspec-expectations) weakremover(ruby2.2-rubygem-rspec-expectations-doc) weakremover(ruby2.2-rubygem-rspec-mocks) weakremover(ruby2.2-rubygem-rspec-mocks-doc) weakremover(ruby2.2-rubygem-rspec-puppet) weakremover(ruby2.2-rubygem-rspec-puppet-doc) weakremover(ruby2.2-rubygem-rspec-support) weakremover(ruby2.2-rubygem-rspec-support-doc) weakremover(ruby2.2-rubygem-ruby-augeas) weakremover(ruby2.2-rubygem-ruby-augeas-doc) weakremover(ruby2.2-rubygem-ruby-libvirt) weakremover(ruby2.2-rubygem-ruby-libvirt-doc) weakremover(ruby2.2-rubygem-ruby-shadow) weakremover(ruby2.2-rubygem-ruby-shadow-doc) weakremover(ruby2.2-rubygem-ruby_dep) weakremover(ruby2.2-rubygem-ruby_dep-doc) weakremover(ruby2.2-rubygem-ruby_parser) weakremover(ruby2.2-rubygem-ruby_parser-doc) weakremover(ruby2.2-rubygem-ruby_parser-testsuite) weakremover(ruby2.2-rubygem-rubyforge) weakremover(ruby2.2-rubygem-rubyforge-doc) weakremover(ruby2.2-rubygem-rubyforge-testsuite) weakremover(ruby2.2-rubygem-rubyzip) weakremover(ruby2.2-rubygem-rubyzip-doc) weakremover(ruby2.2-rubygem-rubyzip-testsuite) weakremover(ruby2.2-rubygem-safe_yaml) weakremover(ruby2.2-rubygem-safe_yaml-doc) weakremover(ruby2.2-rubygem-safe_yaml-testsuite) weakremover(ruby2.2-rubygem-sass) weakremover(ruby2.2-rubygem-sass-doc) weakremover(ruby2.2-rubygem-sass-rails) weakremover(ruby2.2-rubygem-sass-rails-doc) weakremover(ruby2.2-rubygem-sass-testsuite) weakremover(ruby2.2-rubygem-sdoc) weakremover(ruby2.2-rubygem-sdoc-doc) weakremover(ruby2.2-rubygem-sdoc-testsuite) weakremover(ruby2.2-rubygem-semantic_puppet) weakremover(ruby2.2-rubygem-semantic_puppet-doc) weakremover(ruby2.2-rubygem-semantic_puppet-testsuite) weakremover(ruby2.2-rubygem-serverengine) weakremover(ruby2.2-rubygem-serverengine-doc) weakremover(ruby2.2-rubygem-serverengine-testsuite) weakremover(ruby2.2-rubygem-sexp_processor) weakremover(ruby2.2-rubygem-sexp_processor-doc) weakremover(ruby2.2-rubygem-sexp_processor-testsuite) weakremover(ruby2.2-rubygem-sigdump) weakremover(ruby2.2-rubygem-sigdump-doc) weakremover(ruby2.2-rubygem-simple_oauth) weakremover(ruby2.2-rubygem-simple_oauth-doc) weakremover(ruby2.2-rubygem-simplecov) weakremover(ruby2.2-rubygem-simplecov-doc) weakremover(ruby2.2-rubygem-simplecov-html) weakremover(ruby2.2-rubygem-simplecov-html-doc) weakremover(ruby2.2-rubygem-simplecov-html-testsuite) weakremover(ruby2.2-rubygem-simplecov-testsuite) weakremover(ruby2.2-rubygem-sinatra) weakremover(ruby2.2-rubygem-sinatra-doc) weakremover(ruby2.2-rubygem-sinatra-testsuite) weakremover(ruby2.2-rubygem-slop) weakremover(ruby2.2-rubygem-slop-3) weakremover(ruby2.2-rubygem-slop-3_3) weakremover(ruby2.2-rubygem-slop-doc) weakremover(ruby2.2-rubygem-slop-doc-3) weakremover(ruby2.2-rubygem-slop-doc-3_3) weakremover(ruby2.2-rubygem-slop-testsuite) weakremover(ruby2.2-rubygem-slop-testsuite-3) weakremover(ruby2.2-rubygem-slop-testsuite-3_3) weakremover(ruby2.2-rubygem-spring) weakremover(ruby2.2-rubygem-spring-doc) weakremover(ruby2.2-rubygem-spring-watcher-listen) weakremover(ruby2.2-rubygem-spring-watcher-listen-doc) weakremover(ruby2.2-rubygem-spring-watcher-listen-testsuite) weakremover(ruby2.2-rubygem-sprockets) weakremover(ruby2.2-rubygem-sprockets-2_1) weakremover(ruby2.2-rubygem-sprockets-2_2) weakremover(ruby2.2-rubygem-sprockets-doc) weakremover(ruby2.2-rubygem-sprockets-doc-2_1) weakremover(ruby2.2-rubygem-sprockets-doc-2_2) weakremover(ruby2.2-rubygem-sprockets-helpers) weakremover(ruby2.2-rubygem-sprockets-helpers-doc) weakremover(ruby2.2-rubygem-sprockets-helpers-testsuite) weakremover(ruby2.2-rubygem-sprockets-rails) weakremover(ruby2.2-rubygem-sprockets-rails-doc) weakremover(ruby2.2-rubygem-sqlite3) weakremover(ruby2.2-rubygem-sqlite3-doc) weakremover(ruby2.2-rubygem-sqlite3-testsuite) weakremover(ruby2.2-rubygem-sshkit) weakremover(ruby2.2-rubygem-sshkit-doc) weakremover(ruby2.2-rubygem-sshkit-testsuite) weakremover(ruby2.2-rubygem-stackdeck) weakremover(ruby2.2-rubygem-stackdeck-doc) weakremover(ruby2.2-rubygem-stackdeck-testsuite) weakremover(ruby2.2-rubygem-stomp) weakremover(ruby2.2-rubygem-stomp-doc) weakremover(ruby2.2-rubygem-stomp-testsuite) weakremover(ruby2.2-rubygem-strptime) weakremover(ruby2.2-rubygem-strptime-doc) weakremover(ruby2.2-rubygem-studio_api) weakremover(ruby2.2-rubygem-studio_api-doc) weakremover(ruby2.2-rubygem-studio_api-testsuite) weakremover(ruby2.2-rubygem-systemu) weakremover(ruby2.2-rubygem-systemu-doc) weakremover(ruby2.2-rubygem-systemu-testsuite) weakremover(ruby2.2-rubygem-taskjuggler) weakremover(ruby2.2-rubygem-taskjuggler-doc) weakremover(ruby2.2-rubygem-taskjuggler-testsuite) weakremover(ruby2.2-rubygem-term-ansicolor) weakremover(ruby2.2-rubygem-term-ansicolor-doc) weakremover(ruby2.2-rubygem-test-unit) weakremover(ruby2.2-rubygem-test-unit-doc) weakremover(ruby2.2-rubygem-test-unit-testsuite) weakremover(ruby2.2-rubygem-text) weakremover(ruby2.2-rubygem-text-doc) weakremover(ruby2.2-rubygem-text-hyphen) weakremover(ruby2.2-rubygem-text-hyphen-doc) weakremover(ruby2.2-rubygem-text-hyphen-testsuite) weakremover(ruby2.2-rubygem-text-testsuite) weakremover(ruby2.2-rubygem-thor) weakremover(ruby2.2-rubygem-thor-doc) weakremover(ruby2.2-rubygem-thor-testsuite) weakremover(ruby2.2-rubygem-thread_safe) weakremover(ruby2.2-rubygem-thread_safe-doc) weakremover(ruby2.2-rubygem-thread_safe-testsuite) weakremover(ruby2.2-rubygem-tilt-1_1) weakremover(ruby2.2-rubygem-tilt-1_4) weakremover(ruby2.2-rubygem-tilt-doc-1_1) weakremover(ruby2.2-rubygem-tilt-doc-1_4) weakremover(ruby2.2-rubygem-tilt-testsuite-1_1) weakremover(ruby2.2-rubygem-tilt-testsuite-1_4) weakremover(ruby2.2-rubygem-timers) weakremover(ruby2.2-rubygem-timers-doc) weakremover(ruby2.2-rubygem-timers-testsuite) weakremover(ruby2.2-rubygem-tins) weakremover(ruby2.2-rubygem-tins-doc) weakremover(ruby2.2-rubygem-treetop) weakremover(ruby2.2-rubygem-treetop-1_4) weakremover(ruby2.2-rubygem-treetop-doc) weakremover(ruby2.2-rubygem-treetop-doc-1_4) weakremover(ruby2.2-rubygem-treetop-testsuite) weakremover(ruby2.2-rubygem-treetop-testsuite-1_4) weakremover(ruby2.2-rubygem-trollop) weakremover(ruby2.2-rubygem-trollop-doc) weakremover(ruby2.2-rubygem-trollop-testsuite) weakremover(ruby2.2-rubygem-turbolinks) weakremover(ruby2.2-rubygem-turbolinks-doc) weakremover(ruby2.2-rubygem-turbolinks-source) weakremover(ruby2.2-rubygem-turbolinks-source-doc) weakremover(ruby2.2-rubygem-turbolinks-testsuite) weakremover(ruby2.2-rubygem-tzinfo) weakremover(ruby2.2-rubygem-tzinfo-0) weakremover(ruby2.2-rubygem-tzinfo-data) weakremover(ruby2.2-rubygem-tzinfo-data-doc) weakremover(ruby2.2-rubygem-tzinfo-doc) weakremover(ruby2.2-rubygem-tzinfo-doc-0) weakremover(ruby2.2-rubygem-tzinfo-testsuite) weakremover(ruby2.2-rubygem-tzinfo-testsuite-0) weakremover(ruby2.2-rubygem-uglifier) weakremover(ruby2.2-rubygem-uglifier-doc) weakremover(ruby2.2-rubygem-uglifier-testsuite) weakremover(ruby2.2-rubygem-unicorn) weakremover(ruby2.2-rubygem-unicorn-doc) weakremover(ruby2.2-rubygem-unicorn-testsuite) weakremover(ruby2.2-rubygem-virtus) weakremover(ruby2.2-rubygem-virtus-doc) weakremover(ruby2.2-rubygem-virtus-testsuite) weakremover(ruby2.2-rubygem-web-console) weakremover(ruby2.2-rubygem-web-console-2) weakremover(ruby2.2-rubygem-web-console-doc) weakremover(ruby2.2-rubygem-web-console-doc-2) weakremover(ruby2.2-rubygem-websocket) weakremover(ruby2.2-rubygem-websocket-doc) weakremover(ruby2.2-rubygem-websocket-driver) weakremover(ruby2.2-rubygem-websocket-driver-doc) weakremover(ruby2.2-rubygem-websocket-extensions) weakremover(ruby2.2-rubygem-websocket-extensions-doc) weakremover(ruby2.2-rubygem-websocket-testsuite) weakremover(ruby2.2-rubygem-xml-simple) weakremover(ruby2.2-rubygem-xml-simple-doc) weakremover(ruby2.2-rubygem-xmlhash) weakremover(ruby2.2-rubygem-xmlhash-doc) weakremover(ruby2.2-rubygem-xmlhash-testsuite) weakremover(ruby2.2-rubygem-yajl-ruby) weakremover(ruby2.2-rubygem-yajl-ruby-doc) weakremover(ruby2.2-rubygem-yajl-ruby-testsuite) weakremover(ruby2.2-rubygem-yard) weakremover(ruby2.2-rubygem-yard-doc) weakremover(ruby2.2-rubygem-yard-testsuite) weakremover(ruby2.2-rubygem-yast-rake) weakremover(ruby2.2-rubygem-yast-rake-doc) weakremover(ruby2.2-stdlib) weakremover(ruby2.2-tk) weakremover(ruby2.3) weakremover(ruby2.3-devel) weakremover(ruby2.3-devel-extra) weakremover(ruby2.3-doc) weakremover(ruby2.3-doc-ri) weakremover(ruby2.3-rubygem-RedCloth) weakremover(ruby2.3-rubygem-RedCloth-doc) weakremover(ruby2.3-rubygem-RedCloth-testsuite) weakremover(ruby2.3-rubygem-abstract) weakremover(ruby2.3-rubygem-abstract-doc) weakremover(ruby2.3-rubygem-abstract-testsuite) weakremover(ruby2.3-rubygem-abstract_method) weakremover(ruby2.3-rubygem-abstract_method-doc) weakremover(ruby2.3-rubygem-actionmailer-4_2) weakremover(ruby2.3-rubygem-actionmailer-doc-4_2) weakremover(ruby2.3-rubygem-actionpack-4_2) weakremover(ruby2.3-rubygem-actionpack-doc-4_2) weakremover(ruby2.3-rubygem-actionview-4_2) weakremover(ruby2.3-rubygem-actionview-doc-4_2) weakremover(ruby2.3-rubygem-activejob-4_2) weakremover(ruby2.3-rubygem-activejob-doc-4_2) weakremover(ruby2.3-rubygem-activemodel-4_2) weakremover(ruby2.3-rubygem-activemodel-doc-4_2) weakremover(ruby2.3-rubygem-activerecord-4_2) weakremover(ruby2.3-rubygem-activerecord-deprecated_finders) weakremover(ruby2.3-rubygem-activerecord-deprecated_finders-doc) weakremover(ruby2.3-rubygem-activerecord-doc-4_2) weakremover(ruby2.3-rubygem-activesupport-4_2) weakremover(ruby2.3-rubygem-activesupport-doc-4_2) weakremover(ruby2.3-rubygem-addressable) weakremover(ruby2.3-rubygem-addressable-doc) weakremover(ruby2.3-rubygem-addressable-testsuite) weakremover(ruby2.3-rubygem-airbrussh) weakremover(ruby2.3-rubygem-airbrussh-doc) weakremover(ruby2.3-rubygem-amqp) weakremover(ruby2.3-rubygem-amqp-doc) weakremover(ruby2.3-rubygem-amqp-testsuite) weakremover(ruby2.3-rubygem-archive-tar-minitar) weakremover(ruby2.3-rubygem-archive-tar-minitar-doc) weakremover(ruby2.3-rubygem-arel) weakremover(ruby2.3-rubygem-arel-3_0) weakremover(ruby2.3-rubygem-arel-7) weakremover(ruby2.3-rubygem-arel-doc) weakremover(ruby2.3-rubygem-arel-doc-3_0) weakremover(ruby2.3-rubygem-arel-doc-7) weakremover(ruby2.3-rubygem-arel-testsuite-3_0) weakremover(ruby2.3-rubygem-atomic) weakremover(ruby2.3-rubygem-atomic-doc) weakremover(ruby2.3-rubygem-atomic-testsuite) weakremover(ruby2.3-rubygem-augeas) weakremover(ruby2.3-rubygem-augeas-doc) weakremover(ruby2.3-rubygem-autoprefixer-rails) weakremover(ruby2.3-rubygem-autoprefixer-rails-doc) weakremover(ruby2.3-rubygem-autoprefixer-rails-testsuite) weakremover(ruby2.3-rubygem-axiom-types) weakremover(ruby2.3-rubygem-axiom-types-doc) weakremover(ruby2.3-rubygem-axiom-types-testsuite) weakremover(ruby2.3-rubygem-bcrypt) weakremover(ruby2.3-rubygem-bcrypt-doc) weakremover(ruby2.3-rubygem-bcrypt-ruby) weakremover(ruby2.3-rubygem-bcrypt-ruby-doc) weakremover(ruby2.3-rubygem-bcrypt-testsuite) weakremover(ruby2.3-rubygem-binding_of_caller) weakremover(ruby2.3-rubygem-binding_of_caller-doc) weakremover(ruby2.3-rubygem-binding_of_caller-testsuite) weakremover(ruby2.3-rubygem-bootstrap-sass) weakremover(ruby2.3-rubygem-bootstrap-sass-doc) weakremover(ruby2.3-rubygem-bootstrap-sass-testsuite) weakremover(ruby2.3-rubygem-buff-ignore) weakremover(ruby2.3-rubygem-buff-ignore-doc) weakremover(ruby2.3-rubygem-buff-ignore-testsuite) weakremover(ruby2.3-rubygem-builder) weakremover(ruby2.3-rubygem-builder-doc) weakremover(ruby2.3-rubygem-builder-testsuite) weakremover(ruby2.3-rubygem-bundler) weakremover(ruby2.3-rubygem-bundler-audit) weakremover(ruby2.3-rubygem-bundler-audit-doc) weakremover(ruby2.3-rubygem-bundler-audit-testsuite) weakremover(ruby2.3-rubygem-bundler-doc) weakremover(ruby2.3-rubygem-bunny) weakremover(ruby2.3-rubygem-bunny-doc) weakremover(ruby2.3-rubygem-bunny-testsuite) weakremover(ruby2.3-rubygem-byebug) weakremover(ruby2.3-rubygem-byebug-doc) weakremover(ruby2.3-rubygem-capistrano) weakremover(ruby2.3-rubygem-capistrano-doc) weakremover(ruby2.3-rubygem-capistrano-harrow) weakremover(ruby2.3-rubygem-capistrano-harrow-doc) weakremover(ruby2.3-rubygem-capistrano-stats) weakremover(ruby2.3-rubygem-capistrano-stats-doc) weakremover(ruby2.3-rubygem-capistrano-testsuite) weakremover(ruby2.3-rubygem-celluloid) weakremover(ruby2.3-rubygem-celluloid-doc) weakremover(ruby2.3-rubygem-celluloid-testsuite) weakremover(ruby2.3-rubygem-cfa) weakremover(ruby2.3-rubygem-cfa-doc) weakremover(ruby2.3-rubygem-cfa_grub2) weakremover(ruby2.3-rubygem-cfa_grub2-doc) weakremover(ruby2.3-rubygem-cheetah) weakremover(ruby2.3-rubygem-cheetah-doc) weakremover(ruby2.3-rubygem-childprocess) weakremover(ruby2.3-rubygem-childprocess-doc) weakremover(ruby2.3-rubygem-childprocess-testsuite) weakremover(ruby2.3-rubygem-ci_reporter) weakremover(ruby2.3-rubygem-ci_reporter-doc) weakremover(ruby2.3-rubygem-ci_reporter-testsuite) weakremover(ruby2.3-rubygem-cleanroom) weakremover(ruby2.3-rubygem-cleanroom-doc) weakremover(ruby2.3-rubygem-cleanroom-testsuite) weakremover(ruby2.3-rubygem-coderay) weakremover(ruby2.3-rubygem-coderay-doc) weakremover(ruby2.3-rubygem-coderay-testsuite) weakremover(ruby2.3-rubygem-coercible) weakremover(ruby2.3-rubygem-coercible-doc) weakremover(ruby2.3-rubygem-coercible-testsuite) weakremover(ruby2.3-rubygem-coffee-rails) weakremover(ruby2.3-rubygem-coffee-rails-doc) weakremover(ruby2.3-rubygem-coffee-rails-testsuite) weakremover(ruby2.3-rubygem-coffee-script) weakremover(ruby2.3-rubygem-coffee-script-doc) weakremover(ruby2.3-rubygem-coffee-script-source) weakremover(ruby2.3-rubygem-coffee-script-source-doc) weakremover(ruby2.3-rubygem-colorator) weakremover(ruby2.3-rubygem-colorator-doc) weakremover(ruby2.3-rubygem-colorize) weakremover(ruby2.3-rubygem-colorize-doc) weakremover(ruby2.3-rubygem-colorize-testsuite) weakremover(ruby2.3-rubygem-columnize) weakremover(ruby2.3-rubygem-columnize-doc) weakremover(ruby2.3-rubygem-columnize-testsuite) weakremover(ruby2.3-rubygem-commander) weakremover(ruby2.3-rubygem-commander-doc) weakremover(ruby2.3-rubygem-commander-testsuite) weakremover(ruby2.3-rubygem-concurrent-ruby) weakremover(ruby2.3-rubygem-concurrent-ruby-doc) weakremover(ruby2.3-rubygem-cool.io) weakremover(ruby2.3-rubygem-cool.io-doc) weakremover(ruby2.3-rubygem-cool.io-testsuite) weakremover(ruby2.3-rubygem-cri) weakremover(ruby2.3-rubygem-cri-2_6) weakremover(ruby2.3-rubygem-cri-doc) weakremover(ruby2.3-rubygem-cri-doc-2_6) weakremover(ruby2.3-rubygem-cri-testsuite) weakremover(ruby2.3-rubygem-cri-testsuite-2_6) weakremover(ruby2.3-rubygem-cssmin) weakremover(ruby2.3-rubygem-cssmin-doc) weakremover(ruby2.3-rubygem-daemons) weakremover(ruby2.3-rubygem-daemons-doc) weakremover(ruby2.3-rubygem-debug_inspector) weakremover(ruby2.3-rubygem-debug_inspector-doc) weakremover(ruby2.3-rubygem-debugger-linecache) weakremover(ruby2.3-rubygem-debugger-linecache-doc) weakremover(ruby2.3-rubygem-debugger-linecache-testsuite) weakremover(ruby2.3-rubygem-deep_merge) weakremover(ruby2.3-rubygem-deep_merge-doc) weakremover(ruby2.3-rubygem-deep_merge-testsuite) weakremover(ruby2.3-rubygem-delayed_job) weakremover(ruby2.3-rubygem-delayed_job-doc) weakremover(ruby2.3-rubygem-delayed_job-testsuite) weakremover(ruby2.3-rubygem-descendants_tracker) weakremover(ruby2.3-rubygem-descendants_tracker-doc) weakremover(ruby2.3-rubygem-descendants_tracker-testsuite) weakremover(ruby2.3-rubygem-devise) weakremover(ruby2.3-rubygem-devise-doc) weakremover(ruby2.3-rubygem-devise-i18n) weakremover(ruby2.3-rubygem-devise-i18n-doc) weakremover(ruby2.3-rubygem-devise-i18n-testsuite) weakremover(ruby2.3-rubygem-devise-testsuite) weakremover(ruby2.3-rubygem-diff-lcs) weakremover(ruby2.3-rubygem-diff-lcs-doc) weakremover(ruby2.3-rubygem-diff-lcs-testsuite) weakremover(ruby2.3-rubygem-diffy) weakremover(ruby2.3-rubygem-diffy-doc) weakremover(ruby2.3-rubygem-diffy-testsuite) weakremover(ruby2.3-rubygem-docile) weakremover(ruby2.3-rubygem-docile-doc) weakremover(ruby2.3-rubygem-docile-testsuite) weakremover(ruby2.3-rubygem-docker-api) weakremover(ruby2.3-rubygem-docker-api-doc) weakremover(ruby2.3-rubygem-docker-api-testsuite) weakremover(ruby2.3-rubygem-equalizer) weakremover(ruby2.3-rubygem-equalizer-doc) weakremover(ruby2.3-rubygem-equalizer-testsuite) weakremover(ruby2.3-rubygem-erubis) weakremover(ruby2.3-rubygem-erubis-2_6) weakremover(ruby2.3-rubygem-erubis-doc) weakremover(ruby2.3-rubygem-erubis-doc-2_6) weakremover(ruby2.3-rubygem-erubis-testsuite) weakremover(ruby2.3-rubygem-erubis-testsuite-2_6) weakremover(ruby2.3-rubygem-eventmachine) weakremover(ruby2.3-rubygem-eventmachine-doc) weakremover(ruby2.3-rubygem-exception_notification) weakremover(ruby2.3-rubygem-exception_notification-doc) weakremover(ruby2.3-rubygem-exception_notification-testsuite) weakremover(ruby2.3-rubygem-excon) weakremover(ruby2.3-rubygem-excon-doc) weakremover(ruby2.3-rubygem-excon-testsuite) weakremover(ruby2.3-rubygem-execjs) weakremover(ruby2.3-rubygem-execjs-doc) weakremover(ruby2.3-rubygem-extlib) weakremover(ruby2.3-rubygem-extlib-doc) weakremover(ruby2.3-rubygem-extlib-testsuite) weakremover(ruby2.3-rubygem-facter) weakremover(ruby2.3-rubygem-facter-doc) weakremover(ruby2.3-rubygem-facter-testsuite) weakremover(ruby2.3-rubygem-factory_girl) weakremover(ruby2.3-rubygem-factory_girl-doc) weakremover(ruby2.3-rubygem-factory_girl-testsuite) weakremover(ruby2.3-rubygem-factory_girl_rails) weakremover(ruby2.3-rubygem-factory_girl_rails-doc) weakremover(ruby2.3-rubygem-faraday) weakremover(ruby2.3-rubygem-faraday-doc) weakremover(ruby2.3-rubygem-faraday-testsuite) weakremover(ruby2.3-rubygem-faraday_middleware) weakremover(ruby2.3-rubygem-faraday_middleware-0_9) weakremover(ruby2.3-rubygem-faraday_middleware-doc) weakremover(ruby2.3-rubygem-faraday_middleware-doc-0_9) weakremover(ruby2.3-rubygem-faraday_middleware-multi_json) weakremover(ruby2.3-rubygem-faraday_middleware-multi_json-doc) weakremover(ruby2.3-rubygem-faraday_middleware-multi_json-testsuite) weakremover(ruby2.3-rubygem-fast_gettext) weakremover(ruby2.3-rubygem-fast_gettext-1_1) weakremover(ruby2.3-rubygem-fast_gettext-1_2) weakremover(ruby2.3-rubygem-fast_gettext-doc) weakremover(ruby2.3-rubygem-fast_gettext-doc-1_1) weakremover(ruby2.3-rubygem-fast_gettext-doc-1_2) weakremover(ruby2.3-rubygem-fast_xs) weakremover(ruby2.3-rubygem-fast_xs-doc) weakremover(ruby2.3-rubygem-fast_xs-testsuite) weakremover(ruby2.3-rubygem-fastercsv) weakremover(ruby2.3-rubygem-fastercsv-doc) weakremover(ruby2.3-rubygem-fastercsv-testsuite) weakremover(ruby2.3-rubygem-ffi) weakremover(ruby2.3-rubygem-ffi-doc) weakremover(ruby2.3-rubygem-ffi-testsuite) weakremover(ruby2.3-rubygem-file-tail) weakremover(ruby2.3-rubygem-file-tail-doc) weakremover(ruby2.3-rubygem-flog) weakremover(ruby2.3-rubygem-flog-doc) weakremover(ruby2.3-rubygem-flog-testsuite) weakremover(ruby2.3-rubygem-fluentd) weakremover(ruby2.3-rubygem-fluentd-doc) weakremover(ruby2.3-rubygem-fluentd-testsuite) weakremover(ruby2.3-rubygem-gem2rpm) weakremover(ruby2.3-rubygem-gem2rpm-doc) weakremover(ruby2.3-rubygem-get_process_mem) weakremover(ruby2.3-rubygem-get_process_mem-doc) weakremover(ruby2.3-rubygem-get_process_mem-testsuite) weakremover(ruby2.3-rubygem-gettext) weakremover(ruby2.3-rubygem-gettext-doc) weakremover(ruby2.3-rubygem-gettext-setup) weakremover(ruby2.3-rubygem-gettext-setup-doc) weakremover(ruby2.3-rubygem-gettext-setup-testsuite) weakremover(ruby2.3-rubygem-gettext-testsuite) weakremover(ruby2.3-rubygem-gettext_i18n_rails) weakremover(ruby2.3-rubygem-gettext_i18n_rails-doc) weakremover(ruby2.3-rubygem-gettext_i18n_rails_js) weakremover(ruby2.3-rubygem-gettext_i18n_rails_js-doc) weakremover(ruby2.3-rubygem-gettext_i18n_rails_js-testsuite) weakremover(ruby2.3-rubygem-gli) weakremover(ruby2.3-rubygem-gli-doc) weakremover(ruby2.3-rubygem-gli-testsuite) weakremover(ruby2.3-rubygem-globalid) weakremover(ruby2.3-rubygem-globalid-doc) weakremover(ruby2.3-rubygem-gpgme) weakremover(ruby2.3-rubygem-gpgme-doc) weakremover(ruby2.3-rubygem-gpgme-testsuite) weakremover(ruby2.3-rubygem-haml) weakremover(ruby2.3-rubygem-haml-doc) weakremover(ruby2.3-rubygem-haml-rails) weakremover(ruby2.3-rubygem-haml-rails-doc) weakremover(ruby2.3-rubygem-haml-rails-testsuite) weakremover(ruby2.3-rubygem-haml-testsuite) weakremover(ruby2.3-rubygem-has_mobile_views) weakremover(ruby2.3-rubygem-has_mobile_views-doc) weakremover(ruby2.3-rubygem-has_mobile_views-testsuite) weakremover(ruby2.3-rubygem-hashdiff) weakremover(ruby2.3-rubygem-hashdiff-doc) weakremover(ruby2.3-rubygem-hashdiff-testsuite) weakremover(ruby2.3-rubygem-hashicorp-checkpoint) weakremover(ruby2.3-rubygem-hashicorp-checkpoint-doc) weakremover(ruby2.3-rubygem-hashicorp-checkpoint-testsuite) weakremover(ruby2.3-rubygem-hashie) weakremover(ruby2.3-rubygem-hashie-doc) weakremover(ruby2.3-rubygem-hashie-testsuite) weakremover(ruby2.3-rubygem-hiera) weakremover(ruby2.3-rubygem-hiera-doc) weakremover(ruby2.3-rubygem-hiera-eyaml) weakremover(ruby2.3-rubygem-hiera-eyaml-doc) weakremover(ruby2.3-rubygem-hiera-eyaml-gpg) weakremover(ruby2.3-rubygem-hiera-eyaml-gpg-doc) weakremover(ruby2.3-rubygem-hiera-testsuite) weakremover(ruby2.3-rubygem-highline) weakremover(ruby2.3-rubygem-highline-1_6) weakremover(ruby2.3-rubygem-highline-doc) weakremover(ruby2.3-rubygem-highline-doc-1_6) weakremover(ruby2.3-rubygem-highline-testsuite) weakremover(ruby2.3-rubygem-highline-testsuite-1_6) weakremover(ruby2.3-rubygem-hike) weakremover(ruby2.3-rubygem-hike-1_2) weakremover(ruby2.3-rubygem-hike-doc) weakremover(ruby2.3-rubygem-hike-doc-1_2) weakremover(ruby2.3-rubygem-hitimes) weakremover(ruby2.3-rubygem-hitimes-doc) weakremover(ruby2.3-rubygem-hitimes-testsuite) weakremover(ruby2.3-rubygem-hoe) weakremover(ruby2.3-rubygem-hoe-doc) weakremover(ruby2.3-rubygem-hoe-testsuite) weakremover(ruby2.3-rubygem-html2haml) weakremover(ruby2.3-rubygem-html2haml-doc) weakremover(ruby2.3-rubygem-html2haml-testsuite) weakremover(ruby2.3-rubygem-http_accept_language) weakremover(ruby2.3-rubygem-http_accept_language-doc) weakremover(ruby2.3-rubygem-http_accept_language-testsuite) weakremover(ruby2.3-rubygem-http_parser.rb) weakremover(ruby2.3-rubygem-http_parser.rb-doc) weakremover(ruby2.3-rubygem-http_parser.rb-testsuite) weakremover(ruby2.3-rubygem-httpclient) weakremover(ruby2.3-rubygem-httpclient-doc) weakremover(ruby2.3-rubygem-httpclient-testsuite) weakremover(ruby2.3-rubygem-hub) weakremover(ruby2.3-rubygem-hub-doc) weakremover(ruby2.3-rubygem-i18n) weakremover(ruby2.3-rubygem-i18n-doc) weakremover(ruby2.3-rubygem-i18n-testsuite) weakremover(ruby2.3-rubygem-ice_nine) weakremover(ruby2.3-rubygem-ice_nine-doc) weakremover(ruby2.3-rubygem-ice_nine-testsuite) weakremover(ruby2.3-rubygem-inifile) weakremover(ruby2.3-rubygem-inifile-doc) weakremover(ruby2.3-rubygem-inifile-testsuite) weakremover(ruby2.3-rubygem-ipaddress) weakremover(ruby2.3-rubygem-ipaddress-doc) weakremover(ruby2.3-rubygem-ipaddress-testsuite) weakremover(ruby2.3-rubygem-jbuilder) weakremover(ruby2.3-rubygem-jbuilder-doc) weakremover(ruby2.3-rubygem-jbuilder-testsuite) weakremover(ruby2.3-rubygem-jekyll) weakremover(ruby2.3-rubygem-jekyll-doc) weakremover(ruby2.3-rubygem-jekyll-sass-converter) weakremover(ruby2.3-rubygem-jekyll-sass-converter-doc) weakremover(ruby2.3-rubygem-jekyll-watch) weakremover(ruby2.3-rubygem-jekyll-watch-doc) weakremover(ruby2.3-rubygem-jmespath) weakremover(ruby2.3-rubygem-jmespath-doc) weakremover(ruby2.3-rubygem-journey-1_0) weakremover(ruby2.3-rubygem-journey-doc-1_0) weakremover(ruby2.3-rubygem-journey-testsuite-1_0) weakremover(ruby2.3-rubygem-jquery-rails) weakremover(ruby2.3-rubygem-jquery-rails-doc) weakremover(ruby2.3-rubygem-jquery-rails-testsuite) weakremover(ruby2.3-rubygem-jquery-ui-rails) weakremover(ruby2.3-rubygem-jquery-ui-rails-doc) weakremover(ruby2.3-rubygem-js-routes) weakremover(ruby2.3-rubygem-js-routes-doc) weakremover(ruby2.3-rubygem-js-routes-testsuite) weakremover(ruby2.3-rubygem-json) weakremover(ruby2.3-rubygem-json-doc) weakremover(ruby2.3-rubygem-json-schema) weakremover(ruby2.3-rubygem-json-schema-doc) weakremover(ruby2.3-rubygem-json-schema-testsuite) weakremover(ruby2.3-rubygem-json_pure) weakremover(ruby2.3-rubygem-json_pure-doc) weakremover(ruby2.3-rubygem-kgio) weakremover(ruby2.3-rubygem-kgio-doc) weakremover(ruby2.3-rubygem-kgio-testsuite) weakremover(ruby2.3-rubygem-kramdown) weakremover(ruby2.3-rubygem-kramdown-doc) weakremover(ruby2.3-rubygem-kramdown-testsuite) weakremover(ruby2.3-rubygem-launchy) weakremover(ruby2.3-rubygem-launchy-doc) weakremover(ruby2.3-rubygem-launchy-testsuite) weakremover(ruby2.3-rubygem-levenshtein) weakremover(ruby2.3-rubygem-levenshtein-doc) weakremover(ruby2.3-rubygem-levenshtein-testsuite) weakremover(ruby2.3-rubygem-librarian) weakremover(ruby2.3-rubygem-librarian-doc) weakremover(ruby2.3-rubygem-librarian-testsuite) weakremover(ruby2.3-rubygem-libyui-rake) weakremover(ruby2.3-rubygem-libyui-rake-doc) weakremover(ruby2.3-rubygem-liquid) weakremover(ruby2.3-rubygem-liquid-doc) weakremover(ruby2.3-rubygem-liquid-testsuite) weakremover(ruby2.3-rubygem-listen) weakremover(ruby2.3-rubygem-listen-doc) weakremover(ruby2.3-rubygem-locale) weakremover(ruby2.3-rubygem-locale-doc) weakremover(ruby2.3-rubygem-locale-testsuite) weakremover(ruby2.3-rubygem-log4r) weakremover(ruby2.3-rubygem-log4r-doc) weakremover(ruby2.3-rubygem-lolcat) weakremover(ruby2.3-rubygem-lolcat-doc) weakremover(ruby2.3-rubygem-loofah) weakremover(ruby2.3-rubygem-loofah-doc) weakremover(ruby2.3-rubygem-loofah-testsuite) weakremover(ruby2.3-rubygem-mail) weakremover(ruby2.3-rubygem-mail-2_5) weakremover(ruby2.3-rubygem-mail-doc) weakremover(ruby2.3-rubygem-mail-doc-2_5) weakremover(ruby2.3-rubygem-mcollective) weakremover(ruby2.3-rubygem-mcollective-doc) weakremover(ruby2.3-rubygem-mcollective-testsuite) weakremover(ruby2.3-rubygem-mercenary) weakremover(ruby2.3-rubygem-mercenary-doc) weakremover(ruby2.3-rubygem-mercenary-testsuite) weakremover(ruby2.3-rubygem-metaclass) weakremover(ruby2.3-rubygem-metaclass-doc) weakremover(ruby2.3-rubygem-metaclass-testsuite) weakremover(ruby2.3-rubygem-method_source) weakremover(ruby2.3-rubygem-method_source-doc) weakremover(ruby2.3-rubygem-method_source-testsuite) weakremover(ruby2.3-rubygem-mime-types) weakremover(ruby2.3-rubygem-mime-types-1) weakremover(ruby2.3-rubygem-mime-types-data) weakremover(ruby2.3-rubygem-mime-types-data-doc) weakremover(ruby2.3-rubygem-mime-types-doc) weakremover(ruby2.3-rubygem-mime-types-doc-1) weakremover(ruby2.3-rubygem-mime-types-testsuite) weakremover(ruby2.3-rubygem-mime-types-testsuite-1) weakremover(ruby2.3-rubygem-mimemagic) weakremover(ruby2.3-rubygem-mimemagic-doc) weakremover(ruby2.3-rubygem-mimemagic-testsuite) weakremover(ruby2.3-rubygem-mini_magick) weakremover(ruby2.3-rubygem-mini_magick-doc) weakremover(ruby2.3-rubygem-mini_portile) weakremover(ruby2.3-rubygem-mini_portile-doc) weakremover(ruby2.3-rubygem-mini_portile2) weakremover(ruby2.3-rubygem-mini_portile2-doc) weakremover(ruby2.3-rubygem-mini_portile2-testsuite) weakremover(ruby2.3-rubygem-minitar) weakremover(ruby2.3-rubygem-minitar-doc) weakremover(ruby2.3-rubygem-minitest) weakremover(ruby2.3-rubygem-minitest-doc) weakremover(ruby2.3-rubygem-minitest-testsuite) weakremover(ruby2.3-rubygem-mixlib-authentication) weakremover(ruby2.3-rubygem-mixlib-authentication-doc) weakremover(ruby2.3-rubygem-mixlib-authentication-testsuite) weakremover(ruby2.3-rubygem-mixlib-cli) weakremover(ruby2.3-rubygem-mixlib-cli-doc) weakremover(ruby2.3-rubygem-mixlib-cli-testsuite) weakremover(ruby2.3-rubygem-mixlib-config) weakremover(ruby2.3-rubygem-mixlib-config-doc) weakremover(ruby2.3-rubygem-mixlib-config-testsuite) weakremover(ruby2.3-rubygem-mixlib-log) weakremover(ruby2.3-rubygem-mixlib-log-doc) weakremover(ruby2.3-rubygem-mixlib-log-testsuite) weakremover(ruby2.3-rubygem-mixlib-shellout) weakremover(ruby2.3-rubygem-mixlib-shellout-doc) weakremover(ruby2.3-rubygem-mocha) weakremover(ruby2.3-rubygem-mocha-doc) weakremover(ruby2.3-rubygem-mocha-testsuite) weakremover(ruby2.3-rubygem-moneta) weakremover(ruby2.3-rubygem-moneta-0_7) weakremover(ruby2.3-rubygem-moneta-doc) weakremover(ruby2.3-rubygem-moneta-doc-0_7) weakremover(ruby2.3-rubygem-moneta-testsuite) weakremover(ruby2.3-rubygem-moneta-testsuite-0_7) weakremover(ruby2.3-rubygem-msgpack) weakremover(ruby2.3-rubygem-msgpack-doc) weakremover(ruby2.3-rubygem-msgpack-testsuite) weakremover(ruby2.3-rubygem-multi_json) weakremover(ruby2.3-rubygem-multi_json-doc) weakremover(ruby2.3-rubygem-multipart-post) weakremover(ruby2.3-rubygem-multipart-post-doc) weakremover(ruby2.3-rubygem-multipart-post-testsuite) weakremover(ruby2.3-rubygem-mustache) weakremover(ruby2.3-rubygem-mustache-doc) weakremover(ruby2.3-rubygem-mustache-testsuite) weakremover(ruby2.3-rubygem-mysql2) weakremover(ruby2.3-rubygem-mysql2-doc) weakremover(ruby2.3-rubygem-mysql2-testsuite) weakremover(ruby2.3-rubygem-net-scp) weakremover(ruby2.3-rubygem-net-scp-1_1) weakremover(ruby2.3-rubygem-net-scp-doc) weakremover(ruby2.3-rubygem-net-scp-doc-1_1) weakremover(ruby2.3-rubygem-net-scp-testsuite) weakremover(ruby2.3-rubygem-net-scp-testsuite-1_1) weakremover(ruby2.3-rubygem-net-sftp) weakremover(ruby2.3-rubygem-net-sftp-doc) weakremover(ruby2.3-rubygem-net-sftp-testsuite) weakremover(ruby2.3-rubygem-net-ssh) weakremover(ruby2.3-rubygem-net-ssh-doc) weakremover(ruby2.3-rubygem-net-ssh-gateway) weakremover(ruby2.3-rubygem-net-ssh-gateway-doc) weakremover(ruby2.3-rubygem-net-ssh-gateway-testsuite) weakremover(ruby2.3-rubygem-net-ssh-multi) weakremover(ruby2.3-rubygem-net-ssh-multi-1_1) weakremover(ruby2.3-rubygem-net-ssh-multi-doc) weakremover(ruby2.3-rubygem-net-ssh-multi-doc-1_1) weakremover(ruby2.3-rubygem-net-ssh-multi-testsuite) weakremover(ruby2.3-rubygem-net-ssh-multi-testsuite-1_1) weakremover(ruby2.3-rubygem-net-ssh-testsuite) weakremover(ruby2.3-rubygem-netrc) weakremover(ruby2.3-rubygem-netrc-doc) weakremover(ruby2.3-rubygem-netrc-testsuite) weakremover(ruby2.3-rubygem-nio4r) weakremover(ruby2.3-rubygem-nio4r-doc) weakremover(ruby2.3-rubygem-nio4r-testsuite) weakremover(ruby2.3-rubygem-nokogiri) weakremover(ruby2.3-rubygem-nokogiri-doc) weakremover(ruby2.3-rubygem-nokogiri-testsuite) weakremover(ruby2.3-rubygem-open4) weakremover(ruby2.3-rubygem-open4-doc) weakremover(ruby2.3-rubygem-open4-testsuite) weakremover(ruby2.3-rubygem-owncloud-admin) weakremover(ruby2.3-rubygem-owncloud-admin-doc) weakremover(ruby2.3-rubygem-packaging_rake_tasks) weakremover(ruby2.3-rubygem-packaging_rake_tasks-doc) weakremover(ruby2.3-rubygem-paint) weakremover(ruby2.3-rubygem-paint-doc) weakremover(ruby2.3-rubygem-path_expander) weakremover(ruby2.3-rubygem-path_expander-doc) weakremover(ruby2.3-rubygem-path_expander-testsuite) weakremover(ruby2.3-rubygem-pg) weakremover(ruby2.3-rubygem-pg-doc) weakremover(ruby2.3-rubygem-pg-testsuite) weakremover(ruby2.3-rubygem-pkg-config) weakremover(ruby2.3-rubygem-pkg-config-doc) weakremover(ruby2.3-rubygem-pkg-config-testsuite) weakremover(ruby2.3-rubygem-po_to_json) weakremover(ruby2.3-rubygem-po_to_json-doc) weakremover(ruby2.3-rubygem-po_to_json-testsuite) weakremover(ruby2.3-rubygem-polyglot) weakremover(ruby2.3-rubygem-polyglot-doc) weakremover(ruby2.3-rubygem-power_assert) weakremover(ruby2.3-rubygem-power_assert-doc) weakremover(ruby2.3-rubygem-power_assert-testsuite) weakremover(ruby2.3-rubygem-pry) weakremover(ruby2.3-rubygem-pry-doc) weakremover(ruby2.3-rubygem-pry-doc-doc) weakremover(ruby2.3-rubygem-pry-doc-testsuite) weakremover(ruby2.3-rubygem-puma) weakremover(ruby2.3-rubygem-puma-doc) weakremover(ruby2.3-rubygem-puma_worker_killer) weakremover(ruby2.3-rubygem-puma_worker_killer-doc) weakremover(ruby2.3-rubygem-puma_worker_killer-testsuite) weakremover(ruby2.3-rubygem-puppet) weakremover(ruby2.3-rubygem-puppet-doc) weakremover(ruby2.3-rubygem-puppet-lint) weakremover(ruby2.3-rubygem-puppet-lint-doc) weakremover(ruby2.3-rubygem-puppet-lint-testsuite) weakremover(ruby2.3-rubygem-puppet-syntax) weakremover(ruby2.3-rubygem-puppet-syntax-doc) weakremover(ruby2.3-rubygem-puppet-syntax-testsuite) weakremover(ruby2.3-rubygem-puppet-testsuite) weakremover(ruby2.3-rubygem-puppet_forge) weakremover(ruby2.3-rubygem-puppet_forge-doc) weakremover(ruby2.3-rubygem-puppet_forge-testsuite) weakremover(ruby2.3-rubygem-quiet_assets) weakremover(ruby2.3-rubygem-quiet_assets-doc) weakremover(ruby2.3-rubygem-quiet_assets-testsuite) weakremover(ruby2.3-rubygem-quixoten-puppetdb-terminus) weakremover(ruby2.3-rubygem-quixoten-puppetdb-terminus-doc) weakremover(ruby2.3-rubygem-r10k) weakremover(ruby2.3-rubygem-r10k-doc) weakremover(ruby2.3-rubygem-r10k-testsuite) weakremover(ruby2.3-rubygem-ra10ke) weakremover(ruby2.3-rubygem-ra10ke-doc) weakremover(ruby2.3-rubygem-rack) weakremover(ruby2.3-rubygem-rack-1_3) weakremover(ruby2.3-rubygem-rack-1_4) weakremover(ruby2.3-rubygem-rack-1_6) weakremover(ruby2.3-rubygem-rack-cache-1_2) weakremover(ruby2.3-rubygem-rack-cache-doc-1_2) weakremover(ruby2.3-rubygem-rack-cache-testsuite-1_2) weakremover(ruby2.3-rubygem-rack-doc) weakremover(ruby2.3-rubygem-rack-doc-1_3) weakremover(ruby2.3-rubygem-rack-doc-1_4) weakremover(ruby2.3-rubygem-rack-doc-1_6) weakremover(ruby2.3-rubygem-rack-protection) weakremover(ruby2.3-rubygem-rack-protection-doc) weakremover(ruby2.3-rubygem-rack-protection-testsuite) weakremover(ruby2.3-rubygem-rack-ssl-1_3) weakremover(ruby2.3-rubygem-rack-ssl-doc-1_3) weakremover(ruby2.3-rubygem-rack-test-0_6) weakremover(ruby2.3-rubygem-rack-test-doc-0_6) weakremover(ruby2.3-rubygem-rack-test-testsuite-0_6) weakremover(ruby2.3-rubygem-rack-testsuite) weakremover(ruby2.3-rubygem-rack-testsuite-1_3) weakremover(ruby2.3-rubygem-rack-testsuite-1_4) weakremover(ruby2.3-rubygem-rack-testsuite-1_6) weakremover(ruby2.3-rubygem-rails-4_2) weakremover(ruby2.3-rubygem-rails-deprecated_sanitizer) weakremover(ruby2.3-rubygem-rails-deprecated_sanitizer-doc) weakremover(ruby2.3-rubygem-rails-deprecated_sanitizer-testsuite) weakremover(ruby2.3-rubygem-rails-doc-4_2) weakremover(ruby2.3-rubygem-rails-dom-testing) weakremover(ruby2.3-rubygem-rails-dom-testing-doc) weakremover(ruby2.3-rubygem-rails-dom-testing-testsuite) weakremover(ruby2.3-rubygem-rails-html-sanitizer) weakremover(ruby2.3-rubygem-rails-html-sanitizer-doc) weakremover(ruby2.3-rubygem-rails-html-sanitizer-testsuite) weakremover(ruby2.3-rubygem-rails-i18n) weakremover(ruby2.3-rubygem-rails-i18n-doc) weakremover(ruby2.3-rubygem-railties-4_2) weakremover(ruby2.3-rubygem-railties-doc-4_2) weakremover(ruby2.3-rubygem-raindrops) weakremover(ruby2.3-rubygem-raindrops-doc) weakremover(ruby2.3-rubygem-raindrops-testsuite) weakremover(ruby2.3-rubygem-rake) weakremover(ruby2.3-rubygem-rake-compiler) weakremover(ruby2.3-rubygem-rake-compiler-doc) weakremover(ruby2.3-rubygem-rake-compiler-testsuite) weakremover(ruby2.3-rubygem-rake-doc) weakremover(ruby2.3-rubygem-rake-testsuite) weakremover(ruby2.3-rubygem-rb-fsevent) weakremover(ruby2.3-rubygem-rb-fsevent-doc) weakremover(ruby2.3-rubygem-rb-fsevent-testsuite) weakremover(ruby2.3-rubygem-rb-inotify) weakremover(ruby2.3-rubygem-rb-inotify-doc) weakremover(ruby2.3-rubygem-rb-kqueue) weakremover(ruby2.3-rubygem-rb-kqueue-doc) weakremover(ruby2.3-rubygem-rdoc-4) weakremover(ruby2.3-rubygem-rdoc-doc-4) weakremover(ruby2.3-rubygem-rdoc-testsuite-4) weakremover(ruby2.3-rubygem-responders) weakremover(ruby2.3-rubygem-responders-doc) weakremover(ruby2.3-rubygem-rest-client) weakremover(ruby2.3-rubygem-rest-client-doc) weakremover(ruby2.3-rubygem-rest-client-testsuite) weakremover(ruby2.3-rubygem-restility) weakremover(ruby2.3-rubygem-restility-doc) weakremover(ruby2.3-rubygem-restility-testsuite) weakremover(ruby2.3-rubygem-rgen) weakremover(ruby2.3-rubygem-rgen-doc) weakremover(ruby2.3-rubygem-rgen-testsuite) weakremover(ruby2.3-rubygem-rhc) weakremover(ruby2.3-rubygem-rhc-doc) weakremover(ruby2.3-rubygem-rhc-testsuite) weakremover(ruby2.3-rubygem-rouge) weakremover(ruby2.3-rubygem-rouge-doc) weakremover(ruby2.3-rubygem-rpm) weakremover(ruby2.3-rubygem-rpm-doc) weakremover(ruby2.3-rubygem-rpm-testsuite) weakremover(ruby2.3-rubygem-rspec) weakremover(ruby2.3-rubygem-rspec-core) weakremover(ruby2.3-rubygem-rspec-core-doc) weakremover(ruby2.3-rubygem-rspec-doc) weakremover(ruby2.3-rubygem-rspec-expectations) weakremover(ruby2.3-rubygem-rspec-expectations-doc) weakremover(ruby2.3-rubygem-rspec-mocks) weakremover(ruby2.3-rubygem-rspec-mocks-doc) weakremover(ruby2.3-rubygem-rspec-puppet) weakremover(ruby2.3-rubygem-rspec-puppet-doc) weakremover(ruby2.3-rubygem-rspec-support) weakremover(ruby2.3-rubygem-rspec-support-doc) weakremover(ruby2.3-rubygem-ruby-augeas) weakremover(ruby2.3-rubygem-ruby-augeas-doc) weakremover(ruby2.3-rubygem-ruby-libvirt) weakremover(ruby2.3-rubygem-ruby-libvirt-doc) weakremover(ruby2.3-rubygem-ruby-shadow) weakremover(ruby2.3-rubygem-ruby-shadow-doc) weakremover(ruby2.3-rubygem-ruby_dep) weakremover(ruby2.3-rubygem-ruby_dep-doc) weakremover(ruby2.3-rubygem-ruby_parser) weakremover(ruby2.3-rubygem-ruby_parser-doc) weakremover(ruby2.3-rubygem-ruby_parser-testsuite) weakremover(ruby2.3-rubygem-rubyforge) weakremover(ruby2.3-rubygem-rubyforge-doc) weakremover(ruby2.3-rubygem-rubyforge-testsuite) weakremover(ruby2.3-rubygem-rubyzip) weakremover(ruby2.3-rubygem-rubyzip-doc) weakremover(ruby2.3-rubygem-rubyzip-testsuite) weakremover(ruby2.3-rubygem-safe_yaml) weakremover(ruby2.3-rubygem-safe_yaml-doc) weakremover(ruby2.3-rubygem-safe_yaml-testsuite) weakremover(ruby2.3-rubygem-sass) weakremover(ruby2.3-rubygem-sass-doc) weakremover(ruby2.3-rubygem-sass-rails) weakremover(ruby2.3-rubygem-sass-rails-doc) weakremover(ruby2.3-rubygem-sass-testsuite) weakremover(ruby2.3-rubygem-sdoc) weakremover(ruby2.3-rubygem-sdoc-doc) weakremover(ruby2.3-rubygem-sdoc-testsuite) weakremover(ruby2.3-rubygem-semantic_puppet) weakremover(ruby2.3-rubygem-semantic_puppet-doc) weakremover(ruby2.3-rubygem-semantic_puppet-testsuite) weakremover(ruby2.3-rubygem-serverengine) weakremover(ruby2.3-rubygem-serverengine-doc) weakremover(ruby2.3-rubygem-serverengine-testsuite) weakremover(ruby2.3-rubygem-sexp_processor) weakremover(ruby2.3-rubygem-sexp_processor-doc) weakremover(ruby2.3-rubygem-sexp_processor-testsuite) weakremover(ruby2.3-rubygem-sigdump) weakremover(ruby2.3-rubygem-sigdump-doc) weakremover(ruby2.3-rubygem-simple_oauth) weakremover(ruby2.3-rubygem-simple_oauth-doc) weakremover(ruby2.3-rubygem-simplecov) weakremover(ruby2.3-rubygem-simplecov-doc) weakremover(ruby2.3-rubygem-simplecov-html) weakremover(ruby2.3-rubygem-simplecov-html-doc) weakremover(ruby2.3-rubygem-simplecov-html-testsuite) weakremover(ruby2.3-rubygem-simplecov-testsuite) weakremover(ruby2.3-rubygem-sinatra) weakremover(ruby2.3-rubygem-sinatra-doc) weakremover(ruby2.3-rubygem-sinatra-testsuite) weakremover(ruby2.3-rubygem-slop) weakremover(ruby2.3-rubygem-slop-3) weakremover(ruby2.3-rubygem-slop-3_3) weakremover(ruby2.3-rubygem-slop-doc) weakremover(ruby2.3-rubygem-slop-doc-3) weakremover(ruby2.3-rubygem-slop-doc-3_3) weakremover(ruby2.3-rubygem-slop-testsuite) weakremover(ruby2.3-rubygem-slop-testsuite-3) weakremover(ruby2.3-rubygem-slop-testsuite-3_3) weakremover(ruby2.3-rubygem-spring) weakremover(ruby2.3-rubygem-spring-doc) weakremover(ruby2.3-rubygem-spring-watcher-listen) weakremover(ruby2.3-rubygem-spring-watcher-listen-doc) weakremover(ruby2.3-rubygem-spring-watcher-listen-testsuite) weakremover(ruby2.3-rubygem-sprockets) weakremover(ruby2.3-rubygem-sprockets-2_1) weakremover(ruby2.3-rubygem-sprockets-2_2) weakremover(ruby2.3-rubygem-sprockets-doc) weakremover(ruby2.3-rubygem-sprockets-doc-2_1) weakremover(ruby2.3-rubygem-sprockets-doc-2_2) weakremover(ruby2.3-rubygem-sprockets-helpers) weakremover(ruby2.3-rubygem-sprockets-helpers-doc) weakremover(ruby2.3-rubygem-sprockets-helpers-testsuite) weakremover(ruby2.3-rubygem-sprockets-rails) weakremover(ruby2.3-rubygem-sprockets-rails-doc) weakremover(ruby2.3-rubygem-sqlite3) weakremover(ruby2.3-rubygem-sqlite3-doc) weakremover(ruby2.3-rubygem-sqlite3-testsuite) weakremover(ruby2.3-rubygem-sshkit) weakremover(ruby2.3-rubygem-sshkit-doc) weakremover(ruby2.3-rubygem-sshkit-testsuite) weakremover(ruby2.3-rubygem-stackdeck) weakremover(ruby2.3-rubygem-stackdeck-doc) weakremover(ruby2.3-rubygem-stackdeck-testsuite) weakremover(ruby2.3-rubygem-stomp) weakremover(ruby2.3-rubygem-stomp-doc) weakremover(ruby2.3-rubygem-stomp-testsuite) weakremover(ruby2.3-rubygem-strptime) weakremover(ruby2.3-rubygem-strptime-doc) weakremover(ruby2.3-rubygem-studio_api) weakremover(ruby2.3-rubygem-studio_api-doc) weakremover(ruby2.3-rubygem-studio_api-testsuite) weakremover(ruby2.3-rubygem-systemu) weakremover(ruby2.3-rubygem-systemu-doc) weakremover(ruby2.3-rubygem-systemu-testsuite) weakremover(ruby2.3-rubygem-taskjuggler) weakremover(ruby2.3-rubygem-taskjuggler-doc) weakremover(ruby2.3-rubygem-taskjuggler-testsuite) weakremover(ruby2.3-rubygem-term-ansicolor) weakremover(ruby2.3-rubygem-term-ansicolor-doc) weakremover(ruby2.3-rubygem-test-unit) weakremover(ruby2.3-rubygem-test-unit-doc) weakremover(ruby2.3-rubygem-test-unit-testsuite) weakremover(ruby2.3-rubygem-text) weakremover(ruby2.3-rubygem-text-doc) weakremover(ruby2.3-rubygem-text-hyphen) weakremover(ruby2.3-rubygem-text-hyphen-doc) weakremover(ruby2.3-rubygem-text-hyphen-testsuite) weakremover(ruby2.3-rubygem-text-testsuite) weakremover(ruby2.3-rubygem-thor) weakremover(ruby2.3-rubygem-thor-doc) weakremover(ruby2.3-rubygem-thor-testsuite) weakremover(ruby2.3-rubygem-thread_safe) weakremover(ruby2.3-rubygem-thread_safe-doc) weakremover(ruby2.3-rubygem-thread_safe-testsuite) weakremover(ruby2.3-rubygem-tilt-1_1) weakremover(ruby2.3-rubygem-tilt-1_4) weakremover(ruby2.3-rubygem-tilt-doc-1_1) weakremover(ruby2.3-rubygem-tilt-doc-1_4) weakremover(ruby2.3-rubygem-tilt-testsuite-1_1) weakremover(ruby2.3-rubygem-tilt-testsuite-1_4) weakremover(ruby2.3-rubygem-timers) weakremover(ruby2.3-rubygem-timers-doc) weakremover(ruby2.3-rubygem-timers-testsuite) weakremover(ruby2.3-rubygem-tins) weakremover(ruby2.3-rubygem-tins-doc) weakremover(ruby2.3-rubygem-treetop) weakremover(ruby2.3-rubygem-treetop-1_4) weakremover(ruby2.3-rubygem-treetop-doc) weakremover(ruby2.3-rubygem-treetop-doc-1_4) weakremover(ruby2.3-rubygem-treetop-testsuite) weakremover(ruby2.3-rubygem-treetop-testsuite-1_4) weakremover(ruby2.3-rubygem-trollop) weakremover(ruby2.3-rubygem-trollop-doc) weakremover(ruby2.3-rubygem-trollop-testsuite) weakremover(ruby2.3-rubygem-turbolinks) weakremover(ruby2.3-rubygem-turbolinks-doc) weakremover(ruby2.3-rubygem-turbolinks-source) weakremover(ruby2.3-rubygem-turbolinks-source-doc) weakremover(ruby2.3-rubygem-turbolinks-testsuite) weakremover(ruby2.3-rubygem-tzinfo) weakremover(ruby2.3-rubygem-tzinfo-0) weakremover(ruby2.3-rubygem-tzinfo-data) weakremover(ruby2.3-rubygem-tzinfo-data-doc) weakremover(ruby2.3-rubygem-tzinfo-doc) weakremover(ruby2.3-rubygem-tzinfo-doc-0) weakremover(ruby2.3-rubygem-tzinfo-testsuite) weakremover(ruby2.3-rubygem-tzinfo-testsuite-0) weakremover(ruby2.3-rubygem-uglifier) weakremover(ruby2.3-rubygem-uglifier-doc) weakremover(ruby2.3-rubygem-uglifier-testsuite) weakremover(ruby2.3-rubygem-unicorn) weakremover(ruby2.3-rubygem-unicorn-doc) weakremover(ruby2.3-rubygem-unicorn-testsuite) weakremover(ruby2.3-rubygem-virtus) weakremover(ruby2.3-rubygem-virtus-doc) weakremover(ruby2.3-rubygem-virtus-testsuite) weakremover(ruby2.3-rubygem-web-console) weakremover(ruby2.3-rubygem-web-console-2) weakremover(ruby2.3-rubygem-web-console-doc) weakremover(ruby2.3-rubygem-web-console-doc-2) weakremover(ruby2.3-rubygem-websocket) weakremover(ruby2.3-rubygem-websocket-doc) weakremover(ruby2.3-rubygem-websocket-driver) weakremover(ruby2.3-rubygem-websocket-driver-doc) weakremover(ruby2.3-rubygem-websocket-extensions) weakremover(ruby2.3-rubygem-websocket-extensions-doc) weakremover(ruby2.3-rubygem-websocket-testsuite) weakremover(ruby2.3-rubygem-xml-simple) weakremover(ruby2.3-rubygem-xml-simple-doc) weakremover(ruby2.3-rubygem-xmlhash) weakremover(ruby2.3-rubygem-xmlhash-doc) weakremover(ruby2.3-rubygem-xmlhash-testsuite) weakremover(ruby2.3-rubygem-yajl-ruby) weakremover(ruby2.3-rubygem-yajl-ruby-doc) weakremover(ruby2.3-rubygem-yajl-ruby-testsuite) weakremover(ruby2.3-rubygem-yard) weakremover(ruby2.3-rubygem-yard-doc) weakremover(ruby2.3-rubygem-yard-testsuite) weakremover(ruby2.3-rubygem-yast-rake) weakremover(ruby2.3-rubygem-yast-rake-doc) weakremover(ruby2.3-stdlib) weakremover(ruby2.3-tk) weakremover(ruby2.4) weakremover(ruby2.4-devel) weakremover(ruby2.4-devel-extra) weakremover(ruby2.4-doc) weakremover(ruby2.4-doc-ri) weakremover(ruby2.4-rubygem-RedCloth) weakremover(ruby2.4-rubygem-RedCloth-doc) weakremover(ruby2.4-rubygem-RedCloth-testsuite) weakremover(ruby2.4-rubygem-abstract) weakremover(ruby2.4-rubygem-abstract-doc) weakremover(ruby2.4-rubygem-abstract-testsuite) weakremover(ruby2.4-rubygem-abstract_method) weakremover(ruby2.4-rubygem-abstract_method-doc) weakremover(ruby2.4-rubygem-actionmailer-4_2) weakremover(ruby2.4-rubygem-actionmailer-doc-4_2) weakremover(ruby2.4-rubygem-actionpack-4_2) weakremover(ruby2.4-rubygem-actionpack-doc-4_2) weakremover(ruby2.4-rubygem-actionview-4_2) weakremover(ruby2.4-rubygem-actionview-doc-4_2) weakremover(ruby2.4-rubygem-activejob-4_2) weakremover(ruby2.4-rubygem-activejob-doc-4_2) weakremover(ruby2.4-rubygem-activemodel-4_2) weakremover(ruby2.4-rubygem-activemodel-doc-4_2) weakremover(ruby2.4-rubygem-activerecord-4_2) weakremover(ruby2.4-rubygem-activerecord-deprecated_finders) weakremover(ruby2.4-rubygem-activerecord-deprecated_finders-doc) weakremover(ruby2.4-rubygem-activerecord-doc-4_2) weakremover(ruby2.4-rubygem-activesupport-4_2) weakremover(ruby2.4-rubygem-activesupport-doc-4_2) weakremover(ruby2.4-rubygem-addressable) weakremover(ruby2.4-rubygem-addressable-doc) weakremover(ruby2.4-rubygem-addressable-testsuite) weakremover(ruby2.4-rubygem-airbrussh) weakremover(ruby2.4-rubygem-airbrussh-doc) weakremover(ruby2.4-rubygem-amqp) weakremover(ruby2.4-rubygem-amqp-doc) weakremover(ruby2.4-rubygem-amqp-testsuite) weakremover(ruby2.4-rubygem-archive-tar-minitar) weakremover(ruby2.4-rubygem-archive-tar-minitar-doc) weakremover(ruby2.4-rubygem-arel) weakremover(ruby2.4-rubygem-arel-3_0) weakremover(ruby2.4-rubygem-arel-7) weakremover(ruby2.4-rubygem-arel-doc) weakremover(ruby2.4-rubygem-arel-doc-3_0) weakremover(ruby2.4-rubygem-arel-doc-7) weakremover(ruby2.4-rubygem-arel-testsuite-3_0) weakremover(ruby2.4-rubygem-atomic) weakremover(ruby2.4-rubygem-atomic-doc) weakremover(ruby2.4-rubygem-atomic-testsuite) weakremover(ruby2.4-rubygem-augeas) weakremover(ruby2.4-rubygem-augeas-doc) weakremover(ruby2.4-rubygem-autoprefixer-rails) weakremover(ruby2.4-rubygem-autoprefixer-rails-doc) weakremover(ruby2.4-rubygem-autoprefixer-rails-testsuite) weakremover(ruby2.4-rubygem-axiom-types) weakremover(ruby2.4-rubygem-axiom-types-doc) weakremover(ruby2.4-rubygem-axiom-types-testsuite) weakremover(ruby2.4-rubygem-bcrypt) weakremover(ruby2.4-rubygem-bcrypt-doc) weakremover(ruby2.4-rubygem-bcrypt-ruby) weakremover(ruby2.4-rubygem-bcrypt-ruby-doc) weakremover(ruby2.4-rubygem-bcrypt-testsuite) weakremover(ruby2.4-rubygem-binding_of_caller) weakremover(ruby2.4-rubygem-binding_of_caller-doc) weakremover(ruby2.4-rubygem-binding_of_caller-testsuite) weakremover(ruby2.4-rubygem-bootstrap-sass) weakremover(ruby2.4-rubygem-bootstrap-sass-doc) weakremover(ruby2.4-rubygem-bootstrap-sass-testsuite) weakremover(ruby2.4-rubygem-buff-ignore) weakremover(ruby2.4-rubygem-buff-ignore-doc) weakremover(ruby2.4-rubygem-buff-ignore-testsuite) weakremover(ruby2.4-rubygem-builder) weakremover(ruby2.4-rubygem-builder-doc) weakremover(ruby2.4-rubygem-builder-testsuite) weakremover(ruby2.4-rubygem-bundler) weakremover(ruby2.4-rubygem-bundler-audit) weakremover(ruby2.4-rubygem-bundler-audit-doc) weakremover(ruby2.4-rubygem-bundler-audit-testsuite) weakremover(ruby2.4-rubygem-bundler-doc) weakremover(ruby2.4-rubygem-bunny) weakremover(ruby2.4-rubygem-bunny-doc) weakremover(ruby2.4-rubygem-bunny-testsuite) weakremover(ruby2.4-rubygem-byebug) weakremover(ruby2.4-rubygem-byebug-doc) weakremover(ruby2.4-rubygem-capistrano) weakremover(ruby2.4-rubygem-capistrano-doc) weakremover(ruby2.4-rubygem-capistrano-harrow) weakremover(ruby2.4-rubygem-capistrano-harrow-doc) weakremover(ruby2.4-rubygem-capistrano-stats) weakremover(ruby2.4-rubygem-capistrano-stats-doc) weakremover(ruby2.4-rubygem-capistrano-testsuite) weakremover(ruby2.4-rubygem-celluloid) weakremover(ruby2.4-rubygem-celluloid-doc) weakremover(ruby2.4-rubygem-celluloid-testsuite) weakremover(ruby2.4-rubygem-cfa) weakremover(ruby2.4-rubygem-cfa-doc) weakremover(ruby2.4-rubygem-cfa_grub2) weakremover(ruby2.4-rubygem-cfa_grub2-doc) weakremover(ruby2.4-rubygem-cheetah) weakremover(ruby2.4-rubygem-cheetah-doc) weakremover(ruby2.4-rubygem-childprocess) weakremover(ruby2.4-rubygem-childprocess-doc) weakremover(ruby2.4-rubygem-childprocess-testsuite) weakremover(ruby2.4-rubygem-ci_reporter) weakremover(ruby2.4-rubygem-ci_reporter-doc) weakremover(ruby2.4-rubygem-ci_reporter-testsuite) weakremover(ruby2.4-rubygem-cleanroom) weakremover(ruby2.4-rubygem-cleanroom-doc) weakremover(ruby2.4-rubygem-cleanroom-testsuite) weakremover(ruby2.4-rubygem-coderay) weakremover(ruby2.4-rubygem-coderay-doc) weakremover(ruby2.4-rubygem-coderay-testsuite) weakremover(ruby2.4-rubygem-coercible) weakremover(ruby2.4-rubygem-coercible-doc) weakremover(ruby2.4-rubygem-coercible-testsuite) weakremover(ruby2.4-rubygem-coffee-rails) weakremover(ruby2.4-rubygem-coffee-rails-doc) weakremover(ruby2.4-rubygem-coffee-rails-testsuite) weakremover(ruby2.4-rubygem-coffee-script) weakremover(ruby2.4-rubygem-coffee-script-doc) weakremover(ruby2.4-rubygem-coffee-script-source) weakremover(ruby2.4-rubygem-coffee-script-source-doc) weakremover(ruby2.4-rubygem-colorator) weakremover(ruby2.4-rubygem-colorator-doc) weakremover(ruby2.4-rubygem-colorize) weakremover(ruby2.4-rubygem-colorize-doc) weakremover(ruby2.4-rubygem-colorize-testsuite) weakremover(ruby2.4-rubygem-columnize) weakremover(ruby2.4-rubygem-columnize-doc) weakremover(ruby2.4-rubygem-columnize-testsuite) weakremover(ruby2.4-rubygem-commander) weakremover(ruby2.4-rubygem-commander-doc) weakremover(ruby2.4-rubygem-commander-testsuite) weakremover(ruby2.4-rubygem-concurrent-ruby) weakremover(ruby2.4-rubygem-concurrent-ruby-doc) weakremover(ruby2.4-rubygem-cool.io) weakremover(ruby2.4-rubygem-cool.io-doc) weakremover(ruby2.4-rubygem-cool.io-testsuite) weakremover(ruby2.4-rubygem-cri) weakremover(ruby2.4-rubygem-cri-2_6) weakremover(ruby2.4-rubygem-cri-doc) weakremover(ruby2.4-rubygem-cri-doc-2_6) weakremover(ruby2.4-rubygem-cri-testsuite) weakremover(ruby2.4-rubygem-cri-testsuite-2_6) weakremover(ruby2.4-rubygem-cssmin) weakremover(ruby2.4-rubygem-cssmin-doc) weakremover(ruby2.4-rubygem-daemons) weakremover(ruby2.4-rubygem-daemons-doc) weakremover(ruby2.4-rubygem-debug_inspector) weakremover(ruby2.4-rubygem-debug_inspector-doc) weakremover(ruby2.4-rubygem-debugger-linecache) weakremover(ruby2.4-rubygem-debugger-linecache-doc) weakremover(ruby2.4-rubygem-debugger-linecache-testsuite) weakremover(ruby2.4-rubygem-deep_merge) weakremover(ruby2.4-rubygem-deep_merge-doc) weakremover(ruby2.4-rubygem-deep_merge-testsuite) weakremover(ruby2.4-rubygem-delayed_job) weakremover(ruby2.4-rubygem-delayed_job-doc) weakremover(ruby2.4-rubygem-delayed_job-testsuite) weakremover(ruby2.4-rubygem-descendants_tracker) weakremover(ruby2.4-rubygem-descendants_tracker-doc) weakremover(ruby2.4-rubygem-descendants_tracker-testsuite) weakremover(ruby2.4-rubygem-devise) weakremover(ruby2.4-rubygem-devise-doc) weakremover(ruby2.4-rubygem-devise-i18n) weakremover(ruby2.4-rubygem-devise-i18n-doc) weakremover(ruby2.4-rubygem-devise-i18n-testsuite) weakremover(ruby2.4-rubygem-devise-testsuite) weakremover(ruby2.4-rubygem-diff-lcs) weakremover(ruby2.4-rubygem-diff-lcs-doc) weakremover(ruby2.4-rubygem-diff-lcs-testsuite) weakremover(ruby2.4-rubygem-diffy) weakremover(ruby2.4-rubygem-diffy-doc) weakremover(ruby2.4-rubygem-diffy-testsuite) weakremover(ruby2.4-rubygem-docile) weakremover(ruby2.4-rubygem-docile-doc) weakremover(ruby2.4-rubygem-docile-testsuite) weakremover(ruby2.4-rubygem-docker-api) weakremover(ruby2.4-rubygem-docker-api-doc) weakremover(ruby2.4-rubygem-docker-api-testsuite) weakremover(ruby2.4-rubygem-equalizer) weakremover(ruby2.4-rubygem-equalizer-doc) weakremover(ruby2.4-rubygem-equalizer-testsuite) weakremover(ruby2.4-rubygem-erubis) weakremover(ruby2.4-rubygem-erubis-2_6) weakremover(ruby2.4-rubygem-erubis-doc) weakremover(ruby2.4-rubygem-erubis-doc-2_6) weakremover(ruby2.4-rubygem-erubis-testsuite) weakremover(ruby2.4-rubygem-erubis-testsuite-2_6) weakremover(ruby2.4-rubygem-eventmachine) weakremover(ruby2.4-rubygem-eventmachine-doc) weakremover(ruby2.4-rubygem-exception_notification) weakremover(ruby2.4-rubygem-exception_notification-doc) weakremover(ruby2.4-rubygem-exception_notification-testsuite) weakremover(ruby2.4-rubygem-excon) weakremover(ruby2.4-rubygem-excon-doc) weakremover(ruby2.4-rubygem-excon-testsuite) weakremover(ruby2.4-rubygem-execjs) weakremover(ruby2.4-rubygem-execjs-doc) weakremover(ruby2.4-rubygem-extlib) weakremover(ruby2.4-rubygem-extlib-doc) weakremover(ruby2.4-rubygem-extlib-testsuite) weakremover(ruby2.4-rubygem-facter) weakremover(ruby2.4-rubygem-facter-doc) weakremover(ruby2.4-rubygem-facter-testsuite) weakremover(ruby2.4-rubygem-factory_girl) weakremover(ruby2.4-rubygem-factory_girl-doc) weakremover(ruby2.4-rubygem-factory_girl-testsuite) weakremover(ruby2.4-rubygem-factory_girl_rails) weakremover(ruby2.4-rubygem-factory_girl_rails-doc) weakremover(ruby2.4-rubygem-faraday) weakremover(ruby2.4-rubygem-faraday-doc) weakremover(ruby2.4-rubygem-faraday-testsuite) weakremover(ruby2.4-rubygem-faraday_middleware) weakremover(ruby2.4-rubygem-faraday_middleware-0_9) weakremover(ruby2.4-rubygem-faraday_middleware-doc) weakremover(ruby2.4-rubygem-faraday_middleware-doc-0_9) weakremover(ruby2.4-rubygem-faraday_middleware-multi_json) weakremover(ruby2.4-rubygem-faraday_middleware-multi_json-doc) weakremover(ruby2.4-rubygem-faraday_middleware-multi_json-testsuite) weakremover(ruby2.4-rubygem-fast_gettext) weakremover(ruby2.4-rubygem-fast_gettext-1_1) weakremover(ruby2.4-rubygem-fast_gettext-1_2) weakremover(ruby2.4-rubygem-fast_gettext-doc) weakremover(ruby2.4-rubygem-fast_gettext-doc-1_1) weakremover(ruby2.4-rubygem-fast_gettext-doc-1_2) weakremover(ruby2.4-rubygem-fast_xs) weakremover(ruby2.4-rubygem-fast_xs-doc) weakremover(ruby2.4-rubygem-fast_xs-testsuite) weakremover(ruby2.4-rubygem-fastercsv) weakremover(ruby2.4-rubygem-fastercsv-doc) weakremover(ruby2.4-rubygem-fastercsv-testsuite) weakremover(ruby2.4-rubygem-ffi) weakremover(ruby2.4-rubygem-ffi-doc) weakremover(ruby2.4-rubygem-ffi-testsuite) weakremover(ruby2.4-rubygem-file-tail) weakremover(ruby2.4-rubygem-file-tail-doc) weakremover(ruby2.4-rubygem-flog) weakremover(ruby2.4-rubygem-flog-doc) weakremover(ruby2.4-rubygem-flog-testsuite) weakremover(ruby2.4-rubygem-fluentd) weakremover(ruby2.4-rubygem-fluentd-doc) weakremover(ruby2.4-rubygem-fluentd-testsuite) weakremover(ruby2.4-rubygem-gem2rpm) weakremover(ruby2.4-rubygem-gem2rpm-doc) weakremover(ruby2.4-rubygem-get_process_mem) weakremover(ruby2.4-rubygem-get_process_mem-doc) weakremover(ruby2.4-rubygem-get_process_mem-testsuite) weakremover(ruby2.4-rubygem-gettext) weakremover(ruby2.4-rubygem-gettext-doc) weakremover(ruby2.4-rubygem-gettext-setup) weakremover(ruby2.4-rubygem-gettext-setup-doc) weakremover(ruby2.4-rubygem-gettext-setup-testsuite) weakremover(ruby2.4-rubygem-gettext-testsuite) weakremover(ruby2.4-rubygem-gettext_i18n_rails) weakremover(ruby2.4-rubygem-gettext_i18n_rails-doc) weakremover(ruby2.4-rubygem-gettext_i18n_rails_js) weakremover(ruby2.4-rubygem-gettext_i18n_rails_js-doc) weakremover(ruby2.4-rubygem-gettext_i18n_rails_js-testsuite) weakremover(ruby2.4-rubygem-gli) weakremover(ruby2.4-rubygem-gli-doc) weakremover(ruby2.4-rubygem-gli-testsuite) weakremover(ruby2.4-rubygem-globalid) weakremover(ruby2.4-rubygem-globalid-doc) weakremover(ruby2.4-rubygem-gpgme) weakremover(ruby2.4-rubygem-gpgme-doc) weakremover(ruby2.4-rubygem-gpgme-testsuite) weakremover(ruby2.4-rubygem-haml) weakremover(ruby2.4-rubygem-haml-doc) weakremover(ruby2.4-rubygem-haml-rails) weakremover(ruby2.4-rubygem-haml-rails-doc) weakremover(ruby2.4-rubygem-haml-rails-testsuite) weakremover(ruby2.4-rubygem-haml-testsuite) weakremover(ruby2.4-rubygem-has_mobile_views) weakremover(ruby2.4-rubygem-has_mobile_views-doc) weakremover(ruby2.4-rubygem-has_mobile_views-testsuite) weakremover(ruby2.4-rubygem-hashdiff) weakremover(ruby2.4-rubygem-hashdiff-doc) weakremover(ruby2.4-rubygem-hashdiff-testsuite) weakremover(ruby2.4-rubygem-hashicorp-checkpoint) weakremover(ruby2.4-rubygem-hashicorp-checkpoint-doc) weakremover(ruby2.4-rubygem-hashicorp-checkpoint-testsuite) weakremover(ruby2.4-rubygem-hashie) weakremover(ruby2.4-rubygem-hashie-doc) weakremover(ruby2.4-rubygem-hashie-testsuite) weakremover(ruby2.4-rubygem-hiera) weakremover(ruby2.4-rubygem-hiera-doc) weakremover(ruby2.4-rubygem-hiera-eyaml) weakremover(ruby2.4-rubygem-hiera-eyaml-doc) weakremover(ruby2.4-rubygem-hiera-eyaml-gpg) weakremover(ruby2.4-rubygem-hiera-eyaml-gpg-doc) weakremover(ruby2.4-rubygem-hiera-testsuite) weakremover(ruby2.4-rubygem-highline) weakremover(ruby2.4-rubygem-highline-1_6) weakremover(ruby2.4-rubygem-highline-doc) weakremover(ruby2.4-rubygem-highline-doc-1_6) weakremover(ruby2.4-rubygem-highline-testsuite) weakremover(ruby2.4-rubygem-highline-testsuite-1_6) weakremover(ruby2.4-rubygem-hike) weakremover(ruby2.4-rubygem-hike-1_2) weakremover(ruby2.4-rubygem-hike-doc) weakremover(ruby2.4-rubygem-hike-doc-1_2) weakremover(ruby2.4-rubygem-hitimes) weakremover(ruby2.4-rubygem-hitimes-doc) weakremover(ruby2.4-rubygem-hitimes-testsuite) weakremover(ruby2.4-rubygem-hoe) weakremover(ruby2.4-rubygem-hoe-doc) weakremover(ruby2.4-rubygem-hoe-testsuite) weakremover(ruby2.4-rubygem-html2haml) weakremover(ruby2.4-rubygem-html2haml-doc) weakremover(ruby2.4-rubygem-html2haml-testsuite) weakremover(ruby2.4-rubygem-http_accept_language) weakremover(ruby2.4-rubygem-http_accept_language-doc) weakremover(ruby2.4-rubygem-http_accept_language-testsuite) weakremover(ruby2.4-rubygem-http_parser.rb) weakremover(ruby2.4-rubygem-http_parser.rb-doc) weakremover(ruby2.4-rubygem-http_parser.rb-testsuite) weakremover(ruby2.4-rubygem-httpclient) weakremover(ruby2.4-rubygem-httpclient-doc) weakremover(ruby2.4-rubygem-httpclient-testsuite) weakremover(ruby2.4-rubygem-hub) weakremover(ruby2.4-rubygem-hub-doc) weakremover(ruby2.4-rubygem-i18n) weakremover(ruby2.4-rubygem-i18n-doc) weakremover(ruby2.4-rubygem-i18n-testsuite) weakremover(ruby2.4-rubygem-ice_nine) weakremover(ruby2.4-rubygem-ice_nine-doc) weakremover(ruby2.4-rubygem-ice_nine-testsuite) weakremover(ruby2.4-rubygem-inifile) weakremover(ruby2.4-rubygem-inifile-doc) weakremover(ruby2.4-rubygem-inifile-testsuite) weakremover(ruby2.4-rubygem-ipaddress) weakremover(ruby2.4-rubygem-ipaddress-doc) weakremover(ruby2.4-rubygem-ipaddress-testsuite) weakremover(ruby2.4-rubygem-jbuilder) weakremover(ruby2.4-rubygem-jbuilder-doc) weakremover(ruby2.4-rubygem-jbuilder-testsuite) weakremover(ruby2.4-rubygem-jekyll) weakremover(ruby2.4-rubygem-jekyll-doc) weakremover(ruby2.4-rubygem-jekyll-sass-converter) weakremover(ruby2.4-rubygem-jekyll-sass-converter-doc) weakremover(ruby2.4-rubygem-jekyll-watch) weakremover(ruby2.4-rubygem-jekyll-watch-doc) weakremover(ruby2.4-rubygem-jmespath) weakremover(ruby2.4-rubygem-jmespath-doc) weakremover(ruby2.4-rubygem-journey-1_0) weakremover(ruby2.4-rubygem-journey-doc-1_0) weakremover(ruby2.4-rubygem-journey-testsuite-1_0) weakremover(ruby2.4-rubygem-jquery-rails) weakremover(ruby2.4-rubygem-jquery-rails-doc) weakremover(ruby2.4-rubygem-jquery-rails-testsuite) weakremover(ruby2.4-rubygem-jquery-ui-rails) weakremover(ruby2.4-rubygem-jquery-ui-rails-doc) weakremover(ruby2.4-rubygem-js-routes) weakremover(ruby2.4-rubygem-js-routes-doc) weakremover(ruby2.4-rubygem-js-routes-testsuite) weakremover(ruby2.4-rubygem-json) weakremover(ruby2.4-rubygem-json-doc) weakremover(ruby2.4-rubygem-json-schema) weakremover(ruby2.4-rubygem-json-schema-doc) weakremover(ruby2.4-rubygem-json-schema-testsuite) weakremover(ruby2.4-rubygem-json_pure) weakremover(ruby2.4-rubygem-json_pure-doc) weakremover(ruby2.4-rubygem-kgio) weakremover(ruby2.4-rubygem-kgio-doc) weakremover(ruby2.4-rubygem-kgio-testsuite) weakremover(ruby2.4-rubygem-kramdown) weakremover(ruby2.4-rubygem-kramdown-doc) weakremover(ruby2.4-rubygem-kramdown-testsuite) weakremover(ruby2.4-rubygem-launchy) weakremover(ruby2.4-rubygem-launchy-doc) weakremover(ruby2.4-rubygem-launchy-testsuite) weakremover(ruby2.4-rubygem-levenshtein) weakremover(ruby2.4-rubygem-levenshtein-doc) weakremover(ruby2.4-rubygem-levenshtein-testsuite) weakremover(ruby2.4-rubygem-librarian) weakremover(ruby2.4-rubygem-librarian-doc) weakremover(ruby2.4-rubygem-librarian-testsuite) weakremover(ruby2.4-rubygem-libyui-rake) weakremover(ruby2.4-rubygem-libyui-rake-doc) weakremover(ruby2.4-rubygem-liquid) weakremover(ruby2.4-rubygem-liquid-doc) weakremover(ruby2.4-rubygem-liquid-testsuite) weakremover(ruby2.4-rubygem-listen) weakremover(ruby2.4-rubygem-listen-doc) weakremover(ruby2.4-rubygem-locale) weakremover(ruby2.4-rubygem-locale-doc) weakremover(ruby2.4-rubygem-locale-testsuite) weakremover(ruby2.4-rubygem-log4r) weakremover(ruby2.4-rubygem-log4r-doc) weakremover(ruby2.4-rubygem-lolcat) weakremover(ruby2.4-rubygem-lolcat-doc) weakremover(ruby2.4-rubygem-loofah) weakremover(ruby2.4-rubygem-loofah-doc) weakremover(ruby2.4-rubygem-loofah-testsuite) weakremover(ruby2.4-rubygem-mail) weakremover(ruby2.4-rubygem-mail-2_5) weakremover(ruby2.4-rubygem-mail-doc) weakremover(ruby2.4-rubygem-mail-doc-2_5) weakremover(ruby2.4-rubygem-mcollective) weakremover(ruby2.4-rubygem-mcollective-doc) weakremover(ruby2.4-rubygem-mcollective-testsuite) weakremover(ruby2.4-rubygem-mercenary) weakremover(ruby2.4-rubygem-mercenary-doc) weakremover(ruby2.4-rubygem-mercenary-testsuite) weakremover(ruby2.4-rubygem-metaclass) weakremover(ruby2.4-rubygem-metaclass-doc) weakremover(ruby2.4-rubygem-metaclass-testsuite) weakremover(ruby2.4-rubygem-method_source) weakremover(ruby2.4-rubygem-method_source-doc) weakremover(ruby2.4-rubygem-method_source-testsuite) weakremover(ruby2.4-rubygem-mime-types) weakremover(ruby2.4-rubygem-mime-types-1) weakremover(ruby2.4-rubygem-mime-types-data) weakremover(ruby2.4-rubygem-mime-types-data-doc) weakremover(ruby2.4-rubygem-mime-types-doc) weakremover(ruby2.4-rubygem-mime-types-doc-1) weakremover(ruby2.4-rubygem-mime-types-testsuite) weakremover(ruby2.4-rubygem-mime-types-testsuite-1) weakremover(ruby2.4-rubygem-mimemagic) weakremover(ruby2.4-rubygem-mimemagic-doc) weakremover(ruby2.4-rubygem-mimemagic-testsuite) weakremover(ruby2.4-rubygem-mini_magick) weakremover(ruby2.4-rubygem-mini_magick-doc) weakremover(ruby2.4-rubygem-mini_portile) weakremover(ruby2.4-rubygem-mini_portile-doc) weakremover(ruby2.4-rubygem-mini_portile2) weakremover(ruby2.4-rubygem-mini_portile2-doc) weakremover(ruby2.4-rubygem-mini_portile2-testsuite) weakremover(ruby2.4-rubygem-minitar) weakremover(ruby2.4-rubygem-minitar-doc) weakremover(ruby2.4-rubygem-minitest) weakremover(ruby2.4-rubygem-minitest-doc) weakremover(ruby2.4-rubygem-minitest-testsuite) weakremover(ruby2.4-rubygem-mixlib-authentication) weakremover(ruby2.4-rubygem-mixlib-authentication-doc) weakremover(ruby2.4-rubygem-mixlib-authentication-testsuite) weakremover(ruby2.4-rubygem-mixlib-cli) weakremover(ruby2.4-rubygem-mixlib-cli-doc) weakremover(ruby2.4-rubygem-mixlib-cli-testsuite) weakremover(ruby2.4-rubygem-mixlib-config) weakremover(ruby2.4-rubygem-mixlib-config-doc) weakremover(ruby2.4-rubygem-mixlib-config-testsuite) weakremover(ruby2.4-rubygem-mixlib-log) weakremover(ruby2.4-rubygem-mixlib-log-doc) weakremover(ruby2.4-rubygem-mixlib-log-testsuite) weakremover(ruby2.4-rubygem-mixlib-shellout) weakremover(ruby2.4-rubygem-mixlib-shellout-doc) weakremover(ruby2.4-rubygem-mocha) weakremover(ruby2.4-rubygem-mocha-doc) weakremover(ruby2.4-rubygem-mocha-testsuite) weakremover(ruby2.4-rubygem-moneta) weakremover(ruby2.4-rubygem-moneta-0_7) weakremover(ruby2.4-rubygem-moneta-doc) weakremover(ruby2.4-rubygem-moneta-doc-0_7) weakremover(ruby2.4-rubygem-moneta-testsuite) weakremover(ruby2.4-rubygem-moneta-testsuite-0_7) weakremover(ruby2.4-rubygem-msgpack) weakremover(ruby2.4-rubygem-msgpack-doc) weakremover(ruby2.4-rubygem-msgpack-testsuite) weakremover(ruby2.4-rubygem-multi_json) weakremover(ruby2.4-rubygem-multi_json-doc) weakremover(ruby2.4-rubygem-multipart-post) weakremover(ruby2.4-rubygem-multipart-post-doc) weakremover(ruby2.4-rubygem-multipart-post-testsuite) weakremover(ruby2.4-rubygem-mustache) weakremover(ruby2.4-rubygem-mustache-doc) weakremover(ruby2.4-rubygem-mustache-testsuite) weakremover(ruby2.4-rubygem-mysql2) weakremover(ruby2.4-rubygem-mysql2-doc) weakremover(ruby2.4-rubygem-mysql2-testsuite) weakremover(ruby2.4-rubygem-net-scp) weakremover(ruby2.4-rubygem-net-scp-1_1) weakremover(ruby2.4-rubygem-net-scp-doc) weakremover(ruby2.4-rubygem-net-scp-doc-1_1) weakremover(ruby2.4-rubygem-net-scp-testsuite) weakremover(ruby2.4-rubygem-net-scp-testsuite-1_1) weakremover(ruby2.4-rubygem-net-sftp) weakremover(ruby2.4-rubygem-net-sftp-doc) weakremover(ruby2.4-rubygem-net-sftp-testsuite) weakremover(ruby2.4-rubygem-net-ssh) weakremover(ruby2.4-rubygem-net-ssh-doc) weakremover(ruby2.4-rubygem-net-ssh-gateway) weakremover(ruby2.4-rubygem-net-ssh-gateway-doc) weakremover(ruby2.4-rubygem-net-ssh-gateway-testsuite) weakremover(ruby2.4-rubygem-net-ssh-multi) weakremover(ruby2.4-rubygem-net-ssh-multi-1_1) weakremover(ruby2.4-rubygem-net-ssh-multi-doc) weakremover(ruby2.4-rubygem-net-ssh-multi-doc-1_1) weakremover(ruby2.4-rubygem-net-ssh-multi-testsuite) weakremover(ruby2.4-rubygem-net-ssh-multi-testsuite-1_1) weakremover(ruby2.4-rubygem-net-ssh-testsuite) weakremover(ruby2.4-rubygem-netrc) weakremover(ruby2.4-rubygem-netrc-doc) weakremover(ruby2.4-rubygem-netrc-testsuite) weakremover(ruby2.4-rubygem-nio4r) weakremover(ruby2.4-rubygem-nio4r-doc) weakremover(ruby2.4-rubygem-nio4r-testsuite) weakremover(ruby2.4-rubygem-nokogiri) weakremover(ruby2.4-rubygem-nokogiri-doc) weakremover(ruby2.4-rubygem-nokogiri-testsuite) weakremover(ruby2.4-rubygem-open4) weakremover(ruby2.4-rubygem-open4-doc) weakremover(ruby2.4-rubygem-open4-testsuite) weakremover(ruby2.4-rubygem-owncloud-admin) weakremover(ruby2.4-rubygem-owncloud-admin-doc) weakremover(ruby2.4-rubygem-packaging_rake_tasks) weakremover(ruby2.4-rubygem-packaging_rake_tasks-doc) weakremover(ruby2.4-rubygem-paint) weakremover(ruby2.4-rubygem-paint-doc) weakremover(ruby2.4-rubygem-path_expander) weakremover(ruby2.4-rubygem-path_expander-doc) weakremover(ruby2.4-rubygem-path_expander-testsuite) weakremover(ruby2.4-rubygem-pg) weakremover(ruby2.4-rubygem-pg-doc) weakremover(ruby2.4-rubygem-pg-testsuite) weakremover(ruby2.4-rubygem-pkg-config) weakremover(ruby2.4-rubygem-pkg-config-doc) weakremover(ruby2.4-rubygem-pkg-config-testsuite) weakremover(ruby2.4-rubygem-po_to_json) weakremover(ruby2.4-rubygem-po_to_json-doc) weakremover(ruby2.4-rubygem-po_to_json-testsuite) weakremover(ruby2.4-rubygem-polyglot) weakremover(ruby2.4-rubygem-polyglot-doc) weakremover(ruby2.4-rubygem-power_assert) weakremover(ruby2.4-rubygem-power_assert-doc) weakremover(ruby2.4-rubygem-power_assert-testsuite) weakremover(ruby2.4-rubygem-pry) weakremover(ruby2.4-rubygem-pry-doc) weakremover(ruby2.4-rubygem-pry-doc-doc) weakremover(ruby2.4-rubygem-pry-doc-testsuite) weakremover(ruby2.4-rubygem-puma) weakremover(ruby2.4-rubygem-puma-doc) weakremover(ruby2.4-rubygem-puma_worker_killer) weakremover(ruby2.4-rubygem-puma_worker_killer-doc) weakremover(ruby2.4-rubygem-puma_worker_killer-testsuite) weakremover(ruby2.4-rubygem-puppet) weakremover(ruby2.4-rubygem-puppet-doc) weakremover(ruby2.4-rubygem-puppet-lint) weakremover(ruby2.4-rubygem-puppet-lint-doc) weakremover(ruby2.4-rubygem-puppet-lint-testsuite) weakremover(ruby2.4-rubygem-puppet-syntax) weakremover(ruby2.4-rubygem-puppet-syntax-doc) weakremover(ruby2.4-rubygem-puppet-syntax-testsuite) weakremover(ruby2.4-rubygem-puppet-testsuite) weakremover(ruby2.4-rubygem-puppet_forge) weakremover(ruby2.4-rubygem-puppet_forge-doc) weakremover(ruby2.4-rubygem-puppet_forge-testsuite) weakremover(ruby2.4-rubygem-quiet_assets) weakremover(ruby2.4-rubygem-quiet_assets-doc) weakremover(ruby2.4-rubygem-quiet_assets-testsuite) weakremover(ruby2.4-rubygem-quixoten-puppetdb-terminus) weakremover(ruby2.4-rubygem-quixoten-puppetdb-terminus-doc) weakremover(ruby2.4-rubygem-r10k) weakremover(ruby2.4-rubygem-r10k-doc) weakremover(ruby2.4-rubygem-r10k-testsuite) weakremover(ruby2.4-rubygem-ra10ke) weakremover(ruby2.4-rubygem-ra10ke-doc) weakremover(ruby2.4-rubygem-rack) weakremover(ruby2.4-rubygem-rack-1_3) weakremover(ruby2.4-rubygem-rack-1_4) weakremover(ruby2.4-rubygem-rack-1_6) weakremover(ruby2.4-rubygem-rack-cache-1_2) weakremover(ruby2.4-rubygem-rack-cache-doc-1_2) weakremover(ruby2.4-rubygem-rack-cache-testsuite-1_2) weakremover(ruby2.4-rubygem-rack-doc) weakremover(ruby2.4-rubygem-rack-doc-1_3) weakremover(ruby2.4-rubygem-rack-doc-1_4) weakremover(ruby2.4-rubygem-rack-doc-1_6) weakremover(ruby2.4-rubygem-rack-protection) weakremover(ruby2.4-rubygem-rack-protection-doc) weakremover(ruby2.4-rubygem-rack-protection-testsuite) weakremover(ruby2.4-rubygem-rack-ssl-1_3) weakremover(ruby2.4-rubygem-rack-ssl-doc-1_3) weakremover(ruby2.4-rubygem-rack-test-0_6) weakremover(ruby2.4-rubygem-rack-test-doc-0_6) weakremover(ruby2.4-rubygem-rack-test-testsuite-0_6) weakremover(ruby2.4-rubygem-rack-testsuite) weakremover(ruby2.4-rubygem-rack-testsuite-1_3) weakremover(ruby2.4-rubygem-rack-testsuite-1_4) weakremover(ruby2.4-rubygem-rack-testsuite-1_6) weakremover(ruby2.4-rubygem-rails-4_2) weakremover(ruby2.4-rubygem-rails-deprecated_sanitizer) weakremover(ruby2.4-rubygem-rails-deprecated_sanitizer-doc) weakremover(ruby2.4-rubygem-rails-deprecated_sanitizer-testsuite) weakremover(ruby2.4-rubygem-rails-doc-4_2) weakremover(ruby2.4-rubygem-rails-dom-testing) weakremover(ruby2.4-rubygem-rails-dom-testing-doc) weakremover(ruby2.4-rubygem-rails-dom-testing-testsuite) weakremover(ruby2.4-rubygem-rails-html-sanitizer) weakremover(ruby2.4-rubygem-rails-html-sanitizer-doc) weakremover(ruby2.4-rubygem-rails-html-sanitizer-testsuite) weakremover(ruby2.4-rubygem-rails-i18n) weakremover(ruby2.4-rubygem-rails-i18n-doc) weakremover(ruby2.4-rubygem-railties-4_2) weakremover(ruby2.4-rubygem-railties-doc-4_2) weakremover(ruby2.4-rubygem-raindrops) weakremover(ruby2.4-rubygem-raindrops-doc) weakremover(ruby2.4-rubygem-raindrops-testsuite) weakremover(ruby2.4-rubygem-rake) weakremover(ruby2.4-rubygem-rake-compiler) weakremover(ruby2.4-rubygem-rake-compiler-doc) weakremover(ruby2.4-rubygem-rake-compiler-testsuite) weakremover(ruby2.4-rubygem-rake-doc) weakremover(ruby2.4-rubygem-rake-testsuite) weakremover(ruby2.4-rubygem-rb-fsevent) weakremover(ruby2.4-rubygem-rb-fsevent-doc) weakremover(ruby2.4-rubygem-rb-fsevent-testsuite) weakremover(ruby2.4-rubygem-rb-inotify) weakremover(ruby2.4-rubygem-rb-inotify-doc) weakremover(ruby2.4-rubygem-rb-kqueue) weakremover(ruby2.4-rubygem-rb-kqueue-doc) weakremover(ruby2.4-rubygem-rdoc-4) weakremover(ruby2.4-rubygem-rdoc-doc-4) weakremover(ruby2.4-rubygem-rdoc-testsuite-4) weakremover(ruby2.4-rubygem-responders) weakremover(ruby2.4-rubygem-responders-doc) weakremover(ruby2.4-rubygem-rest-client) weakremover(ruby2.4-rubygem-rest-client-doc) weakremover(ruby2.4-rubygem-rest-client-testsuite) weakremover(ruby2.4-rubygem-restility) weakremover(ruby2.4-rubygem-restility-doc) weakremover(ruby2.4-rubygem-restility-testsuite) weakremover(ruby2.4-rubygem-rgen) weakremover(ruby2.4-rubygem-rgen-doc) weakremover(ruby2.4-rubygem-rgen-testsuite) weakremover(ruby2.4-rubygem-rhc) weakremover(ruby2.4-rubygem-rhc-doc) weakremover(ruby2.4-rubygem-rhc-testsuite) weakremover(ruby2.4-rubygem-rouge) weakremover(ruby2.4-rubygem-rouge-doc) weakremover(ruby2.4-rubygem-rpm) weakremover(ruby2.4-rubygem-rpm-doc) weakremover(ruby2.4-rubygem-rpm-testsuite) weakremover(ruby2.4-rubygem-rspec) weakremover(ruby2.4-rubygem-rspec-core) weakremover(ruby2.4-rubygem-rspec-core-doc) weakremover(ruby2.4-rubygem-rspec-doc) weakremover(ruby2.4-rubygem-rspec-expectations) weakremover(ruby2.4-rubygem-rspec-expectations-doc) weakremover(ruby2.4-rubygem-rspec-mocks) weakremover(ruby2.4-rubygem-rspec-mocks-doc) weakremover(ruby2.4-rubygem-rspec-puppet) weakremover(ruby2.4-rubygem-rspec-puppet-doc) weakremover(ruby2.4-rubygem-rspec-support) weakremover(ruby2.4-rubygem-rspec-support-doc) weakremover(ruby2.4-rubygem-ruby-augeas) weakremover(ruby2.4-rubygem-ruby-augeas-doc) weakremover(ruby2.4-rubygem-ruby-libvirt) weakremover(ruby2.4-rubygem-ruby-libvirt-doc) weakremover(ruby2.4-rubygem-ruby-shadow) weakremover(ruby2.4-rubygem-ruby-shadow-doc) weakremover(ruby2.4-rubygem-ruby_dep) weakremover(ruby2.4-rubygem-ruby_dep-doc) weakremover(ruby2.4-rubygem-ruby_parser) weakremover(ruby2.4-rubygem-ruby_parser-doc) weakremover(ruby2.4-rubygem-ruby_parser-testsuite) weakremover(ruby2.4-rubygem-rubyforge) weakremover(ruby2.4-rubygem-rubyforge-doc) weakremover(ruby2.4-rubygem-rubyforge-testsuite) weakremover(ruby2.4-rubygem-rubyzip) weakremover(ruby2.4-rubygem-rubyzip-doc) weakremover(ruby2.4-rubygem-rubyzip-testsuite) weakremover(ruby2.4-rubygem-safe_yaml) weakremover(ruby2.4-rubygem-safe_yaml-doc) weakremover(ruby2.4-rubygem-safe_yaml-testsuite) weakremover(ruby2.4-rubygem-sass) weakremover(ruby2.4-rubygem-sass-doc) weakremover(ruby2.4-rubygem-sass-rails) weakremover(ruby2.4-rubygem-sass-rails-doc) weakremover(ruby2.4-rubygem-sass-testsuite) weakremover(ruby2.4-rubygem-sdoc) weakremover(ruby2.4-rubygem-sdoc-doc) weakremover(ruby2.4-rubygem-sdoc-testsuite) weakremover(ruby2.4-rubygem-semantic_puppet) weakremover(ruby2.4-rubygem-semantic_puppet-doc) weakremover(ruby2.4-rubygem-semantic_puppet-testsuite) weakremover(ruby2.4-rubygem-serverengine) weakremover(ruby2.4-rubygem-serverengine-doc) weakremover(ruby2.4-rubygem-serverengine-testsuite) weakremover(ruby2.4-rubygem-sexp_processor) weakremover(ruby2.4-rubygem-sexp_processor-doc) weakremover(ruby2.4-rubygem-sexp_processor-testsuite) weakremover(ruby2.4-rubygem-sigdump) weakremover(ruby2.4-rubygem-sigdump-doc) weakremover(ruby2.4-rubygem-simple_oauth) weakremover(ruby2.4-rubygem-simple_oauth-doc) weakremover(ruby2.4-rubygem-simplecov) weakremover(ruby2.4-rubygem-simplecov-doc) weakremover(ruby2.4-rubygem-simplecov-html) weakremover(ruby2.4-rubygem-simplecov-html-doc) weakremover(ruby2.4-rubygem-simplecov-html-testsuite) weakremover(ruby2.4-rubygem-simplecov-testsuite) weakremover(ruby2.4-rubygem-sinatra) weakremover(ruby2.4-rubygem-sinatra-doc) weakremover(ruby2.4-rubygem-sinatra-testsuite) weakremover(ruby2.4-rubygem-slop) weakremover(ruby2.4-rubygem-slop-3) weakremover(ruby2.4-rubygem-slop-3_3) weakremover(ruby2.4-rubygem-slop-doc) weakremover(ruby2.4-rubygem-slop-doc-3) weakremover(ruby2.4-rubygem-slop-doc-3_3) weakremover(ruby2.4-rubygem-slop-testsuite) weakremover(ruby2.4-rubygem-slop-testsuite-3) weakremover(ruby2.4-rubygem-slop-testsuite-3_3) weakremover(ruby2.4-rubygem-spring) weakremover(ruby2.4-rubygem-spring-doc) weakremover(ruby2.4-rubygem-spring-watcher-listen) weakremover(ruby2.4-rubygem-spring-watcher-listen-doc) weakremover(ruby2.4-rubygem-spring-watcher-listen-testsuite) weakremover(ruby2.4-rubygem-sprockets) weakremover(ruby2.4-rubygem-sprockets-2_1) weakremover(ruby2.4-rubygem-sprockets-2_2) weakremover(ruby2.4-rubygem-sprockets-doc) weakremover(ruby2.4-rubygem-sprockets-doc-2_1) weakremover(ruby2.4-rubygem-sprockets-doc-2_2) weakremover(ruby2.4-rubygem-sprockets-helpers) weakremover(ruby2.4-rubygem-sprockets-helpers-doc) weakremover(ruby2.4-rubygem-sprockets-helpers-testsuite) weakremover(ruby2.4-rubygem-sprockets-rails) weakremover(ruby2.4-rubygem-sprockets-rails-doc) weakremover(ruby2.4-rubygem-sqlite3) weakremover(ruby2.4-rubygem-sqlite3-doc) weakremover(ruby2.4-rubygem-sqlite3-testsuite) weakremover(ruby2.4-rubygem-sshkit) weakremover(ruby2.4-rubygem-sshkit-doc) weakremover(ruby2.4-rubygem-sshkit-testsuite) weakremover(ruby2.4-rubygem-stackdeck) weakremover(ruby2.4-rubygem-stackdeck-doc) weakremover(ruby2.4-rubygem-stackdeck-testsuite) weakremover(ruby2.4-rubygem-stomp) weakremover(ruby2.4-rubygem-stomp-doc) weakremover(ruby2.4-rubygem-stomp-testsuite) weakremover(ruby2.4-rubygem-strptime) weakremover(ruby2.4-rubygem-strptime-doc) weakremover(ruby2.4-rubygem-studio_api) weakremover(ruby2.4-rubygem-studio_api-doc) weakremover(ruby2.4-rubygem-studio_api-testsuite) weakremover(ruby2.4-rubygem-systemu) weakremover(ruby2.4-rubygem-systemu-doc) weakremover(ruby2.4-rubygem-systemu-testsuite) weakremover(ruby2.4-rubygem-taskjuggler) weakremover(ruby2.4-rubygem-taskjuggler-doc) weakremover(ruby2.4-rubygem-taskjuggler-testsuite) weakremover(ruby2.4-rubygem-term-ansicolor) weakremover(ruby2.4-rubygem-term-ansicolor-doc) weakremover(ruby2.4-rubygem-test-unit) weakremover(ruby2.4-rubygem-test-unit-doc) weakremover(ruby2.4-rubygem-test-unit-testsuite) weakremover(ruby2.4-rubygem-text) weakremover(ruby2.4-rubygem-text-doc) weakremover(ruby2.4-rubygem-text-hyphen) weakremover(ruby2.4-rubygem-text-hyphen-doc) weakremover(ruby2.4-rubygem-text-hyphen-testsuite) weakremover(ruby2.4-rubygem-text-testsuite) weakremover(ruby2.4-rubygem-thor) weakremover(ruby2.4-rubygem-thor-doc) weakremover(ruby2.4-rubygem-thor-testsuite) weakremover(ruby2.4-rubygem-thread_safe) weakremover(ruby2.4-rubygem-thread_safe-doc) weakremover(ruby2.4-rubygem-thread_safe-testsuite) weakremover(ruby2.4-rubygem-tilt-1_1) weakremover(ruby2.4-rubygem-tilt-1_4) weakremover(ruby2.4-rubygem-tilt-doc-1_1) weakremover(ruby2.4-rubygem-tilt-doc-1_4) weakremover(ruby2.4-rubygem-tilt-testsuite-1_1) weakremover(ruby2.4-rubygem-tilt-testsuite-1_4) weakremover(ruby2.4-rubygem-timers) weakremover(ruby2.4-rubygem-timers-doc) weakremover(ruby2.4-rubygem-timers-testsuite) weakremover(ruby2.4-rubygem-tins) weakremover(ruby2.4-rubygem-tins-doc) weakremover(ruby2.4-rubygem-treetop) weakremover(ruby2.4-rubygem-treetop-1_4) weakremover(ruby2.4-rubygem-treetop-doc) weakremover(ruby2.4-rubygem-treetop-doc-1_4) weakremover(ruby2.4-rubygem-treetop-testsuite) weakremover(ruby2.4-rubygem-treetop-testsuite-1_4) weakremover(ruby2.4-rubygem-trollop) weakremover(ruby2.4-rubygem-trollop-doc) weakremover(ruby2.4-rubygem-trollop-testsuite) weakremover(ruby2.4-rubygem-turbolinks) weakremover(ruby2.4-rubygem-turbolinks-doc) weakremover(ruby2.4-rubygem-turbolinks-source) weakremover(ruby2.4-rubygem-turbolinks-source-doc) weakremover(ruby2.4-rubygem-turbolinks-testsuite) weakremover(ruby2.4-rubygem-tzinfo) weakremover(ruby2.4-rubygem-tzinfo-0) weakremover(ruby2.4-rubygem-tzinfo-data) weakremover(ruby2.4-rubygem-tzinfo-data-doc) weakremover(ruby2.4-rubygem-tzinfo-doc) weakremover(ruby2.4-rubygem-tzinfo-doc-0) weakremover(ruby2.4-rubygem-tzinfo-testsuite) weakremover(ruby2.4-rubygem-tzinfo-testsuite-0) weakremover(ruby2.4-rubygem-uglifier) weakremover(ruby2.4-rubygem-uglifier-doc) weakremover(ruby2.4-rubygem-uglifier-testsuite) weakremover(ruby2.4-rubygem-unicorn) weakremover(ruby2.4-rubygem-unicorn-doc) weakremover(ruby2.4-rubygem-unicorn-testsuite) weakremover(ruby2.4-rubygem-virtus) weakremover(ruby2.4-rubygem-virtus-doc) weakremover(ruby2.4-rubygem-virtus-testsuite) weakremover(ruby2.4-rubygem-web-console) weakremover(ruby2.4-rubygem-web-console-2) weakremover(ruby2.4-rubygem-web-console-doc) weakremover(ruby2.4-rubygem-web-console-doc-2) weakremover(ruby2.4-rubygem-websocket) weakremover(ruby2.4-rubygem-websocket-doc) weakremover(ruby2.4-rubygem-websocket-driver) weakremover(ruby2.4-rubygem-websocket-driver-doc) weakremover(ruby2.4-rubygem-websocket-extensions) weakremover(ruby2.4-rubygem-websocket-extensions-doc) weakremover(ruby2.4-rubygem-websocket-testsuite) weakremover(ruby2.4-rubygem-xml-simple) weakremover(ruby2.4-rubygem-xml-simple-doc) weakremover(ruby2.4-rubygem-xmlhash) weakremover(ruby2.4-rubygem-xmlhash-doc) weakremover(ruby2.4-rubygem-xmlhash-testsuite) weakremover(ruby2.4-rubygem-yajl-ruby) weakremover(ruby2.4-rubygem-yajl-ruby-doc) weakremover(ruby2.4-rubygem-yajl-ruby-testsuite) weakremover(ruby2.4-rubygem-yard) weakremover(ruby2.4-rubygem-yard-doc) weakremover(ruby2.4-rubygem-yard-testsuite) weakremover(ruby2.4-rubygem-yast-rake) weakremover(ruby2.4-rubygem-yast-rake-doc) weakremover(ruby2.4-stdlib) weakremover(ruby2.5) weakremover(ruby2.5-devel) weakremover(ruby2.5-devel-extra) weakremover(ruby2.5-doc) weakremover(ruby2.5-doc-ri) weakremover(ruby2.5-rubygem-RedCloth) weakremover(ruby2.5-rubygem-RedCloth-doc) weakremover(ruby2.5-rubygem-RedCloth-testsuite) weakremover(ruby2.5-rubygem-abstract) weakremover(ruby2.5-rubygem-abstract-doc) weakremover(ruby2.5-rubygem-abstract-testsuite) weakremover(ruby2.5-rubygem-abstract_method) weakremover(ruby2.5-rubygem-abstract_method-doc) weakremover(ruby2.5-rubygem-actioncable-5.2) weakremover(ruby2.5-rubygem-actioncable-5_0) weakremover(ruby2.5-rubygem-actioncable-5_1) weakremover(ruby2.5-rubygem-actioncable-doc-5.2) weakremover(ruby2.5-rubygem-actioncable-doc-5_0) weakremover(ruby2.5-rubygem-actioncable-doc-5_1) weakremover(ruby2.5-rubygem-actionmailer-4_2) weakremover(ruby2.5-rubygem-actionmailer-5.2) weakremover(ruby2.5-rubygem-actionmailer-5_0) weakremover(ruby2.5-rubygem-actionmailer-5_1) weakremover(ruby2.5-rubygem-actionmailer-doc-4_2) weakremover(ruby2.5-rubygem-actionmailer-doc-5.2) weakremover(ruby2.5-rubygem-actionmailer-doc-5_0) weakremover(ruby2.5-rubygem-actionmailer-doc-5_1) weakremover(ruby2.5-rubygem-actionpack-4_2) weakremover(ruby2.5-rubygem-actionpack-5.2) weakremover(ruby2.5-rubygem-actionpack-5_0) weakremover(ruby2.5-rubygem-actionpack-5_1) weakremover(ruby2.5-rubygem-actionpack-doc-4_2) weakremover(ruby2.5-rubygem-actionpack-doc-5.2) weakremover(ruby2.5-rubygem-actionpack-doc-5_0) weakremover(ruby2.5-rubygem-actionpack-doc-5_1) weakremover(ruby2.5-rubygem-actionview-4_2) weakremover(ruby2.5-rubygem-actionview-5.2) weakremover(ruby2.5-rubygem-actionview-5_0) weakremover(ruby2.5-rubygem-actionview-5_1) weakremover(ruby2.5-rubygem-actionview-doc-4_2) weakremover(ruby2.5-rubygem-actionview-doc-5.2) weakremover(ruby2.5-rubygem-actionview-doc-5_0) weakremover(ruby2.5-rubygem-actionview-doc-5_1) weakremover(ruby2.5-rubygem-activejob-4_2) weakremover(ruby2.5-rubygem-activejob-5.2) weakremover(ruby2.5-rubygem-activejob-5_0) weakremover(ruby2.5-rubygem-activejob-5_1) weakremover(ruby2.5-rubygem-activejob-doc-4_2) weakremover(ruby2.5-rubygem-activejob-doc-5.2) weakremover(ruby2.5-rubygem-activejob-doc-5_0) weakremover(ruby2.5-rubygem-activejob-doc-5_1) weakremover(ruby2.5-rubygem-activemodel-4_2) weakremover(ruby2.5-rubygem-activemodel-5.2) weakremover(ruby2.5-rubygem-activemodel-5_0) weakremover(ruby2.5-rubygem-activemodel-5_1) weakremover(ruby2.5-rubygem-activemodel-doc-4_2) weakremover(ruby2.5-rubygem-activemodel-doc-5.2) weakremover(ruby2.5-rubygem-activemodel-doc-5_0) weakremover(ruby2.5-rubygem-activemodel-doc-5_1) weakremover(ruby2.5-rubygem-activerecord-4_2) weakremover(ruby2.5-rubygem-activerecord-5.2) weakremover(ruby2.5-rubygem-activerecord-5_0) weakremover(ruby2.5-rubygem-activerecord-5_1) weakremover(ruby2.5-rubygem-activerecord-deprecated_finders) weakremover(ruby2.5-rubygem-activerecord-deprecated_finders-doc) weakremover(ruby2.5-rubygem-activerecord-doc-4_2) weakremover(ruby2.5-rubygem-activerecord-doc-5.2) weakremover(ruby2.5-rubygem-activerecord-doc-5_0) weakremover(ruby2.5-rubygem-activestorage-5.2) weakremover(ruby2.5-rubygem-activestorage-doc-5.2) weakremover(ruby2.5-rubygem-activesupport-4_2) weakremover(ruby2.5-rubygem-activesupport-5.2) weakremover(ruby2.5-rubygem-activesupport-5_0) weakremover(ruby2.5-rubygem-activesupport-5_1) weakremover(ruby2.5-rubygem-activesupport-doc-4_2) weakremover(ruby2.5-rubygem-activesupport-doc-5.2) weakremover(ruby2.5-rubygem-activesupport-doc-5_0) weakremover(ruby2.5-rubygem-activesupport-doc-5_1) weakremover(ruby2.5-rubygem-addressable) weakremover(ruby2.5-rubygem-addressable-2_3) weakremover(ruby2.5-rubygem-addressable-doc) weakremover(ruby2.5-rubygem-addressable-doc-2_3) weakremover(ruby2.5-rubygem-addressable-testsuite) weakremover(ruby2.5-rubygem-addressable-testsuite-2_3) weakremover(ruby2.5-rubygem-aes_key_wrap) weakremover(ruby2.5-rubygem-aes_key_wrap-doc) weakremover(ruby2.5-rubygem-airbrussh) weakremover(ruby2.5-rubygem-airbrussh-doc) weakremover(ruby2.5-rubygem-amq-protocol) weakremover(ruby2.5-rubygem-amq-protocol-doc) weakremover(ruby2.5-rubygem-amq-protocol-testsuite) weakremover(ruby2.5-rubygem-amqp) weakremover(ruby2.5-rubygem-amqp-doc) weakremover(ruby2.5-rubygem-amqp-testsuite) weakremover(ruby2.5-rubygem-archive-tar-minitar) weakremover(ruby2.5-rubygem-archive-tar-minitar-doc) weakremover(ruby2.5-rubygem-arel) weakremover(ruby2.5-rubygem-arel-3_0) weakremover(ruby2.5-rubygem-arel-6) weakremover(ruby2.5-rubygem-arel-7) weakremover(ruby2.5-rubygem-arel-8) weakremover(ruby2.5-rubygem-arel-9) weakremover(ruby2.5-rubygem-arel-doc) weakremover(ruby2.5-rubygem-arel-doc-3_0) weakremover(ruby2.5-rubygem-arel-doc-6) weakremover(ruby2.5-rubygem-arel-doc-7) weakremover(ruby2.5-rubygem-arel-doc-8) weakremover(ruby2.5-rubygem-arel-doc-9) weakremover(ruby2.5-rubygem-arel-testsuite-3_0) weakremover(ruby2.5-rubygem-asciidoctor) weakremover(ruby2.5-rubygem-asciidoctor-doc) weakremover(ruby2.5-rubygem-asciidoctor-testsuite) weakremover(ruby2.5-rubygem-atomic) weakremover(ruby2.5-rubygem-atomic-doc) weakremover(ruby2.5-rubygem-atomic-testsuite) weakremover(ruby2.5-rubygem-attr_required) weakremover(ruby2.5-rubygem-attr_required-doc) weakremover(ruby2.5-rubygem-attr_required-testsuite) weakremover(ruby2.5-rubygem-autoprefixer-rails) weakremover(ruby2.5-rubygem-autoprefixer-rails-doc) weakremover(ruby2.5-rubygem-autoprefixer-rails-testsuite) weakremover(ruby2.5-rubygem-axiom-types) weakremover(ruby2.5-rubygem-axiom-types-doc) weakremover(ruby2.5-rubygem-axiom-types-testsuite) weakremover(ruby2.5-rubygem-base32) weakremover(ruby2.5-rubygem-base32-doc) weakremover(ruby2.5-rubygem-base32-testsuite) weakremover(ruby2.5-rubygem-bcrypt) weakremover(ruby2.5-rubygem-bcrypt-doc) weakremover(ruby2.5-rubygem-bcrypt-ruby) weakremover(ruby2.5-rubygem-bcrypt-ruby-doc) weakremover(ruby2.5-rubygem-bcrypt-testsuite) weakremover(ruby2.5-rubygem-bcrypt_pbkdf) weakremover(ruby2.5-rubygem-bcrypt_pbkdf-doc) weakremover(ruby2.5-rubygem-bcrypt_pbkdf-testsuite) weakremover(ruby2.5-rubygem-bindata) weakremover(ruby2.5-rubygem-bindata-doc) weakremover(ruby2.5-rubygem-bindata-testsuite) weakremover(ruby2.5-rubygem-bindex) weakremover(ruby2.5-rubygem-bindex-doc) weakremover(ruby2.5-rubygem-bindex-testsuite) weakremover(ruby2.5-rubygem-binding_of_caller) weakremover(ruby2.5-rubygem-binding_of_caller-doc) weakremover(ruby2.5-rubygem-binding_of_caller-testsuite) weakremover(ruby2.5-rubygem-bootsnap) weakremover(ruby2.5-rubygem-bootsnap-doc) weakremover(ruby2.5-rubygem-bootstrap-sass) weakremover(ruby2.5-rubygem-bootstrap-sass-doc) weakremover(ruby2.5-rubygem-bootstrap-sass-testsuite) weakremover(ruby2.5-rubygem-buff-extensions) weakremover(ruby2.5-rubygem-buff-extensions-doc) weakremover(ruby2.5-rubygem-buff-extensions-testsuite) weakremover(ruby2.5-rubygem-buff-ignore) weakremover(ruby2.5-rubygem-buff-ignore-doc) weakremover(ruby2.5-rubygem-buff-ignore-testsuite) weakremover(ruby2.5-rubygem-buff-ruby_engine) weakremover(ruby2.5-rubygem-buff-ruby_engine-doc) weakremover(ruby2.5-rubygem-buff-ruby_engine-testsuite) weakremover(ruby2.5-rubygem-builder) weakremover(ruby2.5-rubygem-builder-doc) weakremover(ruby2.5-rubygem-builder-testsuite) weakremover(ruby2.5-rubygem-bundler) weakremover(ruby2.5-rubygem-bundler-audit) weakremover(ruby2.5-rubygem-bundler-audit-doc) weakremover(ruby2.5-rubygem-bundler-audit-testsuite) weakremover(ruby2.5-rubygem-bundler-doc) weakremover(ruby2.5-rubygem-bunny) weakremover(ruby2.5-rubygem-bunny-doc) weakremover(ruby2.5-rubygem-bunny-testsuite) weakremover(ruby2.5-rubygem-byebug) weakremover(ruby2.5-rubygem-byebug-doc) weakremover(ruby2.5-rubygem-capistrano) weakremover(ruby2.5-rubygem-capistrano-doc) weakremover(ruby2.5-rubygem-capistrano-harrow) weakremover(ruby2.5-rubygem-capistrano-harrow-doc) weakremover(ruby2.5-rubygem-capistrano-stats) weakremover(ruby2.5-rubygem-capistrano-stats-doc) weakremover(ruby2.5-rubygem-capistrano-testsuite) weakremover(ruby2.5-rubygem-celluloid) weakremover(ruby2.5-rubygem-celluloid-doc) weakremover(ruby2.5-rubygem-celluloid-testsuite) weakremover(ruby2.5-rubygem-cfa) weakremover(ruby2.5-rubygem-cfa-doc) weakremover(ruby2.5-rubygem-cfa_grub2) weakremover(ruby2.5-rubygem-cfa_grub2-doc) weakremover(ruby2.5-rubygem-changelog_generator) weakremover(ruby2.5-rubygem-changelog_generator-doc) weakremover(ruby2.5-rubygem-changelog_generator-testsuite) weakremover(ruby2.5-rubygem-cheetah) weakremover(ruby2.5-rubygem-cheetah-doc) weakremover(ruby2.5-rubygem-childprocess) weakremover(ruby2.5-rubygem-childprocess-0_6) weakremover(ruby2.5-rubygem-childprocess-doc) weakremover(ruby2.5-rubygem-childprocess-doc-0_6) weakremover(ruby2.5-rubygem-childprocess-testsuite) weakremover(ruby2.5-rubygem-childprocess-testsuite-0_6) weakremover(ruby2.5-rubygem-ci_reporter) weakremover(ruby2.5-rubygem-ci_reporter-doc) weakremover(ruby2.5-rubygem-ci_reporter-testsuite) weakremover(ruby2.5-rubygem-cleanroom) weakremover(ruby2.5-rubygem-cleanroom-doc) weakremover(ruby2.5-rubygem-cleanroom-testsuite) weakremover(ruby2.5-rubygem-coderay) weakremover(ruby2.5-rubygem-coderay-doc) weakremover(ruby2.5-rubygem-coercible) weakremover(ruby2.5-rubygem-coercible-doc) weakremover(ruby2.5-rubygem-coercible-testsuite) weakremover(ruby2.5-rubygem-coffee-rails) weakremover(ruby2.5-rubygem-coffee-rails-doc) weakremover(ruby2.5-rubygem-coffee-script) weakremover(ruby2.5-rubygem-coffee-script-doc) weakremover(ruby2.5-rubygem-coffee-script-source) weakremover(ruby2.5-rubygem-coffee-script-source-doc) weakremover(ruby2.5-rubygem-colorator) weakremover(ruby2.5-rubygem-colorator-0) weakremover(ruby2.5-rubygem-colorator-doc) weakremover(ruby2.5-rubygem-colorator-doc-0) weakremover(ruby2.5-rubygem-colorator-testsuite-0) weakremover(ruby2.5-rubygem-colored) weakremover(ruby2.5-rubygem-colored-doc) weakremover(ruby2.5-rubygem-colored-testsuite) weakremover(ruby2.5-rubygem-colorize) weakremover(ruby2.5-rubygem-colorize-doc) weakremover(ruby2.5-rubygem-colorize-testsuite) weakremover(ruby2.5-rubygem-columnize) weakremover(ruby2.5-rubygem-columnize-doc) weakremover(ruby2.5-rubygem-columnize-testsuite) weakremover(ruby2.5-rubygem-commander) weakremover(ruby2.5-rubygem-commander-doc) weakremover(ruby2.5-rubygem-commander-testsuite) weakremover(ruby2.5-rubygem-concurrent-ruby) weakremover(ruby2.5-rubygem-concurrent-ruby-doc) weakremover(ruby2.5-rubygem-cool.io) weakremover(ruby2.5-rubygem-cool.io-doc) weakremover(ruby2.5-rubygem-cool.io-testsuite) weakremover(ruby2.5-rubygem-crack) weakremover(ruby2.5-rubygem-crack-doc) weakremover(ruby2.5-rubygem-crack-testsuite) weakremover(ruby2.5-rubygem-crass) weakremover(ruby2.5-rubygem-crass-doc) weakremover(ruby2.5-rubygem-crass-testsuite) weakremover(ruby2.5-rubygem-cri) weakremover(ruby2.5-rubygem-cri-doc) weakremover(ruby2.5-rubygem-cri-testsuite) weakremover(ruby2.5-rubygem-cssmin) weakremover(ruby2.5-rubygem-cssmin-doc) weakremover(ruby2.5-rubygem-daemon_controller) weakremover(ruby2.5-rubygem-daemon_controller-doc) weakremover(ruby2.5-rubygem-daemon_controller-testsuite) weakremover(ruby2.5-rubygem-daemons) weakremover(ruby2.5-rubygem-daemons-doc) weakremover(ruby2.5-rubygem-debug_inspector) weakremover(ruby2.5-rubygem-debug_inspector-doc) weakremover(ruby2.5-rubygem-debug_inspector-testsuite) weakremover(ruby2.5-rubygem-debugger-linecache) weakremover(ruby2.5-rubygem-debugger-linecache-doc) weakremover(ruby2.5-rubygem-debugger-linecache-testsuite) weakremover(ruby2.5-rubygem-deep_merge) weakremover(ruby2.5-rubygem-deep_merge-doc) weakremover(ruby2.5-rubygem-deep_merge-testsuite) weakremover(ruby2.5-rubygem-delayed_job) weakremover(ruby2.5-rubygem-delayed_job-doc) weakremover(ruby2.5-rubygem-delayed_job-testsuite) weakremover(ruby2.5-rubygem-delayed_job_active_record) weakremover(ruby2.5-rubygem-delayed_job_active_record-doc) weakremover(ruby2.5-rubygem-descendants_tracker) weakremover(ruby2.5-rubygem-descendants_tracker-doc) weakremover(ruby2.5-rubygem-descendants_tracker-testsuite) weakremover(ruby2.5-rubygem-devise) weakremover(ruby2.5-rubygem-devise-doc) weakremover(ruby2.5-rubygem-devise-i18n) weakremover(ruby2.5-rubygem-devise-i18n-doc) weakremover(ruby2.5-rubygem-devise-testsuite) weakremover(ruby2.5-rubygem-devise_ldap_authenticatable) weakremover(ruby2.5-rubygem-devise_ldap_authenticatable-doc) weakremover(ruby2.5-rubygem-devise_ldap_authenticatable-testsuite) weakremover(ruby2.5-rubygem-dice) weakremover(ruby2.5-rubygem-dice-doc) weakremover(ruby2.5-rubygem-diff-lcs) weakremover(ruby2.5-rubygem-diff-lcs-doc) weakremover(ruby2.5-rubygem-diff-lcs-testsuite) weakremover(ruby2.5-rubygem-diffy) weakremover(ruby2.5-rubygem-diffy-doc) weakremover(ruby2.5-rubygem-diffy-testsuite) weakremover(ruby2.5-rubygem-dig_rb) weakremover(ruby2.5-rubygem-dig_rb-doc) weakremover(ruby2.5-rubygem-docile) weakremover(ruby2.5-rubygem-docile-1_1) weakremover(ruby2.5-rubygem-docile-doc) weakremover(ruby2.5-rubygem-docile-doc-1_1) weakremover(ruby2.5-rubygem-docile-testsuite-1_1) weakremover(ruby2.5-rubygem-domain_name) weakremover(ruby2.5-rubygem-domain_name-doc) weakremover(ruby2.5-rubygem-domain_name-testsuite) weakremover(ruby2.5-rubygem-ed25519) weakremover(ruby2.5-rubygem-ed25519-doc) weakremover(ruby2.5-rubygem-em-websocket) weakremover(ruby2.5-rubygem-em-websocket-doc) weakremover(ruby2.5-rubygem-em-websocket-testsuite) weakremover(ruby2.5-rubygem-equalizer) weakremover(ruby2.5-rubygem-equalizer-doc) weakremover(ruby2.5-rubygem-equalizer-testsuite) weakremover(ruby2.5-rubygem-erubi) weakremover(ruby2.5-rubygem-erubi-doc) weakremover(ruby2.5-rubygem-erubi-testsuite) weakremover(ruby2.5-rubygem-erubis) weakremover(ruby2.5-rubygem-erubis-2_6) weakremover(ruby2.5-rubygem-erubis-doc) weakremover(ruby2.5-rubygem-erubis-doc-2_6) weakremover(ruby2.5-rubygem-erubis-testsuite) weakremover(ruby2.5-rubygem-erubis-testsuite-2_6) weakremover(ruby2.5-rubygem-eventmachine) weakremover(ruby2.5-rubygem-eventmachine-doc) weakremover(ruby2.5-rubygem-exception_notification) weakremover(ruby2.5-rubygem-exception_notification-doc) weakremover(ruby2.5-rubygem-exception_notification-testsuite) weakremover(ruby2.5-rubygem-excon) weakremover(ruby2.5-rubygem-excon-doc) weakremover(ruby2.5-rubygem-excon-testsuite) weakremover(ruby2.5-rubygem-execjs) weakremover(ruby2.5-rubygem-execjs-doc) weakremover(ruby2.5-rubygem-extlib) weakremover(ruby2.5-rubygem-extlib-doc) weakremover(ruby2.5-rubygem-extlib-testsuite) weakremover(ruby2.5-rubygem-factory_girl) weakremover(ruby2.5-rubygem-factory_girl-doc) weakremover(ruby2.5-rubygem-factory_girl_rails) weakremover(ruby2.5-rubygem-factory_girl_rails-doc) weakremover(ruby2.5-rubygem-fake_ftp) weakremover(ruby2.5-rubygem-fake_ftp-0_1) weakremover(ruby2.5-rubygem-fake_ftp-doc) weakremover(ruby2.5-rubygem-fake_ftp-doc-0_1) weakremover(ruby2.5-rubygem-fake_ftp-testsuite) weakremover(ruby2.5-rubygem-fake_ftp-testsuite-0_1) weakremover(ruby2.5-rubygem-faraday) weakremover(ruby2.5-rubygem-faraday-0_12) weakremover(ruby2.5-rubygem-faraday-doc) weakremover(ruby2.5-rubygem-faraday-doc-0_12) weakremover(ruby2.5-rubygem-faraday_middleware) weakremover(ruby2.5-rubygem-faraday_middleware-doc) weakremover(ruby2.5-rubygem-faraday_middleware-multi_json) weakremover(ruby2.5-rubygem-faraday_middleware-multi_json-doc) weakremover(ruby2.5-rubygem-faraday_middleware-multi_json-testsuite) weakremover(ruby2.5-rubygem-fast_gettext) weakremover(ruby2.5-rubygem-fast_gettext-doc) weakremover(ruby2.5-rubygem-fast_xs) weakremover(ruby2.5-rubygem-fast_xs-doc) weakremover(ruby2.5-rubygem-fast_xs-testsuite) weakremover(ruby2.5-rubygem-fastercsv) weakremover(ruby2.5-rubygem-fastercsv-doc) weakremover(ruby2.5-rubygem-fastercsv-testsuite) weakremover(ruby2.5-rubygem-ffi) weakremover(ruby2.5-rubygem-ffi-doc) weakremover(ruby2.5-rubygem-ffi-testsuite) weakremover(ruby2.5-rubygem-file-tail) weakremover(ruby2.5-rubygem-file-tail-doc) weakremover(ruby2.5-rubygem-flog) weakremover(ruby2.5-rubygem-flog-doc) weakremover(ruby2.5-rubygem-flog-testsuite) weakremover(ruby2.5-rubygem-fluentd) weakremover(ruby2.5-rubygem-fluentd-doc) weakremover(ruby2.5-rubygem-fluentd-testsuite) weakremover(ruby2.5-rubygem-font-awesome-rails) weakremover(ruby2.5-rubygem-font-awesome-rails-doc) weakremover(ruby2.5-rubygem-font-awesome-rails-testsuite) weakremover(ruby2.5-rubygem-forwardable-extended) weakremover(ruby2.5-rubygem-forwardable-extended-doc) weakremover(ruby2.5-rubygem-gem2rpm) weakremover(ruby2.5-rubygem-gem2rpm-doc) weakremover(ruby2.5-rubygem-get_process_mem) weakremover(ruby2.5-rubygem-get_process_mem-doc) weakremover(ruby2.5-rubygem-get_process_mem-testsuite) weakremover(ruby2.5-rubygem-gettext) weakremover(ruby2.5-rubygem-gettext-doc) weakremover(ruby2.5-rubygem-gettext-setup) weakremover(ruby2.5-rubygem-gettext-setup-doc) weakremover(ruby2.5-rubygem-gettext-setup-testsuite) weakremover(ruby2.5-rubygem-gettext-testsuite) weakremover(ruby2.5-rubygem-gettext_i18n_rails) weakremover(ruby2.5-rubygem-gettext_i18n_rails-doc) weakremover(ruby2.5-rubygem-gettext_i18n_rails_js) weakremover(ruby2.5-rubygem-gettext_i18n_rails_js-doc) weakremover(ruby2.5-rubygem-gettext_i18n_rails_js-testsuite) weakremover(ruby2.5-rubygem-gli) weakremover(ruby2.5-rubygem-gli-doc) weakremover(ruby2.5-rubygem-gli-testsuite) weakremover(ruby2.5-rubygem-globalid) weakremover(ruby2.5-rubygem-globalid-doc) weakremover(ruby2.5-rubygem-gpgme) weakremover(ruby2.5-rubygem-gpgme-doc) weakremover(ruby2.5-rubygem-gpgme-testsuite) weakremover(ruby2.5-rubygem-grape) weakremover(ruby2.5-rubygem-grape-doc) weakremover(ruby2.5-rubygem-grape-testsuite) weakremover(ruby2.5-rubygem-gravatar_image_tag) weakremover(ruby2.5-rubygem-gravatar_image_tag-doc) weakremover(ruby2.5-rubygem-gravatar_image_tag-testsuite) weakremover(ruby2.5-rubygem-gssapi) weakremover(ruby2.5-rubygem-gssapi-doc) weakremover(ruby2.5-rubygem-gssapi-testsuite) weakremover(ruby2.5-rubygem-gyoku) weakremover(ruby2.5-rubygem-gyoku-doc) weakremover(ruby2.5-rubygem-gyoku-testsuite) weakremover(ruby2.5-rubygem-haml) weakremover(ruby2.5-rubygem-haml-doc) weakremover(ruby2.5-rubygem-haml-rails) weakremover(ruby2.5-rubygem-haml-rails-doc) weakremover(ruby2.5-rubygem-haml-rails-testsuite) weakremover(ruby2.5-rubygem-has_mobile_views) weakremover(ruby2.5-rubygem-has_mobile_views-doc) weakremover(ruby2.5-rubygem-has_mobile_views-testsuite) weakremover(ruby2.5-rubygem-hashdiff) weakremover(ruby2.5-rubygem-hashdiff-doc) weakremover(ruby2.5-rubygem-hashdiff-testsuite) weakremover(ruby2.5-rubygem-hashicorp-checkpoint) weakremover(ruby2.5-rubygem-hashicorp-checkpoint-doc) weakremover(ruby2.5-rubygem-hashicorp-checkpoint-testsuite) weakremover(ruby2.5-rubygem-hashie) weakremover(ruby2.5-rubygem-hashie-doc) weakremover(ruby2.5-rubygem-hashie-testsuite) weakremover(ruby2.5-rubygem-highline) weakremover(ruby2.5-rubygem-highline-1_6) weakremover(ruby2.5-rubygem-highline-1_7) weakremover(ruby2.5-rubygem-highline-doc) weakremover(ruby2.5-rubygem-highline-doc-1_6) weakremover(ruby2.5-rubygem-highline-doc-1_7) weakremover(ruby2.5-rubygem-highline-testsuite) weakremover(ruby2.5-rubygem-highline-testsuite-1_6) weakremover(ruby2.5-rubygem-highline-testsuite-1_7) weakremover(ruby2.5-rubygem-hike) weakremover(ruby2.5-rubygem-hike-1_2) weakremover(ruby2.5-rubygem-hike-doc) weakremover(ruby2.5-rubygem-hike-doc-1_2) weakremover(ruby2.5-rubygem-hitimes) weakremover(ruby2.5-rubygem-hitimes-doc) weakremover(ruby2.5-rubygem-hitimes-testsuite) weakremover(ruby2.5-rubygem-hoe) weakremover(ruby2.5-rubygem-hoe-doc) weakremover(ruby2.5-rubygem-hoe-testsuite) weakremover(ruby2.5-rubygem-hpricot) weakremover(ruby2.5-rubygem-hpricot-doc) weakremover(ruby2.5-rubygem-hpricot-testsuite) weakremover(ruby2.5-rubygem-html2haml) weakremover(ruby2.5-rubygem-html2haml-doc) weakremover(ruby2.5-rubygem-html2haml-testsuite) weakremover(ruby2.5-rubygem-http-cookie) weakremover(ruby2.5-rubygem-http-cookie-doc) weakremover(ruby2.5-rubygem-http-cookie-testsuite) weakremover(ruby2.5-rubygem-http_accept_language) weakremover(ruby2.5-rubygem-http_accept_language-doc) weakremover(ruby2.5-rubygem-http_accept_language-testsuite) weakremover(ruby2.5-rubygem-http_parser.rb) weakremover(ruby2.5-rubygem-http_parser.rb-doc) weakremover(ruby2.5-rubygem-http_parser.rb-testsuite) weakremover(ruby2.5-rubygem-httpclient) weakremover(ruby2.5-rubygem-httpclient-doc) weakremover(ruby2.5-rubygem-httpclient-testsuite) weakremover(ruby2.5-rubygem-i18n) weakremover(ruby2.5-rubygem-i18n-0_6) weakremover(ruby2.5-rubygem-i18n-0_9) weakremover(ruby2.5-rubygem-i18n-doc) weakremover(ruby2.5-rubygem-i18n-doc-0_6) weakremover(ruby2.5-rubygem-i18n-doc-0_9) weakremover(ruby2.5-rubygem-i18n-testsuite) weakremover(ruby2.5-rubygem-i18n-testsuite-0_6) weakremover(ruby2.5-rubygem-i18n-testsuite-0_9) weakremover(ruby2.5-rubygem-ice_nine) weakremover(ruby2.5-rubygem-ice_nine-doc) weakremover(ruby2.5-rubygem-ice_nine-testsuite) weakremover(ruby2.5-rubygem-inifile) weakremover(ruby2.5-rubygem-inifile-doc) weakremover(ruby2.5-rubygem-inifile-testsuite) weakremover(ruby2.5-rubygem-ipaddress) weakremover(ruby2.5-rubygem-ipaddress-doc) weakremover(ruby2.5-rubygem-ipaddress-testsuite) weakremover(ruby2.5-rubygem-jbuilder) weakremover(ruby2.5-rubygem-jbuilder-doc) weakremover(ruby2.5-rubygem-jbuilder-testsuite) weakremover(ruby2.5-rubygem-jekyll) weakremover(ruby2.5-rubygem-jekyll-doc) weakremover(ruby2.5-rubygem-jekyll-sass-converter) weakremover(ruby2.5-rubygem-jekyll-sass-converter-doc) weakremover(ruby2.5-rubygem-jekyll-watch) weakremover(ruby2.5-rubygem-jekyll-watch-doc) weakremover(ruby2.5-rubygem-jmespath) weakremover(ruby2.5-rubygem-jmespath-doc) weakremover(ruby2.5-rubygem-journey-1_0) weakremover(ruby2.5-rubygem-journey-doc-1_0) weakremover(ruby2.5-rubygem-journey-testsuite-1_0) weakremover(ruby2.5-rubygem-jquery-rails) weakremover(ruby2.5-rubygem-jquery-rails-doc) weakremover(ruby2.5-rubygem-jquery-rails-testsuite) weakremover(ruby2.5-rubygem-jquery-ui-rails) weakremover(ruby2.5-rubygem-jquery-ui-rails-doc) weakremover(ruby2.5-rubygem-js-routes) weakremover(ruby2.5-rubygem-js-routes-doc) weakremover(ruby2.5-rubygem-js-routes-testsuite) weakremover(ruby2.5-rubygem-json) weakremover(ruby2.5-rubygem-json-doc) weakremover(ruby2.5-rubygem-json-jwt) weakremover(ruby2.5-rubygem-json-jwt-doc) weakremover(ruby2.5-rubygem-json-jwt-testsuite) weakremover(ruby2.5-rubygem-json-schema) weakremover(ruby2.5-rubygem-json-schema-2_2) weakremover(ruby2.5-rubygem-json-schema-doc) weakremover(ruby2.5-rubygem-json-schema-doc-2_2) weakremover(ruby2.5-rubygem-json-schema-testsuite-2_2) weakremover(ruby2.5-rubygem-json_pure) weakremover(ruby2.5-rubygem-json_pure-doc) weakremover(ruby2.5-rubygem-jwt) weakremover(ruby2.5-rubygem-jwt-1_5) weakremover(ruby2.5-rubygem-jwt-doc) weakremover(ruby2.5-rubygem-jwt-doc-1_5) weakremover(ruby2.5-rubygem-jwt-testsuite) weakremover(ruby2.5-rubygem-jwt-testsuite-1_5) weakremover(ruby2.5-rubygem-kgio) weakremover(ruby2.5-rubygem-kgio-doc) weakremover(ruby2.5-rubygem-kgio-testsuite) weakremover(ruby2.5-rubygem-kramdown) weakremover(ruby2.5-rubygem-kramdown-doc) weakremover(ruby2.5-rubygem-kramdown-testsuite) weakremover(ruby2.5-rubygem-launchy) weakremover(ruby2.5-rubygem-launchy-doc) weakremover(ruby2.5-rubygem-launchy-testsuite) weakremover(ruby2.5-rubygem-levenshtein) weakremover(ruby2.5-rubygem-levenshtein-doc) weakremover(ruby2.5-rubygem-levenshtein-testsuite) weakremover(ruby2.5-rubygem-librarian) weakremover(ruby2.5-rubygem-librarian-doc) weakremover(ruby2.5-rubygem-librarian-testsuite) weakremover(ruby2.5-rubygem-libyui-rake) weakremover(ruby2.5-rubygem-libyui-rake-doc) weakremover(ruby2.5-rubygem-liquid) weakremover(ruby2.5-rubygem-liquid-3) weakremover(ruby2.5-rubygem-liquid-doc) weakremover(ruby2.5-rubygem-liquid-doc-3) weakremover(ruby2.5-rubygem-liquid-testsuite) weakremover(ruby2.5-rubygem-liquid-testsuite-3) weakremover(ruby2.5-rubygem-listen) weakremover(ruby2.5-rubygem-listen-3_0) weakremover(ruby2.5-rubygem-listen-doc) weakremover(ruby2.5-rubygem-listen-doc-3_0) weakremover(ruby2.5-rubygem-little-plugger) weakremover(ruby2.5-rubygem-little-plugger-doc) weakremover(ruby2.5-rubygem-little-plugger-testsuite) weakremover(ruby2.5-rubygem-locale) weakremover(ruby2.5-rubygem-locale-doc) weakremover(ruby2.5-rubygem-locale-testsuite) weakremover(ruby2.5-rubygem-log4r) weakremover(ruby2.5-rubygem-log4r-doc) weakremover(ruby2.5-rubygem-logging) weakremover(ruby2.5-rubygem-logging-doc) weakremover(ruby2.5-rubygem-logging-testsuite) weakremover(ruby2.5-rubygem-lolcat) weakremover(ruby2.5-rubygem-lolcat-doc) weakremover(ruby2.5-rubygem-loofah) weakremover(ruby2.5-rubygem-loofah-doc) weakremover(ruby2.5-rubygem-loofah-testsuite) weakremover(ruby2.5-rubygem-mail) weakremover(ruby2.5-rubygem-mail-2_5) weakremover(ruby2.5-rubygem-mail-doc) weakremover(ruby2.5-rubygem-mail-doc-2_5) weakremover(ruby2.5-rubygem-marcel) weakremover(ruby2.5-rubygem-marcel-doc) weakremover(ruby2.5-rubygem-memcache-client) weakremover(ruby2.5-rubygem-memcache-client-doc) weakremover(ruby2.5-rubygem-memcache-client-testsuite) weakremover(ruby2.5-rubygem-mercenary) weakremover(ruby2.5-rubygem-mercenary-doc) weakremover(ruby2.5-rubygem-mercenary-testsuite) weakremover(ruby2.5-rubygem-metaclass) weakremover(ruby2.5-rubygem-metaclass-doc) weakremover(ruby2.5-rubygem-metaclass-testsuite) weakremover(ruby2.5-rubygem-method_source) weakremover(ruby2.5-rubygem-method_source-doc) weakremover(ruby2.5-rubygem-method_source-testsuite) weakremover(ruby2.5-rubygem-mime-types) weakremover(ruby2.5-rubygem-mime-types-1) weakremover(ruby2.5-rubygem-mime-types-data) weakremover(ruby2.5-rubygem-mime-types-data-doc) weakremover(ruby2.5-rubygem-mime-types-doc) weakremover(ruby2.5-rubygem-mime-types-doc-1) weakremover(ruby2.5-rubygem-mime-types-testsuite) weakremover(ruby2.5-rubygem-mime-types-testsuite-1) weakremover(ruby2.5-rubygem-mimemagic) weakremover(ruby2.5-rubygem-mimemagic-doc) weakremover(ruby2.5-rubygem-mimemagic-testsuite) weakremover(ruby2.5-rubygem-mini_magick) weakremover(ruby2.5-rubygem-mini_magick-doc) weakremover(ruby2.5-rubygem-mini_mime) weakremover(ruby2.5-rubygem-mini_mime-doc) weakremover(ruby2.5-rubygem-mini_portile2) weakremover(ruby2.5-rubygem-mini_portile2-2_3) weakremover(ruby2.5-rubygem-mini_portile2-doc) weakremover(ruby2.5-rubygem-mini_portile2-doc-2_3) weakremover(ruby2.5-rubygem-mini_portile2-testsuite) weakremover(ruby2.5-rubygem-mini_portile2-testsuite-2_3) weakremover(ruby2.5-rubygem-minitar) weakremover(ruby2.5-rubygem-minitar-doc) weakremover(ruby2.5-rubygem-minitest) weakremover(ruby2.5-rubygem-minitest-doc) weakremover(ruby2.5-rubygem-minitest-testsuite) weakremover(ruby2.5-rubygem-mixlib-authentication) weakremover(ruby2.5-rubygem-mixlib-authentication-doc) weakremover(ruby2.5-rubygem-mixlib-authentication-testsuite) weakremover(ruby2.5-rubygem-mixlib-cli) weakremover(ruby2.5-rubygem-mixlib-cli-doc) weakremover(ruby2.5-rubygem-mixlib-cli-testsuite) weakremover(ruby2.5-rubygem-mixlib-config) weakremover(ruby2.5-rubygem-mixlib-config-doc) weakremover(ruby2.5-rubygem-mixlib-config-testsuite) weakremover(ruby2.5-rubygem-mixlib-log) weakremover(ruby2.5-rubygem-mixlib-log-doc) weakremover(ruby2.5-rubygem-mixlib-log-testsuite) weakremover(ruby2.5-rubygem-mixlib-shellout) weakremover(ruby2.5-rubygem-mixlib-shellout-doc) weakremover(ruby2.5-rubygem-mobileesp_converted) weakremover(ruby2.5-rubygem-mobileesp_converted-doc) weakremover(ruby2.5-rubygem-mobileesp_converted-testsuite) weakremover(ruby2.5-rubygem-mocha) weakremover(ruby2.5-rubygem-mocha-doc) weakremover(ruby2.5-rubygem-mocha-testsuite) weakremover(ruby2.5-rubygem-moneta) weakremover(ruby2.5-rubygem-moneta-0_7) weakremover(ruby2.5-rubygem-moneta-doc) weakremover(ruby2.5-rubygem-moneta-doc-0_7) weakremover(ruby2.5-rubygem-moneta-testsuite) weakremover(ruby2.5-rubygem-moneta-testsuite-0_7) weakremover(ruby2.5-rubygem-msgpack) weakremover(ruby2.5-rubygem-msgpack-doc) weakremover(ruby2.5-rubygem-msgpack-testsuite) weakremover(ruby2.5-rubygem-multi_json) weakremover(ruby2.5-rubygem-multi_json-doc) weakremover(ruby2.5-rubygem-multi_xml) weakremover(ruby2.5-rubygem-multi_xml-doc) weakremover(ruby2.5-rubygem-multipart-post) weakremover(ruby2.5-rubygem-multipart-post-doc) weakremover(ruby2.5-rubygem-multipart-post-testsuite) weakremover(ruby2.5-rubygem-mustache) weakremover(ruby2.5-rubygem-mustache-doc) weakremover(ruby2.5-rubygem-mustache-testsuite) weakremover(ruby2.5-rubygem-mustermann) weakremover(ruby2.5-rubygem-mustermann-doc) weakremover(ruby2.5-rubygem-mustermann-grape) weakremover(ruby2.5-rubygem-mustermann-grape-doc) weakremover(ruby2.5-rubygem-mustermann-grape-testsuite) weakremover(ruby2.5-rubygem-mustermann-testsuite) weakremover(ruby2.5-rubygem-mysql2) weakremover(ruby2.5-rubygem-mysql2-0.4) weakremover(ruby2.5-rubygem-mysql2-doc) weakremover(ruby2.5-rubygem-mysql2-doc-0.4) weakremover(ruby2.5-rubygem-mysql2-testsuite) weakremover(ruby2.5-rubygem-mysql2-testsuite-0.4) weakremover(ruby2.5-rubygem-net-ldap) weakremover(ruby2.5-rubygem-net-ldap-doc) weakremover(ruby2.5-rubygem-net-ldap-testsuite) weakremover(ruby2.5-rubygem-net-scp) weakremover(ruby2.5-rubygem-net-scp-1_1) weakremover(ruby2.5-rubygem-net-scp-doc) weakremover(ruby2.5-rubygem-net-scp-doc-1_1) weakremover(ruby2.5-rubygem-net-scp-testsuite) weakremover(ruby2.5-rubygem-net-scp-testsuite-1_1) weakremover(ruby2.5-rubygem-net-sftp) weakremover(ruby2.5-rubygem-net-sftp-doc) weakremover(ruby2.5-rubygem-net-sftp-testsuite) weakremover(ruby2.5-rubygem-net-ssh) weakremover(ruby2.5-rubygem-net-ssh-4_1) weakremover(ruby2.5-rubygem-net-ssh-5.0) weakremover(ruby2.5-rubygem-net-ssh-doc) weakremover(ruby2.5-rubygem-net-ssh-doc-4_1) weakremover(ruby2.5-rubygem-net-ssh-doc-5.0) weakremover(ruby2.5-rubygem-net-ssh-gateway) weakremover(ruby2.5-rubygem-net-ssh-gateway-doc) weakremover(ruby2.5-rubygem-net-ssh-multi) weakremover(ruby2.5-rubygem-net-ssh-multi-1_1) weakremover(ruby2.5-rubygem-net-ssh-multi-doc) weakremover(ruby2.5-rubygem-net-ssh-multi-doc-1_1) weakremover(ruby2.5-rubygem-net-ssh-multi-testsuite) weakremover(ruby2.5-rubygem-net-ssh-multi-testsuite-1_1) weakremover(ruby2.5-rubygem-netrc) weakremover(ruby2.5-rubygem-netrc-doc) weakremover(ruby2.5-rubygem-netrc-testsuite) weakremover(ruby2.5-rubygem-nio4r) weakremover(ruby2.5-rubygem-nio4r-doc) weakremover(ruby2.5-rubygem-nio4r-testsuite) weakremover(ruby2.5-rubygem-nokogiri) weakremover(ruby2.5-rubygem-nokogiri-doc) weakremover(ruby2.5-rubygem-nokogiri-testsuite) weakremover(ruby2.5-rubygem-nori) weakremover(ruby2.5-rubygem-nori-doc) weakremover(ruby2.5-rubygem-nori-testsuite) weakremover(ruby2.5-rubygem-oauth) weakremover(ruby2.5-rubygem-oauth-doc) weakremover(ruby2.5-rubygem-oauth2) weakremover(ruby2.5-rubygem-oauth2-doc) weakremover(ruby2.5-rubygem-omniauth) weakremover(ruby2.5-rubygem-omniauth-doc) weakremover(ruby2.5-rubygem-omniauth-github) weakremover(ruby2.5-rubygem-omniauth-github-doc) weakremover(ruby2.5-rubygem-omniauth-github-testsuite) weakremover(ruby2.5-rubygem-omniauth-gitlab) weakremover(ruby2.5-rubygem-omniauth-gitlab-doc) weakremover(ruby2.5-rubygem-omniauth-gitlab-testsuite) weakremover(ruby2.5-rubygem-omniauth-google-oauth2) weakremover(ruby2.5-rubygem-omniauth-google-oauth2-doc) weakremover(ruby2.5-rubygem-omniauth-google-oauth2-testsuite) weakremover(ruby2.5-rubygem-omniauth-oauth) weakremover(ruby2.5-rubygem-omniauth-oauth-doc) weakremover(ruby2.5-rubygem-omniauth-oauth-testsuite) weakremover(ruby2.5-rubygem-omniauth-oauth2) weakremover(ruby2.5-rubygem-omniauth-oauth2-doc) weakremover(ruby2.5-rubygem-omniauth-oauth2-testsuite) weakremover(ruby2.5-rubygem-open4) weakremover(ruby2.5-rubygem-open4-doc) weakremover(ruby2.5-rubygem-open4-testsuite) weakremover(ruby2.5-rubygem-openid_connect) weakremover(ruby2.5-rubygem-openid_connect-doc) weakremover(ruby2.5-rubygem-openid_connect-testsuite) weakremover(ruby2.5-rubygem-orm_adapter) weakremover(ruby2.5-rubygem-orm_adapter-doc) weakremover(ruby2.5-rubygem-orm_adapter-testsuite) weakremover(ruby2.5-rubygem-owncloud-admin) weakremover(ruby2.5-rubygem-owncloud-admin-doc) weakremover(ruby2.5-rubygem-packaging_rake_tasks) weakremover(ruby2.5-rubygem-packaging_rake_tasks-doc) weakremover(ruby2.5-rubygem-paint) weakremover(ruby2.5-rubygem-paint-doc) weakremover(ruby2.5-rubygem-parallel) weakremover(ruby2.5-rubygem-parallel-doc) weakremover(ruby2.5-rubygem-parallel_tests) weakremover(ruby2.5-rubygem-parallel_tests-doc) weakremover(ruby2.5-rubygem-passenger) weakremover(ruby2.5-rubygem-passenger-doc) weakremover(ruby2.5-rubygem-path_expander) weakremover(ruby2.5-rubygem-path_expander-doc) weakremover(ruby2.5-rubygem-path_expander-testsuite) weakremover(ruby2.5-rubygem-pathutil) weakremover(ruby2.5-rubygem-pathutil-doc) weakremover(ruby2.5-rubygem-pg) weakremover(ruby2.5-rubygem-pg-doc) weakremover(ruby2.5-rubygem-pg-testsuite) weakremover(ruby2.5-rubygem-pkg-config) weakremover(ruby2.5-rubygem-pkg-config-doc) weakremover(ruby2.5-rubygem-pkg-config-testsuite) weakremover(ruby2.5-rubygem-po_to_json) weakremover(ruby2.5-rubygem-po_to_json-doc) weakremover(ruby2.5-rubygem-po_to_json-testsuite) weakremover(ruby2.5-rubygem-polyglot) weakremover(ruby2.5-rubygem-polyglot-doc) weakremover(ruby2.5-rubygem-power_assert) weakremover(ruby2.5-rubygem-power_assert-doc) weakremover(ruby2.5-rubygem-pry) weakremover(ruby2.5-rubygem-pry-doc) weakremover(ruby2.5-rubygem-pry-doc-testsuite) weakremover(ruby2.5-rubygem-pry_debug) weakremover(ruby2.5-rubygem-pry_debug-doc) weakremover(ruby2.5-rubygem-pry_debug-testsuite) weakremover(ruby2.5-rubygem-public_suffix) weakremover(ruby2.5-rubygem-public_suffix-doc) weakremover(ruby2.5-rubygem-public_suffix-testsuite) weakremover(ruby2.5-rubygem-puma) weakremover(ruby2.5-rubygem-puma-doc) weakremover(ruby2.5-rubygem-puma_worker_killer) weakremover(ruby2.5-rubygem-puma_worker_killer-doc) weakremover(ruby2.5-rubygem-puma_worker_killer-testsuite) weakremover(ruby2.5-rubygem-pundit) weakremover(ruby2.5-rubygem-pundit-doc) weakremover(ruby2.5-rubygem-pundit-testsuite) weakremover(ruby2.5-rubygem-quiet_assets) weakremover(ruby2.5-rubygem-quiet_assets-doc) weakremover(ruby2.5-rubygem-quiet_assets-testsuite) weakremover(ruby2.5-rubygem-rack) weakremover(ruby2.5-rubygem-rack-1_3) weakremover(ruby2.5-rubygem-rack-1_4) weakremover(ruby2.5-rubygem-rack-1_6) weakremover(ruby2.5-rubygem-rack-accept) weakremover(ruby2.5-rubygem-rack-accept-doc) weakremover(ruby2.5-rubygem-rack-accept-testsuite) weakremover(ruby2.5-rubygem-rack-cache-1_2) weakremover(ruby2.5-rubygem-rack-cache-doc-1_2) weakremover(ruby2.5-rubygem-rack-cache-testsuite-1_2) weakremover(ruby2.5-rubygem-rack-doc) weakremover(ruby2.5-rubygem-rack-doc-1_3) weakremover(ruby2.5-rubygem-rack-doc-1_4) weakremover(ruby2.5-rubygem-rack-doc-1_6) weakremover(ruby2.5-rubygem-rack-oauth2) weakremover(ruby2.5-rubygem-rack-oauth2-doc) weakremover(ruby2.5-rubygem-rack-oauth2-testsuite) weakremover(ruby2.5-rubygem-rack-protection) weakremover(ruby2.5-rubygem-rack-protection-doc) weakremover(ruby2.5-rubygem-rack-ssl) weakremover(ruby2.5-rubygem-rack-ssl-1_3) weakremover(ruby2.5-rubygem-rack-ssl-doc) weakremover(ruby2.5-rubygem-rack-ssl-doc-1_3) weakremover(ruby2.5-rubygem-rack-test-0_6) weakremover(ruby2.5-rubygem-rack-test-doc-0_6) weakremover(ruby2.5-rubygem-rack-test-testsuite-0_6) weakremover(ruby2.5-rubygem-rack-testsuite) weakremover(ruby2.5-rubygem-rack-testsuite-1_3) weakremover(ruby2.5-rubygem-rack-testsuite-1_4) weakremover(ruby2.5-rubygem-rack-testsuite-1_6) weakremover(ruby2.5-rubygem-rails-4_2) weakremover(ruby2.5-rubygem-rails-5.2) weakremover(ruby2.5-rubygem-rails-5_0) weakremover(ruby2.5-rubygem-rails-5_1) weakremover(ruby2.5-rubygem-rails-deprecated_sanitizer) weakremover(ruby2.5-rubygem-rails-deprecated_sanitizer-doc) weakremover(ruby2.5-rubygem-rails-deprecated_sanitizer-testsuite) weakremover(ruby2.5-rubygem-rails-doc-4_2) weakremover(ruby2.5-rubygem-rails-doc-5.2) weakremover(ruby2.5-rubygem-rails-doc-5_0) weakremover(ruby2.5-rubygem-rails-doc-5_1) weakremover(ruby2.5-rubygem-rails-dom-testing) weakremover(ruby2.5-rubygem-rails-dom-testing-1_0) weakremover(ruby2.5-rubygem-rails-dom-testing-doc) weakremover(ruby2.5-rubygem-rails-dom-testing-doc-1_0) weakremover(ruby2.5-rubygem-rails-dom-testing-testsuite) weakremover(ruby2.5-rubygem-rails-dom-testing-testsuite-1_0) weakremover(ruby2.5-rubygem-rails-html-sanitizer) weakremover(ruby2.5-rubygem-rails-html-sanitizer-doc) weakremover(ruby2.5-rubygem-rails-html-sanitizer-testsuite) weakremover(ruby2.5-rubygem-rails-i18n) weakremover(ruby2.5-rubygem-rails-i18n-doc) weakremover(ruby2.5-rubygem-rails_stdout_logging) weakremover(ruby2.5-rubygem-rails_stdout_logging-doc) weakremover(ruby2.5-rubygem-rails_stdout_logging-testsuite) weakremover(ruby2.5-rubygem-railties-4_2) weakremover(ruby2.5-rubygem-railties-5.2) weakremover(ruby2.5-rubygem-railties-5_0) weakremover(ruby2.5-rubygem-railties-5_1) weakremover(ruby2.5-rubygem-railties-doc-4_2) weakremover(ruby2.5-rubygem-railties-doc-5.2) weakremover(ruby2.5-rubygem-railties-doc-5_0) weakremover(ruby2.5-rubygem-railties-doc-5_1) weakremover(ruby2.5-rubygem-raindrops) weakremover(ruby2.5-rubygem-raindrops-doc) weakremover(ruby2.5-rubygem-raindrops-testsuite) weakremover(ruby2.5-rubygem-rake) weakremover(ruby2.5-rubygem-rake-11_3) weakremover(ruby2.5-rubygem-rake-12_0) weakremover(ruby2.5-rubygem-rake-compiler) weakremover(ruby2.5-rubygem-rake-compiler-doc) weakremover(ruby2.5-rubygem-rake-compiler-testsuite) weakremover(ruby2.5-rubygem-rake-doc) weakremover(ruby2.5-rubygem-rake-doc-11_3) weakremover(ruby2.5-rubygem-rake-doc-12_0) weakremover(ruby2.5-rubygem-rb-fsevent) weakremover(ruby2.5-rubygem-rb-fsevent-doc) weakremover(ruby2.5-rubygem-rb-inotify) weakremover(ruby2.5-rubygem-rb-inotify-doc) weakremover(ruby2.5-rubygem-rb-inotify-testsuite) weakremover(ruby2.5-rubygem-rb-kqueue) weakremover(ruby2.5-rubygem-rb-kqueue-doc) weakremover(ruby2.5-rubygem-rb-kqueue-testsuite) weakremover(ruby2.5-rubygem-rdiscount) weakremover(ruby2.5-rubygem-rdiscount-doc) weakremover(ruby2.5-rubygem-rdiscount-testsuite) weakremover(ruby2.5-rubygem-rdoc-4) weakremover(ruby2.5-rubygem-rdoc-doc-4) weakremover(ruby2.5-rubygem-rdoc-testsuite-4) weakremover(ruby2.5-rubygem-responders) weakremover(ruby2.5-rubygem-responders-doc) weakremover(ruby2.5-rubygem-rest-client) weakremover(ruby2.5-rubygem-rest-client-doc) weakremover(ruby2.5-rubygem-rest-client-testsuite) weakremover(ruby2.5-rubygem-restility) weakremover(ruby2.5-rubygem-restility-doc) weakremover(ruby2.5-rubygem-restility-testsuite) weakremover(ruby2.5-rubygem-rgen) weakremover(ruby2.5-rubygem-rgen-doc) weakremover(ruby2.5-rubygem-rgen-testsuite) weakremover(ruby2.5-rubygem-rhc) weakremover(ruby2.5-rubygem-rhc-doc) weakremover(ruby2.5-rubygem-rhc-testsuite) weakremover(ruby2.5-rubygem-ronn) weakremover(ruby2.5-rubygem-ronn-doc) weakremover(ruby2.5-rubygem-ronn-testsuite) weakremover(ruby2.5-rubygem-rouge) weakremover(ruby2.5-rubygem-rouge-1) weakremover(ruby2.5-rubygem-rouge-doc) weakremover(ruby2.5-rubygem-rouge-doc-1) weakremover(ruby2.5-rubygem-rpm) weakremover(ruby2.5-rubygem-rpm-doc) weakremover(ruby2.5-rubygem-rpm-testsuite) weakremover(ruby2.5-rubygem-rspec) weakremover(ruby2.5-rubygem-rspec-3_5) weakremover(ruby2.5-rubygem-rspec-core) weakremover(ruby2.5-rubygem-rspec-core-3_5) weakremover(ruby2.5-rubygem-rspec-core-doc) weakremover(ruby2.5-rubygem-rspec-core-doc-3_5) weakremover(ruby2.5-rubygem-rspec-doc) weakremover(ruby2.5-rubygem-rspec-doc-3_5) weakremover(ruby2.5-rubygem-rspec-expectations) weakremover(ruby2.5-rubygem-rspec-expectations-3_5) weakremover(ruby2.5-rubygem-rspec-expectations-doc) weakremover(ruby2.5-rubygem-rspec-expectations-doc-3_5) weakremover(ruby2.5-rubygem-rspec-its) weakremover(ruby2.5-rubygem-rspec-its-doc) weakremover(ruby2.5-rubygem-rspec-its-testsuite) weakremover(ruby2.5-rubygem-rspec-mocks) weakremover(ruby2.5-rubygem-rspec-mocks-3_5) weakremover(ruby2.5-rubygem-rspec-mocks-doc) weakremover(ruby2.5-rubygem-rspec-mocks-doc-3_5) weakremover(ruby2.5-rubygem-rspec-support) weakremover(ruby2.5-rubygem-rspec-support-3_5) weakremover(ruby2.5-rubygem-rspec-support-doc) weakremover(ruby2.5-rubygem-rspec-support-doc-3_5) weakremover(ruby2.5-rubygem-ruby-augeas) weakremover(ruby2.5-rubygem-ruby-augeas-doc) weakremover(ruby2.5-rubygem-ruby-dbus) weakremover(ruby2.5-rubygem-ruby-dbus-doc) weakremover(ruby2.5-rubygem-ruby-dbus-testsuite) weakremover(ruby2.5-rubygem-ruby-libvirt) weakremover(ruby2.5-rubygem-ruby-libvirt-doc) weakremover(ruby2.5-rubygem-ruby-openid) weakremover(ruby2.5-rubygem-ruby-openid-doc) weakremover(ruby2.5-rubygem-ruby-openid-testsuite) weakremover(ruby2.5-rubygem-ruby-shadow) weakremover(ruby2.5-rubygem-ruby-shadow-doc) weakremover(ruby2.5-rubygem-ruby_dep) weakremover(ruby2.5-rubygem-ruby_dep-1_3) weakremover(ruby2.5-rubygem-ruby_dep-doc) weakremover(ruby2.5-rubygem-ruby_dep-doc-1_3) weakremover(ruby2.5-rubygem-ruby_dig) weakremover(ruby2.5-rubygem-ruby_dig-doc) weakremover(ruby2.5-rubygem-ruby_dig-testsuite) weakremover(ruby2.5-rubygem-ruby_parser) weakremover(ruby2.5-rubygem-ruby_parser-doc) weakremover(ruby2.5-rubygem-ruby_parser-testsuite) weakremover(ruby2.5-rubygem-rubyforge) weakremover(ruby2.5-rubygem-rubyforge-doc) weakremover(ruby2.5-rubygem-rubyforge-testsuite) weakremover(ruby2.5-rubygem-rubyntlm) weakremover(ruby2.5-rubygem-rubyntlm-doc) weakremover(ruby2.5-rubygem-rubyntlm-testsuite) weakremover(ruby2.5-rubygem-rubyzip) weakremover(ruby2.5-rubygem-rubyzip-doc) weakremover(ruby2.5-rubygem-rubyzip-testsuite) weakremover(ruby2.5-rubygem-safe_yaml) weakremover(ruby2.5-rubygem-safe_yaml-doc) weakremover(ruby2.5-rubygem-safe_yaml-testsuite) weakremover(ruby2.5-rubygem-sass) weakremover(ruby2.5-rubygem-sass-doc) weakremover(ruby2.5-rubygem-sass-listen) weakremover(ruby2.5-rubygem-sass-listen-doc) weakremover(ruby2.5-rubygem-sass-rails) weakremover(ruby2.5-rubygem-sass-rails-doc) weakremover(ruby2.5-rubygem-sass-testsuite) weakremover(ruby2.5-rubygem-sdoc) weakremover(ruby2.5-rubygem-sdoc-doc) weakremover(ruby2.5-rubygem-sdoc-testsuite) weakremover(ruby2.5-rubygem-securecompare) weakremover(ruby2.5-rubygem-securecompare-doc) weakremover(ruby2.5-rubygem-securecompare-testsuite) weakremover(ruby2.5-rubygem-serverengine) weakremover(ruby2.5-rubygem-serverengine-doc) weakremover(ruby2.5-rubygem-serverengine-testsuite) weakremover(ruby2.5-rubygem-sexp_processor) weakremover(ruby2.5-rubygem-sexp_processor-doc) weakremover(ruby2.5-rubygem-sexp_processor-testsuite) weakremover(ruby2.5-rubygem-sigdump) weakremover(ruby2.5-rubygem-sigdump-doc) weakremover(ruby2.5-rubygem-simple_oauth) weakremover(ruby2.5-rubygem-simple_oauth-doc) weakremover(ruby2.5-rubygem-simplecov) weakremover(ruby2.5-rubygem-simplecov-doc) weakremover(ruby2.5-rubygem-simplecov-html) weakremover(ruby2.5-rubygem-simplecov-html-doc) weakremover(ruby2.5-rubygem-simplecov-html-testsuite) weakremover(ruby2.5-rubygem-simplecov-testsuite) weakremover(ruby2.5-rubygem-simpleidn) weakremover(ruby2.5-rubygem-simpleidn-doc) weakremover(ruby2.5-rubygem-sinatra) weakremover(ruby2.5-rubygem-sinatra-doc) weakremover(ruby2.5-rubygem-slim) weakremover(ruby2.5-rubygem-slim-doc) weakremover(ruby2.5-rubygem-slim-testsuite) weakremover(ruby2.5-rubygem-slop) weakremover(ruby2.5-rubygem-slop-3) weakremover(ruby2.5-rubygem-slop-3_3) weakremover(ruby2.5-rubygem-slop-doc) weakremover(ruby2.5-rubygem-slop-doc-3) weakremover(ruby2.5-rubygem-slop-doc-3_3) weakremover(ruby2.5-rubygem-slop-testsuite) weakremover(ruby2.5-rubygem-slop-testsuite-3) weakremover(ruby2.5-rubygem-slop-testsuite-3_3) weakremover(ruby2.5-rubygem-spring) weakremover(ruby2.5-rubygem-spring-doc) weakremover(ruby2.5-rubygem-spring-watcher-listen) weakremover(ruby2.5-rubygem-spring-watcher-listen-doc) weakremover(ruby2.5-rubygem-spring-watcher-listen-testsuite) weakremover(ruby2.5-rubygem-sprockets) weakremover(ruby2.5-rubygem-sprockets-2_1) weakremover(ruby2.5-rubygem-sprockets-2_2) weakremover(ruby2.5-rubygem-sprockets-doc) weakremover(ruby2.5-rubygem-sprockets-doc-2_1) weakremover(ruby2.5-rubygem-sprockets-doc-2_2) weakremover(ruby2.5-rubygem-sprockets-helpers) weakremover(ruby2.5-rubygem-sprockets-helpers-doc) weakremover(ruby2.5-rubygem-sprockets-helpers-testsuite) weakremover(ruby2.5-rubygem-sprockets-rails) weakremover(ruby2.5-rubygem-sprockets-rails-doc) weakremover(ruby2.5-rubygem-sqlite3) weakremover(ruby2.5-rubygem-sqlite3-doc) weakremover(ruby2.5-rubygem-sqlite3-testsuite) weakremover(ruby2.5-rubygem-sshkit) weakremover(ruby2.5-rubygem-sshkit-doc) weakremover(ruby2.5-rubygem-sshkit-testsuite) weakremover(ruby2.5-rubygem-stackdeck) weakremover(ruby2.5-rubygem-stackdeck-doc) weakremover(ruby2.5-rubygem-stackdeck-testsuite) weakremover(ruby2.5-rubygem-stomp) weakremover(ruby2.5-rubygem-stomp-doc) weakremover(ruby2.5-rubygem-stomp-testsuite) weakremover(ruby2.5-rubygem-strptime) weakremover(ruby2.5-rubygem-strptime-doc) weakremover(ruby2.5-rubygem-swd) weakremover(ruby2.5-rubygem-swd-doc) weakremover(ruby2.5-rubygem-swd-testsuite) weakremover(ruby2.5-rubygem-systemu) weakremover(ruby2.5-rubygem-systemu-doc) weakremover(ruby2.5-rubygem-systemu-testsuite) weakremover(ruby2.5-rubygem-taskjuggler) weakremover(ruby2.5-rubygem-taskjuggler-doc) weakremover(ruby2.5-rubygem-taskjuggler-testsuite) weakremover(ruby2.5-rubygem-temple) weakremover(ruby2.5-rubygem-temple-doc) weakremover(ruby2.5-rubygem-temple-testsuite) weakremover(ruby2.5-rubygem-term-ansicolor) weakremover(ruby2.5-rubygem-term-ansicolor-doc) weakremover(ruby2.5-rubygem-test-unit) weakremover(ruby2.5-rubygem-test-unit-doc) weakremover(ruby2.5-rubygem-test-unit-testsuite) weakremover(ruby2.5-rubygem-text) weakremover(ruby2.5-rubygem-text-doc) weakremover(ruby2.5-rubygem-text-hyphen) weakremover(ruby2.5-rubygem-text-hyphen-doc) weakremover(ruby2.5-rubygem-text-hyphen-testsuite) weakremover(ruby2.5-rubygem-text-testsuite) weakremover(ruby2.5-rubygem-thor) weakremover(ruby2.5-rubygem-thor-0_19) weakremover(ruby2.5-rubygem-thor-doc) weakremover(ruby2.5-rubygem-thor-doc-0_19) weakremover(ruby2.5-rubygem-thread_safe) weakremover(ruby2.5-rubygem-thread_safe-doc) weakremover(ruby2.5-rubygem-thread_safe-testsuite) weakremover(ruby2.5-rubygem-tilt) weakremover(ruby2.5-rubygem-tilt-1_1) weakremover(ruby2.5-rubygem-tilt-1_4) weakremover(ruby2.5-rubygem-tilt-doc) weakremover(ruby2.5-rubygem-tilt-doc-1_1) weakremover(ruby2.5-rubygem-tilt-doc-1_4) weakremover(ruby2.5-rubygem-tilt-testsuite) weakremover(ruby2.5-rubygem-tilt-testsuite-1_1) weakremover(ruby2.5-rubygem-tilt-testsuite-1_4) weakremover(ruby2.5-rubygem-timers) weakremover(ruby2.5-rubygem-timers-doc) weakremover(ruby2.5-rubygem-timers-testsuite) weakremover(ruby2.5-rubygem-tins) weakremover(ruby2.5-rubygem-tins-doc) weakremover(ruby2.5-rubygem-tmuxinator) weakremover(ruby2.5-rubygem-tmuxinator-doc) weakremover(ruby2.5-rubygem-tmuxinator-testsuite) weakremover(ruby2.5-rubygem-tomlrb) weakremover(ruby2.5-rubygem-tomlrb-doc) weakremover(ruby2.5-rubygem-treetop) weakremover(ruby2.5-rubygem-treetop-1_4) weakremover(ruby2.5-rubygem-treetop-doc) weakremover(ruby2.5-rubygem-treetop-doc-1_4) weakremover(ruby2.5-rubygem-treetop-testsuite-1_4) weakremover(ruby2.5-rubygem-trollop) weakremover(ruby2.5-rubygem-trollop-doc) weakremover(ruby2.5-rubygem-trollop-testsuite) weakremover(ruby2.5-rubygem-turbolinks) weakremover(ruby2.5-rubygem-turbolinks-doc) weakremover(ruby2.5-rubygem-turbolinks-source) weakremover(ruby2.5-rubygem-turbolinks-source-doc) weakremover(ruby2.5-rubygem-tzinfo) weakremover(ruby2.5-rubygem-tzinfo-0) weakremover(ruby2.5-rubygem-tzinfo-data) weakremover(ruby2.5-rubygem-tzinfo-data-doc) weakremover(ruby2.5-rubygem-tzinfo-doc) weakremover(ruby2.5-rubygem-tzinfo-doc-0) weakremover(ruby2.5-rubygem-tzinfo-testsuite) weakremover(ruby2.5-rubygem-tzinfo-testsuite-0) weakremover(ruby2.5-rubygem-uglifier) weakremover(ruby2.5-rubygem-uglifier-doc) weakremover(ruby2.5-rubygem-unf) weakremover(ruby2.5-rubygem-unf-doc) weakremover(ruby2.5-rubygem-unf-testsuite) weakremover(ruby2.5-rubygem-unf_ext) weakremover(ruby2.5-rubygem-unf_ext-doc) weakremover(ruby2.5-rubygem-unf_ext-testsuite) weakremover(ruby2.5-rubygem-unicorn) weakremover(ruby2.5-rubygem-unicorn-doc) weakremover(ruby2.5-rubygem-unicorn-testsuite) weakremover(ruby2.5-rubygem-unicorn-worker-killer) weakremover(ruby2.5-rubygem-unicorn-worker-killer-doc) weakremover(ruby2.5-rubygem-url_safe_base64) weakremover(ruby2.5-rubygem-url_safe_base64-doc) weakremover(ruby2.5-rubygem-url_safe_base64-testsuite) weakremover(ruby2.5-rubygem-vagrant_cloud) weakremover(ruby2.5-rubygem-vagrant_cloud-doc) weakremover(ruby2.5-rubygem-validate_email) weakremover(ruby2.5-rubygem-validate_email-doc) weakremover(ruby2.5-rubygem-validate_url) weakremover(ruby2.5-rubygem-validate_url-doc) weakremover(ruby2.5-rubygem-virtus) weakremover(ruby2.5-rubygem-virtus-doc) weakremover(ruby2.5-rubygem-virtus-testsuite) weakremover(ruby2.5-rubygem-warden) weakremover(ruby2.5-rubygem-warden-doc) weakremover(ruby2.5-rubygem-warden-testsuite) weakremover(ruby2.5-rubygem-web-console) weakremover(ruby2.5-rubygem-web-console-2) weakremover(ruby2.5-rubygem-web-console-doc) weakremover(ruby2.5-rubygem-web-console-doc-2) weakremover(ruby2.5-rubygem-webfinger) weakremover(ruby2.5-rubygem-webfinger-doc) weakremover(ruby2.5-rubygem-webfinger-testsuite) weakremover(ruby2.5-rubygem-webmock-1_2) weakremover(ruby2.5-rubygem-webmock-2_3) weakremover(ruby2.5-rubygem-webmock-doc-1_2) weakremover(ruby2.5-rubygem-webmock-doc-2_3) weakremover(ruby2.5-rubygem-webmock-testsuite-1_2) weakremover(ruby2.5-rubygem-webmock-testsuite-2_3) weakremover(ruby2.5-rubygem-websocket) weakremover(ruby2.5-rubygem-websocket-doc) weakremover(ruby2.5-rubygem-websocket-driver) weakremover(ruby2.5-rubygem-websocket-driver-0_6) weakremover(ruby2.5-rubygem-websocket-driver-doc) weakremover(ruby2.5-rubygem-websocket-driver-doc-0_6) weakremover(ruby2.5-rubygem-websocket-extensions) weakremover(ruby2.5-rubygem-websocket-extensions-doc) weakremover(ruby2.5-rubygem-websocket-testsuite) weakremover(ruby2.5-rubygem-winrm-2_1) weakremover(ruby2.5-rubygem-winrm-doc-2_1) weakremover(ruby2.5-rubygem-winrm-elevated) weakremover(ruby2.5-rubygem-winrm-elevated-doc) weakremover(ruby2.5-rubygem-winrm-fs) weakremover(ruby2.5-rubygem-winrm-fs-doc) weakremover(ruby2.5-rubygem-winrm-fs-testsuite) weakremover(ruby2.5-rubygem-xdg) weakremover(ruby2.5-rubygem-xdg-doc) weakremover(ruby2.5-rubygem-xdg-testsuite) weakremover(ruby2.5-rubygem-xml-simple) weakremover(ruby2.5-rubygem-xml-simple-doc) weakremover(ruby2.5-rubygem-xmlhash) weakremover(ruby2.5-rubygem-xmlhash-doc) weakremover(ruby2.5-rubygem-xmlhash-testsuite) weakremover(ruby2.5-rubygem-yajl-ruby) weakremover(ruby2.5-rubygem-yajl-ruby-doc) weakremover(ruby2.5-rubygem-yajl-ruby-testsuite) weakremover(ruby2.5-rubygem-yard) weakremover(ruby2.5-rubygem-yard-doc) weakremover(ruby2.5-rubygem-yard-testsuite) weakremover(ruby2.5-rubygem-yast-rake) weakremover(ruby2.5-rubygem-yast-rake-doc) weakremover(ruby2.5-stdlib) weakremover(ruby2.6) weakremover(ruby2.6-devel) weakremover(ruby2.6-devel-extra) weakremover(ruby2.6-doc) weakremover(ruby2.6-doc-ri) weakremover(ruby2.6-rubygem-RedCloth) weakremover(ruby2.6-rubygem-RedCloth-doc) weakremover(ruby2.6-rubygem-RedCloth-testsuite) weakremover(ruby2.6-rubygem-abstract) weakremover(ruby2.6-rubygem-abstract-doc) weakremover(ruby2.6-rubygem-abstract-testsuite) weakremover(ruby2.6-rubygem-abstract_method) weakremover(ruby2.6-rubygem-abstract_method-doc) weakremover(ruby2.6-rubygem-actioncable-5.2) weakremover(ruby2.6-rubygem-actioncable-5_0) weakremover(ruby2.6-rubygem-actioncable-5_1) weakremover(ruby2.6-rubygem-actioncable-6.0) weakremover(ruby2.6-rubygem-actioncable-doc-5.2) weakremover(ruby2.6-rubygem-actioncable-doc-5_0) weakremover(ruby2.6-rubygem-actioncable-doc-5_1) weakremover(ruby2.6-rubygem-actioncable-doc-6.0) weakremover(ruby2.6-rubygem-actionmailbox-6.0) weakremover(ruby2.6-rubygem-actionmailbox-doc-6.0) weakremover(ruby2.6-rubygem-actionmailer-5.2) weakremover(ruby2.6-rubygem-actionmailer-5_0) weakremover(ruby2.6-rubygem-actionmailer-5_1) weakremover(ruby2.6-rubygem-actionmailer-6.0) weakremover(ruby2.6-rubygem-actionmailer-doc-5.2) weakremover(ruby2.6-rubygem-actionmailer-doc-5_0) weakremover(ruby2.6-rubygem-actionmailer-doc-5_1) weakremover(ruby2.6-rubygem-actionmailer-doc-6.0) weakremover(ruby2.6-rubygem-actionpack-5.2) weakremover(ruby2.6-rubygem-actionpack-5_0) weakremover(ruby2.6-rubygem-actionpack-5_1) weakremover(ruby2.6-rubygem-actionpack-6.0) weakremover(ruby2.6-rubygem-actionpack-doc-5.2) weakremover(ruby2.6-rubygem-actionpack-doc-5_0) weakremover(ruby2.6-rubygem-actionpack-doc-5_1) weakremover(ruby2.6-rubygem-actionpack-doc-6.0) weakremover(ruby2.6-rubygem-actiontext-6.0) weakremover(ruby2.6-rubygem-actiontext-doc-6.0) weakremover(ruby2.6-rubygem-actionview-5.2) weakremover(ruby2.6-rubygem-actionview-5_0) weakremover(ruby2.6-rubygem-actionview-5_1) weakremover(ruby2.6-rubygem-actionview-6.0) weakremover(ruby2.6-rubygem-actionview-doc-5.2) weakremover(ruby2.6-rubygem-actionview-doc-5_0) weakremover(ruby2.6-rubygem-actionview-doc-5_1) weakremover(ruby2.6-rubygem-actionview-doc-6.0) weakremover(ruby2.6-rubygem-activejob-5.2) weakremover(ruby2.6-rubygem-activejob-5_0) weakremover(ruby2.6-rubygem-activejob-5_1) weakremover(ruby2.6-rubygem-activejob-6.0) weakremover(ruby2.6-rubygem-activejob-doc-5.2) weakremover(ruby2.6-rubygem-activejob-doc-5_0) weakremover(ruby2.6-rubygem-activejob-doc-5_1) weakremover(ruby2.6-rubygem-activejob-doc-6.0) weakremover(ruby2.6-rubygem-activemodel-5.2) weakremover(ruby2.6-rubygem-activemodel-5_0) weakremover(ruby2.6-rubygem-activemodel-5_1) weakremover(ruby2.6-rubygem-activemodel-6.0) weakremover(ruby2.6-rubygem-activemodel-doc-5.2) weakremover(ruby2.6-rubygem-activemodel-doc-5_0) weakremover(ruby2.6-rubygem-activemodel-doc-5_1) weakremover(ruby2.6-rubygem-activemodel-doc-6.0) weakremover(ruby2.6-rubygem-activerecord-5.2) weakremover(ruby2.6-rubygem-activerecord-5_0) weakremover(ruby2.6-rubygem-activerecord-5_1) weakremover(ruby2.6-rubygem-activerecord-6.0) weakremover(ruby2.6-rubygem-activerecord-deprecated_finders) weakremover(ruby2.6-rubygem-activerecord-deprecated_finders-doc) weakremover(ruby2.6-rubygem-activerecord-doc-5.2) weakremover(ruby2.6-rubygem-activerecord-doc-5_0) weakremover(ruby2.6-rubygem-activerecord-doc-6.0) weakremover(ruby2.6-rubygem-activestorage-5.2) weakremover(ruby2.6-rubygem-activestorage-6.0) weakremover(ruby2.6-rubygem-activestorage-doc-5.2) weakremover(ruby2.6-rubygem-activestorage-doc-6.0) weakremover(ruby2.6-rubygem-activesupport-5.2) weakremover(ruby2.6-rubygem-activesupport-5_0) weakremover(ruby2.6-rubygem-activesupport-5_1) weakremover(ruby2.6-rubygem-activesupport-6.0) weakremover(ruby2.6-rubygem-activesupport-doc-5.2) weakremover(ruby2.6-rubygem-activesupport-doc-5_0) weakremover(ruby2.6-rubygem-activesupport-doc-5_1) weakremover(ruby2.6-rubygem-activesupport-doc-6.0) weakremover(ruby2.6-rubygem-addressable) weakremover(ruby2.6-rubygem-addressable-2_3) weakremover(ruby2.6-rubygem-addressable-doc) weakremover(ruby2.6-rubygem-addressable-doc-2_3) weakremover(ruby2.6-rubygem-addressable-testsuite) weakremover(ruby2.6-rubygem-addressable-testsuite-2_3) weakremover(ruby2.6-rubygem-aes_key_wrap) weakremover(ruby2.6-rubygem-aes_key_wrap-doc) weakremover(ruby2.6-rubygem-airbrussh) weakremover(ruby2.6-rubygem-airbrussh-doc) weakremover(ruby2.6-rubygem-amq-protocol) weakremover(ruby2.6-rubygem-amq-protocol-doc) weakremover(ruby2.6-rubygem-amq-protocol-testsuite) weakremover(ruby2.6-rubygem-amqp) weakremover(ruby2.6-rubygem-amqp-doc) weakremover(ruby2.6-rubygem-amqp-testsuite) weakremover(ruby2.6-rubygem-archive-tar-minitar) weakremover(ruby2.6-rubygem-archive-tar-minitar-doc) weakremover(ruby2.6-rubygem-arel) weakremover(ruby2.6-rubygem-arel-3_0) weakremover(ruby2.6-rubygem-arel-6) weakremover(ruby2.6-rubygem-arel-7) weakremover(ruby2.6-rubygem-arel-8) weakremover(ruby2.6-rubygem-arel-doc) weakremover(ruby2.6-rubygem-arel-doc-3_0) weakremover(ruby2.6-rubygem-arel-doc-6) weakremover(ruby2.6-rubygem-arel-doc-7) weakremover(ruby2.6-rubygem-arel-doc-8) weakremover(ruby2.6-rubygem-arel-testsuite-3_0) weakremover(ruby2.6-rubygem-asciidoctor) weakremover(ruby2.6-rubygem-asciidoctor-doc) weakremover(ruby2.6-rubygem-asciidoctor-testsuite) weakremover(ruby2.6-rubygem-ast) weakremover(ruby2.6-rubygem-ast-doc) weakremover(ruby2.6-rubygem-ast-testsuite) weakremover(ruby2.6-rubygem-atomic) weakremover(ruby2.6-rubygem-atomic-doc) weakremover(ruby2.6-rubygem-atomic-testsuite) weakremover(ruby2.6-rubygem-attr_required) weakremover(ruby2.6-rubygem-attr_required-doc) weakremover(ruby2.6-rubygem-attr_required-testsuite) weakremover(ruby2.6-rubygem-autoprefixer-rails) weakremover(ruby2.6-rubygem-autoprefixer-rails-doc) weakremover(ruby2.6-rubygem-autoprefixer-rails-testsuite) weakremover(ruby2.6-rubygem-axiom-types) weakremover(ruby2.6-rubygem-axiom-types-doc) weakremover(ruby2.6-rubygem-axiom-types-testsuite) weakremover(ruby2.6-rubygem-backport) weakremover(ruby2.6-rubygem-backport-doc) weakremover(ruby2.6-rubygem-base32) weakremover(ruby2.6-rubygem-base32-doc) weakremover(ruby2.6-rubygem-base32-testsuite) weakremover(ruby2.6-rubygem-bcrypt) weakremover(ruby2.6-rubygem-bcrypt-doc) weakremover(ruby2.6-rubygem-bcrypt-ruby) weakremover(ruby2.6-rubygem-bcrypt-ruby-doc) weakremover(ruby2.6-rubygem-bcrypt-testsuite) weakremover(ruby2.6-rubygem-bcrypt_pbkdf) weakremover(ruby2.6-rubygem-bcrypt_pbkdf-doc) weakremover(ruby2.6-rubygem-bcrypt_pbkdf-testsuite) weakremover(ruby2.6-rubygem-benchmark) weakremover(ruby2.6-rubygem-benchmark-doc) weakremover(ruby2.6-rubygem-bindata) weakremover(ruby2.6-rubygem-bindata-doc) weakremover(ruby2.6-rubygem-bindata-testsuite) weakremover(ruby2.6-rubygem-bindex) weakremover(ruby2.6-rubygem-bindex-doc) weakremover(ruby2.6-rubygem-bindex-testsuite) weakremover(ruby2.6-rubygem-binding_of_caller) weakremover(ruby2.6-rubygem-binding_of_caller-doc) weakremover(ruby2.6-rubygem-binding_of_caller-testsuite) weakremover(ruby2.6-rubygem-bootsnap) weakremover(ruby2.6-rubygem-bootsnap-doc) weakremover(ruby2.6-rubygem-bootstrap-sass) weakremover(ruby2.6-rubygem-bootstrap-sass-doc) weakremover(ruby2.6-rubygem-bootstrap-sass-testsuite) weakremover(ruby2.6-rubygem-buff-extensions) weakremover(ruby2.6-rubygem-buff-extensions-doc) weakremover(ruby2.6-rubygem-buff-extensions-testsuite) weakremover(ruby2.6-rubygem-buff-ignore) weakremover(ruby2.6-rubygem-buff-ignore-doc) weakremover(ruby2.6-rubygem-buff-ignore-testsuite) weakremover(ruby2.6-rubygem-buff-ruby_engine) weakremover(ruby2.6-rubygem-buff-ruby_engine-doc) weakremover(ruby2.6-rubygem-buff-ruby_engine-testsuite) weakremover(ruby2.6-rubygem-builder) weakremover(ruby2.6-rubygem-builder-doc) weakremover(ruby2.6-rubygem-builder-testsuite) weakremover(ruby2.6-rubygem-bundler) weakremover(ruby2.6-rubygem-bundler-audit) weakremover(ruby2.6-rubygem-bundler-audit-doc) weakremover(ruby2.6-rubygem-bundler-audit-testsuite) weakremover(ruby2.6-rubygem-bundler-doc) weakremover(ruby2.6-rubygem-bunny) weakremover(ruby2.6-rubygem-bunny-doc) weakremover(ruby2.6-rubygem-bunny-testsuite) weakremover(ruby2.6-rubygem-byebug) weakremover(ruby2.6-rubygem-byebug-doc) weakremover(ruby2.6-rubygem-capistrano) weakremover(ruby2.6-rubygem-capistrano-doc) weakremover(ruby2.6-rubygem-capistrano-harrow) weakremover(ruby2.6-rubygem-capistrano-harrow-doc) weakremover(ruby2.6-rubygem-capistrano-stats) weakremover(ruby2.6-rubygem-capistrano-stats-doc) weakremover(ruby2.6-rubygem-capistrano-testsuite) weakremover(ruby2.6-rubygem-celluloid) weakremover(ruby2.6-rubygem-celluloid-doc) weakremover(ruby2.6-rubygem-celluloid-essentials) weakremover(ruby2.6-rubygem-celluloid-essentials-doc) weakremover(ruby2.6-rubygem-celluloid-extras) weakremover(ruby2.6-rubygem-celluloid-extras-doc) weakremover(ruby2.6-rubygem-celluloid-fsm) weakremover(ruby2.6-rubygem-celluloid-fsm-doc) weakremover(ruby2.6-rubygem-celluloid-pool) weakremover(ruby2.6-rubygem-celluloid-pool-doc) weakremover(ruby2.6-rubygem-celluloid-supervision) weakremover(ruby2.6-rubygem-celluloid-supervision-doc) weakremover(ruby2.6-rubygem-celluloid-testsuite) weakremover(ruby2.6-rubygem-cfa) weakremover(ruby2.6-rubygem-cfa-doc) weakremover(ruby2.6-rubygem-cfa_grub2) weakremover(ruby2.6-rubygem-cfa_grub2-doc) weakremover(ruby2.6-rubygem-changelog_generator) weakremover(ruby2.6-rubygem-changelog_generator-doc) weakremover(ruby2.6-rubygem-changelog_generator-testsuite) weakremover(ruby2.6-rubygem-cheetah) weakremover(ruby2.6-rubygem-cheetah-doc) weakremover(ruby2.6-rubygem-childprocess) weakremover(ruby2.6-rubygem-childprocess-0_6) weakremover(ruby2.6-rubygem-childprocess-2.0) weakremover(ruby2.6-rubygem-childprocess-doc) weakremover(ruby2.6-rubygem-childprocess-doc-0_6) weakremover(ruby2.6-rubygem-childprocess-doc-2.0) weakremover(ruby2.6-rubygem-childprocess-testsuite) weakremover(ruby2.6-rubygem-childprocess-testsuite-0_6) weakremover(ruby2.6-rubygem-childprocess-testsuite-2.0) weakremover(ruby2.6-rubygem-ci_reporter) weakremover(ruby2.6-rubygem-ci_reporter-doc) weakremover(ruby2.6-rubygem-ci_reporter-testsuite) weakremover(ruby2.6-rubygem-cleanroom) weakremover(ruby2.6-rubygem-cleanroom-doc) weakremover(ruby2.6-rubygem-cleanroom-testsuite) weakremover(ruby2.6-rubygem-coderay) weakremover(ruby2.6-rubygem-coderay-doc) weakremover(ruby2.6-rubygem-coercible) weakremover(ruby2.6-rubygem-coercible-doc) weakremover(ruby2.6-rubygem-coercible-testsuite) weakremover(ruby2.6-rubygem-coffee-rails) weakremover(ruby2.6-rubygem-coffee-rails-doc) weakremover(ruby2.6-rubygem-coffee-script) weakremover(ruby2.6-rubygem-coffee-script-doc) weakremover(ruby2.6-rubygem-coffee-script-source) weakremover(ruby2.6-rubygem-coffee-script-source-doc) weakremover(ruby2.6-rubygem-colorator) weakremover(ruby2.6-rubygem-colorator-0) weakremover(ruby2.6-rubygem-colorator-doc) weakremover(ruby2.6-rubygem-colorator-doc-0) weakremover(ruby2.6-rubygem-colorator-testsuite-0) weakremover(ruby2.6-rubygem-colored) weakremover(ruby2.6-rubygem-colored-doc) weakremover(ruby2.6-rubygem-colored-testsuite) weakremover(ruby2.6-rubygem-colorize) weakremover(ruby2.6-rubygem-colorize-doc) weakremover(ruby2.6-rubygem-colorize-testsuite) weakremover(ruby2.6-rubygem-columnize) weakremover(ruby2.6-rubygem-columnize-doc) weakremover(ruby2.6-rubygem-columnize-testsuite) weakremover(ruby2.6-rubygem-commander) weakremover(ruby2.6-rubygem-commander-doc) weakremover(ruby2.6-rubygem-commander-testsuite) weakremover(ruby2.6-rubygem-concurrent-ruby) weakremover(ruby2.6-rubygem-concurrent-ruby-doc) weakremover(ruby2.6-rubygem-cool.io) weakremover(ruby2.6-rubygem-cool.io-doc) weakremover(ruby2.6-rubygem-cool.io-testsuite) weakremover(ruby2.6-rubygem-crack) weakremover(ruby2.6-rubygem-crack-doc) weakremover(ruby2.6-rubygem-crack-testsuite) weakremover(ruby2.6-rubygem-crass) weakremover(ruby2.6-rubygem-crass-doc) weakremover(ruby2.6-rubygem-crass-testsuite) weakremover(ruby2.6-rubygem-cri) weakremover(ruby2.6-rubygem-cri-doc) weakremover(ruby2.6-rubygem-cri-testsuite) weakremover(ruby2.6-rubygem-cssmin) weakremover(ruby2.6-rubygem-cssmin-doc) weakremover(ruby2.6-rubygem-daemon_controller) weakremover(ruby2.6-rubygem-daemon_controller-doc) weakremover(ruby2.6-rubygem-daemon_controller-testsuite) weakremover(ruby2.6-rubygem-daemons) weakremover(ruby2.6-rubygem-daemons-doc) weakremover(ruby2.6-rubygem-debase) weakremover(ruby2.6-rubygem-debase-doc) weakremover(ruby2.6-rubygem-debase-ruby_core_source) weakremover(ruby2.6-rubygem-debase-ruby_core_source-doc) weakremover(ruby2.6-rubygem-debase-testsuite) weakremover(ruby2.6-rubygem-debug_inspector) weakremover(ruby2.6-rubygem-debug_inspector-doc) weakremover(ruby2.6-rubygem-debug_inspector-testsuite) weakremover(ruby2.6-rubygem-debugger-linecache) weakremover(ruby2.6-rubygem-debugger-linecache-doc) weakremover(ruby2.6-rubygem-debugger-linecache-testsuite) weakremover(ruby2.6-rubygem-deep_merge) weakremover(ruby2.6-rubygem-deep_merge-doc) weakremover(ruby2.6-rubygem-deep_merge-testsuite) weakremover(ruby2.6-rubygem-delayed_job) weakremover(ruby2.6-rubygem-delayed_job-doc) weakremover(ruby2.6-rubygem-delayed_job-testsuite) weakremover(ruby2.6-rubygem-delayed_job_active_record) weakremover(ruby2.6-rubygem-delayed_job_active_record-doc) weakremover(ruby2.6-rubygem-descendants_tracker) weakremover(ruby2.6-rubygem-descendants_tracker-doc) weakremover(ruby2.6-rubygem-descendants_tracker-testsuite) weakremover(ruby2.6-rubygem-devise) weakremover(ruby2.6-rubygem-devise-doc) weakremover(ruby2.6-rubygem-devise-i18n) weakremover(ruby2.6-rubygem-devise-i18n-doc) weakremover(ruby2.6-rubygem-devise-testsuite) weakremover(ruby2.6-rubygem-devise_ldap_authenticatable) weakremover(ruby2.6-rubygem-devise_ldap_authenticatable-doc) weakremover(ruby2.6-rubygem-devise_ldap_authenticatable-testsuite) weakremover(ruby2.6-rubygem-dice) weakremover(ruby2.6-rubygem-dice-doc) weakremover(ruby2.6-rubygem-diff-lcs) weakremover(ruby2.6-rubygem-diff-lcs-doc) weakremover(ruby2.6-rubygem-diff-lcs-testsuite) weakremover(ruby2.6-rubygem-diffy) weakremover(ruby2.6-rubygem-diffy-doc) weakremover(ruby2.6-rubygem-diffy-testsuite) weakremover(ruby2.6-rubygem-dig_rb) weakremover(ruby2.6-rubygem-dig_rb-doc) weakremover(ruby2.6-rubygem-docile) weakremover(ruby2.6-rubygem-docile-1_1) weakremover(ruby2.6-rubygem-docile-doc) weakremover(ruby2.6-rubygem-docile-doc-1_1) weakremover(ruby2.6-rubygem-docile-testsuite-1_1) weakremover(ruby2.6-rubygem-domain_name) weakremover(ruby2.6-rubygem-domain_name-doc) weakremover(ruby2.6-rubygem-domain_name-testsuite) weakremover(ruby2.6-rubygem-dry-configurable) weakremover(ruby2.6-rubygem-dry-configurable-doc) weakremover(ruby2.6-rubygem-dry-container) weakremover(ruby2.6-rubygem-dry-container-doc) weakremover(ruby2.6-rubygem-dry-container-testsuite) weakremover(ruby2.6-rubygem-dry-core) weakremover(ruby2.6-rubygem-dry-core-doc) weakremover(ruby2.6-rubygem-dry-equalizer) weakremover(ruby2.6-rubygem-dry-equalizer-doc) weakremover(ruby2.6-rubygem-dry-equalizer-testsuite) weakremover(ruby2.6-rubygem-dry-inflector) weakremover(ruby2.6-rubygem-dry-inflector-doc) weakremover(ruby2.6-rubygem-dry-logic) weakremover(ruby2.6-rubygem-dry-logic-doc) weakremover(ruby2.6-rubygem-dry-types) weakremover(ruby2.6-rubygem-dry-types-doc) weakremover(ruby2.6-rubygem-ed25519) weakremover(ruby2.6-rubygem-ed25519-doc) weakremover(ruby2.6-rubygem-em-websocket) weakremover(ruby2.6-rubygem-em-websocket-doc) weakremover(ruby2.6-rubygem-em-websocket-testsuite) weakremover(ruby2.6-rubygem-equalizer) weakremover(ruby2.6-rubygem-equalizer-doc) weakremover(ruby2.6-rubygem-equalizer-testsuite) weakremover(ruby2.6-rubygem-erubi) weakremover(ruby2.6-rubygem-erubi-doc) weakremover(ruby2.6-rubygem-erubi-testsuite) weakremover(ruby2.6-rubygem-erubis) weakremover(ruby2.6-rubygem-erubis-2_6) weakremover(ruby2.6-rubygem-erubis-doc) weakremover(ruby2.6-rubygem-erubis-doc-2_6) weakremover(ruby2.6-rubygem-erubis-testsuite) weakremover(ruby2.6-rubygem-erubis-testsuite-2_6) weakremover(ruby2.6-rubygem-eventmachine) weakremover(ruby2.6-rubygem-eventmachine-doc) weakremover(ruby2.6-rubygem-exception_notification) weakremover(ruby2.6-rubygem-exception_notification-doc) weakremover(ruby2.6-rubygem-exception_notification-testsuite) weakremover(ruby2.6-rubygem-excon) weakremover(ruby2.6-rubygem-excon-doc) weakremover(ruby2.6-rubygem-excon-testsuite) weakremover(ruby2.6-rubygem-execjs) weakremover(ruby2.6-rubygem-execjs-doc) weakremover(ruby2.6-rubygem-extlib) weakremover(ruby2.6-rubygem-extlib-doc) weakremover(ruby2.6-rubygem-extlib-testsuite) weakremover(ruby2.6-rubygem-factory_girl) weakremover(ruby2.6-rubygem-factory_girl-doc) weakremover(ruby2.6-rubygem-factory_girl_rails) weakremover(ruby2.6-rubygem-factory_girl_rails-doc) weakremover(ruby2.6-rubygem-fake_ftp) weakremover(ruby2.6-rubygem-fake_ftp-0_1) weakremover(ruby2.6-rubygem-fake_ftp-doc) weakremover(ruby2.6-rubygem-fake_ftp-doc-0_1) weakremover(ruby2.6-rubygem-fake_ftp-testsuite) weakremover(ruby2.6-rubygem-fake_ftp-testsuite-0_1) weakremover(ruby2.6-rubygem-faraday) weakremover(ruby2.6-rubygem-faraday-0_12) weakremover(ruby2.6-rubygem-faraday-doc) weakremover(ruby2.6-rubygem-faraday-doc-0_12) weakremover(ruby2.6-rubygem-faraday-testsuite) weakremover(ruby2.6-rubygem-faraday_middleware) weakremover(ruby2.6-rubygem-faraday_middleware-doc) weakremover(ruby2.6-rubygem-faraday_middleware-multi_json) weakremover(ruby2.6-rubygem-faraday_middleware-multi_json-doc) weakremover(ruby2.6-rubygem-faraday_middleware-multi_json-testsuite) weakremover(ruby2.6-rubygem-fast_gettext) weakremover(ruby2.6-rubygem-fast_gettext-1.1) weakremover(ruby2.6-rubygem-fast_gettext-doc) weakremover(ruby2.6-rubygem-fast_gettext-doc-1.1) weakremover(ruby2.6-rubygem-fast_xs) weakremover(ruby2.6-rubygem-fast_xs-doc) weakremover(ruby2.6-rubygem-fast_xs-testsuite) weakremover(ruby2.6-rubygem-fastercsv) weakremover(ruby2.6-rubygem-fastercsv-doc) weakremover(ruby2.6-rubygem-fastercsv-testsuite) weakremover(ruby2.6-rubygem-ffi) weakremover(ruby2.6-rubygem-ffi-doc) weakremover(ruby2.6-rubygem-file-tail) weakremover(ruby2.6-rubygem-file-tail-doc) weakremover(ruby2.6-rubygem-flog) weakremover(ruby2.6-rubygem-flog-doc) weakremover(ruby2.6-rubygem-flog-testsuite) weakremover(ruby2.6-rubygem-fluentd) weakremover(ruby2.6-rubygem-fluentd-doc) weakremover(ruby2.6-rubygem-fluentd-testsuite) weakremover(ruby2.6-rubygem-fog-core) weakremover(ruby2.6-rubygem-fog-core-doc) weakremover(ruby2.6-rubygem-fog-core-testsuite) weakremover(ruby2.6-rubygem-fog-json) weakremover(ruby2.6-rubygem-fog-json-doc) weakremover(ruby2.6-rubygem-fog-json-testsuite) weakremover(ruby2.6-rubygem-fog-libvirt) weakremover(ruby2.6-rubygem-fog-libvirt-doc) weakremover(ruby2.6-rubygem-fog-xml) weakremover(ruby2.6-rubygem-fog-xml-doc) weakremover(ruby2.6-rubygem-fog-xml-testsuite) weakremover(ruby2.6-rubygem-font-awesome-rails) weakremover(ruby2.6-rubygem-font-awesome-rails-doc) weakremover(ruby2.6-rubygem-font-awesome-rails-testsuite) weakremover(ruby2.6-rubygem-formatador) weakremover(ruby2.6-rubygem-formatador-doc) weakremover(ruby2.6-rubygem-forwardable-extended) weakremover(ruby2.6-rubygem-forwardable-extended-doc) weakremover(ruby2.6-rubygem-gem2rpm) weakremover(ruby2.6-rubygem-gem2rpm-doc) weakremover(ruby2.6-rubygem-get_process_mem) weakremover(ruby2.6-rubygem-get_process_mem-doc) weakremover(ruby2.6-rubygem-get_process_mem-testsuite) weakremover(ruby2.6-rubygem-gettext) weakremover(ruby2.6-rubygem-gettext-doc) weakremover(ruby2.6-rubygem-gettext-setup) weakremover(ruby2.6-rubygem-gettext-setup-doc) weakremover(ruby2.6-rubygem-gettext-setup-testsuite) weakremover(ruby2.6-rubygem-gettext-testsuite) weakremover(ruby2.6-rubygem-gettext_i18n_rails) weakremover(ruby2.6-rubygem-gettext_i18n_rails-doc) weakremover(ruby2.6-rubygem-gettext_i18n_rails_js) weakremover(ruby2.6-rubygem-gettext_i18n_rails_js-doc) weakremover(ruby2.6-rubygem-gettext_i18n_rails_js-testsuite) weakremover(ruby2.6-rubygem-gli) weakremover(ruby2.6-rubygem-gli-doc) weakremover(ruby2.6-rubygem-gli-testsuite) weakremover(ruby2.6-rubygem-globalid) weakremover(ruby2.6-rubygem-globalid-doc) weakremover(ruby2.6-rubygem-gpgme) weakremover(ruby2.6-rubygem-gpgme-doc) weakremover(ruby2.6-rubygem-gpgme-testsuite) weakremover(ruby2.6-rubygem-grape) weakremover(ruby2.6-rubygem-grape-doc) weakremover(ruby2.6-rubygem-grape-testsuite) weakremover(ruby2.6-rubygem-gravatar_image_tag) weakremover(ruby2.6-rubygem-gravatar_image_tag-doc) weakremover(ruby2.6-rubygem-gravatar_image_tag-testsuite) weakremover(ruby2.6-rubygem-gssapi) weakremover(ruby2.6-rubygem-gssapi-doc) weakremover(ruby2.6-rubygem-gssapi-testsuite) weakremover(ruby2.6-rubygem-gyoku) weakremover(ruby2.6-rubygem-gyoku-doc) weakremover(ruby2.6-rubygem-gyoku-testsuite) weakremover(ruby2.6-rubygem-haml) weakremover(ruby2.6-rubygem-haml-doc) weakremover(ruby2.6-rubygem-haml-rails) weakremover(ruby2.6-rubygem-haml-rails-doc) weakremover(ruby2.6-rubygem-haml-rails-testsuite) weakremover(ruby2.6-rubygem-has_mobile_views) weakremover(ruby2.6-rubygem-has_mobile_views-doc) weakremover(ruby2.6-rubygem-has_mobile_views-testsuite) weakremover(ruby2.6-rubygem-hashdiff) weakremover(ruby2.6-rubygem-hashdiff-doc) weakremover(ruby2.6-rubygem-hashdiff-testsuite) weakremover(ruby2.6-rubygem-hashicorp-checkpoint) weakremover(ruby2.6-rubygem-hashicorp-checkpoint-doc) weakremover(ruby2.6-rubygem-hashicorp-checkpoint-testsuite) weakremover(ruby2.6-rubygem-hashie) weakremover(ruby2.6-rubygem-hashie-doc) weakremover(ruby2.6-rubygem-hashie-testsuite) weakremover(ruby2.6-rubygem-highline) weakremover(ruby2.6-rubygem-highline-1_6) weakremover(ruby2.6-rubygem-highline-1_7) weakremover(ruby2.6-rubygem-highline-doc) weakremover(ruby2.6-rubygem-highline-doc-1_6) weakremover(ruby2.6-rubygem-highline-doc-1_7) weakremover(ruby2.6-rubygem-highline-testsuite-1_6) weakremover(ruby2.6-rubygem-highline-testsuite-1_7) weakremover(ruby2.6-rubygem-hike) weakremover(ruby2.6-rubygem-hike-1_2) weakremover(ruby2.6-rubygem-hike-doc) weakremover(ruby2.6-rubygem-hike-doc-1_2) weakremover(ruby2.6-rubygem-hitimes) weakremover(ruby2.6-rubygem-hitimes-doc) weakremover(ruby2.6-rubygem-hitimes-testsuite) weakremover(ruby2.6-rubygem-hoe) weakremover(ruby2.6-rubygem-hoe-doc) weakremover(ruby2.6-rubygem-hoe-testsuite) weakremover(ruby2.6-rubygem-hpricot) weakremover(ruby2.6-rubygem-hpricot-doc) weakremover(ruby2.6-rubygem-hpricot-testsuite) weakremover(ruby2.6-rubygem-html2haml) weakremover(ruby2.6-rubygem-html2haml-doc) weakremover(ruby2.6-rubygem-html2haml-testsuite) weakremover(ruby2.6-rubygem-http-accept-1.7) weakremover(ruby2.6-rubygem-http-accept-doc-1.7) weakremover(ruby2.6-rubygem-http-cookie) weakremover(ruby2.6-rubygem-http-cookie-doc) weakremover(ruby2.6-rubygem-http-cookie-testsuite) weakremover(ruby2.6-rubygem-http_accept_language) weakremover(ruby2.6-rubygem-http_accept_language-doc) weakremover(ruby2.6-rubygem-http_accept_language-testsuite) weakremover(ruby2.6-rubygem-http_parser.rb) weakremover(ruby2.6-rubygem-http_parser.rb-doc) weakremover(ruby2.6-rubygem-http_parser.rb-testsuite) weakremover(ruby2.6-rubygem-httpclient) weakremover(ruby2.6-rubygem-httpclient-doc) weakremover(ruby2.6-rubygem-httpclient-testsuite) weakremover(ruby2.6-rubygem-i18n) weakremover(ruby2.6-rubygem-i18n-0_6) weakremover(ruby2.6-rubygem-i18n-0_9) weakremover(ruby2.6-rubygem-i18n-1.1) weakremover(ruby2.6-rubygem-i18n-doc) weakremover(ruby2.6-rubygem-i18n-doc-0_6) weakremover(ruby2.6-rubygem-i18n-doc-0_9) weakremover(ruby2.6-rubygem-i18n-doc-1.1) weakremover(ruby2.6-rubygem-i18n-testsuite-0_6) weakremover(ruby2.6-rubygem-i18n-testsuite-0_9) weakremover(ruby2.6-rubygem-i18n-testsuite-1.1) weakremover(ruby2.6-rubygem-ice_nine) weakremover(ruby2.6-rubygem-ice_nine-doc) weakremover(ruby2.6-rubygem-ice_nine-testsuite) weakremover(ruby2.6-rubygem-inifile) weakremover(ruby2.6-rubygem-inifile-doc) weakremover(ruby2.6-rubygem-inifile-testsuite) weakremover(ruby2.6-rubygem-ipaddress) weakremover(ruby2.6-rubygem-ipaddress-doc) weakremover(ruby2.6-rubygem-ipaddress-testsuite) weakremover(ruby2.6-rubygem-jaro_winkler) weakremover(ruby2.6-rubygem-jaro_winkler-doc) weakremover(ruby2.6-rubygem-jbuilder) weakremover(ruby2.6-rubygem-jbuilder-doc) weakremover(ruby2.6-rubygem-jbuilder-testsuite) weakremover(ruby2.6-rubygem-jekyll) weakremover(ruby2.6-rubygem-jekyll-doc) weakremover(ruby2.6-rubygem-jekyll-sass-converter) weakremover(ruby2.6-rubygem-jekyll-sass-converter-doc) weakremover(ruby2.6-rubygem-jekyll-watch) weakremover(ruby2.6-rubygem-jekyll-watch-doc) weakremover(ruby2.6-rubygem-jmespath) weakremover(ruby2.6-rubygem-jmespath-doc) weakremover(ruby2.6-rubygem-journey-1_0) weakremover(ruby2.6-rubygem-journey-doc-1_0) weakremover(ruby2.6-rubygem-journey-testsuite-1_0) weakremover(ruby2.6-rubygem-jquery-rails) weakremover(ruby2.6-rubygem-jquery-rails-doc) weakremover(ruby2.6-rubygem-jquery-rails-testsuite) weakremover(ruby2.6-rubygem-jquery-ui-rails) weakremover(ruby2.6-rubygem-jquery-ui-rails-doc) weakremover(ruby2.6-rubygem-js-routes) weakremover(ruby2.6-rubygem-js-routes-doc) weakremover(ruby2.6-rubygem-js-routes-testsuite) weakremover(ruby2.6-rubygem-json) weakremover(ruby2.6-rubygem-json-doc) weakremover(ruby2.6-rubygem-json-jwt) weakremover(ruby2.6-rubygem-json-jwt-doc) weakremover(ruby2.6-rubygem-json-jwt-testsuite) weakremover(ruby2.6-rubygem-json-schema) weakremover(ruby2.6-rubygem-json-schema-2_2) weakremover(ruby2.6-rubygem-json-schema-doc) weakremover(ruby2.6-rubygem-json-schema-doc-2_2) weakremover(ruby2.6-rubygem-json-schema-testsuite-2_2) weakremover(ruby2.6-rubygem-json_pure) weakremover(ruby2.6-rubygem-json_pure-doc) weakremover(ruby2.6-rubygem-jwt) weakremover(ruby2.6-rubygem-jwt-1_5) weakremover(ruby2.6-rubygem-jwt-doc) weakremover(ruby2.6-rubygem-jwt-doc-1_5) weakremover(ruby2.6-rubygem-jwt-testsuite) weakremover(ruby2.6-rubygem-jwt-testsuite-1_5) weakremover(ruby2.6-rubygem-kgio) weakremover(ruby2.6-rubygem-kgio-doc) weakremover(ruby2.6-rubygem-kgio-testsuite) weakremover(ruby2.6-rubygem-kramdown) weakremover(ruby2.6-rubygem-kramdown-doc) weakremover(ruby2.6-rubygem-kramdown-testsuite) weakremover(ruby2.6-rubygem-launchy) weakremover(ruby2.6-rubygem-launchy-doc) weakremover(ruby2.6-rubygem-launchy-testsuite) weakremover(ruby2.6-rubygem-levenshtein) weakremover(ruby2.6-rubygem-levenshtein-doc) weakremover(ruby2.6-rubygem-levenshtein-testsuite) weakremover(ruby2.6-rubygem-librarian) weakremover(ruby2.6-rubygem-librarian-doc) weakremover(ruby2.6-rubygem-librarian-testsuite) weakremover(ruby2.6-rubygem-libyui-rake) weakremover(ruby2.6-rubygem-libyui-rake-doc) weakremover(ruby2.6-rubygem-lightbox2) weakremover(ruby2.6-rubygem-lightbox2-doc) weakremover(ruby2.6-rubygem-liquid) weakremover(ruby2.6-rubygem-liquid-3) weakremover(ruby2.6-rubygem-liquid-doc) weakremover(ruby2.6-rubygem-liquid-doc-3) weakremover(ruby2.6-rubygem-liquid-testsuite) weakremover(ruby2.6-rubygem-liquid-testsuite-3) weakremover(ruby2.6-rubygem-listen) weakremover(ruby2.6-rubygem-listen-3_0) weakremover(ruby2.6-rubygem-listen-3_1) weakremover(ruby2.6-rubygem-listen-doc) weakremover(ruby2.6-rubygem-listen-doc-3_0) weakremover(ruby2.6-rubygem-listen-doc-3_1) weakremover(ruby2.6-rubygem-little-plugger) weakremover(ruby2.6-rubygem-little-plugger-doc) weakremover(ruby2.6-rubygem-little-plugger-testsuite) weakremover(ruby2.6-rubygem-locale) weakremover(ruby2.6-rubygem-locale-doc) weakremover(ruby2.6-rubygem-locale-testsuite) weakremover(ruby2.6-rubygem-log4r) weakremover(ruby2.6-rubygem-log4r-doc) weakremover(ruby2.6-rubygem-logging) weakremover(ruby2.6-rubygem-logging-doc) weakremover(ruby2.6-rubygem-logging-testsuite) weakremover(ruby2.6-rubygem-lolcat) weakremover(ruby2.6-rubygem-lolcat-doc) weakremover(ruby2.6-rubygem-loofah) weakremover(ruby2.6-rubygem-loofah-doc) weakremover(ruby2.6-rubygem-loofah-testsuite) weakremover(ruby2.6-rubygem-mail) weakremover(ruby2.6-rubygem-mail-2_5) weakremover(ruby2.6-rubygem-mail-doc) weakremover(ruby2.6-rubygem-mail-doc-2_5) weakremover(ruby2.6-rubygem-manpages) weakremover(ruby2.6-rubygem-manpages-doc) weakremover(ruby2.6-rubygem-marcel) weakremover(ruby2.6-rubygem-marcel-doc) weakremover(ruby2.6-rubygem-memcache-client) weakremover(ruby2.6-rubygem-memcache-client-doc) weakremover(ruby2.6-rubygem-memcache-client-testsuite) weakremover(ruby2.6-rubygem-mercenary) weakremover(ruby2.6-rubygem-mercenary-doc) weakremover(ruby2.6-rubygem-mercenary-testsuite) weakremover(ruby2.6-rubygem-metaclass) weakremover(ruby2.6-rubygem-metaclass-doc) weakremover(ruby2.6-rubygem-metaclass-testsuite) weakremover(ruby2.6-rubygem-method_source) weakremover(ruby2.6-rubygem-method_source-doc) weakremover(ruby2.6-rubygem-method_source-testsuite) weakremover(ruby2.6-rubygem-micromachine) weakremover(ruby2.6-rubygem-micromachine-doc) weakremover(ruby2.6-rubygem-micromachine-testsuite) weakremover(ruby2.6-rubygem-mime) weakremover(ruby2.6-rubygem-mime-doc) weakremover(ruby2.6-rubygem-mime-testsuite) weakremover(ruby2.6-rubygem-mime-types) weakremover(ruby2.6-rubygem-mime-types-1) weakremover(ruby2.6-rubygem-mime-types-data) weakremover(ruby2.6-rubygem-mime-types-data-doc) weakremover(ruby2.6-rubygem-mime-types-doc) weakremover(ruby2.6-rubygem-mime-types-doc-1) weakremover(ruby2.6-rubygem-mime-types-testsuite) weakremover(ruby2.6-rubygem-mime-types-testsuite-1) weakremover(ruby2.6-rubygem-mimemagic) weakremover(ruby2.6-rubygem-mimemagic-doc) weakremover(ruby2.6-rubygem-mimemagic-testsuite) weakremover(ruby2.6-rubygem-mini_magick) weakremover(ruby2.6-rubygem-mini_magick-doc) weakremover(ruby2.6-rubygem-mini_mime) weakremover(ruby2.6-rubygem-mini_mime-doc) weakremover(ruby2.6-rubygem-mini_portile2) weakremover(ruby2.6-rubygem-mini_portile2-2_3) weakremover(ruby2.6-rubygem-mini_portile2-doc) weakremover(ruby2.6-rubygem-mini_portile2-doc-2_3) weakremover(ruby2.6-rubygem-mini_portile2-testsuite) weakremover(ruby2.6-rubygem-mini_portile2-testsuite-2_3) weakremover(ruby2.6-rubygem-minitar) weakremover(ruby2.6-rubygem-minitar-doc) weakremover(ruby2.6-rubygem-minitest) weakremover(ruby2.6-rubygem-minitest-doc) weakremover(ruby2.6-rubygem-minitest-testsuite) weakremover(ruby2.6-rubygem-mixlib-authentication) weakremover(ruby2.6-rubygem-mixlib-authentication-doc) weakremover(ruby2.6-rubygem-mixlib-authentication-testsuite) weakremover(ruby2.6-rubygem-mixlib-cli) weakremover(ruby2.6-rubygem-mixlib-cli-doc) weakremover(ruby2.6-rubygem-mixlib-cli-testsuite) weakremover(ruby2.6-rubygem-mixlib-config) weakremover(ruby2.6-rubygem-mixlib-config-doc) weakremover(ruby2.6-rubygem-mixlib-config-testsuite) weakremover(ruby2.6-rubygem-mixlib-log) weakremover(ruby2.6-rubygem-mixlib-log-doc) weakremover(ruby2.6-rubygem-mixlib-log-testsuite) weakremover(ruby2.6-rubygem-mixlib-shellout) weakremover(ruby2.6-rubygem-mixlib-shellout-doc) weakremover(ruby2.6-rubygem-mobileesp_converted) weakremover(ruby2.6-rubygem-mobileesp_converted-doc) weakremover(ruby2.6-rubygem-mobileesp_converted-testsuite) weakremover(ruby2.6-rubygem-mocha) weakremover(ruby2.6-rubygem-mocha-doc) weakremover(ruby2.6-rubygem-mocha-testsuite) weakremover(ruby2.6-rubygem-moneta) weakremover(ruby2.6-rubygem-moneta-0_7) weakremover(ruby2.6-rubygem-moneta-doc) weakremover(ruby2.6-rubygem-moneta-doc-0_7) weakremover(ruby2.6-rubygem-moneta-testsuite) weakremover(ruby2.6-rubygem-moneta-testsuite-0_7) weakremover(ruby2.6-rubygem-msgpack) weakremover(ruby2.6-rubygem-msgpack-doc) weakremover(ruby2.6-rubygem-msgpack-testsuite) weakremover(ruby2.6-rubygem-multi_json) weakremover(ruby2.6-rubygem-multi_json-doc) weakremover(ruby2.6-rubygem-multi_xml) weakremover(ruby2.6-rubygem-multi_xml-doc) weakremover(ruby2.6-rubygem-multipart-post) weakremover(ruby2.6-rubygem-multipart-post-doc) weakremover(ruby2.6-rubygem-multipart-post-testsuite) weakremover(ruby2.6-rubygem-mustache) weakremover(ruby2.6-rubygem-mustache-doc) weakremover(ruby2.6-rubygem-mustache-testsuite) weakremover(ruby2.6-rubygem-mustermann) weakremover(ruby2.6-rubygem-mustermann-doc) weakremover(ruby2.6-rubygem-mustermann-grape) weakremover(ruby2.6-rubygem-mustermann-grape-doc) weakremover(ruby2.6-rubygem-mustermann-grape-testsuite) weakremover(ruby2.6-rubygem-mustermann-testsuite) weakremover(ruby2.6-rubygem-mysql2) weakremover(ruby2.6-rubygem-mysql2-0.4) weakremover(ruby2.6-rubygem-mysql2-doc) weakremover(ruby2.6-rubygem-mysql2-doc-0.4) weakremover(ruby2.6-rubygem-mysql2-testsuite) weakremover(ruby2.6-rubygem-mysql2-testsuite-0.4) weakremover(ruby2.6-rubygem-net-ldap) weakremover(ruby2.6-rubygem-net-ldap-doc) weakremover(ruby2.6-rubygem-net-ldap-testsuite) weakremover(ruby2.6-rubygem-net-scp) weakremover(ruby2.6-rubygem-net-scp-1_1) weakremover(ruby2.6-rubygem-net-scp-1_2) weakremover(ruby2.6-rubygem-net-scp-doc) weakremover(ruby2.6-rubygem-net-scp-doc-1_1) weakremover(ruby2.6-rubygem-net-scp-doc-1_2) weakremover(ruby2.6-rubygem-net-scp-testsuite) weakremover(ruby2.6-rubygem-net-scp-testsuite-1_1) weakremover(ruby2.6-rubygem-net-scp-testsuite-1_2) weakremover(ruby2.6-rubygem-net-sftp) weakremover(ruby2.6-rubygem-net-sftp-doc) weakremover(ruby2.6-rubygem-net-sftp-testsuite) weakremover(ruby2.6-rubygem-net-ssh) weakremover(ruby2.6-rubygem-net-ssh-4_1) weakremover(ruby2.6-rubygem-net-ssh-5.0) weakremover(ruby2.6-rubygem-net-ssh-5.1) weakremover(ruby2.6-rubygem-net-ssh-doc) weakremover(ruby2.6-rubygem-net-ssh-doc-4_1) weakremover(ruby2.6-rubygem-net-ssh-doc-5.0) weakremover(ruby2.6-rubygem-net-ssh-doc-5.1) weakremover(ruby2.6-rubygem-net-ssh-gateway) weakremover(ruby2.6-rubygem-net-ssh-gateway-doc) weakremover(ruby2.6-rubygem-net-ssh-multi) weakremover(ruby2.6-rubygem-net-ssh-multi-1_1) weakremover(ruby2.6-rubygem-net-ssh-multi-doc) weakremover(ruby2.6-rubygem-net-ssh-multi-doc-1_1) weakremover(ruby2.6-rubygem-net-ssh-multi-testsuite) weakremover(ruby2.6-rubygem-net-ssh-multi-testsuite-1_1) weakremover(ruby2.6-rubygem-netrc) weakremover(ruby2.6-rubygem-netrc-doc) weakremover(ruby2.6-rubygem-netrc-testsuite) weakremover(ruby2.6-rubygem-nio4r) weakremover(ruby2.6-rubygem-nio4r-doc) weakremover(ruby2.6-rubygem-nio4r-testsuite) weakremover(ruby2.6-rubygem-nokogiri) weakremover(ruby2.6-rubygem-nokogiri-doc) weakremover(ruby2.6-rubygem-nori) weakremover(ruby2.6-rubygem-nori-doc) weakremover(ruby2.6-rubygem-nori-testsuite) weakremover(ruby2.6-rubygem-oauth) weakremover(ruby2.6-rubygem-oauth-doc) weakremover(ruby2.6-rubygem-oauth2) weakremover(ruby2.6-rubygem-oauth2-doc) weakremover(ruby2.6-rubygem-omniauth) weakremover(ruby2.6-rubygem-omniauth-doc) weakremover(ruby2.6-rubygem-omniauth-github) weakremover(ruby2.6-rubygem-omniauth-github-doc) weakremover(ruby2.6-rubygem-omniauth-github-testsuite) weakremover(ruby2.6-rubygem-omniauth-gitlab) weakremover(ruby2.6-rubygem-omniauth-gitlab-doc) weakremover(ruby2.6-rubygem-omniauth-gitlab-testsuite) weakremover(ruby2.6-rubygem-omniauth-google-oauth2) weakremover(ruby2.6-rubygem-omniauth-google-oauth2-doc) weakremover(ruby2.6-rubygem-omniauth-google-oauth2-testsuite) weakremover(ruby2.6-rubygem-omniauth-oauth) weakremover(ruby2.6-rubygem-omniauth-oauth-doc) weakremover(ruby2.6-rubygem-omniauth-oauth-testsuite) weakremover(ruby2.6-rubygem-omniauth-oauth2) weakremover(ruby2.6-rubygem-omniauth-oauth2-doc) weakremover(ruby2.6-rubygem-omniauth-oauth2-testsuite) weakremover(ruby2.6-rubygem-open4) weakremover(ruby2.6-rubygem-open4-doc) weakremover(ruby2.6-rubygem-open4-testsuite) weakremover(ruby2.6-rubygem-openid_connect) weakremover(ruby2.6-rubygem-openid_connect-doc) weakremover(ruby2.6-rubygem-openid_connect-testsuite) weakremover(ruby2.6-rubygem-optimist) weakremover(ruby2.6-rubygem-optimist-doc) weakremover(ruby2.6-rubygem-optimist-testsuite) weakremover(ruby2.6-rubygem-orm_adapter) weakremover(ruby2.6-rubygem-orm_adapter-doc) weakremover(ruby2.6-rubygem-orm_adapter-testsuite) weakremover(ruby2.6-rubygem-owncloud-admin) weakremover(ruby2.6-rubygem-owncloud-admin-doc) weakremover(ruby2.6-rubygem-packaging_rake_tasks) weakremover(ruby2.6-rubygem-packaging_rake_tasks-doc) weakremover(ruby2.6-rubygem-paint) weakremover(ruby2.6-rubygem-paint-doc) weakremover(ruby2.6-rubygem-parallel) weakremover(ruby2.6-rubygem-parallel-doc) weakremover(ruby2.6-rubygem-parallel_tests) weakremover(ruby2.6-rubygem-parallel_tests-doc) weakremover(ruby2.6-rubygem-parser) weakremover(ruby2.6-rubygem-parser-doc) weakremover(ruby2.6-rubygem-parser-testsuite) weakremover(ruby2.6-rubygem-passenger) weakremover(ruby2.6-rubygem-passenger-doc) weakremover(ruby2.6-rubygem-path_expander) weakremover(ruby2.6-rubygem-path_expander-doc) weakremover(ruby2.6-rubygem-path_expander-testsuite) weakremover(ruby2.6-rubygem-pathutil) weakremover(ruby2.6-rubygem-pathutil-doc) weakremover(ruby2.6-rubygem-pg) weakremover(ruby2.6-rubygem-pg-doc) weakremover(ruby2.6-rubygem-pg-testsuite) weakremover(ruby2.6-rubygem-pkg-config) weakremover(ruby2.6-rubygem-pkg-config-doc) weakremover(ruby2.6-rubygem-pkg-config-testsuite) weakremover(ruby2.6-rubygem-po_to_json) weakremover(ruby2.6-rubygem-po_to_json-doc) weakremover(ruby2.6-rubygem-po_to_json-testsuite) weakremover(ruby2.6-rubygem-polyglot) weakremover(ruby2.6-rubygem-polyglot-doc) weakremover(ruby2.6-rubygem-power_assert) weakremover(ruby2.6-rubygem-power_assert-doc) weakremover(ruby2.6-rubygem-pry) weakremover(ruby2.6-rubygem-pry-doc) weakremover(ruby2.6-rubygem-pry-doc-testsuite) weakremover(ruby2.6-rubygem-pry_debug) weakremover(ruby2.6-rubygem-pry_debug-doc) weakremover(ruby2.6-rubygem-pry_debug-testsuite) weakremover(ruby2.6-rubygem-public_suffix) weakremover(ruby2.6-rubygem-public_suffix-3.1) weakremover(ruby2.6-rubygem-public_suffix-doc) weakremover(ruby2.6-rubygem-public_suffix-doc-3.1) weakremover(ruby2.6-rubygem-public_suffix-testsuite) weakremover(ruby2.6-rubygem-public_suffix-testsuite-3.1) weakremover(ruby2.6-rubygem-puma) weakremover(ruby2.6-rubygem-puma-doc) weakremover(ruby2.6-rubygem-puma_worker_killer) weakremover(ruby2.6-rubygem-puma_worker_killer-doc) weakremover(ruby2.6-rubygem-puma_worker_killer-testsuite) weakremover(ruby2.6-rubygem-pundit) weakremover(ruby2.6-rubygem-pundit-doc) weakremover(ruby2.6-rubygem-pundit-testsuite) weakremover(ruby2.6-rubygem-quiet_assets) weakremover(ruby2.6-rubygem-quiet_assets-doc) weakremover(ruby2.6-rubygem-quiet_assets-testsuite) weakremover(ruby2.6-rubygem-rack) weakremover(ruby2.6-rubygem-rack-1_3) weakremover(ruby2.6-rubygem-rack-1_4) weakremover(ruby2.6-rubygem-rack-1_6) weakremover(ruby2.6-rubygem-rack-2.0) weakremover(ruby2.6-rubygem-rack-accept) weakremover(ruby2.6-rubygem-rack-accept-doc) weakremover(ruby2.6-rubygem-rack-accept-testsuite) weakremover(ruby2.6-rubygem-rack-cache-1_2) weakremover(ruby2.6-rubygem-rack-cache-doc-1_2) weakremover(ruby2.6-rubygem-rack-cache-testsuite-1_2) weakremover(ruby2.6-rubygem-rack-doc) weakremover(ruby2.6-rubygem-rack-doc-1_3) weakremover(ruby2.6-rubygem-rack-doc-1_4) weakremover(ruby2.6-rubygem-rack-doc-1_6) weakremover(ruby2.6-rubygem-rack-doc-2.0) weakremover(ruby2.6-rubygem-rack-oauth2) weakremover(ruby2.6-rubygem-rack-oauth2-doc) weakremover(ruby2.6-rubygem-rack-oauth2-testsuite) weakremover(ruby2.6-rubygem-rack-protection) weakremover(ruby2.6-rubygem-rack-protection-doc) weakremover(ruby2.6-rubygem-rack-proxy) weakremover(ruby2.6-rubygem-rack-proxy-doc) weakremover(ruby2.6-rubygem-rack-proxy-testsuite) weakremover(ruby2.6-rubygem-rack-ssl) weakremover(ruby2.6-rubygem-rack-ssl-1_3) weakremover(ruby2.6-rubygem-rack-ssl-doc) weakremover(ruby2.6-rubygem-rack-ssl-doc-1_3) weakremover(ruby2.6-rubygem-rack-test-0_6) weakremover(ruby2.6-rubygem-rack-test-doc-0_6) weakremover(ruby2.6-rubygem-rack-test-testsuite-0_6) weakremover(ruby2.6-rubygem-rack-testsuite) weakremover(ruby2.6-rubygem-rack-testsuite-1_3) weakremover(ruby2.6-rubygem-rack-testsuite-1_4) weakremover(ruby2.6-rubygem-rack-testsuite-1_6) weakremover(ruby2.6-rubygem-rack-testsuite-2.0) weakremover(ruby2.6-rubygem-rails-5.2) weakremover(ruby2.6-rubygem-rails-5_0) weakremover(ruby2.6-rubygem-rails-5_1) weakremover(ruby2.6-rubygem-rails-6.0) weakremover(ruby2.6-rubygem-rails-deprecated_sanitizer) weakremover(ruby2.6-rubygem-rails-deprecated_sanitizer-doc) weakremover(ruby2.6-rubygem-rails-deprecated_sanitizer-testsuite) weakremover(ruby2.6-rubygem-rails-doc-5.2) weakremover(ruby2.6-rubygem-rails-doc-5_0) weakremover(ruby2.6-rubygem-rails-doc-5_1) weakremover(ruby2.6-rubygem-rails-doc-6.0) weakremover(ruby2.6-rubygem-rails-dom-testing) weakremover(ruby2.6-rubygem-rails-dom-testing-doc) weakremover(ruby2.6-rubygem-rails-dom-testing-testsuite) weakremover(ruby2.6-rubygem-rails-html-sanitizer) weakremover(ruby2.6-rubygem-rails-html-sanitizer-doc) weakremover(ruby2.6-rubygem-rails-html-sanitizer-testsuite) weakremover(ruby2.6-rubygem-rails-i18n) weakremover(ruby2.6-rubygem-rails-i18n-doc) weakremover(ruby2.6-rubygem-rails_stdout_logging) weakremover(ruby2.6-rubygem-rails_stdout_logging-doc) weakremover(ruby2.6-rubygem-rails_stdout_logging-testsuite) weakremover(ruby2.6-rubygem-railties-5.2) weakremover(ruby2.6-rubygem-railties-5_0) weakremover(ruby2.6-rubygem-railties-5_1) weakremover(ruby2.6-rubygem-railties-6.0) weakremover(ruby2.6-rubygem-railties-doc-5.2) weakremover(ruby2.6-rubygem-railties-doc-5_0) weakremover(ruby2.6-rubygem-railties-doc-5_1) weakremover(ruby2.6-rubygem-railties-doc-6.0) weakremover(ruby2.6-rubygem-rainbow) weakremover(ruby2.6-rubygem-rainbow-doc) weakremover(ruby2.6-rubygem-rainbow-testsuite) weakremover(ruby2.6-rubygem-raindrops) weakremover(ruby2.6-rubygem-raindrops-doc) weakremover(ruby2.6-rubygem-raindrops-testsuite) weakremover(ruby2.6-rubygem-rake) weakremover(ruby2.6-rubygem-rake-11_3) weakremover(ruby2.6-rubygem-rake-12.3) weakremover(ruby2.6-rubygem-rake-12_0) weakremover(ruby2.6-rubygem-rake-compiler) weakremover(ruby2.6-rubygem-rake-compiler-doc) weakremover(ruby2.6-rubygem-rake-compiler-testsuite) weakremover(ruby2.6-rubygem-rake-doc) weakremover(ruby2.6-rubygem-rake-doc-11_3) weakremover(ruby2.6-rubygem-rake-doc-12.3) weakremover(ruby2.6-rubygem-rake-doc-12_0) weakremover(ruby2.6-rubygem-rb-fsevent) weakremover(ruby2.6-rubygem-rb-fsevent-doc) weakremover(ruby2.6-rubygem-rb-inotify) weakremover(ruby2.6-rubygem-rb-inotify-doc) weakremover(ruby2.6-rubygem-rb-inotify-testsuite) weakremover(ruby2.6-rubygem-rb-kqueue) weakremover(ruby2.6-rubygem-rb-kqueue-doc) weakremover(ruby2.6-rubygem-rb-kqueue-testsuite) weakremover(ruby2.6-rubygem-rdiscount) weakremover(ruby2.6-rubygem-rdiscount-doc) weakremover(ruby2.6-rubygem-rdiscount-testsuite) weakremover(ruby2.6-rubygem-rdoc-4) weakremover(ruby2.6-rubygem-rdoc-doc-4) weakremover(ruby2.6-rubygem-rdoc-testsuite-4) weakremover(ruby2.6-rubygem-regexp_parser) weakremover(ruby2.6-rubygem-regexp_parser-doc) weakremover(ruby2.6-rubygem-regexp_parser-testsuite) weakremover(ruby2.6-rubygem-responders) weakremover(ruby2.6-rubygem-responders-doc) weakremover(ruby2.6-rubygem-rest-client) weakremover(ruby2.6-rubygem-rest-client-doc) weakremover(ruby2.6-rubygem-rest-client-testsuite) weakremover(ruby2.6-rubygem-restility) weakremover(ruby2.6-rubygem-restility-doc) weakremover(ruby2.6-rubygem-restility-testsuite) weakremover(ruby2.6-rubygem-reverse_markdown) weakremover(ruby2.6-rubygem-reverse_markdown-doc) weakremover(ruby2.6-rubygem-reverse_markdown-testsuite) weakremover(ruby2.6-rubygem-rgen) weakremover(ruby2.6-rubygem-rgen-doc) weakremover(ruby2.6-rubygem-rgen-testsuite) weakremover(ruby2.6-rubygem-rhc) weakremover(ruby2.6-rubygem-rhc-doc) weakremover(ruby2.6-rubygem-rhc-testsuite) weakremover(ruby2.6-rubygem-rice) weakremover(ruby2.6-rubygem-rice-doc) weakremover(ruby2.6-rubygem-rice-testsuite) weakremover(ruby2.6-rubygem-ronn) weakremover(ruby2.6-rubygem-ronn-doc) weakremover(ruby2.6-rubygem-ronn-testsuite) weakremover(ruby2.6-rubygem-rouge) weakremover(ruby2.6-rubygem-rouge-1) weakremover(ruby2.6-rubygem-rouge-doc) weakremover(ruby2.6-rubygem-rouge-doc-1) weakremover(ruby2.6-rubygem-rpm) weakremover(ruby2.6-rubygem-rpm-doc) weakremover(ruby2.6-rubygem-rpm-testsuite) weakremover(ruby2.6-rubygem-rspec) weakremover(ruby2.6-rubygem-rspec-3_5) weakremover(ruby2.6-rubygem-rspec-core) weakremover(ruby2.6-rubygem-rspec-core-3_5) weakremover(ruby2.6-rubygem-rspec-core-doc) weakremover(ruby2.6-rubygem-rspec-core-doc-3_5) weakremover(ruby2.6-rubygem-rspec-doc) weakremover(ruby2.6-rubygem-rspec-doc-3_5) weakremover(ruby2.6-rubygem-rspec-expectations) weakremover(ruby2.6-rubygem-rspec-expectations-3_5) weakremover(ruby2.6-rubygem-rspec-expectations-doc) weakremover(ruby2.6-rubygem-rspec-expectations-doc-3_5) weakremover(ruby2.6-rubygem-rspec-its) weakremover(ruby2.6-rubygem-rspec-its-doc) weakremover(ruby2.6-rubygem-rspec-its-testsuite) weakremover(ruby2.6-rubygem-rspec-mocks) weakremover(ruby2.6-rubygem-rspec-mocks-3_5) weakremover(ruby2.6-rubygem-rspec-mocks-doc) weakremover(ruby2.6-rubygem-rspec-mocks-doc-3_5) weakremover(ruby2.6-rubygem-rspec-rails) weakremover(ruby2.6-rubygem-rspec-rails-3.9) weakremover(ruby2.6-rubygem-rspec-rails-doc) weakremover(ruby2.6-rubygem-rspec-rails-doc-3.9) weakremover(ruby2.6-rubygem-rspec-support) weakremover(ruby2.6-rubygem-rspec-support-3_5) weakremover(ruby2.6-rubygem-rspec-support-doc) weakremover(ruby2.6-rubygem-rspec-support-doc-3_5) weakremover(ruby2.6-rubygem-rubocop) weakremover(ruby2.6-rubygem-rubocop-ast) weakremover(ruby2.6-rubygem-rubocop-ast-doc) weakremover(ruby2.6-rubygem-rubocop-doc) weakremover(ruby2.6-rubygem-ruby-augeas) weakremover(ruby2.6-rubygem-ruby-augeas-doc) weakremover(ruby2.6-rubygem-ruby-dbus) weakremover(ruby2.6-rubygem-ruby-dbus-doc) weakremover(ruby2.6-rubygem-ruby-dbus-testsuite) weakremover(ruby2.6-rubygem-ruby-filemagic) weakremover(ruby2.6-rubygem-ruby-filemagic-doc) weakremover(ruby2.6-rubygem-ruby-filemagic-testsuite) weakremover(ruby2.6-rubygem-ruby-libvirt) weakremover(ruby2.6-rubygem-ruby-libvirt-doc) weakremover(ruby2.6-rubygem-ruby-openid) weakremover(ruby2.6-rubygem-ruby-openid-doc) weakremover(ruby2.6-rubygem-ruby-openid-testsuite) weakremover(ruby2.6-rubygem-ruby-progressbar) weakremover(ruby2.6-rubygem-ruby-progressbar-doc) weakremover(ruby2.6-rubygem-ruby-rc4) weakremover(ruby2.6-rubygem-ruby-rc4-doc) weakremover(ruby2.6-rubygem-ruby-rc4-testsuite) weakremover(ruby2.6-rubygem-ruby-shadow) weakremover(ruby2.6-rubygem-ruby-shadow-doc) weakremover(ruby2.6-rubygem-ruby2_keywords) weakremover(ruby2.6-rubygem-ruby2_keywords-doc) weakremover(ruby2.6-rubygem-ruby_dep) weakremover(ruby2.6-rubygem-ruby_dep-1_3) weakremover(ruby2.6-rubygem-ruby_dep-doc) weakremover(ruby2.6-rubygem-ruby_dep-doc-1_3) weakremover(ruby2.6-rubygem-ruby_dig) weakremover(ruby2.6-rubygem-ruby_dig-doc) weakremover(ruby2.6-rubygem-ruby_dig-testsuite) weakremover(ruby2.6-rubygem-ruby_parser) weakremover(ruby2.6-rubygem-ruby_parser-doc) weakremover(ruby2.6-rubygem-ruby_parser-testsuite) weakremover(ruby2.6-rubygem-rubyforge) weakremover(ruby2.6-rubygem-rubyforge-doc) weakremover(ruby2.6-rubygem-rubyforge-testsuite) weakremover(ruby2.6-rubygem-rubyntlm) weakremover(ruby2.6-rubygem-rubyntlm-doc) weakremover(ruby2.6-rubygem-rubyntlm-testsuite) weakremover(ruby2.6-rubygem-rubyzip) weakremover(ruby2.6-rubygem-rubyzip-1.3) weakremover(ruby2.6-rubygem-rubyzip-doc) weakremover(ruby2.6-rubygem-rubyzip-doc-1.3) weakremover(ruby2.6-rubygem-rubyzip-testsuite) weakremover(ruby2.6-rubygem-rubyzip-testsuite-1.3) weakremover(ruby2.6-rubygem-safe_yaml) weakremover(ruby2.6-rubygem-safe_yaml-doc) weakremover(ruby2.6-rubygem-safe_yaml-testsuite) weakremover(ruby2.6-rubygem-sass) weakremover(ruby2.6-rubygem-sass-doc) weakremover(ruby2.6-rubygem-sass-listen) weakremover(ruby2.6-rubygem-sass-listen-doc) weakremover(ruby2.6-rubygem-sass-rails) weakremover(ruby2.6-rubygem-sass-rails-5.1) weakremover(ruby2.6-rubygem-sass-rails-doc) weakremover(ruby2.6-rubygem-sass-rails-doc-5.1) weakremover(ruby2.6-rubygem-sassc) weakremover(ruby2.6-rubygem-sassc-2.2) weakremover(ruby2.6-rubygem-sassc-doc) weakremover(ruby2.6-rubygem-sassc-doc-2.2) weakremover(ruby2.6-rubygem-sassc-rails) weakremover(ruby2.6-rubygem-sassc-rails-doc) weakremover(ruby2.6-rubygem-sassc-rails-testsuite) weakremover(ruby2.6-rubygem-sassc-testsuite) weakremover(ruby2.6-rubygem-sassc-testsuite-2.2) weakremover(ruby2.6-rubygem-sdoc) weakremover(ruby2.6-rubygem-sdoc-doc) weakremover(ruby2.6-rubygem-sdoc-testsuite) weakremover(ruby2.6-rubygem-securecompare) weakremover(ruby2.6-rubygem-securecompare-doc) weakremover(ruby2.6-rubygem-securecompare-testsuite) weakremover(ruby2.6-rubygem-serverengine) weakremover(ruby2.6-rubygem-serverengine-doc) weakremover(ruby2.6-rubygem-serverengine-testsuite) weakremover(ruby2.6-rubygem-sexp_processor) weakremover(ruby2.6-rubygem-sexp_processor-doc) weakremover(ruby2.6-rubygem-sexp_processor-testsuite) weakremover(ruby2.6-rubygem-sigdump) weakremover(ruby2.6-rubygem-sigdump-doc) weakremover(ruby2.6-rubygem-simple_oauth) weakremover(ruby2.6-rubygem-simple_oauth-doc) weakremover(ruby2.6-rubygem-simplecov) weakremover(ruby2.6-rubygem-simplecov-doc) weakremover(ruby2.6-rubygem-simplecov-html) weakremover(ruby2.6-rubygem-simplecov-html-doc) weakremover(ruby2.6-rubygem-simplecov-html-testsuite) weakremover(ruby2.6-rubygem-simpleidn) weakremover(ruby2.6-rubygem-simpleidn-doc) weakremover(ruby2.6-rubygem-sinatra) weakremover(ruby2.6-rubygem-sinatra-doc) weakremover(ruby2.6-rubygem-slim) weakremover(ruby2.6-rubygem-slim-doc) weakremover(ruby2.6-rubygem-slim-testsuite) weakremover(ruby2.6-rubygem-slop) weakremover(ruby2.6-rubygem-slop-3) weakremover(ruby2.6-rubygem-slop-3_3) weakremover(ruby2.6-rubygem-slop-doc) weakremover(ruby2.6-rubygem-slop-doc-3) weakremover(ruby2.6-rubygem-slop-doc-3_3) weakremover(ruby2.6-rubygem-slop-testsuite) weakremover(ruby2.6-rubygem-slop-testsuite-3) weakremover(ruby2.6-rubygem-slop-testsuite-3_3) weakremover(ruby2.6-rubygem-spring) weakremover(ruby2.6-rubygem-spring-doc) weakremover(ruby2.6-rubygem-spring-watcher-listen) weakremover(ruby2.6-rubygem-spring-watcher-listen-doc) weakremover(ruby2.6-rubygem-spring-watcher-listen-testsuite) weakremover(ruby2.6-rubygem-sprockets) weakremover(ruby2.6-rubygem-sprockets-2_1) weakremover(ruby2.6-rubygem-sprockets-2_2) weakremover(ruby2.6-rubygem-sprockets-3.7) weakremover(ruby2.6-rubygem-sprockets-doc) weakremover(ruby2.6-rubygem-sprockets-doc-2_1) weakremover(ruby2.6-rubygem-sprockets-doc-2_2) weakremover(ruby2.6-rubygem-sprockets-doc-3.7) weakremover(ruby2.6-rubygem-sprockets-helpers) weakremover(ruby2.6-rubygem-sprockets-helpers-doc) weakremover(ruby2.6-rubygem-sprockets-helpers-testsuite) weakremover(ruby2.6-rubygem-sprockets-rails) weakremover(ruby2.6-rubygem-sprockets-rails-doc) weakremover(ruby2.6-rubygem-sqlite3) weakremover(ruby2.6-rubygem-sqlite3-doc) weakremover(ruby2.6-rubygem-sqlite3-testsuite) weakremover(ruby2.6-rubygem-sshkit) weakremover(ruby2.6-rubygem-sshkit-doc) weakremover(ruby2.6-rubygem-sshkit-testsuite) weakremover(ruby2.6-rubygem-stackdeck) weakremover(ruby2.6-rubygem-stackdeck-doc) weakremover(ruby2.6-rubygem-stackdeck-testsuite) weakremover(ruby2.6-rubygem-stomp) weakremover(ruby2.6-rubygem-stomp-doc) weakremover(ruby2.6-rubygem-stomp-testsuite) weakremover(ruby2.6-rubygem-strptime) weakremover(ruby2.6-rubygem-strptime-doc) weakremover(ruby2.6-rubygem-swd) weakremover(ruby2.6-rubygem-swd-doc) weakremover(ruby2.6-rubygem-swd-testsuite) weakremover(ruby2.6-rubygem-systemu) weakremover(ruby2.6-rubygem-systemu-doc) weakremover(ruby2.6-rubygem-systemu-testsuite) weakremover(ruby2.6-rubygem-taskjuggler) weakremover(ruby2.6-rubygem-taskjuggler-doc) weakremover(ruby2.6-rubygem-taskjuggler-testsuite) weakremover(ruby2.6-rubygem-temple) weakremover(ruby2.6-rubygem-temple-doc) weakremover(ruby2.6-rubygem-temple-testsuite) weakremover(ruby2.6-rubygem-term-ansicolor) weakremover(ruby2.6-rubygem-term-ansicolor-doc) weakremover(ruby2.6-rubygem-test-unit) weakremover(ruby2.6-rubygem-test-unit-doc) weakremover(ruby2.6-rubygem-test-unit-testsuite) weakremover(ruby2.6-rubygem-text) weakremover(ruby2.6-rubygem-text-doc) weakremover(ruby2.6-rubygem-text-hyphen) weakremover(ruby2.6-rubygem-text-hyphen-doc) weakremover(ruby2.6-rubygem-text-hyphen-testsuite) weakremover(ruby2.6-rubygem-text-testsuite) weakremover(ruby2.6-rubygem-thor) weakremover(ruby2.6-rubygem-thor-0_19) weakremover(ruby2.6-rubygem-thor-doc) weakremover(ruby2.6-rubygem-thor-doc-0_19) weakremover(ruby2.6-rubygem-thread_safe) weakremover(ruby2.6-rubygem-thread_safe-doc) weakremover(ruby2.6-rubygem-thread_safe-testsuite) weakremover(ruby2.6-rubygem-tilt) weakremover(ruby2.6-rubygem-tilt-1_1) weakremover(ruby2.6-rubygem-tilt-1_4) weakremover(ruby2.6-rubygem-tilt-doc) weakremover(ruby2.6-rubygem-tilt-doc-1_1) weakremover(ruby2.6-rubygem-tilt-doc-1_4) weakremover(ruby2.6-rubygem-tilt-testsuite) weakremover(ruby2.6-rubygem-tilt-testsuite-1_1) weakremover(ruby2.6-rubygem-tilt-testsuite-1_4) weakremover(ruby2.6-rubygem-timers) weakremover(ruby2.6-rubygem-timers-doc) weakremover(ruby2.6-rubygem-timers-testsuite) weakremover(ruby2.6-rubygem-tins) weakremover(ruby2.6-rubygem-tins-doc) weakremover(ruby2.6-rubygem-tmuxinator) weakremover(ruby2.6-rubygem-tmuxinator-doc) weakremover(ruby2.6-rubygem-tmuxinator-testsuite) weakremover(ruby2.6-rubygem-tomlrb) weakremover(ruby2.6-rubygem-tomlrb-doc) weakremover(ruby2.6-rubygem-treetop) weakremover(ruby2.6-rubygem-treetop-1_4) weakremover(ruby2.6-rubygem-treetop-doc) weakremover(ruby2.6-rubygem-treetop-doc-1_4) weakremover(ruby2.6-rubygem-treetop-testsuite-1_4) weakremover(ruby2.6-rubygem-trollop) weakremover(ruby2.6-rubygem-trollop-doc) weakremover(ruby2.6-rubygem-trollop-testsuite) weakremover(ruby2.6-rubygem-turbolinks) weakremover(ruby2.6-rubygem-turbolinks-doc) weakremover(ruby2.6-rubygem-turbolinks-source) weakremover(ruby2.6-rubygem-turbolinks-source-doc) weakremover(ruby2.6-rubygem-tzinfo) weakremover(ruby2.6-rubygem-tzinfo-0) weakremover(ruby2.6-rubygem-tzinfo-1.2) weakremover(ruby2.6-rubygem-tzinfo-data) weakremover(ruby2.6-rubygem-tzinfo-data-doc) weakremover(ruby2.6-rubygem-tzinfo-doc) weakremover(ruby2.6-rubygem-tzinfo-doc-0) weakremover(ruby2.6-rubygem-tzinfo-doc-1.2) weakremover(ruby2.6-rubygem-tzinfo-testsuite-0) weakremover(ruby2.6-rubygem-tzinfo-testsuite-1.2) weakremover(ruby2.6-rubygem-uglifier) weakremover(ruby2.6-rubygem-uglifier-doc) weakremover(ruby2.6-rubygem-unf) weakremover(ruby2.6-rubygem-unf-doc) weakremover(ruby2.6-rubygem-unf-testsuite) weakremover(ruby2.6-rubygem-unf_ext) weakremover(ruby2.6-rubygem-unf_ext-doc) weakremover(ruby2.6-rubygem-unf_ext-testsuite) weakremover(ruby2.6-rubygem-unicode-display_width) weakremover(ruby2.6-rubygem-unicode-display_width-doc) weakremover(ruby2.6-rubygem-unicorn) weakremover(ruby2.6-rubygem-unicorn-doc) weakremover(ruby2.6-rubygem-unicorn-testsuite) weakremover(ruby2.6-rubygem-unicorn-worker-killer) weakremover(ruby2.6-rubygem-unicorn-worker-killer-doc) weakremover(ruby2.6-rubygem-url_safe_base64) weakremover(ruby2.6-rubygem-url_safe_base64-doc) weakremover(ruby2.6-rubygem-url_safe_base64-testsuite) weakremover(ruby2.6-rubygem-vagrant-spec) weakremover(ruby2.6-rubygem-vagrant-spec-doc) weakremover(ruby2.6-rubygem-vagrant-spec-testsuite) weakremover(ruby2.6-rubygem-vagrant_cloud) weakremover(ruby2.6-rubygem-vagrant_cloud-doc) weakremover(ruby2.6-rubygem-validate_email) weakremover(ruby2.6-rubygem-validate_email-doc) weakremover(ruby2.6-rubygem-validate_url) weakremover(ruby2.6-rubygem-validate_url-doc) weakremover(ruby2.6-rubygem-virtus) weakremover(ruby2.6-rubygem-virtus-doc) weakremover(ruby2.6-rubygem-virtus-testsuite) weakremover(ruby2.6-rubygem-warden) weakremover(ruby2.6-rubygem-warden-doc) weakremover(ruby2.6-rubygem-web-console) weakremover(ruby2.6-rubygem-web-console-2) weakremover(ruby2.6-rubygem-web-console-doc) weakremover(ruby2.6-rubygem-web-console-doc-2) weakremover(ruby2.6-rubygem-webfinger) weakremover(ruby2.6-rubygem-webfinger-doc) weakremover(ruby2.6-rubygem-webfinger-testsuite) weakremover(ruby2.6-rubygem-webmock-1_2) weakremover(ruby2.6-rubygem-webmock-2_3) weakremover(ruby2.6-rubygem-webmock-doc-1_2) weakremover(ruby2.6-rubygem-webmock-doc-2_3) weakremover(ruby2.6-rubygem-webmock-testsuite-1_2) weakremover(ruby2.6-rubygem-webmock-testsuite-2_3) weakremover(ruby2.6-rubygem-webpacker) weakremover(ruby2.6-rubygem-webpacker-doc) weakremover(ruby2.6-rubygem-webpacker-testsuite) weakremover(ruby2.6-rubygem-websocket) weakremover(ruby2.6-rubygem-websocket-doc) weakremover(ruby2.6-rubygem-websocket-driver) weakremover(ruby2.6-rubygem-websocket-driver-0_6) weakremover(ruby2.6-rubygem-websocket-driver-doc) weakremover(ruby2.6-rubygem-websocket-driver-doc-0_6) weakremover(ruby2.6-rubygem-websocket-extensions) weakremover(ruby2.6-rubygem-websocket-extensions-doc) weakremover(ruby2.6-rubygem-websocket-testsuite) weakremover(ruby2.6-rubygem-winrm) weakremover(ruby2.6-rubygem-winrm-2_1) weakremover(ruby2.6-rubygem-winrm-doc) weakremover(ruby2.6-rubygem-winrm-doc-2_1) weakremover(ruby2.6-rubygem-winrm-elevated) weakremover(ruby2.6-rubygem-winrm-elevated-doc) weakremover(ruby2.6-rubygem-winrm-fs) weakremover(ruby2.6-rubygem-winrm-fs-doc) weakremover(ruby2.6-rubygem-xdg) weakremover(ruby2.6-rubygem-xdg-2) weakremover(ruby2.6-rubygem-xdg-doc) weakremover(ruby2.6-rubygem-xdg-doc-2) weakremover(ruby2.6-rubygem-xdg-testsuite) weakremover(ruby2.6-rubygem-xdg-testsuite-2) weakremover(ruby2.6-rubygem-xml-simple) weakremover(ruby2.6-rubygem-xml-simple-doc) weakremover(ruby2.6-rubygem-xmlhash) weakremover(ruby2.6-rubygem-xmlhash-doc) weakremover(ruby2.6-rubygem-xmlhash-testsuite) weakremover(ruby2.6-rubygem-yajl-ruby) weakremover(ruby2.6-rubygem-yajl-ruby-doc) weakremover(ruby2.6-rubygem-yajl-ruby-testsuite) weakremover(ruby2.6-rubygem-yard) weakremover(ruby2.6-rubygem-yard-doc) weakremover(ruby2.6-rubygem-yard-testsuite) weakremover(ruby2.6-rubygem-yast-rake) weakremover(ruby2.6-rubygem-yast-rake-doc) weakremover(ruby2.6-rubygem-zeitwerk) weakremover(ruby2.6-rubygem-zeitwerk-doc) weakremover(ruby2.7) weakremover(ruby2.7-devel) weakremover(ruby2.7-devel-extra) weakremover(ruby2.7-doc) weakremover(ruby2.7-doc-ri) weakremover(ruby2.7-rubygem-Ascii85) weakremover(ruby2.7-rubygem-Ascii85-doc) weakremover(ruby2.7-rubygem-Ascii85-testsuite) weakremover(ruby2.7-rubygem-RedCloth) weakremover(ruby2.7-rubygem-RedCloth-doc) weakremover(ruby2.7-rubygem-RedCloth-testsuite) weakremover(ruby2.7-rubygem-abstract) weakremover(ruby2.7-rubygem-abstract-doc) weakremover(ruby2.7-rubygem-abstract-testsuite) weakremover(ruby2.7-rubygem-abstract_method) weakremover(ruby2.7-rubygem-abstract_method-doc) weakremover(ruby2.7-rubygem-actioncable-5.2) weakremover(ruby2.7-rubygem-actioncable-5_1) weakremover(ruby2.7-rubygem-actioncable-6.0) weakremover(ruby2.7-rubygem-actioncable-doc-5.2) weakremover(ruby2.7-rubygem-actioncable-doc-5_1) weakremover(ruby2.7-rubygem-actioncable-doc-6.0) weakremover(ruby2.7-rubygem-actionmailbox-6.0) weakremover(ruby2.7-rubygem-actionmailbox-doc-6.0) weakremover(ruby2.7-rubygem-actionmailer-5.2) weakremover(ruby2.7-rubygem-actionmailer-5_1) weakremover(ruby2.7-rubygem-actionmailer-6.0) weakremover(ruby2.7-rubygem-actionmailer-doc-5.2) weakremover(ruby2.7-rubygem-actionmailer-doc-5_1) weakremover(ruby2.7-rubygem-actionmailer-doc-6.0) weakremover(ruby2.7-rubygem-actionpack-5.2) weakremover(ruby2.7-rubygem-actionpack-5_1) weakremover(ruby2.7-rubygem-actionpack-6.0) weakremover(ruby2.7-rubygem-actionpack-doc-5.2) weakremover(ruby2.7-rubygem-actionpack-doc-5_1) weakremover(ruby2.7-rubygem-actionpack-doc-6.0) weakremover(ruby2.7-rubygem-actiontext-6.0) weakremover(ruby2.7-rubygem-actiontext-doc-6.0) weakremover(ruby2.7-rubygem-actionview-5.2) weakremover(ruby2.7-rubygem-actionview-5_1) weakremover(ruby2.7-rubygem-actionview-6.0) weakremover(ruby2.7-rubygem-actionview-doc-5.2) weakremover(ruby2.7-rubygem-actionview-doc-5_1) weakremover(ruby2.7-rubygem-actionview-doc-6.0) weakremover(ruby2.7-rubygem-activejob-5.2) weakremover(ruby2.7-rubygem-activejob-5_1) weakremover(ruby2.7-rubygem-activejob-6.0) weakremover(ruby2.7-rubygem-activejob-doc-5.2) weakremover(ruby2.7-rubygem-activejob-doc-5_1) weakremover(ruby2.7-rubygem-activejob-doc-6.0) weakremover(ruby2.7-rubygem-activemodel-5.2) weakremover(ruby2.7-rubygem-activemodel-5_1) weakremover(ruby2.7-rubygem-activemodel-6.0) weakremover(ruby2.7-rubygem-activemodel-doc-5.2) weakremover(ruby2.7-rubygem-activemodel-doc-5_1) weakremover(ruby2.7-rubygem-activemodel-doc-6.0) weakremover(ruby2.7-rubygem-activerecord-5.2) weakremover(ruby2.7-rubygem-activerecord-5_1) weakremover(ruby2.7-rubygem-activerecord-6.0) weakremover(ruby2.7-rubygem-activerecord-deprecated_finders) weakremover(ruby2.7-rubygem-activerecord-deprecated_finders-doc) weakremover(ruby2.7-rubygem-activerecord-doc-5.2) weakremover(ruby2.7-rubygem-activerecord-doc-6.0) weakremover(ruby2.7-rubygem-activestorage-5.2) weakremover(ruby2.7-rubygem-activestorage-6.0) weakremover(ruby2.7-rubygem-activestorage-doc-5.2) weakremover(ruby2.7-rubygem-activestorage-doc-6.0) weakremover(ruby2.7-rubygem-activesupport-5.2) weakremover(ruby2.7-rubygem-activesupport-5_1) weakremover(ruby2.7-rubygem-activesupport-6.0) weakremover(ruby2.7-rubygem-activesupport-doc-5.2) weakremover(ruby2.7-rubygem-activesupport-doc-5_1) weakremover(ruby2.7-rubygem-activesupport-doc-6.0) weakremover(ruby2.7-rubygem-addressable) weakremover(ruby2.7-rubygem-addressable-2_3) weakremover(ruby2.7-rubygem-addressable-doc) weakremover(ruby2.7-rubygem-addressable-doc-2_3) weakremover(ruby2.7-rubygem-addressable-testsuite) weakremover(ruby2.7-rubygem-addressable-testsuite-2_3) weakremover(ruby2.7-rubygem-aes_key_wrap) weakremover(ruby2.7-rubygem-aes_key_wrap-doc) weakremover(ruby2.7-rubygem-afm) weakremover(ruby2.7-rubygem-afm-doc) weakremover(ruby2.7-rubygem-afm-testsuite) weakremover(ruby2.7-rubygem-airbrussh) weakremover(ruby2.7-rubygem-airbrussh-doc) weakremover(ruby2.7-rubygem-amq-protocol) weakremover(ruby2.7-rubygem-amq-protocol-doc) weakremover(ruby2.7-rubygem-amq-protocol-testsuite) weakremover(ruby2.7-rubygem-amqp) weakremover(ruby2.7-rubygem-amqp-doc) weakremover(ruby2.7-rubygem-amqp-testsuite) weakremover(ruby2.7-rubygem-archive-tar-minitar) weakremover(ruby2.7-rubygem-archive-tar-minitar-doc) weakremover(ruby2.7-rubygem-arel) weakremover(ruby2.7-rubygem-arel-3_0) weakremover(ruby2.7-rubygem-arel-6) weakremover(ruby2.7-rubygem-arel-7) weakremover(ruby2.7-rubygem-arel-8) weakremover(ruby2.7-rubygem-arel-doc) weakremover(ruby2.7-rubygem-arel-doc-3_0) weakremover(ruby2.7-rubygem-arel-doc-6) weakremover(ruby2.7-rubygem-arel-doc-7) weakremover(ruby2.7-rubygem-arel-doc-8) weakremover(ruby2.7-rubygem-arel-testsuite-3_0) weakremover(ruby2.7-rubygem-asciidoctor) weakremover(ruby2.7-rubygem-asciidoctor-doc) weakremover(ruby2.7-rubygem-ast) weakremover(ruby2.7-rubygem-ast-doc) weakremover(ruby2.7-rubygem-ast-testsuite) weakremover(ruby2.7-rubygem-atomic) weakremover(ruby2.7-rubygem-atomic-doc) weakremover(ruby2.7-rubygem-atomic-testsuite) weakremover(ruby2.7-rubygem-attr_required) weakremover(ruby2.7-rubygem-attr_required-doc) weakremover(ruby2.7-rubygem-attr_required-testsuite) weakremover(ruby2.7-rubygem-autoprefixer-rails) weakremover(ruby2.7-rubygem-autoprefixer-rails-doc) weakremover(ruby2.7-rubygem-autoprefixer-rails-testsuite) weakremover(ruby2.7-rubygem-axiom-types) weakremover(ruby2.7-rubygem-axiom-types-doc) weakremover(ruby2.7-rubygem-axiom-types-testsuite) weakremover(ruby2.7-rubygem-backport) weakremover(ruby2.7-rubygem-backport-doc) weakremover(ruby2.7-rubygem-base32) weakremover(ruby2.7-rubygem-base32-doc) weakremover(ruby2.7-rubygem-base32-testsuite) weakremover(ruby2.7-rubygem-bcrypt) weakremover(ruby2.7-rubygem-bcrypt-doc) weakremover(ruby2.7-rubygem-bcrypt-ruby) weakremover(ruby2.7-rubygem-bcrypt-ruby-doc) weakremover(ruby2.7-rubygem-bcrypt-testsuite) weakremover(ruby2.7-rubygem-bcrypt_pbkdf) weakremover(ruby2.7-rubygem-bcrypt_pbkdf-doc) weakremover(ruby2.7-rubygem-bcrypt_pbkdf-testsuite) weakremover(ruby2.7-rubygem-benchmark) weakremover(ruby2.7-rubygem-benchmark-doc) weakremover(ruby2.7-rubygem-bindata) weakremover(ruby2.7-rubygem-bindata-doc) weakremover(ruby2.7-rubygem-bindata-testsuite) weakremover(ruby2.7-rubygem-bindex) weakremover(ruby2.7-rubygem-bindex-doc) weakremover(ruby2.7-rubygem-bindex-testsuite) weakremover(ruby2.7-rubygem-binding_of_caller) weakremover(ruby2.7-rubygem-binding_of_caller-doc) weakremover(ruby2.7-rubygem-binding_of_caller-testsuite) weakremover(ruby2.7-rubygem-bootsnap) weakremover(ruby2.7-rubygem-bootsnap-doc) weakremover(ruby2.7-rubygem-bootstrap-sass) weakremover(ruby2.7-rubygem-bootstrap-sass-doc) weakremover(ruby2.7-rubygem-bootstrap-sass-testsuite) weakremover(ruby2.7-rubygem-buff-extensions) weakremover(ruby2.7-rubygem-buff-extensions-doc) weakremover(ruby2.7-rubygem-buff-extensions-testsuite) weakremover(ruby2.7-rubygem-buff-ignore) weakremover(ruby2.7-rubygem-buff-ignore-doc) weakremover(ruby2.7-rubygem-buff-ignore-testsuite) weakremover(ruby2.7-rubygem-buff-ruby_engine) weakremover(ruby2.7-rubygem-buff-ruby_engine-doc) weakremover(ruby2.7-rubygem-buff-ruby_engine-testsuite) weakremover(ruby2.7-rubygem-builder) weakremover(ruby2.7-rubygem-builder-doc) weakremover(ruby2.7-rubygem-builder-testsuite) weakremover(ruby2.7-rubygem-bundler) weakremover(ruby2.7-rubygem-bundler-audit) weakremover(ruby2.7-rubygem-bundler-audit-doc) weakremover(ruby2.7-rubygem-bundler-audit-testsuite) weakremover(ruby2.7-rubygem-bundler-doc) weakremover(ruby2.7-rubygem-bunny) weakremover(ruby2.7-rubygem-bunny-doc) weakremover(ruby2.7-rubygem-bunny-testsuite) weakremover(ruby2.7-rubygem-byebug) weakremover(ruby2.7-rubygem-byebug-doc) weakremover(ruby2.7-rubygem-capistrano) weakremover(ruby2.7-rubygem-capistrano-doc) weakremover(ruby2.7-rubygem-capistrano-harrow) weakremover(ruby2.7-rubygem-capistrano-harrow-doc) weakremover(ruby2.7-rubygem-capistrano-stats) weakremover(ruby2.7-rubygem-capistrano-stats-doc) weakremover(ruby2.7-rubygem-capistrano-testsuite) weakremover(ruby2.7-rubygem-celluloid) weakremover(ruby2.7-rubygem-celluloid-doc) weakremover(ruby2.7-rubygem-celluloid-essentials) weakremover(ruby2.7-rubygem-celluloid-essentials-doc) weakremover(ruby2.7-rubygem-celluloid-extras) weakremover(ruby2.7-rubygem-celluloid-extras-doc) weakremover(ruby2.7-rubygem-celluloid-fsm) weakremover(ruby2.7-rubygem-celluloid-fsm-doc) weakremover(ruby2.7-rubygem-celluloid-pool) weakremover(ruby2.7-rubygem-celluloid-pool-doc) weakremover(ruby2.7-rubygem-celluloid-supervision) weakremover(ruby2.7-rubygem-celluloid-supervision-doc) weakremover(ruby2.7-rubygem-celluloid-testsuite) weakremover(ruby2.7-rubygem-cfa) weakremover(ruby2.7-rubygem-cfa-doc) weakremover(ruby2.7-rubygem-cfa_grub2) weakremover(ruby2.7-rubygem-cfa_grub2-doc) weakremover(ruby2.7-rubygem-changelog_generator) weakremover(ruby2.7-rubygem-changelog_generator-doc) weakremover(ruby2.7-rubygem-changelog_generator-testsuite) weakremover(ruby2.7-rubygem-cheetah) weakremover(ruby2.7-rubygem-cheetah-doc) weakremover(ruby2.7-rubygem-chef-utils) weakremover(ruby2.7-rubygem-chef-utils-doc) weakremover(ruby2.7-rubygem-chef-utils-testsuite) weakremover(ruby2.7-rubygem-childprocess) weakremover(ruby2.7-rubygem-childprocess-0_6) weakremover(ruby2.7-rubygem-childprocess-2.0) weakremover(ruby2.7-rubygem-childprocess-doc) weakremover(ruby2.7-rubygem-childprocess-doc-0_6) weakremover(ruby2.7-rubygem-childprocess-doc-2.0) weakremover(ruby2.7-rubygem-childprocess-testsuite) weakremover(ruby2.7-rubygem-childprocess-testsuite-0_6) weakremover(ruby2.7-rubygem-childprocess-testsuite-2.0) weakremover(ruby2.7-rubygem-ci_reporter) weakremover(ruby2.7-rubygem-ci_reporter-doc) weakremover(ruby2.7-rubygem-ci_reporter-testsuite) weakremover(ruby2.7-rubygem-cleanroom) weakremover(ruby2.7-rubygem-cleanroom-doc) weakremover(ruby2.7-rubygem-cleanroom-testsuite) weakremover(ruby2.7-rubygem-coderay) weakremover(ruby2.7-rubygem-coderay-doc) weakremover(ruby2.7-rubygem-coercible) weakremover(ruby2.7-rubygem-coercible-doc) weakremover(ruby2.7-rubygem-coercible-testsuite) weakremover(ruby2.7-rubygem-coffee-rails) weakremover(ruby2.7-rubygem-coffee-rails-doc) weakremover(ruby2.7-rubygem-coffee-script) weakremover(ruby2.7-rubygem-coffee-script-doc) weakremover(ruby2.7-rubygem-coffee-script-source) weakremover(ruby2.7-rubygem-coffee-script-source-doc) weakremover(ruby2.7-rubygem-colorator) weakremover(ruby2.7-rubygem-colorator-0) weakremover(ruby2.7-rubygem-colorator-doc) weakremover(ruby2.7-rubygem-colorator-doc-0) weakremover(ruby2.7-rubygem-colorator-testsuite-0) weakremover(ruby2.7-rubygem-colored) weakremover(ruby2.7-rubygem-colored-doc) weakremover(ruby2.7-rubygem-colored-testsuite) weakremover(ruby2.7-rubygem-colorize) weakremover(ruby2.7-rubygem-colorize-doc) weakremover(ruby2.7-rubygem-colorize-testsuite) weakremover(ruby2.7-rubygem-columnize) weakremover(ruby2.7-rubygem-columnize-doc) weakremover(ruby2.7-rubygem-columnize-testsuite) weakremover(ruby2.7-rubygem-commander) weakremover(ruby2.7-rubygem-commander-doc) weakremover(ruby2.7-rubygem-commander-testsuite) weakremover(ruby2.7-rubygem-concurrent-ruby) weakremover(ruby2.7-rubygem-concurrent-ruby-doc) weakremover(ruby2.7-rubygem-cool.io) weakremover(ruby2.7-rubygem-cool.io-doc) weakremover(ruby2.7-rubygem-cool.io-testsuite) weakremover(ruby2.7-rubygem-crack) weakremover(ruby2.7-rubygem-crack-doc) weakremover(ruby2.7-rubygem-crack-testsuite) weakremover(ruby2.7-rubygem-crass) weakremover(ruby2.7-rubygem-crass-doc) weakremover(ruby2.7-rubygem-cri) weakremover(ruby2.7-rubygem-cri-doc) weakremover(ruby2.7-rubygem-cri-testsuite) weakremover(ruby2.7-rubygem-css_parser) weakremover(ruby2.7-rubygem-css_parser-doc) weakremover(ruby2.7-rubygem-cssmin) weakremover(ruby2.7-rubygem-cssmin-doc) weakremover(ruby2.7-rubygem-daemon_controller) weakremover(ruby2.7-rubygem-daemon_controller-doc) weakremover(ruby2.7-rubygem-daemon_controller-testsuite) weakremover(ruby2.7-rubygem-daemons) weakremover(ruby2.7-rubygem-daemons-doc) weakremover(ruby2.7-rubygem-debase) weakremover(ruby2.7-rubygem-debase-doc) weakremover(ruby2.7-rubygem-debase-ruby_core_source) weakremover(ruby2.7-rubygem-debase-ruby_core_source-doc) weakremover(ruby2.7-rubygem-debase-testsuite) weakremover(ruby2.7-rubygem-debug_inspector) weakremover(ruby2.7-rubygem-debug_inspector-doc) weakremover(ruby2.7-rubygem-debug_inspector-testsuite) weakremover(ruby2.7-rubygem-debugger-linecache) weakremover(ruby2.7-rubygem-debugger-linecache-doc) weakremover(ruby2.7-rubygem-debugger-linecache-testsuite) weakremover(ruby2.7-rubygem-deep_merge) weakremover(ruby2.7-rubygem-deep_merge-doc) weakremover(ruby2.7-rubygem-deep_merge-testsuite) weakremover(ruby2.7-rubygem-delayed_job) weakremover(ruby2.7-rubygem-delayed_job-doc) weakremover(ruby2.7-rubygem-delayed_job-testsuite) weakremover(ruby2.7-rubygem-delayed_job_active_record) weakremover(ruby2.7-rubygem-delayed_job_active_record-doc) weakremover(ruby2.7-rubygem-descendants_tracker) weakremover(ruby2.7-rubygem-descendants_tracker-doc) weakremover(ruby2.7-rubygem-descendants_tracker-testsuite) weakremover(ruby2.7-rubygem-devise) weakremover(ruby2.7-rubygem-devise-doc) weakremover(ruby2.7-rubygem-devise-i18n) weakremover(ruby2.7-rubygem-devise-i18n-doc) weakremover(ruby2.7-rubygem-devise_ldap_authenticatable) weakremover(ruby2.7-rubygem-devise_ldap_authenticatable-doc) weakremover(ruby2.7-rubygem-devise_ldap_authenticatable-testsuite) weakremover(ruby2.7-rubygem-diff-lcs) weakremover(ruby2.7-rubygem-diff-lcs-doc) weakremover(ruby2.7-rubygem-diff-lcs-testsuite) weakremover(ruby2.7-rubygem-diffy) weakremover(ruby2.7-rubygem-diffy-doc) weakremover(ruby2.7-rubygem-diffy-testsuite) weakremover(ruby2.7-rubygem-dig_rb) weakremover(ruby2.7-rubygem-dig_rb-doc) weakremover(ruby2.7-rubygem-docile) weakremover(ruby2.7-rubygem-docile-1_1) weakremover(ruby2.7-rubygem-docile-doc) weakremover(ruby2.7-rubygem-docile-doc-1_1) weakremover(ruby2.7-rubygem-docile-testsuite-1_1) weakremover(ruby2.7-rubygem-domain_name) weakremover(ruby2.7-rubygem-domain_name-doc) weakremover(ruby2.7-rubygem-domain_name-testsuite) weakremover(ruby2.7-rubygem-down) weakremover(ruby2.7-rubygem-dry-configurable) weakremover(ruby2.7-rubygem-dry-configurable-doc) weakremover(ruby2.7-rubygem-dry-container) weakremover(ruby2.7-rubygem-dry-container-doc) weakremover(ruby2.7-rubygem-dry-container-testsuite) weakremover(ruby2.7-rubygem-dry-core) weakremover(ruby2.7-rubygem-dry-core-doc) weakremover(ruby2.7-rubygem-dry-equalizer) weakremover(ruby2.7-rubygem-dry-equalizer-doc) weakremover(ruby2.7-rubygem-dry-equalizer-testsuite) weakremover(ruby2.7-rubygem-dry-inflector) weakremover(ruby2.7-rubygem-dry-inflector-doc) weakremover(ruby2.7-rubygem-dry-logic) weakremover(ruby2.7-rubygem-dry-logic-doc) weakremover(ruby2.7-rubygem-dry-types) weakremover(ruby2.7-rubygem-dry-types-doc) weakremover(ruby2.7-rubygem-ed25519) weakremover(ruby2.7-rubygem-ed25519-doc) weakremover(ruby2.7-rubygem-em-websocket) weakremover(ruby2.7-rubygem-em-websocket-doc) weakremover(ruby2.7-rubygem-em-websocket-testsuite) weakremover(ruby2.7-rubygem-equalizer) weakremover(ruby2.7-rubygem-equalizer-doc) weakremover(ruby2.7-rubygem-equalizer-testsuite) weakremover(ruby2.7-rubygem-erubi) weakremover(ruby2.7-rubygem-erubi-doc) weakremover(ruby2.7-rubygem-erubi-testsuite) weakremover(ruby2.7-rubygem-erubis) weakremover(ruby2.7-rubygem-erubis-2_6) weakremover(ruby2.7-rubygem-erubis-doc) weakremover(ruby2.7-rubygem-erubis-doc-2_6) weakremover(ruby2.7-rubygem-erubis-testsuite) weakremover(ruby2.7-rubygem-erubis-testsuite-2_6) weakremover(ruby2.7-rubygem-eventmachine) weakremover(ruby2.7-rubygem-eventmachine-doc) weakremover(ruby2.7-rubygem-exception_notification) weakremover(ruby2.7-rubygem-exception_notification-doc) weakremover(ruby2.7-rubygem-exception_notification-testsuite) weakremover(ruby2.7-rubygem-excon) weakremover(ruby2.7-rubygem-excon-doc) weakremover(ruby2.7-rubygem-execjs) weakremover(ruby2.7-rubygem-execjs-doc) weakremover(ruby2.7-rubygem-extlib) weakremover(ruby2.7-rubygem-extlib-doc) weakremover(ruby2.7-rubygem-extlib-testsuite) weakremover(ruby2.7-rubygem-factory_girl) weakremover(ruby2.7-rubygem-factory_girl-doc) weakremover(ruby2.7-rubygem-factory_girl_rails) weakremover(ruby2.7-rubygem-factory_girl_rails-doc) weakremover(ruby2.7-rubygem-fake_ftp) weakremover(ruby2.7-rubygem-fake_ftp-0_1) weakremover(ruby2.7-rubygem-fake_ftp-doc) weakremover(ruby2.7-rubygem-fake_ftp-doc-0_1) weakremover(ruby2.7-rubygem-fake_ftp-testsuite) weakremover(ruby2.7-rubygem-fake_ftp-testsuite-0_1) weakremover(ruby2.7-rubygem-faraday) weakremover(ruby2.7-rubygem-faraday-0_12) weakremover(ruby2.7-rubygem-faraday-doc) weakremover(ruby2.7-rubygem-faraday-doc-0_12) weakremover(ruby2.7-rubygem-faraday-net_http) weakremover(ruby2.7-rubygem-faraday-net_http-doc) weakremover(ruby2.7-rubygem-faraday-testsuite) weakremover(ruby2.7-rubygem-faraday_middleware) weakremover(ruby2.7-rubygem-faraday_middleware-doc) weakremover(ruby2.7-rubygem-faraday_middleware-multi_json) weakremover(ruby2.7-rubygem-faraday_middleware-multi_json-doc) weakremover(ruby2.7-rubygem-faraday_middleware-multi_json-testsuite) weakremover(ruby2.7-rubygem-fast_gettext) weakremover(ruby2.7-rubygem-fast_gettext-1.1) weakremover(ruby2.7-rubygem-fast_gettext-doc) weakremover(ruby2.7-rubygem-fast_gettext-doc-1.1) weakremover(ruby2.7-rubygem-fast_xs) weakremover(ruby2.7-rubygem-fast_xs-doc) weakremover(ruby2.7-rubygem-fast_xs-testsuite) weakremover(ruby2.7-rubygem-fastercsv) weakremover(ruby2.7-rubygem-fastercsv-doc) weakremover(ruby2.7-rubygem-fastercsv-testsuite) weakremover(ruby2.7-rubygem-ffi) weakremover(ruby2.7-rubygem-ffi-compiler) weakremover(ruby2.7-rubygem-ffi-doc) weakremover(ruby2.7-rubygem-file-tail) weakremover(ruby2.7-rubygem-file-tail-doc) weakremover(ruby2.7-rubygem-flog) weakremover(ruby2.7-rubygem-flog-doc) weakremover(ruby2.7-rubygem-flog-testsuite) weakremover(ruby2.7-rubygem-fluentd) weakremover(ruby2.7-rubygem-fluentd-doc) weakremover(ruby2.7-rubygem-fluentd-testsuite) weakremover(ruby2.7-rubygem-fog-core) weakremover(ruby2.7-rubygem-fog-core-doc) weakremover(ruby2.7-rubygem-fog-core-testsuite) weakremover(ruby2.7-rubygem-fog-json) weakremover(ruby2.7-rubygem-fog-json-doc) weakremover(ruby2.7-rubygem-fog-json-testsuite) weakremover(ruby2.7-rubygem-fog-libvirt) weakremover(ruby2.7-rubygem-fog-libvirt-doc) weakremover(ruby2.7-rubygem-fog-xml) weakremover(ruby2.7-rubygem-fog-xml-doc) weakremover(ruby2.7-rubygem-fog-xml-testsuite) weakremover(ruby2.7-rubygem-font-awesome-rails) weakremover(ruby2.7-rubygem-font-awesome-rails-doc) weakremover(ruby2.7-rubygem-font-awesome-rails-testsuite) weakremover(ruby2.7-rubygem-formatador) weakremover(ruby2.7-rubygem-formatador-doc) weakremover(ruby2.7-rubygem-forwardable-extended) weakremover(ruby2.7-rubygem-forwardable-extended-doc) weakremover(ruby2.7-rubygem-gem2rpm) weakremover(ruby2.7-rubygem-get_process_mem) weakremover(ruby2.7-rubygem-get_process_mem-doc) weakremover(ruby2.7-rubygem-get_process_mem-testsuite) weakremover(ruby2.7-rubygem-gettext) weakremover(ruby2.7-rubygem-gettext-doc) weakremover(ruby2.7-rubygem-gettext-setup) weakremover(ruby2.7-rubygem-gettext-setup-doc) weakremover(ruby2.7-rubygem-gettext-setup-testsuite) weakremover(ruby2.7-rubygem-gettext-testsuite) weakremover(ruby2.7-rubygem-gettext_i18n_rails) weakremover(ruby2.7-rubygem-gettext_i18n_rails-doc) weakremover(ruby2.7-rubygem-gettext_i18n_rails_js) weakremover(ruby2.7-rubygem-gettext_i18n_rails_js-doc) weakremover(ruby2.7-rubygem-gettext_i18n_rails_js-testsuite) weakremover(ruby2.7-rubygem-gli) weakremover(ruby2.7-rubygem-gli-doc) weakremover(ruby2.7-rubygem-gli-testsuite) weakremover(ruby2.7-rubygem-globalid) weakremover(ruby2.7-rubygem-globalid-doc) weakremover(ruby2.7-rubygem-gpgme) weakremover(ruby2.7-rubygem-gpgme-doc) weakremover(ruby2.7-rubygem-gpgme-testsuite) weakremover(ruby2.7-rubygem-grape) weakremover(ruby2.7-rubygem-grape-doc) weakremover(ruby2.7-rubygem-grape-testsuite) weakremover(ruby2.7-rubygem-gravatar_image_tag) weakremover(ruby2.7-rubygem-gravatar_image_tag-doc) weakremover(ruby2.7-rubygem-gravatar_image_tag-testsuite) weakremover(ruby2.7-rubygem-gssapi) weakremover(ruby2.7-rubygem-gssapi-doc) weakremover(ruby2.7-rubygem-gssapi-testsuite) weakremover(ruby2.7-rubygem-gyoku) weakremover(ruby2.7-rubygem-gyoku-doc) weakremover(ruby2.7-rubygem-gyoku-testsuite) weakremover(ruby2.7-rubygem-haml) weakremover(ruby2.7-rubygem-haml-doc) weakremover(ruby2.7-rubygem-haml-rails) weakremover(ruby2.7-rubygem-haml-rails-doc) weakremover(ruby2.7-rubygem-haml-rails-testsuite) weakremover(ruby2.7-rubygem-has_mobile_views) weakremover(ruby2.7-rubygem-has_mobile_views-doc) weakremover(ruby2.7-rubygem-has_mobile_views-testsuite) weakremover(ruby2.7-rubygem-hashdiff) weakremover(ruby2.7-rubygem-hashdiff-doc) weakremover(ruby2.7-rubygem-hashdiff-testsuite) weakremover(ruby2.7-rubygem-hashery) weakremover(ruby2.7-rubygem-hashery-doc) weakremover(ruby2.7-rubygem-hashery-testsuite) weakremover(ruby2.7-rubygem-hashicorp-checkpoint) weakremover(ruby2.7-rubygem-hashicorp-checkpoint-doc) weakremover(ruby2.7-rubygem-hashicorp-checkpoint-testsuite) weakremover(ruby2.7-rubygem-hashie) weakremover(ruby2.7-rubygem-hashie-doc) weakremover(ruby2.7-rubygem-hashie-testsuite) weakremover(ruby2.7-rubygem-highline) weakremover(ruby2.7-rubygem-highline-1_6) weakremover(ruby2.7-rubygem-highline-1_7) weakremover(ruby2.7-rubygem-highline-doc) weakremover(ruby2.7-rubygem-highline-doc-1_6) weakremover(ruby2.7-rubygem-highline-doc-1_7) weakremover(ruby2.7-rubygem-highline-testsuite-1_6) weakremover(ruby2.7-rubygem-highline-testsuite-1_7) weakremover(ruby2.7-rubygem-hike) weakremover(ruby2.7-rubygem-hike-1_2) weakremover(ruby2.7-rubygem-hike-doc) weakremover(ruby2.7-rubygem-hike-doc-1_2) weakremover(ruby2.7-rubygem-hitimes) weakremover(ruby2.7-rubygem-hitimes-doc) weakremover(ruby2.7-rubygem-hitimes-testsuite) weakremover(ruby2.7-rubygem-hoe) weakremover(ruby2.7-rubygem-hoe-doc) weakremover(ruby2.7-rubygem-hoe-testsuite) weakremover(ruby2.7-rubygem-hpricot) weakremover(ruby2.7-rubygem-hpricot-doc) weakremover(ruby2.7-rubygem-hpricot-testsuite) weakremover(ruby2.7-rubygem-html2haml) weakremover(ruby2.7-rubygem-html2haml-doc) weakremover(ruby2.7-rubygem-html2haml-testsuite) weakremover(ruby2.7-rubygem-http) weakremover(ruby2.7-rubygem-http-accept-1.7) weakremover(ruby2.7-rubygem-http-accept-doc-1.7) weakremover(ruby2.7-rubygem-http-cookie) weakremover(ruby2.7-rubygem-http-cookie-doc) weakremover(ruby2.7-rubygem-http-cookie-testsuite) weakremover(ruby2.7-rubygem-http-form_data) weakremover(ruby2.7-rubygem-http_accept_language) weakremover(ruby2.7-rubygem-http_accept_language-doc) weakremover(ruby2.7-rubygem-http_accept_language-testsuite) weakremover(ruby2.7-rubygem-http_parser.rb) weakremover(ruby2.7-rubygem-http_parser.rb-doc) weakremover(ruby2.7-rubygem-http_parser.rb-testsuite) weakremover(ruby2.7-rubygem-httpclient) weakremover(ruby2.7-rubygem-httpclient-doc) weakremover(ruby2.7-rubygem-httpclient-testsuite) weakremover(ruby2.7-rubygem-i18n) weakremover(ruby2.7-rubygem-i18n-0_6) weakremover(ruby2.7-rubygem-i18n-0_9) weakremover(ruby2.7-rubygem-i18n-1.1) weakremover(ruby2.7-rubygem-i18n-doc) weakremover(ruby2.7-rubygem-i18n-doc-0_6) weakremover(ruby2.7-rubygem-i18n-doc-0_9) weakremover(ruby2.7-rubygem-i18n-doc-1.1) weakremover(ruby2.7-rubygem-i18n-testsuite-0_6) weakremover(ruby2.7-rubygem-i18n-testsuite-0_9) weakremover(ruby2.7-rubygem-i18n-testsuite-1.1) weakremover(ruby2.7-rubygem-ice_nine) weakremover(ruby2.7-rubygem-ice_nine-doc) weakremover(ruby2.7-rubygem-ice_nine-testsuite) weakremover(ruby2.7-rubygem-inifile) weakremover(ruby2.7-rubygem-inifile-doc) weakremover(ruby2.7-rubygem-inifile-testsuite) weakremover(ruby2.7-rubygem-ipaddress) weakremover(ruby2.7-rubygem-ipaddress-doc) weakremover(ruby2.7-rubygem-ipaddress-testsuite) weakremover(ruby2.7-rubygem-jaro_winkler) weakremover(ruby2.7-rubygem-jaro_winkler-doc) weakremover(ruby2.7-rubygem-jbuilder) weakremover(ruby2.7-rubygem-jbuilder-doc) weakremover(ruby2.7-rubygem-jbuilder-testsuite) weakremover(ruby2.7-rubygem-jekyll) weakremover(ruby2.7-rubygem-jekyll-doc) weakremover(ruby2.7-rubygem-jekyll-sass-converter) weakremover(ruby2.7-rubygem-jekyll-sass-converter-doc) weakremover(ruby2.7-rubygem-jekyll-watch) weakremover(ruby2.7-rubygem-jekyll-watch-doc) weakremover(ruby2.7-rubygem-jmespath) weakremover(ruby2.7-rubygem-jmespath-doc) weakremover(ruby2.7-rubygem-journey-1_0) weakremover(ruby2.7-rubygem-journey-doc-1_0) weakremover(ruby2.7-rubygem-journey-testsuite-1_0) weakremover(ruby2.7-rubygem-jquery-rails) weakremover(ruby2.7-rubygem-jquery-rails-doc) weakremover(ruby2.7-rubygem-jquery-rails-testsuite) weakremover(ruby2.7-rubygem-jquery-ui-rails) weakremover(ruby2.7-rubygem-jquery-ui-rails-doc) weakremover(ruby2.7-rubygem-js-routes) weakremover(ruby2.7-rubygem-js-routes-doc) weakremover(ruby2.7-rubygem-js-routes-testsuite) weakremover(ruby2.7-rubygem-json) weakremover(ruby2.7-rubygem-json-doc) weakremover(ruby2.7-rubygem-json-jwt) weakremover(ruby2.7-rubygem-json-jwt-doc) weakremover(ruby2.7-rubygem-json-schema) weakremover(ruby2.7-rubygem-json-schema-doc) weakremover(ruby2.7-rubygem-json_pure) weakremover(ruby2.7-rubygem-json_pure-doc) weakremover(ruby2.7-rubygem-jwt) weakremover(ruby2.7-rubygem-jwt-1_5) weakremover(ruby2.7-rubygem-jwt-doc) weakremover(ruby2.7-rubygem-jwt-doc-1_5) weakremover(ruby2.7-rubygem-jwt-testsuite-1_5) weakremover(ruby2.7-rubygem-kgio) weakremover(ruby2.7-rubygem-kgio-doc) weakremover(ruby2.7-rubygem-kgio-testsuite) weakremover(ruby2.7-rubygem-kramdown) weakremover(ruby2.7-rubygem-kramdown-doc) weakremover(ruby2.7-rubygem-kramdown-parser-gfm) weakremover(ruby2.7-rubygem-kramdown-parser-gfm-doc) weakremover(ruby2.7-rubygem-kramdown-parser-gfm-testsuite) weakremover(ruby2.7-rubygem-kramdown-testsuite) weakremover(ruby2.7-rubygem-launchy) weakremover(ruby2.7-rubygem-launchy-doc) weakremover(ruby2.7-rubygem-launchy-testsuite) weakremover(ruby2.7-rubygem-levenshtein) weakremover(ruby2.7-rubygem-levenshtein-doc) weakremover(ruby2.7-rubygem-levenshtein-testsuite) weakremover(ruby2.7-rubygem-librarian) weakremover(ruby2.7-rubygem-librarian-doc) weakremover(ruby2.7-rubygem-librarian-testsuite) weakremover(ruby2.7-rubygem-libyui-rake) weakremover(ruby2.7-rubygem-libyui-rake-doc) weakremover(ruby2.7-rubygem-lightbox2) weakremover(ruby2.7-rubygem-lightbox2-doc) weakremover(ruby2.7-rubygem-liquid) weakremover(ruby2.7-rubygem-liquid-3) weakremover(ruby2.7-rubygem-liquid-4) weakremover(ruby2.7-rubygem-liquid-doc) weakremover(ruby2.7-rubygem-liquid-doc-3) weakremover(ruby2.7-rubygem-liquid-doc-4) weakremover(ruby2.7-rubygem-liquid-testsuite) weakremover(ruby2.7-rubygem-liquid-testsuite-3) weakremover(ruby2.7-rubygem-liquid-testsuite-4) weakremover(ruby2.7-rubygem-listen) weakremover(ruby2.7-rubygem-listen-3.2) weakremover(ruby2.7-rubygem-listen-3_0) weakremover(ruby2.7-rubygem-listen-3_1) weakremover(ruby2.7-rubygem-listen-doc) weakremover(ruby2.7-rubygem-listen-doc-3_0) weakremover(ruby2.7-rubygem-listen-doc-3_1) weakremover(ruby2.7-rubygem-little-plugger) weakremover(ruby2.7-rubygem-little-plugger-doc) weakremover(ruby2.7-rubygem-little-plugger-testsuite) weakremover(ruby2.7-rubygem-llhttp-ffi) weakremover(ruby2.7-rubygem-locale) weakremover(ruby2.7-rubygem-locale-doc) weakremover(ruby2.7-rubygem-locale-testsuite) weakremover(ruby2.7-rubygem-log4r) weakremover(ruby2.7-rubygem-log4r-doc) weakremover(ruby2.7-rubygem-logging) weakremover(ruby2.7-rubygem-logging-doc) weakremover(ruby2.7-rubygem-logging-testsuite) weakremover(ruby2.7-rubygem-lolcat) weakremover(ruby2.7-rubygem-lolcat-doc) weakremover(ruby2.7-rubygem-loofah) weakremover(ruby2.7-rubygem-loofah-doc) weakremover(ruby2.7-rubygem-mail) weakremover(ruby2.7-rubygem-mail-2_5) weakremover(ruby2.7-rubygem-mail-doc) weakremover(ruby2.7-rubygem-mail-doc-2_5) weakremover(ruby2.7-rubygem-manpages) weakremover(ruby2.7-rubygem-manpages-doc) weakremover(ruby2.7-rubygem-marcel) weakremover(ruby2.7-rubygem-marcel-doc) weakremover(ruby2.7-rubygem-memcache-client) weakremover(ruby2.7-rubygem-memcache-client-doc) weakremover(ruby2.7-rubygem-memcache-client-testsuite) weakremover(ruby2.7-rubygem-mercenary) weakremover(ruby2.7-rubygem-mercenary-doc) weakremover(ruby2.7-rubygem-mercenary-testsuite) weakremover(ruby2.7-rubygem-metaclass) weakremover(ruby2.7-rubygem-metaclass-doc) weakremover(ruby2.7-rubygem-metaclass-testsuite) weakremover(ruby2.7-rubygem-method_source) weakremover(ruby2.7-rubygem-method_source-doc) weakremover(ruby2.7-rubygem-method_source-testsuite) weakremover(ruby2.7-rubygem-micromachine) weakremover(ruby2.7-rubygem-micromachine-doc) weakremover(ruby2.7-rubygem-micromachine-testsuite) weakremover(ruby2.7-rubygem-mime) weakremover(ruby2.7-rubygem-mime-doc) weakremover(ruby2.7-rubygem-mime-testsuite) weakremover(ruby2.7-rubygem-mime-types) weakremover(ruby2.7-rubygem-mime-types-1) weakremover(ruby2.7-rubygem-mime-types-data) weakremover(ruby2.7-rubygem-mime-types-data-doc) weakremover(ruby2.7-rubygem-mime-types-doc) weakremover(ruby2.7-rubygem-mime-types-doc-1) weakremover(ruby2.7-rubygem-mime-types-testsuite) weakremover(ruby2.7-rubygem-mime-types-testsuite-1) weakremover(ruby2.7-rubygem-mimemagic) weakremover(ruby2.7-rubygem-mimemagic-doc) weakremover(ruby2.7-rubygem-mimemagic-testsuite) weakremover(ruby2.7-rubygem-mini_magick) weakremover(ruby2.7-rubygem-mini_magick-doc) weakremover(ruby2.7-rubygem-mini_mime) weakremover(ruby2.7-rubygem-mini_mime-doc) weakremover(ruby2.7-rubygem-mini_portile2) weakremover(ruby2.7-rubygem-mini_portile2-2_3) weakremover(ruby2.7-rubygem-mini_portile2-doc) weakremover(ruby2.7-rubygem-mini_portile2-doc-2_3) weakremover(ruby2.7-rubygem-mini_portile2-testsuite) weakremover(ruby2.7-rubygem-mini_portile2-testsuite-2_3) weakremover(ruby2.7-rubygem-minitar) weakremover(ruby2.7-rubygem-minitar-doc) weakremover(ruby2.7-rubygem-minitar-testsuite) weakremover(ruby2.7-rubygem-mixlib-authentication) weakremover(ruby2.7-rubygem-mixlib-authentication-doc) weakremover(ruby2.7-rubygem-mixlib-cli) weakremover(ruby2.7-rubygem-mixlib-cli-doc) weakremover(ruby2.7-rubygem-mixlib-config) weakremover(ruby2.7-rubygem-mixlib-config-doc) weakremover(ruby2.7-rubygem-mixlib-log) weakremover(ruby2.7-rubygem-mixlib-log-doc) weakremover(ruby2.7-rubygem-mixlib-shellout) weakremover(ruby2.7-rubygem-mixlib-shellout-doc) weakremover(ruby2.7-rubygem-mobileesp_converted) weakremover(ruby2.7-rubygem-mobileesp_converted-doc) weakremover(ruby2.7-rubygem-mobileesp_converted-testsuite) weakremover(ruby2.7-rubygem-mocha) weakremover(ruby2.7-rubygem-mocha-doc) weakremover(ruby2.7-rubygem-mocha-testsuite) weakremover(ruby2.7-rubygem-moneta) weakremover(ruby2.7-rubygem-moneta-0_7) weakremover(ruby2.7-rubygem-moneta-doc) weakremover(ruby2.7-rubygem-moneta-doc-0_7) weakremover(ruby2.7-rubygem-moneta-testsuite) weakremover(ruby2.7-rubygem-moneta-testsuite-0_7) weakremover(ruby2.7-rubygem-msgpack) weakremover(ruby2.7-rubygem-msgpack-doc) weakremover(ruby2.7-rubygem-msgpack-testsuite) weakremover(ruby2.7-rubygem-multi_json) weakremover(ruby2.7-rubygem-multi_json-doc) weakremover(ruby2.7-rubygem-multi_xml) weakremover(ruby2.7-rubygem-multi_xml-doc) weakremover(ruby2.7-rubygem-multipart-post) weakremover(ruby2.7-rubygem-multipart-post-doc) weakremover(ruby2.7-rubygem-multipart-post-testsuite) weakremover(ruby2.7-rubygem-mustache) weakremover(ruby2.7-rubygem-mustache-doc) weakremover(ruby2.7-rubygem-mustache-testsuite) weakremover(ruby2.7-rubygem-mustermann) weakremover(ruby2.7-rubygem-mustermann-doc) weakremover(ruby2.7-rubygem-mustermann-grape) weakremover(ruby2.7-rubygem-mustermann-grape-doc) weakremover(ruby2.7-rubygem-mustermann-grape-testsuite) weakremover(ruby2.7-rubygem-mustermann-testsuite) weakremover(ruby2.7-rubygem-mysql2) weakremover(ruby2.7-rubygem-mysql2-doc) weakremover(ruby2.7-rubygem-net-ldap) weakremover(ruby2.7-rubygem-net-ldap-doc) weakremover(ruby2.7-rubygem-net-ldap-testsuite) weakremover(ruby2.7-rubygem-net-scp) weakremover(ruby2.7-rubygem-net-scp-1_1) weakremover(ruby2.7-rubygem-net-scp-1_2) weakremover(ruby2.7-rubygem-net-scp-doc) weakremover(ruby2.7-rubygem-net-scp-doc-1_1) weakremover(ruby2.7-rubygem-net-scp-doc-1_2) weakremover(ruby2.7-rubygem-net-scp-testsuite-1_1) weakremover(ruby2.7-rubygem-net-scp-testsuite-1_2) weakremover(ruby2.7-rubygem-net-sftp) weakremover(ruby2.7-rubygem-net-sftp-doc) weakremover(ruby2.7-rubygem-net-sftp-testsuite) weakremover(ruby2.7-rubygem-net-ssh) weakremover(ruby2.7-rubygem-net-ssh-4_1) weakremover(ruby2.7-rubygem-net-ssh-5.1) weakremover(ruby2.7-rubygem-net-ssh-6.1) weakremover(ruby2.7-rubygem-net-ssh-doc) weakremover(ruby2.7-rubygem-net-ssh-doc-4_1) weakremover(ruby2.7-rubygem-net-ssh-doc-5.1) weakremover(ruby2.7-rubygem-net-ssh-gateway) weakremover(ruby2.7-rubygem-net-ssh-gateway-doc) weakremover(ruby2.7-rubygem-net-ssh-multi) weakremover(ruby2.7-rubygem-net-ssh-multi-1_1) weakremover(ruby2.7-rubygem-net-ssh-multi-doc) weakremover(ruby2.7-rubygem-net-ssh-multi-doc-1_1) weakremover(ruby2.7-rubygem-net-ssh-multi-testsuite) weakremover(ruby2.7-rubygem-net-ssh-multi-testsuite-1_1) weakremover(ruby2.7-rubygem-netrc) weakremover(ruby2.7-rubygem-netrc-doc) weakremover(ruby2.7-rubygem-netrc-testsuite) weakremover(ruby2.7-rubygem-nio4r) weakremover(ruby2.7-rubygem-nio4r-doc) weakremover(ruby2.7-rubygem-nio4r-testsuite) weakremover(ruby2.7-rubygem-nokogiri) weakremover(ruby2.7-rubygem-nokogiri-doc) weakremover(ruby2.7-rubygem-nori) weakremover(ruby2.7-rubygem-nori-doc) weakremover(ruby2.7-rubygem-nori-testsuite) weakremover(ruby2.7-rubygem-oauth) weakremover(ruby2.7-rubygem-oauth-doc) weakremover(ruby2.7-rubygem-oauth2) weakremover(ruby2.7-rubygem-oauth2-doc) weakremover(ruby2.7-rubygem-omniauth) weakremover(ruby2.7-rubygem-omniauth-doc) weakremover(ruby2.7-rubygem-omniauth-github) weakremover(ruby2.7-rubygem-omniauth-github-doc) weakremover(ruby2.7-rubygem-omniauth-github-testsuite) weakremover(ruby2.7-rubygem-omniauth-gitlab) weakremover(ruby2.7-rubygem-omniauth-gitlab-doc) weakremover(ruby2.7-rubygem-omniauth-gitlab-testsuite) weakremover(ruby2.7-rubygem-omniauth-google-oauth2) weakremover(ruby2.7-rubygem-omniauth-google-oauth2-doc) weakremover(ruby2.7-rubygem-omniauth-google-oauth2-testsuite) weakremover(ruby2.7-rubygem-omniauth-oauth) weakremover(ruby2.7-rubygem-omniauth-oauth-doc) weakremover(ruby2.7-rubygem-omniauth-oauth-testsuite) weakremover(ruby2.7-rubygem-omniauth-oauth2) weakremover(ruby2.7-rubygem-omniauth-oauth2-doc) weakremover(ruby2.7-rubygem-omniauth-oauth2-testsuite) weakremover(ruby2.7-rubygem-open4) weakremover(ruby2.7-rubygem-open4-doc) weakremover(ruby2.7-rubygem-open4-testsuite) weakremover(ruby2.7-rubygem-openid_connect) weakremover(ruby2.7-rubygem-openid_connect-doc) weakremover(ruby2.7-rubygem-openid_connect-testsuite) weakremover(ruby2.7-rubygem-optimist) weakremover(ruby2.7-rubygem-optimist-doc) weakremover(ruby2.7-rubygem-optimist-testsuite) weakremover(ruby2.7-rubygem-orm_adapter) weakremover(ruby2.7-rubygem-orm_adapter-doc) weakremover(ruby2.7-rubygem-orm_adapter-testsuite) weakremover(ruby2.7-rubygem-os) weakremover(ruby2.7-rubygem-os-doc) weakremover(ruby2.7-rubygem-os-testsuite) weakremover(ruby2.7-rubygem-owncloud-admin) weakremover(ruby2.7-rubygem-owncloud-admin-doc) weakremover(ruby2.7-rubygem-packaging_rake_tasks) weakremover(ruby2.7-rubygem-packaging_rake_tasks-doc) weakremover(ruby2.7-rubygem-paint) weakremover(ruby2.7-rubygem-paint-doc) weakremover(ruby2.7-rubygem-parallel) weakremover(ruby2.7-rubygem-parallel-doc) weakremover(ruby2.7-rubygem-parallel_tests) weakremover(ruby2.7-rubygem-parallel_tests-doc) weakremover(ruby2.7-rubygem-parser) weakremover(ruby2.7-rubygem-parser-doc) weakremover(ruby2.7-rubygem-parser-testsuite) weakremover(ruby2.7-rubygem-passenger) weakremover(ruby2.7-rubygem-passenger-doc) weakremover(ruby2.7-rubygem-path_expander) weakremover(ruby2.7-rubygem-path_expander-doc) weakremover(ruby2.7-rubygem-path_expander-testsuite) weakremover(ruby2.7-rubygem-pathutil) weakremover(ruby2.7-rubygem-pathutil-doc) weakremover(ruby2.7-rubygem-pdf-core) weakremover(ruby2.7-rubygem-pdf-core-doc) weakremover(ruby2.7-rubygem-pdf-reader) weakremover(ruby2.7-rubygem-pdf-reader-doc) weakremover(ruby2.7-rubygem-pg) weakremover(ruby2.7-rubygem-pg-doc) weakremover(ruby2.7-rubygem-pg-testsuite) weakremover(ruby2.7-rubygem-pkg-config) weakremover(ruby2.7-rubygem-pkg-config-doc) weakremover(ruby2.7-rubygem-pkg-config-testsuite) weakremover(ruby2.7-rubygem-po_to_json) weakremover(ruby2.7-rubygem-po_to_json-doc) weakremover(ruby2.7-rubygem-po_to_json-testsuite) weakremover(ruby2.7-rubygem-polyglot) weakremover(ruby2.7-rubygem-polyglot-doc) weakremover(ruby2.7-rubygem-prawn) weakremover(ruby2.7-rubygem-prawn-core) weakremover(ruby2.7-rubygem-prawn-core-doc) weakremover(ruby2.7-rubygem-prawn-core-testsuite) weakremover(ruby2.7-rubygem-prawn-doc) weakremover(ruby2.7-rubygem-prawn-icon) weakremover(ruby2.7-rubygem-prawn-icon-doc) weakremover(ruby2.7-rubygem-prawn-icon-testsuite) weakremover(ruby2.7-rubygem-prawn-svg) weakremover(ruby2.7-rubygem-prawn-svg-doc) weakremover(ruby2.7-rubygem-prawn-svg-testsuite) weakremover(ruby2.7-rubygem-prawn-table) weakremover(ruby2.7-rubygem-prawn-table-doc) weakremover(ruby2.7-rubygem-prawn-table-testsuite) weakremover(ruby2.7-rubygem-prawn-templates) weakremover(ruby2.7-rubygem-prawn-testsuite) weakremover(ruby2.7-rubygem-pry) weakremover(ruby2.7-rubygem-pry-doc) weakremover(ruby2.7-rubygem-pry-doc-testsuite) weakremover(ruby2.7-rubygem-pry_debug) weakremover(ruby2.7-rubygem-pry_debug-doc) weakremover(ruby2.7-rubygem-pry_debug-testsuite) weakremover(ruby2.7-rubygem-public_suffix) weakremover(ruby2.7-rubygem-public_suffix-3.1) weakremover(ruby2.7-rubygem-public_suffix-doc) weakremover(ruby2.7-rubygem-public_suffix-doc-3.1) weakremover(ruby2.7-rubygem-public_suffix-testsuite) weakremover(ruby2.7-rubygem-public_suffix-testsuite-3.1) weakremover(ruby2.7-rubygem-puma) weakremover(ruby2.7-rubygem-puma-4) weakremover(ruby2.7-rubygem-puma-4.1) weakremover(ruby2.7-rubygem-puma-doc) weakremover(ruby2.7-rubygem-puma_worker_killer) weakremover(ruby2.7-rubygem-puma_worker_killer-doc) weakremover(ruby2.7-rubygem-puma_worker_killer-testsuite) weakremover(ruby2.7-rubygem-pundit) weakremover(ruby2.7-rubygem-pundit-doc) weakremover(ruby2.7-rubygem-pundit-testsuite) weakremover(ruby2.7-rubygem-rack) weakremover(ruby2.7-rubygem-rack-1_3) weakremover(ruby2.7-rubygem-rack-1_4) weakremover(ruby2.7-rubygem-rack-1_6) weakremover(ruby2.7-rubygem-rack-2.0) weakremover(ruby2.7-rubygem-rack-accept) weakremover(ruby2.7-rubygem-rack-accept-doc) weakremover(ruby2.7-rubygem-rack-accept-testsuite) weakremover(ruby2.7-rubygem-rack-cache-1_2) weakremover(ruby2.7-rubygem-rack-cache-doc-1_2) weakremover(ruby2.7-rubygem-rack-cache-testsuite-1_2) weakremover(ruby2.7-rubygem-rack-doc) weakremover(ruby2.7-rubygem-rack-doc-1_3) weakremover(ruby2.7-rubygem-rack-doc-1_4) weakremover(ruby2.7-rubygem-rack-doc-1_6) weakremover(ruby2.7-rubygem-rack-doc-2.0) weakremover(ruby2.7-rubygem-rack-oauth2) weakremover(ruby2.7-rubygem-rack-oauth2-doc) weakremover(ruby2.7-rubygem-rack-oauth2-testsuite) weakremover(ruby2.7-rubygem-rack-protection) weakremover(ruby2.7-rubygem-rack-protection-doc) weakremover(ruby2.7-rubygem-rack-proxy) weakremover(ruby2.7-rubygem-rack-proxy-doc) weakremover(ruby2.7-rubygem-rack-proxy-testsuite) weakremover(ruby2.7-rubygem-rack-ssl) weakremover(ruby2.7-rubygem-rack-ssl-1_3) weakremover(ruby2.7-rubygem-rack-ssl-doc) weakremover(ruby2.7-rubygem-rack-ssl-doc-1_3) weakremover(ruby2.7-rubygem-rack-test-0_6) weakremover(ruby2.7-rubygem-rack-test-doc-0_6) weakremover(ruby2.7-rubygem-rack-test-testsuite-0_6) weakremover(ruby2.7-rubygem-rack-testsuite-1_3) weakremover(ruby2.7-rubygem-rack-testsuite-1_4) weakremover(ruby2.7-rubygem-rack-testsuite-1_6) weakremover(ruby2.7-rubygem-rack-testsuite-2.0) weakremover(ruby2.7-rubygem-rails-5.2) weakremover(ruby2.7-rubygem-rails-5_1) weakremover(ruby2.7-rubygem-rails-6.0) weakremover(ruby2.7-rubygem-rails-deprecated_sanitizer) weakremover(ruby2.7-rubygem-rails-deprecated_sanitizer-doc) weakremover(ruby2.7-rubygem-rails-deprecated_sanitizer-testsuite) weakremover(ruby2.7-rubygem-rails-doc-5.2) weakremover(ruby2.7-rubygem-rails-doc-5_1) weakremover(ruby2.7-rubygem-rails-doc-6.0) weakremover(ruby2.7-rubygem-rails-dom-testing) weakremover(ruby2.7-rubygem-rails-dom-testing-doc) weakremover(ruby2.7-rubygem-rails-dom-testing-testsuite) weakremover(ruby2.7-rubygem-rails-html-sanitizer) weakremover(ruby2.7-rubygem-rails-html-sanitizer-doc) weakremover(ruby2.7-rubygem-rails-html-sanitizer-testsuite) weakremover(ruby2.7-rubygem-rails-i18n) weakremover(ruby2.7-rubygem-rails-i18n-doc) weakremover(ruby2.7-rubygem-rails_stdout_logging) weakremover(ruby2.7-rubygem-rails_stdout_logging-doc) weakremover(ruby2.7-rubygem-rails_stdout_logging-testsuite) weakremover(ruby2.7-rubygem-railties-5.2) weakremover(ruby2.7-rubygem-railties-5_1) weakremover(ruby2.7-rubygem-railties-6.0) weakremover(ruby2.7-rubygem-railties-doc-5.2) weakremover(ruby2.7-rubygem-railties-doc-5_1) weakremover(ruby2.7-rubygem-railties-doc-6.0) weakremover(ruby2.7-rubygem-rainbow) weakremover(ruby2.7-rubygem-rainbow-doc) weakremover(ruby2.7-rubygem-rainbow-testsuite) weakremover(ruby2.7-rubygem-raindrops) weakremover(ruby2.7-rubygem-raindrops-doc) weakremover(ruby2.7-rubygem-raindrops-testsuite) weakremover(ruby2.7-rubygem-rake-11_3) weakremover(ruby2.7-rubygem-rake-12.3) weakremover(ruby2.7-rubygem-rake-12_0) weakremover(ruby2.7-rubygem-rake-compiler) weakremover(ruby2.7-rubygem-rake-compiler-doc) weakremover(ruby2.7-rubygem-rake-compiler-testsuite) weakremover(ruby2.7-rubygem-rake-doc-11_3) weakremover(ruby2.7-rubygem-rake-doc-12.3) weakremover(ruby2.7-rubygem-rake-doc-12_0) weakremover(ruby2.7-rubygem-rb-fsevent) weakremover(ruby2.7-rubygem-rb-fsevent-doc) weakremover(ruby2.7-rubygem-rb-inotify) weakremover(ruby2.7-rubygem-rb-inotify-doc) weakremover(ruby2.7-rubygem-rb-inotify-testsuite) weakremover(ruby2.7-rubygem-rb-kqueue) weakremover(ruby2.7-rubygem-rb-kqueue-doc) weakremover(ruby2.7-rubygem-rb-kqueue-testsuite) weakremover(ruby2.7-rubygem-rdiscount) weakremover(ruby2.7-rubygem-rdiscount-doc) weakremover(ruby2.7-rubygem-rdiscount-testsuite) weakremover(ruby2.7-rubygem-rdoc-4) weakremover(ruby2.7-rubygem-rdoc-doc-4) weakremover(ruby2.7-rubygem-rdoc-testsuite-4) weakremover(ruby2.7-rubygem-red-datasets) weakremover(ruby2.7-rubygem-regexp_parser) weakremover(ruby2.7-rubygem-regexp_parser-doc) weakremover(ruby2.7-rubygem-regexp_parser-testsuite) weakremover(ruby2.7-rubygem-responders) weakremover(ruby2.7-rubygem-responders-doc) weakremover(ruby2.7-rubygem-rest-client) weakremover(ruby2.7-rubygem-rest-client-doc) weakremover(ruby2.7-rubygem-rest-client-testsuite) weakremover(ruby2.7-rubygem-restility) weakremover(ruby2.7-rubygem-restility-doc) weakremover(ruby2.7-rubygem-restility-testsuite) weakremover(ruby2.7-rubygem-reverse_markdown) weakremover(ruby2.7-rubygem-reverse_markdown-doc) weakremover(ruby2.7-rubygem-reverse_markdown-testsuite) weakremover(ruby2.7-rubygem-rgen) weakremover(ruby2.7-rubygem-rgen-doc) weakremover(ruby2.7-rubygem-rgen-testsuite) weakremover(ruby2.7-rubygem-rice) weakremover(ruby2.7-rubygem-rice-doc) weakremover(ruby2.7-rubygem-rice-testsuite) weakremover(ruby2.7-rubygem-ronn) weakremover(ruby2.7-rubygem-ronn-doc) weakremover(ruby2.7-rubygem-ronn-testsuite) weakremover(ruby2.7-rubygem-rouge) weakremover(ruby2.7-rubygem-rouge-1) weakremover(ruby2.7-rubygem-rouge-doc) weakremover(ruby2.7-rubygem-rouge-doc-1) weakremover(ruby2.7-rubygem-rpm) weakremover(ruby2.7-rubygem-rpm-doc) weakremover(ruby2.7-rubygem-rpm-testsuite) weakremover(ruby2.7-rubygem-rspec) weakremover(ruby2.7-rubygem-rspec-3_5) weakremover(ruby2.7-rubygem-rspec-core) weakremover(ruby2.7-rubygem-rspec-core-3_5) weakremover(ruby2.7-rubygem-rspec-core-doc) weakremover(ruby2.7-rubygem-rspec-core-doc-3_5) weakremover(ruby2.7-rubygem-rspec-doc) weakremover(ruby2.7-rubygem-rspec-doc-3_5) weakremover(ruby2.7-rubygem-rspec-expectations) weakremover(ruby2.7-rubygem-rspec-expectations-3_5) weakremover(ruby2.7-rubygem-rspec-expectations-doc) weakremover(ruby2.7-rubygem-rspec-expectations-doc-3_5) weakremover(ruby2.7-rubygem-rspec-its) weakremover(ruby2.7-rubygem-rspec-its-doc) weakremover(ruby2.7-rubygem-rspec-its-testsuite) weakremover(ruby2.7-rubygem-rspec-mocks) weakremover(ruby2.7-rubygem-rspec-mocks-3_5) weakremover(ruby2.7-rubygem-rspec-mocks-doc) weakremover(ruby2.7-rubygem-rspec-mocks-doc-3_5) weakremover(ruby2.7-rubygem-rspec-rails) weakremover(ruby2.7-rubygem-rspec-rails-3.9) weakremover(ruby2.7-rubygem-rspec-rails-4.0) weakremover(ruby2.7-rubygem-rspec-rails-doc) weakremover(ruby2.7-rubygem-rspec-rails-doc-3.9) weakremover(ruby2.7-rubygem-rspec-support) weakremover(ruby2.7-rubygem-rspec-support-3_5) weakremover(ruby2.7-rubygem-rspec-support-doc) weakremover(ruby2.7-rubygem-rspec-support-doc-3_5) weakremover(ruby2.7-rubygem-rubocop) weakremover(ruby2.7-rubygem-rubocop-ast) weakremover(ruby2.7-rubygem-rubocop-ast-doc) weakremover(ruby2.7-rubygem-rubocop-doc) weakremover(ruby2.7-rubygem-ruby-augeas) weakremover(ruby2.7-rubygem-ruby-augeas-doc) weakremover(ruby2.7-rubygem-ruby-dbus) weakremover(ruby2.7-rubygem-ruby-dbus-doc) weakremover(ruby2.7-rubygem-ruby-dbus-testsuite) weakremover(ruby2.7-rubygem-ruby-filemagic) weakremover(ruby2.7-rubygem-ruby-filemagic-doc) weakremover(ruby2.7-rubygem-ruby-filemagic-testsuite) weakremover(ruby2.7-rubygem-ruby-libvirt) weakremover(ruby2.7-rubygem-ruby-libvirt-doc) weakremover(ruby2.7-rubygem-ruby-openid) weakremover(ruby2.7-rubygem-ruby-openid-doc) weakremover(ruby2.7-rubygem-ruby-openid-testsuite) weakremover(ruby2.7-rubygem-ruby-progressbar) weakremover(ruby2.7-rubygem-ruby-progressbar-doc) weakremover(ruby2.7-rubygem-ruby-rc4) weakremover(ruby2.7-rubygem-ruby-rc4-doc) weakremover(ruby2.7-rubygem-ruby-rc4-testsuite) weakremover(ruby2.7-rubygem-ruby-shadow) weakremover(ruby2.7-rubygem-ruby-shadow-doc) weakremover(ruby2.7-rubygem-ruby2_keywords) weakremover(ruby2.7-rubygem-ruby2_keywords-doc) weakremover(ruby2.7-rubygem-ruby_dep) weakremover(ruby2.7-rubygem-ruby_dep-1_3) weakremover(ruby2.7-rubygem-ruby_dep-doc) weakremover(ruby2.7-rubygem-ruby_dep-doc-1_3) weakremover(ruby2.7-rubygem-ruby_dig) weakremover(ruby2.7-rubygem-ruby_dig-doc) weakremover(ruby2.7-rubygem-ruby_dig-testsuite) weakremover(ruby2.7-rubygem-ruby_parser) weakremover(ruby2.7-rubygem-ruby_parser-doc) weakremover(ruby2.7-rubygem-ruby_parser-testsuite) weakremover(ruby2.7-rubygem-rubyforge) weakremover(ruby2.7-rubygem-rubyforge-doc) weakremover(ruby2.7-rubygem-rubyforge-testsuite) weakremover(ruby2.7-rubygem-rubyntlm) weakremover(ruby2.7-rubygem-rubyntlm-doc) weakremover(ruby2.7-rubygem-rubyntlm-testsuite) weakremover(ruby2.7-rubygem-rubyzip) weakremover(ruby2.7-rubygem-rubyzip-1.3) weakremover(ruby2.7-rubygem-rubyzip-doc) weakremover(ruby2.7-rubygem-rubyzip-doc-1.3) weakremover(ruby2.7-rubygem-rubyzip-testsuite-1.3) weakremover(ruby2.7-rubygem-safe_yaml) weakremover(ruby2.7-rubygem-safe_yaml-doc) weakremover(ruby2.7-rubygem-safe_yaml-testsuite) weakremover(ruby2.7-rubygem-sass) weakremover(ruby2.7-rubygem-sass-doc) weakremover(ruby2.7-rubygem-sass-listen) weakremover(ruby2.7-rubygem-sass-listen-doc) weakremover(ruby2.7-rubygem-sass-rails) weakremover(ruby2.7-rubygem-sass-rails-5.1) weakremover(ruby2.7-rubygem-sass-rails-doc) weakremover(ruby2.7-rubygem-sass-rails-doc-5.1) weakremover(ruby2.7-rubygem-sassc) weakremover(ruby2.7-rubygem-sassc-2.2) weakremover(ruby2.7-rubygem-sassc-doc) weakremover(ruby2.7-rubygem-sassc-doc-2.2) weakremover(ruby2.7-rubygem-sassc-rails) weakremover(ruby2.7-rubygem-sassc-rails-doc) weakremover(ruby2.7-rubygem-sassc-rails-testsuite) weakremover(ruby2.7-rubygem-sassc-testsuite) weakremover(ruby2.7-rubygem-sassc-testsuite-2.2) weakremover(ruby2.7-rubygem-sdoc) weakremover(ruby2.7-rubygem-sdoc-doc) weakremover(ruby2.7-rubygem-sdoc-testsuite) weakremover(ruby2.7-rubygem-securecompare) weakremover(ruby2.7-rubygem-securecompare-doc) weakremover(ruby2.7-rubygem-securecompare-testsuite) weakremover(ruby2.7-rubygem-semantic_range) weakremover(ruby2.7-rubygem-semantic_range-doc) weakremover(ruby2.7-rubygem-serverengine) weakremover(ruby2.7-rubygem-serverengine-doc) weakremover(ruby2.7-rubygem-serverengine-testsuite) weakremover(ruby2.7-rubygem-sexp_processor) weakremover(ruby2.7-rubygem-sexp_processor-doc) weakremover(ruby2.7-rubygem-sexp_processor-testsuite) weakremover(ruby2.7-rubygem-sigdump) weakremover(ruby2.7-rubygem-sigdump-doc) weakremover(ruby2.7-rubygem-simple_oauth) weakremover(ruby2.7-rubygem-simple_oauth-doc) weakremover(ruby2.7-rubygem-simplecov) weakremover(ruby2.7-rubygem-simplecov-doc) weakremover(ruby2.7-rubygem-simplecov-html) weakremover(ruby2.7-rubygem-simplecov-html-doc) weakremover(ruby2.7-rubygem-simplecov-html-testsuite) weakremover(ruby2.7-rubygem-simplecov_json_formatter) weakremover(ruby2.7-rubygem-simplecov_json_formatter-doc) weakremover(ruby2.7-rubygem-simpleidn) weakremover(ruby2.7-rubygem-simpleidn-doc) weakremover(ruby2.7-rubygem-sinatra) weakremover(ruby2.7-rubygem-sinatra-doc) weakremover(ruby2.7-rubygem-slim) weakremover(ruby2.7-rubygem-slim-doc) weakremover(ruby2.7-rubygem-slim-testsuite) weakremover(ruby2.7-rubygem-slop) weakremover(ruby2.7-rubygem-slop-3) weakremover(ruby2.7-rubygem-slop-3_3) weakremover(ruby2.7-rubygem-slop-doc) weakremover(ruby2.7-rubygem-slop-doc-3) weakremover(ruby2.7-rubygem-slop-doc-3_3) weakremover(ruby2.7-rubygem-slop-testsuite) weakremover(ruby2.7-rubygem-slop-testsuite-3) weakremover(ruby2.7-rubygem-slop-testsuite-3_3) weakremover(ruby2.7-rubygem-spring) weakremover(ruby2.7-rubygem-spring-doc) weakremover(ruby2.7-rubygem-spring-watcher-listen) weakremover(ruby2.7-rubygem-spring-watcher-listen-doc) weakremover(ruby2.7-rubygem-spring-watcher-listen-testsuite) weakremover(ruby2.7-rubygem-sprockets) weakremover(ruby2.7-rubygem-sprockets-2_1) weakremover(ruby2.7-rubygem-sprockets-2_2) weakremover(ruby2.7-rubygem-sprockets-3.7) weakremover(ruby2.7-rubygem-sprockets-doc) weakremover(ruby2.7-rubygem-sprockets-doc-2_1) weakremover(ruby2.7-rubygem-sprockets-doc-2_2) weakremover(ruby2.7-rubygem-sprockets-doc-3.7) weakremover(ruby2.7-rubygem-sprockets-helpers) weakremover(ruby2.7-rubygem-sprockets-helpers-doc) weakremover(ruby2.7-rubygem-sprockets-helpers-testsuite) weakremover(ruby2.7-rubygem-sprockets-rails) weakremover(ruby2.7-rubygem-sprockets-rails-doc) weakremover(ruby2.7-rubygem-sqlite3) weakremover(ruby2.7-rubygem-sqlite3-doc) weakremover(ruby2.7-rubygem-sqlite3-testsuite) weakremover(ruby2.7-rubygem-sshkit) weakremover(ruby2.7-rubygem-sshkit-doc) weakremover(ruby2.7-rubygem-sshkit-testsuite) weakremover(ruby2.7-rubygem-stackdeck) weakremover(ruby2.7-rubygem-stackdeck-doc) weakremover(ruby2.7-rubygem-stackdeck-testsuite) weakremover(ruby2.7-rubygem-stomp) weakremover(ruby2.7-rubygem-stomp-doc) weakremover(ruby2.7-rubygem-stomp-testsuite) weakremover(ruby2.7-rubygem-strptime) weakremover(ruby2.7-rubygem-strptime-doc) weakremover(ruby2.7-rubygem-swd) weakremover(ruby2.7-rubygem-swd-doc) weakremover(ruby2.7-rubygem-swd-testsuite) weakremover(ruby2.7-rubygem-sync) weakremover(ruby2.7-rubygem-systemu) weakremover(ruby2.7-rubygem-systemu-doc) weakremover(ruby2.7-rubygem-systemu-testsuite) weakremover(ruby2.7-rubygem-taskjuggler) weakremover(ruby2.7-rubygem-taskjuggler-doc) weakremover(ruby2.7-rubygem-taskjuggler-testsuite) weakremover(ruby2.7-rubygem-temple) weakremover(ruby2.7-rubygem-temple-doc) weakremover(ruby2.7-rubygem-temple-testsuite) weakremover(ruby2.7-rubygem-term-ansicolor) weakremover(ruby2.7-rubygem-term-ansicolor-doc) weakremover(ruby2.7-rubygem-terminal-table) weakremover(ruby2.7-rubygem-terminal-table-doc) weakremover(ruby2.7-rubygem-text) weakremover(ruby2.7-rubygem-text-doc) weakremover(ruby2.7-rubygem-text-hyphen) weakremover(ruby2.7-rubygem-text-hyphen-doc) weakremover(ruby2.7-rubygem-text-hyphen-testsuite) weakremover(ruby2.7-rubygem-text-testsuite) weakremover(ruby2.7-rubygem-thor) weakremover(ruby2.7-rubygem-thor-0_19) weakremover(ruby2.7-rubygem-thor-doc) weakremover(ruby2.7-rubygem-thor-doc-0_19) weakremover(ruby2.7-rubygem-thread_safe) weakremover(ruby2.7-rubygem-thread_safe-doc) weakremover(ruby2.7-rubygem-thread_safe-testsuite) weakremover(ruby2.7-rubygem-tilt) weakremover(ruby2.7-rubygem-tilt-1_1) weakremover(ruby2.7-rubygem-tilt-1_4) weakremover(ruby2.7-rubygem-tilt-doc) weakremover(ruby2.7-rubygem-tilt-doc-1_1) weakremover(ruby2.7-rubygem-tilt-doc-1_4) weakremover(ruby2.7-rubygem-tilt-testsuite-1_1) weakremover(ruby2.7-rubygem-tilt-testsuite-1_4) weakremover(ruby2.7-rubygem-timers) weakremover(ruby2.7-rubygem-timers-doc) weakremover(ruby2.7-rubygem-timers-testsuite) weakremover(ruby2.7-rubygem-tins) weakremover(ruby2.7-rubygem-tins-doc) weakremover(ruby2.7-rubygem-tmuxinator) weakremover(ruby2.7-rubygem-tmuxinator-doc) weakremover(ruby2.7-rubygem-tmuxinator-testsuite) weakremover(ruby2.7-rubygem-tomlrb) weakremover(ruby2.7-rubygem-tomlrb-doc) weakremover(ruby2.7-rubygem-treetop) weakremover(ruby2.7-rubygem-treetop-1_4) weakremover(ruby2.7-rubygem-treetop-doc) weakremover(ruby2.7-rubygem-treetop-doc-1_4) weakremover(ruby2.7-rubygem-treetop-testsuite-1_4) weakremover(ruby2.7-rubygem-trollop) weakremover(ruby2.7-rubygem-trollop-doc) weakremover(ruby2.7-rubygem-trollop-testsuite) weakremover(ruby2.7-rubygem-ttfunk) weakremover(ruby2.7-rubygem-ttfunk-doc) weakremover(ruby2.7-rubygem-turbolinks) weakremover(ruby2.7-rubygem-turbolinks-doc) weakremover(ruby2.7-rubygem-turbolinks-source) weakremover(ruby2.7-rubygem-turbolinks-source-doc) weakremover(ruby2.7-rubygem-tzinfo) weakremover(ruby2.7-rubygem-tzinfo-0) weakremover(ruby2.7-rubygem-tzinfo-1.2) weakremover(ruby2.7-rubygem-tzinfo-data) weakremover(ruby2.7-rubygem-tzinfo-data-doc) weakremover(ruby2.7-rubygem-tzinfo-doc) weakremover(ruby2.7-rubygem-tzinfo-doc-0) weakremover(ruby2.7-rubygem-tzinfo-doc-1.2) weakremover(ruby2.7-rubygem-tzinfo-testsuite-0) weakremover(ruby2.7-rubygem-tzinfo-testsuite-1.2) weakremover(ruby2.7-rubygem-uglifier) weakremover(ruby2.7-rubygem-uglifier-doc) weakremover(ruby2.7-rubygem-unf) weakremover(ruby2.7-rubygem-unf-doc) weakremover(ruby2.7-rubygem-unf-testsuite) weakremover(ruby2.7-rubygem-unf_ext) weakremover(ruby2.7-rubygem-unf_ext-doc) weakremover(ruby2.7-rubygem-unf_ext-testsuite) weakremover(ruby2.7-rubygem-unicode-display_width) weakremover(ruby2.7-rubygem-unicode-display_width-1) weakremover(ruby2.7-rubygem-unicode-display_width-doc) weakremover(ruby2.7-rubygem-unicode-display_width-doc-1) weakremover(ruby2.7-rubygem-unicorn) weakremover(ruby2.7-rubygem-unicorn-doc) weakremover(ruby2.7-rubygem-unicorn-testsuite) weakremover(ruby2.7-rubygem-unicorn-worker-killer) weakremover(ruby2.7-rubygem-unicorn-worker-killer-doc) weakremover(ruby2.7-rubygem-url_safe_base64) weakremover(ruby2.7-rubygem-url_safe_base64-doc) weakremover(ruby2.7-rubygem-url_safe_base64-testsuite) weakremover(ruby2.7-rubygem-vagrant-spec) weakremover(ruby2.7-rubygem-vagrant-spec-doc) weakremover(ruby2.7-rubygem-vagrant-spec-testsuite) weakremover(ruby2.7-rubygem-vagrant_cloud) weakremover(ruby2.7-rubygem-vagrant_cloud-doc) weakremover(ruby2.7-rubygem-validate_email) weakremover(ruby2.7-rubygem-validate_email-doc) weakremover(ruby2.7-rubygem-validate_url) weakremover(ruby2.7-rubygem-validate_url-doc) weakremover(ruby2.7-rubygem-virtus) weakremover(ruby2.7-rubygem-virtus-doc) weakremover(ruby2.7-rubygem-virtus-testsuite) weakremover(ruby2.7-rubygem-warden) weakremover(ruby2.7-rubygem-warden-doc) weakremover(ruby2.7-rubygem-web-console) weakremover(ruby2.7-rubygem-web-console-2) weakremover(ruby2.7-rubygem-web-console-doc) weakremover(ruby2.7-rubygem-web-console-doc-2) weakremover(ruby2.7-rubygem-webfinger) weakremover(ruby2.7-rubygem-webfinger-doc) weakremover(ruby2.7-rubygem-webfinger-testsuite) weakremover(ruby2.7-rubygem-webmock-1_2) weakremover(ruby2.7-rubygem-webmock-2_3) weakremover(ruby2.7-rubygem-webmock-doc-1_2) weakremover(ruby2.7-rubygem-webmock-doc-2_3) weakremover(ruby2.7-rubygem-webmock-testsuite-1_2) weakremover(ruby2.7-rubygem-webmock-testsuite-2_3) weakremover(ruby2.7-rubygem-webpacker) weakremover(ruby2.7-rubygem-webpacker-4.0) weakremover(ruby2.7-rubygem-webpacker-doc) weakremover(ruby2.7-rubygem-webpacker-testsuite) weakremover(ruby2.7-rubygem-webrick) weakremover(ruby2.7-rubygem-websocket) weakremover(ruby2.7-rubygem-websocket-doc) weakremover(ruby2.7-rubygem-websocket-driver) weakremover(ruby2.7-rubygem-websocket-driver-0_6) weakremover(ruby2.7-rubygem-websocket-driver-doc) weakremover(ruby2.7-rubygem-websocket-driver-doc-0_6) weakremover(ruby2.7-rubygem-websocket-extensions) weakremover(ruby2.7-rubygem-websocket-extensions-doc) weakremover(ruby2.7-rubygem-websocket-testsuite) weakremover(ruby2.7-rubygem-winrm) weakremover(ruby2.7-rubygem-winrm-2_1) weakremover(ruby2.7-rubygem-winrm-doc) weakremover(ruby2.7-rubygem-winrm-doc-2_1) weakremover(ruby2.7-rubygem-winrm-elevated) weakremover(ruby2.7-rubygem-winrm-elevated-doc) weakremover(ruby2.7-rubygem-winrm-fs) weakremover(ruby2.7-rubygem-winrm-fs-doc) weakremover(ruby2.7-rubygem-xdg) weakremover(ruby2.7-rubygem-xdg-2) weakremover(ruby2.7-rubygem-xdg-doc) weakremover(ruby2.7-rubygem-xdg-doc-2) weakremover(ruby2.7-rubygem-xdg-testsuite-2) weakremover(ruby2.7-rubygem-xml-simple) weakremover(ruby2.7-rubygem-xml-simple-doc) weakremover(ruby2.7-rubygem-xmlhash) weakremover(ruby2.7-rubygem-xmlhash-doc) weakremover(ruby2.7-rubygem-xmlhash-testsuite) weakremover(ruby2.7-rubygem-yajl-ruby) weakremover(ruby2.7-rubygem-yajl-ruby-doc) weakremover(ruby2.7-rubygem-yajl-ruby-testsuite) weakremover(ruby2.7-rubygem-yard) weakremover(ruby2.7-rubygem-yard-doc) weakremover(ruby2.7-rubygem-yard-testsuite) weakremover(ruby2.7-rubygem-yast-rake) weakremover(ruby2.7-rubygem-yast-rake-doc) weakremover(ruby2.7-rubygem-zeitwerk) weakremover(ruby2.7-rubygem-zeitwerk-doc) weakremover(ruby3.0) weakremover(ruby3.0-devel) weakremover(ruby3.0-devel-extra) weakremover(ruby3.0-doc) weakremover(ruby3.0-doc-ri) weakremover(ruby3.0-rubygem-Ascii85) weakremover(ruby3.0-rubygem-Ascii85-doc) weakremover(ruby3.0-rubygem-Ascii85-testsuite) weakremover(ruby3.0-rubygem-RedCloth) weakremover(ruby3.0-rubygem-RedCloth-doc) weakremover(ruby3.0-rubygem-RedCloth-testsuite) weakremover(ruby3.0-rubygem-abstract) weakremover(ruby3.0-rubygem-abstract-doc) weakremover(ruby3.0-rubygem-abstract-testsuite) weakremover(ruby3.0-rubygem-abstract_method) weakremover(ruby3.0-rubygem-abstract_method-doc) weakremover(ruby3.0-rubygem-actioncable-5.2) weakremover(ruby3.0-rubygem-actioncable-6.0) weakremover(ruby3.0-rubygem-actioncable-doc-5.2) weakremover(ruby3.0-rubygem-actioncable-doc-6.0) weakremover(ruby3.0-rubygem-actionmailbox-6.0) weakremover(ruby3.0-rubygem-actionmailbox-doc-6.0) weakremover(ruby3.0-rubygem-actionmailer-5.2) weakremover(ruby3.0-rubygem-actionmailer-6.0) weakremover(ruby3.0-rubygem-actionmailer-doc-5.2) weakremover(ruby3.0-rubygem-actionmailer-doc-6.0) weakremover(ruby3.0-rubygem-actionpack-5.2) weakremover(ruby3.0-rubygem-actionpack-6.0) weakremover(ruby3.0-rubygem-actionpack-doc-5.2) weakremover(ruby3.0-rubygem-actionpack-doc-6.0) weakremover(ruby3.0-rubygem-actiontext-6.0) weakremover(ruby3.0-rubygem-actiontext-doc-6.0) weakremover(ruby3.0-rubygem-actionview-5.2) weakremover(ruby3.0-rubygem-actionview-6.0) weakremover(ruby3.0-rubygem-actionview-doc-5.2) weakremover(ruby3.0-rubygem-actionview-doc-6.0) weakremover(ruby3.0-rubygem-activejob-5.2) weakremover(ruby3.0-rubygem-activejob-6.0) weakremover(ruby3.0-rubygem-activejob-doc-5.2) weakremover(ruby3.0-rubygem-activejob-doc-6.0) weakremover(ruby3.0-rubygem-activemodel-5.2) weakremover(ruby3.0-rubygem-activemodel-6.0) weakremover(ruby3.0-rubygem-activemodel-doc-5.2) weakremover(ruby3.0-rubygem-activemodel-doc-6.0) weakremover(ruby3.0-rubygem-activerecord-5.2) weakremover(ruby3.0-rubygem-activerecord-6.0) weakremover(ruby3.0-rubygem-activerecord-deprecated_finders) weakremover(ruby3.0-rubygem-activerecord-deprecated_finders-doc) weakremover(ruby3.0-rubygem-activerecord-doc-5.2) weakremover(ruby3.0-rubygem-activerecord-doc-6.0) weakremover(ruby3.0-rubygem-activestorage-5.2) weakremover(ruby3.0-rubygem-activestorage-6.0) weakremover(ruby3.0-rubygem-activestorage-doc-5.2) weakremover(ruby3.0-rubygem-activestorage-doc-6.0) weakremover(ruby3.0-rubygem-activesupport-5.2) weakremover(ruby3.0-rubygem-activesupport-6.0) weakremover(ruby3.0-rubygem-activesupport-doc-5.2) weakremover(ruby3.0-rubygem-activesupport-doc-6.0) weakremover(ruby3.0-rubygem-addressable) weakremover(ruby3.0-rubygem-addressable-2_3) weakremover(ruby3.0-rubygem-addressable-doc) weakremover(ruby3.0-rubygem-addressable-doc-2_3) weakremover(ruby3.0-rubygem-addressable-testsuite) weakremover(ruby3.0-rubygem-addressable-testsuite-2_3) weakremover(ruby3.0-rubygem-aes_key_wrap) weakremover(ruby3.0-rubygem-aes_key_wrap-doc) weakremover(ruby3.0-rubygem-afm) weakremover(ruby3.0-rubygem-afm-doc) weakremover(ruby3.0-rubygem-afm-testsuite) weakremover(ruby3.0-rubygem-airbrussh) weakremover(ruby3.0-rubygem-airbrussh-doc) weakremover(ruby3.0-rubygem-amq-protocol) weakremover(ruby3.0-rubygem-amq-protocol-doc) weakremover(ruby3.0-rubygem-amq-protocol-testsuite) weakremover(ruby3.0-rubygem-amqp) weakremover(ruby3.0-rubygem-amqp-doc) weakremover(ruby3.0-rubygem-amqp-testsuite) weakremover(ruby3.0-rubygem-archive-tar-minitar) weakremover(ruby3.0-rubygem-archive-tar-minitar-doc) weakremover(ruby3.0-rubygem-arel) weakremover(ruby3.0-rubygem-arel-3_0) weakremover(ruby3.0-rubygem-arel-6) weakremover(ruby3.0-rubygem-arel-7) weakremover(ruby3.0-rubygem-arel-8) weakremover(ruby3.0-rubygem-arel-doc) weakremover(ruby3.0-rubygem-arel-doc-3_0) weakremover(ruby3.0-rubygem-arel-doc-6) weakremover(ruby3.0-rubygem-arel-doc-7) weakremover(ruby3.0-rubygem-arel-doc-8) weakremover(ruby3.0-rubygem-arel-testsuite-3_0) weakremover(ruby3.0-rubygem-asciidoctor) weakremover(ruby3.0-rubygem-asciidoctor-doc) weakremover(ruby3.0-rubygem-ast) weakremover(ruby3.0-rubygem-ast-doc) weakremover(ruby3.0-rubygem-atomic) weakremover(ruby3.0-rubygem-atomic-doc) weakremover(ruby3.0-rubygem-atomic-testsuite) weakremover(ruby3.0-rubygem-attr_required) weakremover(ruby3.0-rubygem-attr_required-doc) weakremover(ruby3.0-rubygem-attr_required-testsuite) weakremover(ruby3.0-rubygem-autoprefixer-rails) weakremover(ruby3.0-rubygem-autoprefixer-rails-doc) weakremover(ruby3.0-rubygem-axiom-types) weakremover(ruby3.0-rubygem-axiom-types-doc) weakremover(ruby3.0-rubygem-axiom-types-testsuite) weakremover(ruby3.0-rubygem-backport) weakremover(ruby3.0-rubygem-backport-doc) weakremover(ruby3.0-rubygem-base32) weakremover(ruby3.0-rubygem-base32-doc) weakremover(ruby3.0-rubygem-base32-testsuite) weakremover(ruby3.0-rubygem-bcrypt) weakremover(ruby3.0-rubygem-bcrypt-doc) weakremover(ruby3.0-rubygem-bcrypt-ruby) weakremover(ruby3.0-rubygem-bcrypt-ruby-doc) weakremover(ruby3.0-rubygem-bcrypt-testsuite) weakremover(ruby3.0-rubygem-bcrypt_pbkdf) weakremover(ruby3.0-rubygem-bcrypt_pbkdf-doc) weakremover(ruby3.0-rubygem-bcrypt_pbkdf-testsuite) weakremover(ruby3.0-rubygem-benchmark) weakremover(ruby3.0-rubygem-benchmark-doc) weakremover(ruby3.0-rubygem-bindata) weakremover(ruby3.0-rubygem-bindata-doc) weakremover(ruby3.0-rubygem-bindata-testsuite) weakremover(ruby3.0-rubygem-bindex) weakremover(ruby3.0-rubygem-bindex-doc) weakremover(ruby3.0-rubygem-bindex-testsuite) weakremover(ruby3.0-rubygem-binding_of_caller) weakremover(ruby3.0-rubygem-binding_of_caller-doc) weakremover(ruby3.0-rubygem-binding_of_caller-testsuite) weakremover(ruby3.0-rubygem-bootsnap) weakremover(ruby3.0-rubygem-bootsnap-doc) weakremover(ruby3.0-rubygem-bootstrap-sass) weakremover(ruby3.0-rubygem-bootstrap-sass-doc) weakremover(ruby3.0-rubygem-bootstrap-sass-testsuite) weakremover(ruby3.0-rubygem-buff-extensions) weakremover(ruby3.0-rubygem-buff-extensions-doc) weakremover(ruby3.0-rubygem-buff-extensions-testsuite) weakremover(ruby3.0-rubygem-buff-ignore) weakremover(ruby3.0-rubygem-buff-ignore-doc) weakremover(ruby3.0-rubygem-buff-ignore-testsuite) weakremover(ruby3.0-rubygem-buff-ruby_engine) weakremover(ruby3.0-rubygem-buff-ruby_engine-doc) weakremover(ruby3.0-rubygem-buff-ruby_engine-testsuite) weakremover(ruby3.0-rubygem-builder) weakremover(ruby3.0-rubygem-builder-doc) weakremover(ruby3.0-rubygem-builder-testsuite) weakremover(ruby3.0-rubygem-bundler) weakremover(ruby3.0-rubygem-bundler-audit) weakremover(ruby3.0-rubygem-bundler-audit-doc) weakremover(ruby3.0-rubygem-bundler-audit-testsuite) weakremover(ruby3.0-rubygem-bundler-doc) weakremover(ruby3.0-rubygem-bunny) weakremover(ruby3.0-rubygem-bunny-doc) weakremover(ruby3.0-rubygem-bunny-testsuite) weakremover(ruby3.0-rubygem-byebug) weakremover(ruby3.0-rubygem-byebug-doc) weakremover(ruby3.0-rubygem-capistrano) weakremover(ruby3.0-rubygem-capistrano-doc) weakremover(ruby3.0-rubygem-capistrano-harrow) weakremover(ruby3.0-rubygem-capistrano-harrow-doc) weakremover(ruby3.0-rubygem-capistrano-stats) weakremover(ruby3.0-rubygem-capistrano-stats-doc) weakremover(ruby3.0-rubygem-capistrano-testsuite) weakremover(ruby3.0-rubygem-celluloid) weakremover(ruby3.0-rubygem-celluloid-doc) weakremover(ruby3.0-rubygem-celluloid-essentials) weakremover(ruby3.0-rubygem-celluloid-essentials-doc) weakremover(ruby3.0-rubygem-celluloid-extras) weakremover(ruby3.0-rubygem-celluloid-extras-doc) weakremover(ruby3.0-rubygem-celluloid-fsm) weakremover(ruby3.0-rubygem-celluloid-fsm-doc) weakremover(ruby3.0-rubygem-celluloid-pool) weakremover(ruby3.0-rubygem-celluloid-pool-doc) weakremover(ruby3.0-rubygem-celluloid-supervision) weakremover(ruby3.0-rubygem-celluloid-supervision-doc) weakremover(ruby3.0-rubygem-celluloid-testsuite) weakremover(ruby3.0-rubygem-cfa) weakremover(ruby3.0-rubygem-cfa-doc) weakremover(ruby3.0-rubygem-cfa_grub2) weakremover(ruby3.0-rubygem-cfa_grub2-doc) weakremover(ruby3.0-rubygem-changelog_generator) weakremover(ruby3.0-rubygem-changelog_generator-doc) weakremover(ruby3.0-rubygem-changelog_generator-testsuite) weakremover(ruby3.0-rubygem-cheetah) weakremover(ruby3.0-rubygem-cheetah-doc) weakremover(ruby3.0-rubygem-chef-utils) weakremover(ruby3.0-rubygem-chef-utils-doc) weakremover(ruby3.0-rubygem-chef-utils-testsuite) weakremover(ruby3.0-rubygem-childprocess) weakremover(ruby3.0-rubygem-childprocess-0_6) weakremover(ruby3.0-rubygem-childprocess-2.0) weakremover(ruby3.0-rubygem-childprocess-doc) weakremover(ruby3.0-rubygem-childprocess-doc-0_6) weakremover(ruby3.0-rubygem-childprocess-doc-2.0) weakremover(ruby3.0-rubygem-childprocess-testsuite) weakremover(ruby3.0-rubygem-childprocess-testsuite-0_6) weakremover(ruby3.0-rubygem-childprocess-testsuite-2.0) weakremover(ruby3.0-rubygem-ci_reporter) weakremover(ruby3.0-rubygem-ci_reporter-doc) weakremover(ruby3.0-rubygem-ci_reporter-testsuite) weakremover(ruby3.0-rubygem-cleanroom) weakremover(ruby3.0-rubygem-cleanroom-doc) weakremover(ruby3.0-rubygem-cleanroom-testsuite) weakremover(ruby3.0-rubygem-coderay) weakremover(ruby3.0-rubygem-coderay-doc) weakremover(ruby3.0-rubygem-coercible) weakremover(ruby3.0-rubygem-coercible-doc) weakremover(ruby3.0-rubygem-coercible-testsuite) weakremover(ruby3.0-rubygem-coffee-rails) weakremover(ruby3.0-rubygem-coffee-rails-doc) weakremover(ruby3.0-rubygem-coffee-script) weakremover(ruby3.0-rubygem-coffee-script-doc) weakremover(ruby3.0-rubygem-coffee-script-source) weakremover(ruby3.0-rubygem-coffee-script-source-doc) weakremover(ruby3.0-rubygem-colorator) weakremover(ruby3.0-rubygem-colorator-0) weakremover(ruby3.0-rubygem-colorator-doc) weakremover(ruby3.0-rubygem-colorator-doc-0) weakremover(ruby3.0-rubygem-colorator-testsuite-0) weakremover(ruby3.0-rubygem-colored) weakremover(ruby3.0-rubygem-colored-doc) weakremover(ruby3.0-rubygem-colored-testsuite) weakremover(ruby3.0-rubygem-colorize) weakremover(ruby3.0-rubygem-colorize-doc) weakremover(ruby3.0-rubygem-colorize-testsuite) weakremover(ruby3.0-rubygem-columnize) weakremover(ruby3.0-rubygem-columnize-doc) weakremover(ruby3.0-rubygem-columnize-testsuite) weakremover(ruby3.0-rubygem-commander) weakremover(ruby3.0-rubygem-commander-doc) weakremover(ruby3.0-rubygem-commander-testsuite) weakremover(ruby3.0-rubygem-concurrent-ruby) weakremover(ruby3.0-rubygem-concurrent-ruby-doc) weakremover(ruby3.0-rubygem-cool.io) weakremover(ruby3.0-rubygem-cool.io-doc) weakremover(ruby3.0-rubygem-cool.io-testsuite) weakremover(ruby3.0-rubygem-crack) weakremover(ruby3.0-rubygem-crack-doc) weakremover(ruby3.0-rubygem-crass) weakremover(ruby3.0-rubygem-crass-doc) weakremover(ruby3.0-rubygem-css_parser) weakremover(ruby3.0-rubygem-css_parser-doc) weakremover(ruby3.0-rubygem-cssmin) weakremover(ruby3.0-rubygem-cssmin-doc) weakremover(ruby3.0-rubygem-daemons) weakremover(ruby3.0-rubygem-daemons-doc) weakremover(ruby3.0-rubygem-debase) weakremover(ruby3.0-rubygem-debase-ruby_core_source) weakremover(ruby3.0-rubygem-debase-ruby_core_source-doc) weakremover(ruby3.0-rubygem-debug_inspector) weakremover(ruby3.0-rubygem-debug_inspector-doc) weakremover(ruby3.0-rubygem-debug_inspector-testsuite) weakremover(ruby3.0-rubygem-debugger-linecache) weakremover(ruby3.0-rubygem-debugger-linecache-doc) weakremover(ruby3.0-rubygem-debugger-linecache-testsuite) weakremover(ruby3.0-rubygem-deep_merge) weakremover(ruby3.0-rubygem-deep_merge-doc) weakremover(ruby3.0-rubygem-deep_merge-testsuite) weakremover(ruby3.0-rubygem-delayed_job) weakremover(ruby3.0-rubygem-delayed_job-doc) weakremover(ruby3.0-rubygem-delayed_job-testsuite) weakremover(ruby3.0-rubygem-delayed_job_active_record) weakremover(ruby3.0-rubygem-delayed_job_active_record-doc) weakremover(ruby3.0-rubygem-descendants_tracker) weakremover(ruby3.0-rubygem-descendants_tracker-doc) weakremover(ruby3.0-rubygem-descendants_tracker-testsuite) weakremover(ruby3.0-rubygem-devise) weakremover(ruby3.0-rubygem-devise-doc) weakremover(ruby3.0-rubygem-devise-i18n) weakremover(ruby3.0-rubygem-devise-i18n-doc) weakremover(ruby3.0-rubygem-devise_ldap_authenticatable) weakremover(ruby3.0-rubygem-devise_ldap_authenticatable-doc) weakremover(ruby3.0-rubygem-devise_ldap_authenticatable-testsuite) weakremover(ruby3.0-rubygem-diff-lcs) weakremover(ruby3.0-rubygem-diff-lcs-doc) weakremover(ruby3.0-rubygem-diff-lcs-testsuite) weakremover(ruby3.0-rubygem-diffy) weakremover(ruby3.0-rubygem-diffy-doc) weakremover(ruby3.0-rubygem-diffy-testsuite) weakremover(ruby3.0-rubygem-dig_rb) weakremover(ruby3.0-rubygem-dig_rb-doc) weakremover(ruby3.0-rubygem-docile) weakremover(ruby3.0-rubygem-docile-1_1) weakremover(ruby3.0-rubygem-docile-doc) weakremover(ruby3.0-rubygem-docile-doc-1_1) weakremover(ruby3.0-rubygem-docile-testsuite-1_1) weakremover(ruby3.0-rubygem-domain_name) weakremover(ruby3.0-rubygem-domain_name-doc) weakremover(ruby3.0-rubygem-domain_name-testsuite) weakremover(ruby3.0-rubygem-down) weakremover(ruby3.0-rubygem-dry-configurable) weakremover(ruby3.0-rubygem-dry-configurable-doc) weakremover(ruby3.0-rubygem-dry-container) weakremover(ruby3.0-rubygem-dry-container-doc) weakremover(ruby3.0-rubygem-dry-container-testsuite) weakremover(ruby3.0-rubygem-dry-core) weakremover(ruby3.0-rubygem-dry-core-doc) weakremover(ruby3.0-rubygem-dry-equalizer) weakremover(ruby3.0-rubygem-dry-equalizer-doc) weakremover(ruby3.0-rubygem-dry-equalizer-testsuite) weakremover(ruby3.0-rubygem-dry-inflector) weakremover(ruby3.0-rubygem-dry-inflector-doc) weakremover(ruby3.0-rubygem-dry-logic) weakremover(ruby3.0-rubygem-dry-logic-doc) weakremover(ruby3.0-rubygem-dry-types) weakremover(ruby3.0-rubygem-dry-types-doc) weakremover(ruby3.0-rubygem-ed25519) weakremover(ruby3.0-rubygem-ed25519-doc) weakremover(ruby3.0-rubygem-em-websocket) weakremover(ruby3.0-rubygem-em-websocket-doc) weakremover(ruby3.0-rubygem-em-websocket-testsuite) weakremover(ruby3.0-rubygem-equalizer) weakremover(ruby3.0-rubygem-equalizer-doc) weakremover(ruby3.0-rubygem-equalizer-testsuite) weakremover(ruby3.0-rubygem-erubi) weakremover(ruby3.0-rubygem-erubi-doc) weakremover(ruby3.0-rubygem-erubis) weakremover(ruby3.0-rubygem-erubis-2_6) weakremover(ruby3.0-rubygem-erubis-doc) weakremover(ruby3.0-rubygem-erubis-doc-2_6) weakremover(ruby3.0-rubygem-erubis-testsuite) weakremover(ruby3.0-rubygem-erubis-testsuite-2_6) weakremover(ruby3.0-rubygem-eventmachine) weakremover(ruby3.0-rubygem-eventmachine-doc) weakremover(ruby3.0-rubygem-exception_notification) weakremover(ruby3.0-rubygem-exception_notification-doc) weakremover(ruby3.0-rubygem-exception_notification-testsuite) weakremover(ruby3.0-rubygem-excon) weakremover(ruby3.0-rubygem-excon-doc) weakremover(ruby3.0-rubygem-execjs) weakremover(ruby3.0-rubygem-execjs-doc) weakremover(ruby3.0-rubygem-extlib) weakremover(ruby3.0-rubygem-extlib-doc) weakremover(ruby3.0-rubygem-extlib-testsuite) weakremover(ruby3.0-rubygem-factory_girl) weakremover(ruby3.0-rubygem-factory_girl-doc) weakremover(ruby3.0-rubygem-factory_girl_rails) weakremover(ruby3.0-rubygem-factory_girl_rails-doc) weakremover(ruby3.0-rubygem-fake_ftp) weakremover(ruby3.0-rubygem-fake_ftp-0_1) weakremover(ruby3.0-rubygem-fake_ftp-doc) weakremover(ruby3.0-rubygem-fake_ftp-doc-0_1) weakremover(ruby3.0-rubygem-fake_ftp-testsuite) weakremover(ruby3.0-rubygem-fake_ftp-testsuite-0_1) weakremover(ruby3.0-rubygem-faraday) weakremover(ruby3.0-rubygem-faraday-0_12) weakremover(ruby3.0-rubygem-faraday-doc) weakremover(ruby3.0-rubygem-faraday-doc-0_12) weakremover(ruby3.0-rubygem-faraday-net_http) weakremover(ruby3.0-rubygem-faraday-net_http-doc) weakremover(ruby3.0-rubygem-faraday-testsuite) weakremover(ruby3.0-rubygem-faraday_middleware) weakremover(ruby3.0-rubygem-faraday_middleware-doc) weakremover(ruby3.0-rubygem-faraday_middleware-multi_json) weakremover(ruby3.0-rubygem-faraday_middleware-multi_json-doc) weakremover(ruby3.0-rubygem-faraday_middleware-multi_json-testsuite) weakremover(ruby3.0-rubygem-fast_gettext) weakremover(ruby3.0-rubygem-fast_gettext-1.1) weakremover(ruby3.0-rubygem-fast_gettext-doc) weakremover(ruby3.0-rubygem-fast_gettext-doc-1.1) weakremover(ruby3.0-rubygem-fast_xs) weakremover(ruby3.0-rubygem-fast_xs-doc) weakremover(ruby3.0-rubygem-fast_xs-testsuite) weakremover(ruby3.0-rubygem-fastercsv) weakremover(ruby3.0-rubygem-fastercsv-doc) weakremover(ruby3.0-rubygem-fastercsv-testsuite) weakremover(ruby3.0-rubygem-ffi) weakremover(ruby3.0-rubygem-ffi-compiler) weakremover(ruby3.0-rubygem-ffi-doc) weakremover(ruby3.0-rubygem-flog) weakremover(ruby3.0-rubygem-flog-doc) weakremover(ruby3.0-rubygem-flog-testsuite) weakremover(ruby3.0-rubygem-fluentd) weakremover(ruby3.0-rubygem-fluentd-doc) weakremover(ruby3.0-rubygem-fluentd-testsuite) weakremover(ruby3.0-rubygem-fog-core) weakremover(ruby3.0-rubygem-fog-core-doc) weakremover(ruby3.0-rubygem-fog-core-testsuite) weakremover(ruby3.0-rubygem-fog-json) weakremover(ruby3.0-rubygem-fog-json-doc) weakremover(ruby3.0-rubygem-fog-json-testsuite) weakremover(ruby3.0-rubygem-fog-libvirt) weakremover(ruby3.0-rubygem-fog-libvirt-doc) weakremover(ruby3.0-rubygem-fog-xml) weakremover(ruby3.0-rubygem-fog-xml-doc) weakremover(ruby3.0-rubygem-fog-xml-testsuite) weakremover(ruby3.0-rubygem-font-awesome-rails) weakremover(ruby3.0-rubygem-font-awesome-rails-doc) weakremover(ruby3.0-rubygem-font-awesome-rails-testsuite) weakremover(ruby3.0-rubygem-formatador) weakremover(ruby3.0-rubygem-formatador-doc) weakremover(ruby3.0-rubygem-forwardable-extended) weakremover(ruby3.0-rubygem-forwardable-extended-doc) weakremover(ruby3.0-rubygem-gem2rpm) weakremover(ruby3.0-rubygem-get_process_mem) weakremover(ruby3.0-rubygem-get_process_mem-doc) weakremover(ruby3.0-rubygem-get_process_mem-testsuite) weakremover(ruby3.0-rubygem-gettext) weakremover(ruby3.0-rubygem-gettext-doc) weakremover(ruby3.0-rubygem-gettext-setup) weakremover(ruby3.0-rubygem-gettext-setup-doc) weakremover(ruby3.0-rubygem-gettext-setup-testsuite) weakremover(ruby3.0-rubygem-gettext-testsuite) weakremover(ruby3.0-rubygem-gettext_i18n_rails) weakremover(ruby3.0-rubygem-gettext_i18n_rails-doc) weakremover(ruby3.0-rubygem-gettext_i18n_rails_js) weakremover(ruby3.0-rubygem-gettext_i18n_rails_js-doc) weakremover(ruby3.0-rubygem-gettext_i18n_rails_js-testsuite) weakremover(ruby3.0-rubygem-gli) weakremover(ruby3.0-rubygem-gli-doc) weakremover(ruby3.0-rubygem-gli-testsuite) weakremover(ruby3.0-rubygem-globalid) weakremover(ruby3.0-rubygem-globalid-doc) weakremover(ruby3.0-rubygem-gpgme) weakremover(ruby3.0-rubygem-gpgme-doc) weakremover(ruby3.0-rubygem-gpgme-testsuite) weakremover(ruby3.0-rubygem-grape) weakremover(ruby3.0-rubygem-grape-doc) weakremover(ruby3.0-rubygem-grape-testsuite) weakremover(ruby3.0-rubygem-gravatar_image_tag) weakremover(ruby3.0-rubygem-gravatar_image_tag-doc) weakremover(ruby3.0-rubygem-gravatar_image_tag-testsuite) weakremover(ruby3.0-rubygem-gssapi) weakremover(ruby3.0-rubygem-gssapi-doc) weakremover(ruby3.0-rubygem-gssapi-testsuite) weakremover(ruby3.0-rubygem-gyoku) weakremover(ruby3.0-rubygem-gyoku-doc) weakremover(ruby3.0-rubygem-gyoku-testsuite) weakremover(ruby3.0-rubygem-haml) weakremover(ruby3.0-rubygem-haml-doc) weakremover(ruby3.0-rubygem-haml-rails) weakremover(ruby3.0-rubygem-haml-rails-doc) weakremover(ruby3.0-rubygem-haml-rails-testsuite) weakremover(ruby3.0-rubygem-has_mobile_views) weakremover(ruby3.0-rubygem-has_mobile_views-doc) weakremover(ruby3.0-rubygem-has_mobile_views-testsuite) weakremover(ruby3.0-rubygem-hashdiff) weakremover(ruby3.0-rubygem-hashdiff-doc) weakremover(ruby3.0-rubygem-hashdiff-testsuite) weakremover(ruby3.0-rubygem-hashery) weakremover(ruby3.0-rubygem-hashery-doc) weakremover(ruby3.0-rubygem-hashery-testsuite) weakremover(ruby3.0-rubygem-hashicorp-checkpoint) weakremover(ruby3.0-rubygem-hashicorp-checkpoint-doc) weakremover(ruby3.0-rubygem-hashicorp-checkpoint-testsuite) weakremover(ruby3.0-rubygem-hashie) weakremover(ruby3.0-rubygem-hashie-doc) weakremover(ruby3.0-rubygem-hashie-testsuite) weakremover(ruby3.0-rubygem-highline) weakremover(ruby3.0-rubygem-highline-1_6) weakremover(ruby3.0-rubygem-highline-1_7) weakremover(ruby3.0-rubygem-highline-doc) weakremover(ruby3.0-rubygem-highline-doc-1_6) weakremover(ruby3.0-rubygem-highline-doc-1_7) weakremover(ruby3.0-rubygem-highline-testsuite-1_6) weakremover(ruby3.0-rubygem-highline-testsuite-1_7) weakremover(ruby3.0-rubygem-hike) weakremover(ruby3.0-rubygem-hike-1_2) weakremover(ruby3.0-rubygem-hike-doc) weakremover(ruby3.0-rubygem-hike-doc-1_2) weakremover(ruby3.0-rubygem-hitimes) weakremover(ruby3.0-rubygem-hitimes-doc) weakremover(ruby3.0-rubygem-hitimes-testsuite) weakremover(ruby3.0-rubygem-hoe) weakremover(ruby3.0-rubygem-hoe-doc) weakremover(ruby3.0-rubygem-hoe-testsuite) weakremover(ruby3.0-rubygem-hpricot) weakremover(ruby3.0-rubygem-hpricot-doc) weakremover(ruby3.0-rubygem-hpricot-testsuite) weakremover(ruby3.0-rubygem-html2haml) weakremover(ruby3.0-rubygem-html2haml-doc) weakremover(ruby3.0-rubygem-html2haml-testsuite) weakremover(ruby3.0-rubygem-http) weakremover(ruby3.0-rubygem-http-accept-1.7) weakremover(ruby3.0-rubygem-http-accept-doc-1.7) weakremover(ruby3.0-rubygem-http-cookie) weakremover(ruby3.0-rubygem-http-cookie-doc) weakremover(ruby3.0-rubygem-http-cookie-testsuite) weakremover(ruby3.0-rubygem-http-form_data) weakremover(ruby3.0-rubygem-http_accept_language) weakremover(ruby3.0-rubygem-http_accept_language-doc) weakremover(ruby3.0-rubygem-http_accept_language-testsuite) weakremover(ruby3.0-rubygem-http_parser.rb) weakremover(ruby3.0-rubygem-http_parser.rb-doc) weakremover(ruby3.0-rubygem-http_parser.rb-testsuite) weakremover(ruby3.0-rubygem-httpclient) weakremover(ruby3.0-rubygem-httpclient-doc) weakremover(ruby3.0-rubygem-httpclient-testsuite) weakremover(ruby3.0-rubygem-i18n) weakremover(ruby3.0-rubygem-i18n-0_6) weakremover(ruby3.0-rubygem-i18n-0_9) weakremover(ruby3.0-rubygem-i18n-1.1) weakremover(ruby3.0-rubygem-i18n-doc) weakremover(ruby3.0-rubygem-i18n-doc-0_6) weakremover(ruby3.0-rubygem-i18n-doc-0_9) weakremover(ruby3.0-rubygem-i18n-doc-1.1) weakremover(ruby3.0-rubygem-i18n-testsuite-0_6) weakremover(ruby3.0-rubygem-i18n-testsuite-0_9) weakremover(ruby3.0-rubygem-i18n-testsuite-1.1) weakremover(ruby3.0-rubygem-ice_nine) weakremover(ruby3.0-rubygem-ice_nine-doc) weakremover(ruby3.0-rubygem-ice_nine-testsuite) weakremover(ruby3.0-rubygem-inifile) weakremover(ruby3.0-rubygem-inifile-doc) weakremover(ruby3.0-rubygem-inifile-testsuite) weakremover(ruby3.0-rubygem-ipaddress) weakremover(ruby3.0-rubygem-ipaddress-doc) weakremover(ruby3.0-rubygem-ipaddress-testsuite) weakremover(ruby3.0-rubygem-jaro_winkler) weakremover(ruby3.0-rubygem-jaro_winkler-doc) weakremover(ruby3.0-rubygem-jbuilder) weakremover(ruby3.0-rubygem-jbuilder-doc) weakremover(ruby3.0-rubygem-jbuilder-testsuite) weakremover(ruby3.0-rubygem-jekyll) weakremover(ruby3.0-rubygem-jekyll-doc) weakremover(ruby3.0-rubygem-jekyll-sass-converter) weakremover(ruby3.0-rubygem-jekyll-sass-converter-doc) weakremover(ruby3.0-rubygem-jekyll-watch) weakremover(ruby3.0-rubygem-jekyll-watch-doc) weakremover(ruby3.0-rubygem-jmespath) weakremover(ruby3.0-rubygem-jmespath-doc) weakremover(ruby3.0-rubygem-journey-1_0) weakremover(ruby3.0-rubygem-journey-doc-1_0) weakremover(ruby3.0-rubygem-journey-testsuite-1_0) weakremover(ruby3.0-rubygem-jquery-rails) weakremover(ruby3.0-rubygem-jquery-rails-doc) weakremover(ruby3.0-rubygem-jquery-rails-testsuite) weakremover(ruby3.0-rubygem-jquery-ui-rails) weakremover(ruby3.0-rubygem-jquery-ui-rails-doc) weakremover(ruby3.0-rubygem-js-routes) weakremover(ruby3.0-rubygem-js-routes-doc) weakremover(ruby3.0-rubygem-js-routes-testsuite) weakremover(ruby3.0-rubygem-json) weakremover(ruby3.0-rubygem-json-doc) weakremover(ruby3.0-rubygem-json-jwt) weakremover(ruby3.0-rubygem-json-jwt-doc) weakremover(ruby3.0-rubygem-json-schema) weakremover(ruby3.0-rubygem-json-schema-doc) weakremover(ruby3.0-rubygem-json_pure) weakremover(ruby3.0-rubygem-json_pure-doc) weakremover(ruby3.0-rubygem-jwt) weakremover(ruby3.0-rubygem-jwt-1_5) weakremover(ruby3.0-rubygem-jwt-doc) weakremover(ruby3.0-rubygem-jwt-doc-1_5) weakremover(ruby3.0-rubygem-jwt-testsuite-1_5) weakremover(ruby3.0-rubygem-kgio) weakremover(ruby3.0-rubygem-kgio-doc) weakremover(ruby3.0-rubygem-kgio-testsuite) weakremover(ruby3.0-rubygem-kramdown) weakremover(ruby3.0-rubygem-kramdown-doc) weakremover(ruby3.0-rubygem-kramdown-parser-gfm) weakremover(ruby3.0-rubygem-kramdown-parser-gfm-doc) weakremover(ruby3.0-rubygem-kramdown-parser-gfm-testsuite) weakremover(ruby3.0-rubygem-kramdown-testsuite) weakremover(ruby3.0-rubygem-launchy) weakremover(ruby3.0-rubygem-launchy-doc) weakremover(ruby3.0-rubygem-launchy-testsuite) weakremover(ruby3.0-rubygem-levenshtein) weakremover(ruby3.0-rubygem-levenshtein-doc) weakremover(ruby3.0-rubygem-levenshtein-testsuite) weakremover(ruby3.0-rubygem-librarian) weakremover(ruby3.0-rubygem-librarian-doc) weakremover(ruby3.0-rubygem-librarian-testsuite) weakremover(ruby3.0-rubygem-libyui-rake) weakremover(ruby3.0-rubygem-libyui-rake-doc) weakremover(ruby3.0-rubygem-lightbox2) weakremover(ruby3.0-rubygem-lightbox2-doc) weakremover(ruby3.0-rubygem-liquid) weakremover(ruby3.0-rubygem-liquid-3) weakremover(ruby3.0-rubygem-liquid-4) weakremover(ruby3.0-rubygem-liquid-doc) weakremover(ruby3.0-rubygem-liquid-doc-3) weakremover(ruby3.0-rubygem-liquid-doc-4) weakremover(ruby3.0-rubygem-liquid-testsuite) weakremover(ruby3.0-rubygem-liquid-testsuite-3) weakremover(ruby3.0-rubygem-liquid-testsuite-4) weakremover(ruby3.0-rubygem-listen) weakremover(ruby3.0-rubygem-listen-3_0) weakremover(ruby3.0-rubygem-listen-doc-3_0) weakremover(ruby3.0-rubygem-little-plugger) weakremover(ruby3.0-rubygem-little-plugger-doc) weakremover(ruby3.0-rubygem-little-plugger-testsuite) weakremover(ruby3.0-rubygem-llhttp-ffi) weakremover(ruby3.0-rubygem-locale) weakremover(ruby3.0-rubygem-locale-doc) weakremover(ruby3.0-rubygem-locale-testsuite) weakremover(ruby3.0-rubygem-log4r) weakremover(ruby3.0-rubygem-log4r-doc) weakremover(ruby3.0-rubygem-logging) weakremover(ruby3.0-rubygem-logging-doc) weakremover(ruby3.0-rubygem-logging-testsuite) weakremover(ruby3.0-rubygem-lolcat) weakremover(ruby3.0-rubygem-lolcat-doc) weakremover(ruby3.0-rubygem-loofah) weakremover(ruby3.0-rubygem-loofah-doc) weakremover(ruby3.0-rubygem-mail) weakremover(ruby3.0-rubygem-mail-2_5) weakremover(ruby3.0-rubygem-mail-doc) weakremover(ruby3.0-rubygem-mail-doc-2_5) weakremover(ruby3.0-rubygem-manpages) weakremover(ruby3.0-rubygem-marcel) weakremover(ruby3.0-rubygem-marcel-doc) weakremover(ruby3.0-rubygem-mercenary) weakremover(ruby3.0-rubygem-mercenary-doc) weakremover(ruby3.0-rubygem-mercenary-testsuite) weakremover(ruby3.0-rubygem-metaclass) weakremover(ruby3.0-rubygem-metaclass-doc) weakremover(ruby3.0-rubygem-metaclass-testsuite) weakremover(ruby3.0-rubygem-method_source) weakremover(ruby3.0-rubygem-method_source-doc) weakremover(ruby3.0-rubygem-method_source-testsuite) weakremover(ruby3.0-rubygem-micromachine) weakremover(ruby3.0-rubygem-micromachine-doc) weakremover(ruby3.0-rubygem-micromachine-testsuite) weakremover(ruby3.0-rubygem-mime) weakremover(ruby3.0-rubygem-mime-doc) weakremover(ruby3.0-rubygem-mime-testsuite) weakremover(ruby3.0-rubygem-mime-types) weakremover(ruby3.0-rubygem-mime-types-1) weakremover(ruby3.0-rubygem-mime-types-data) weakremover(ruby3.0-rubygem-mime-types-data-doc) weakremover(ruby3.0-rubygem-mime-types-doc) weakremover(ruby3.0-rubygem-mime-types-doc-1) weakremover(ruby3.0-rubygem-mime-types-testsuite) weakremover(ruby3.0-rubygem-mime-types-testsuite-1) weakremover(ruby3.0-rubygem-mimemagic) weakremover(ruby3.0-rubygem-mimemagic-doc) weakremover(ruby3.0-rubygem-mimemagic-testsuite) weakremover(ruby3.0-rubygem-mini_magick) weakremover(ruby3.0-rubygem-mini_magick-doc) weakremover(ruby3.0-rubygem-mini_mime) weakremover(ruby3.0-rubygem-mini_mime-doc) weakremover(ruby3.0-rubygem-mini_portile2) weakremover(ruby3.0-rubygem-mini_portile2-2_3) weakremover(ruby3.0-rubygem-mini_portile2-doc) weakremover(ruby3.0-rubygem-mini_portile2-doc-2_3) weakremover(ruby3.0-rubygem-mini_portile2-testsuite) weakremover(ruby3.0-rubygem-mini_portile2-testsuite-2_3) weakremover(ruby3.0-rubygem-minitar) weakremover(ruby3.0-rubygem-minitar-doc) weakremover(ruby3.0-rubygem-minitar-testsuite) weakremover(ruby3.0-rubygem-mixlib-authentication) weakremover(ruby3.0-rubygem-mixlib-authentication-doc) weakremover(ruby3.0-rubygem-mixlib-cli) weakremover(ruby3.0-rubygem-mixlib-cli-doc) weakremover(ruby3.0-rubygem-mixlib-config) weakremover(ruby3.0-rubygem-mixlib-config-doc) weakremover(ruby3.0-rubygem-mixlib-log) weakremover(ruby3.0-rubygem-mixlib-log-doc) weakremover(ruby3.0-rubygem-mixlib-shellout) weakremover(ruby3.0-rubygem-mixlib-shellout-doc) weakremover(ruby3.0-rubygem-mobileesp_converted) weakremover(ruby3.0-rubygem-mobileesp_converted-doc) weakremover(ruby3.0-rubygem-mobileesp_converted-testsuite) weakremover(ruby3.0-rubygem-mocha) weakremover(ruby3.0-rubygem-mocha-doc) weakremover(ruby3.0-rubygem-mocha-testsuite) weakremover(ruby3.0-rubygem-moneta) weakremover(ruby3.0-rubygem-moneta-0_7) weakremover(ruby3.0-rubygem-moneta-doc) weakremover(ruby3.0-rubygem-moneta-doc-0_7) weakremover(ruby3.0-rubygem-moneta-testsuite) weakremover(ruby3.0-rubygem-moneta-testsuite-0_7) weakremover(ruby3.0-rubygem-msgpack) weakremover(ruby3.0-rubygem-msgpack-doc) weakremover(ruby3.0-rubygem-msgpack-testsuite) weakremover(ruby3.0-rubygem-multi_json) weakremover(ruby3.0-rubygem-multi_json-doc) weakremover(ruby3.0-rubygem-multi_xml) weakremover(ruby3.0-rubygem-multi_xml-doc) weakremover(ruby3.0-rubygem-multipart-post) weakremover(ruby3.0-rubygem-multipart-post-doc) weakremover(ruby3.0-rubygem-multipart-post-testsuite) weakremover(ruby3.0-rubygem-mustache) weakremover(ruby3.0-rubygem-mustache-doc) weakremover(ruby3.0-rubygem-mustache-testsuite) weakremover(ruby3.0-rubygem-mustermann) weakremover(ruby3.0-rubygem-mustermann-doc) weakremover(ruby3.0-rubygem-mustermann-grape) weakremover(ruby3.0-rubygem-mustermann-grape-doc) weakremover(ruby3.0-rubygem-mustermann-grape-testsuite) weakremover(ruby3.0-rubygem-mustermann-testsuite) weakremover(ruby3.0-rubygem-mysql2) weakremover(ruby3.0-rubygem-mysql2-doc) weakremover(ruby3.0-rubygem-net-ldap) weakremover(ruby3.0-rubygem-net-ldap-doc) weakremover(ruby3.0-rubygem-net-scp) weakremover(ruby3.0-rubygem-net-scp-1_1) weakremover(ruby3.0-rubygem-net-scp-1_2) weakremover(ruby3.0-rubygem-net-scp-doc) weakremover(ruby3.0-rubygem-net-scp-doc-1_1) weakremover(ruby3.0-rubygem-net-scp-doc-1_2) weakremover(ruby3.0-rubygem-net-scp-testsuite-1_1) weakremover(ruby3.0-rubygem-net-scp-testsuite-1_2) weakremover(ruby3.0-rubygem-net-sftp) weakremover(ruby3.0-rubygem-net-sftp-doc) weakremover(ruby3.0-rubygem-net-ssh) weakremover(ruby3.0-rubygem-net-ssh-4_1) weakremover(ruby3.0-rubygem-net-ssh-5.1) weakremover(ruby3.0-rubygem-net-ssh-6.1) weakremover(ruby3.0-rubygem-net-ssh-doc) weakremover(ruby3.0-rubygem-net-ssh-doc-4_1) weakremover(ruby3.0-rubygem-net-ssh-doc-5.1) weakremover(ruby3.0-rubygem-net-ssh-gateway) weakremover(ruby3.0-rubygem-net-ssh-gateway-doc) weakremover(ruby3.0-rubygem-net-ssh-multi) weakremover(ruby3.0-rubygem-net-ssh-multi-1_1) weakremover(ruby3.0-rubygem-net-ssh-multi-doc) weakremover(ruby3.0-rubygem-net-ssh-multi-doc-1_1) weakremover(ruby3.0-rubygem-net-ssh-multi-testsuite) weakremover(ruby3.0-rubygem-net-ssh-multi-testsuite-1_1) weakremover(ruby3.0-rubygem-netrc) weakremover(ruby3.0-rubygem-netrc-doc) weakremover(ruby3.0-rubygem-netrc-testsuite) weakremover(ruby3.0-rubygem-nio4r) weakremover(ruby3.0-rubygem-nio4r-doc) weakremover(ruby3.0-rubygem-nio4r-testsuite) weakremover(ruby3.0-rubygem-nokogiri) weakremover(ruby3.0-rubygem-nokogiri-doc) weakremover(ruby3.0-rubygem-nori) weakremover(ruby3.0-rubygem-nori-doc) weakremover(ruby3.0-rubygem-nori-testsuite) weakremover(ruby3.0-rubygem-oauth) weakremover(ruby3.0-rubygem-oauth-doc) weakremover(ruby3.0-rubygem-oauth2) weakremover(ruby3.0-rubygem-oauth2-doc) weakremover(ruby3.0-rubygem-omniauth) weakremover(ruby3.0-rubygem-omniauth-doc) weakremover(ruby3.0-rubygem-omniauth-github) weakremover(ruby3.0-rubygem-omniauth-github-doc) weakremover(ruby3.0-rubygem-omniauth-github-testsuite) weakremover(ruby3.0-rubygem-omniauth-gitlab) weakremover(ruby3.0-rubygem-omniauth-gitlab-doc) weakremover(ruby3.0-rubygem-omniauth-gitlab-testsuite) weakremover(ruby3.0-rubygem-omniauth-google-oauth2) weakremover(ruby3.0-rubygem-omniauth-google-oauth2-doc) weakremover(ruby3.0-rubygem-omniauth-google-oauth2-testsuite) weakremover(ruby3.0-rubygem-omniauth-oauth) weakremover(ruby3.0-rubygem-omniauth-oauth-doc) weakremover(ruby3.0-rubygem-omniauth-oauth-testsuite) weakremover(ruby3.0-rubygem-omniauth-oauth2) weakremover(ruby3.0-rubygem-omniauth-oauth2-doc) weakremover(ruby3.0-rubygem-omniauth-oauth2-testsuite) weakremover(ruby3.0-rubygem-open4) weakremover(ruby3.0-rubygem-open4-doc) weakremover(ruby3.0-rubygem-open4-testsuite) weakremover(ruby3.0-rubygem-openid_connect) weakremover(ruby3.0-rubygem-openid_connect-doc) weakremover(ruby3.0-rubygem-openid_connect-testsuite) weakremover(ruby3.0-rubygem-optimist) weakremover(ruby3.0-rubygem-optimist-doc) weakremover(ruby3.0-rubygem-optimist-testsuite) weakremover(ruby3.0-rubygem-orm_adapter) weakremover(ruby3.0-rubygem-orm_adapter-doc) weakremover(ruby3.0-rubygem-orm_adapter-testsuite) weakremover(ruby3.0-rubygem-os) weakremover(ruby3.0-rubygem-os-doc) weakremover(ruby3.0-rubygem-os-testsuite) weakremover(ruby3.0-rubygem-owncloud-admin) weakremover(ruby3.0-rubygem-owncloud-admin-doc) weakremover(ruby3.0-rubygem-packaging_rake_tasks) weakremover(ruby3.0-rubygem-packaging_rake_tasks-doc) weakremover(ruby3.0-rubygem-paint) weakremover(ruby3.0-rubygem-paint-doc) weakremover(ruby3.0-rubygem-parallel) weakremover(ruby3.0-rubygem-parallel-doc) weakremover(ruby3.0-rubygem-parallel_tests) weakremover(ruby3.0-rubygem-parallel_tests-doc) weakremover(ruby3.0-rubygem-parser) weakremover(ruby3.0-rubygem-parser-doc) weakremover(ruby3.0-rubygem-parser-testsuite) weakremover(ruby3.0-rubygem-passenger) weakremover(ruby3.0-rubygem-passenger-doc) weakremover(ruby3.0-rubygem-path_expander) weakremover(ruby3.0-rubygem-path_expander-doc) weakremover(ruby3.0-rubygem-path_expander-testsuite) weakremover(ruby3.0-rubygem-pathutil) weakremover(ruby3.0-rubygem-pathutil-doc) weakremover(ruby3.0-rubygem-pdf-core) weakremover(ruby3.0-rubygem-pdf-core-doc) weakremover(ruby3.0-rubygem-pdf-reader) weakremover(ruby3.0-rubygem-pdf-reader-doc) weakremover(ruby3.0-rubygem-pg) weakremover(ruby3.0-rubygem-pg-doc) weakremover(ruby3.0-rubygem-pg-testsuite) weakremover(ruby3.0-rubygem-pkg-config) weakremover(ruby3.0-rubygem-pkg-config-doc) weakremover(ruby3.0-rubygem-pkg-config-testsuite) weakremover(ruby3.0-rubygem-po_to_json) weakremover(ruby3.0-rubygem-po_to_json-doc) weakremover(ruby3.0-rubygem-po_to_json-testsuite) weakremover(ruby3.0-rubygem-polyglot) weakremover(ruby3.0-rubygem-polyglot-doc) weakremover(ruby3.0-rubygem-prawn) weakremover(ruby3.0-rubygem-prawn-core) weakremover(ruby3.0-rubygem-prawn-core-doc) weakremover(ruby3.0-rubygem-prawn-core-testsuite) weakremover(ruby3.0-rubygem-prawn-doc) weakremover(ruby3.0-rubygem-prawn-icon) weakremover(ruby3.0-rubygem-prawn-icon-doc) weakremover(ruby3.0-rubygem-prawn-icon-testsuite) weakremover(ruby3.0-rubygem-prawn-svg) weakremover(ruby3.0-rubygem-prawn-svg-doc) weakremover(ruby3.0-rubygem-prawn-svg-testsuite) weakremover(ruby3.0-rubygem-prawn-table) weakremover(ruby3.0-rubygem-prawn-table-doc) weakremover(ruby3.0-rubygem-prawn-table-testsuite) weakremover(ruby3.0-rubygem-prawn-templates) weakremover(ruby3.0-rubygem-prawn-testsuite) weakremover(ruby3.0-rubygem-pry) weakremover(ruby3.0-rubygem-pry-doc) weakremover(ruby3.0-rubygem-pry-doc-testsuite) weakremover(ruby3.0-rubygem-public_suffix) weakremover(ruby3.0-rubygem-public_suffix-3.1) weakremover(ruby3.0-rubygem-public_suffix-doc) weakremover(ruby3.0-rubygem-public_suffix-doc-3.1) weakremover(ruby3.0-rubygem-public_suffix-testsuite) weakremover(ruby3.0-rubygem-public_suffix-testsuite-3.1) weakremover(ruby3.0-rubygem-puma) weakremover(ruby3.0-rubygem-puma-4) weakremover(ruby3.0-rubygem-puma-4.1) weakremover(ruby3.0-rubygem-puma-doc) weakremover(ruby3.0-rubygem-puma_worker_killer) weakremover(ruby3.0-rubygem-puma_worker_killer-doc) weakremover(ruby3.0-rubygem-puma_worker_killer-testsuite) weakremover(ruby3.0-rubygem-pundit) weakremover(ruby3.0-rubygem-pundit-doc) weakremover(ruby3.0-rubygem-pundit-testsuite) weakremover(ruby3.0-rubygem-rack) weakremover(ruby3.0-rubygem-rack-1_3) weakremover(ruby3.0-rubygem-rack-1_4) weakremover(ruby3.0-rubygem-rack-1_6) weakremover(ruby3.0-rubygem-rack-2.0) weakremover(ruby3.0-rubygem-rack-accept) weakremover(ruby3.0-rubygem-rack-accept-doc) weakremover(ruby3.0-rubygem-rack-accept-testsuite) weakremover(ruby3.0-rubygem-rack-cache-1_2) weakremover(ruby3.0-rubygem-rack-cache-doc-1_2) weakremover(ruby3.0-rubygem-rack-cache-testsuite-1_2) weakremover(ruby3.0-rubygem-rack-doc) weakremover(ruby3.0-rubygem-rack-doc-1_3) weakremover(ruby3.0-rubygem-rack-doc-1_4) weakremover(ruby3.0-rubygem-rack-doc-1_6) weakremover(ruby3.0-rubygem-rack-doc-2.0) weakremover(ruby3.0-rubygem-rack-oauth2) weakremover(ruby3.0-rubygem-rack-oauth2-doc) weakremover(ruby3.0-rubygem-rack-oauth2-testsuite) weakremover(ruby3.0-rubygem-rack-protection) weakremover(ruby3.0-rubygem-rack-protection-doc) weakremover(ruby3.0-rubygem-rack-proxy) weakremover(ruby3.0-rubygem-rack-proxy-doc) weakremover(ruby3.0-rubygem-rack-proxy-testsuite) weakremover(ruby3.0-rubygem-rack-ssl-1_3) weakremover(ruby3.0-rubygem-rack-ssl-doc-1_3) weakremover(ruby3.0-rubygem-rack-test-0_6) weakremover(ruby3.0-rubygem-rack-test-doc-0_6) weakremover(ruby3.0-rubygem-rack-test-testsuite-0_6) weakremover(ruby3.0-rubygem-rack-testsuite-1_3) weakremover(ruby3.0-rubygem-rack-testsuite-1_4) weakremover(ruby3.0-rubygem-rack-testsuite-1_6) weakremover(ruby3.0-rubygem-rack-testsuite-2.0) weakremover(ruby3.0-rubygem-rails-5.2) weakremover(ruby3.0-rubygem-rails-6.0) weakremover(ruby3.0-rubygem-rails-deprecated_sanitizer) weakremover(ruby3.0-rubygem-rails-deprecated_sanitizer-doc) weakremover(ruby3.0-rubygem-rails-deprecated_sanitizer-testsuite) weakremover(ruby3.0-rubygem-rails-doc-5.2) weakremover(ruby3.0-rubygem-rails-doc-6.0) weakremover(ruby3.0-rubygem-rails-dom-testing) weakremover(ruby3.0-rubygem-rails-dom-testing-doc) weakremover(ruby3.0-rubygem-rails-dom-testing-testsuite) weakremover(ruby3.0-rubygem-rails-html-sanitizer) weakremover(ruby3.0-rubygem-rails-html-sanitizer-doc) weakremover(ruby3.0-rubygem-rails-html-sanitizer-testsuite) weakremover(ruby3.0-rubygem-rails-i18n) weakremover(ruby3.0-rubygem-rails-i18n-doc) weakremover(ruby3.0-rubygem-rails_stdout_logging) weakremover(ruby3.0-rubygem-rails_stdout_logging-doc) weakremover(ruby3.0-rubygem-rails_stdout_logging-testsuite) weakremover(ruby3.0-rubygem-railties-5.2) weakremover(ruby3.0-rubygem-railties-6.0) weakremover(ruby3.0-rubygem-railties-doc-5.2) weakremover(ruby3.0-rubygem-railties-doc-6.0) weakremover(ruby3.0-rubygem-rainbow) weakremover(ruby3.0-rubygem-rainbow-doc) weakremover(ruby3.0-rubygem-rainbow-testsuite) weakremover(ruby3.0-rubygem-raindrops) weakremover(ruby3.0-rubygem-raindrops-doc) weakremover(ruby3.0-rubygem-raindrops-testsuite) weakremover(ruby3.0-rubygem-rake-12_0) weakremover(ruby3.0-rubygem-rake-compiler) weakremover(ruby3.0-rubygem-rake-compiler-doc) weakremover(ruby3.0-rubygem-rake-compiler-testsuite) weakremover(ruby3.0-rubygem-rake-doc-12_0) weakremover(ruby3.0-rubygem-rb-fsevent) weakremover(ruby3.0-rubygem-rb-fsevent-doc) weakremover(ruby3.0-rubygem-rb-inotify) weakremover(ruby3.0-rubygem-rb-inotify-doc) weakremover(ruby3.0-rubygem-rb-inotify-testsuite) weakremover(ruby3.0-rubygem-rb-kqueue) weakremover(ruby3.0-rubygem-rb-kqueue-doc) weakremover(ruby3.0-rubygem-rb-kqueue-testsuite) weakremover(ruby3.0-rubygem-rdiscount) weakremover(ruby3.0-rubygem-rdiscount-doc) weakremover(ruby3.0-rubygem-rdiscount-testsuite) weakremover(ruby3.0-rubygem-rdoc-4) weakremover(ruby3.0-rubygem-rdoc-doc-4) weakremover(ruby3.0-rubygem-rdoc-testsuite-4) weakremover(ruby3.0-rubygem-red-datasets) weakremover(ruby3.0-rubygem-regexp_parser) weakremover(ruby3.0-rubygem-regexp_parser-doc) weakremover(ruby3.0-rubygem-regexp_parser-testsuite) weakremover(ruby3.0-rubygem-responders) weakremover(ruby3.0-rubygem-responders-doc) weakremover(ruby3.0-rubygem-rest-client) weakremover(ruby3.0-rubygem-rest-client-doc) weakremover(ruby3.0-rubygem-rest-client-testsuite) weakremover(ruby3.0-rubygem-restility) weakremover(ruby3.0-rubygem-restility-doc) weakremover(ruby3.0-rubygem-restility-testsuite) weakremover(ruby3.0-rubygem-reverse_markdown) weakremover(ruby3.0-rubygem-reverse_markdown-doc) weakremover(ruby3.0-rubygem-reverse_markdown-testsuite) weakremover(ruby3.0-rubygem-rgen) weakremover(ruby3.0-rubygem-rgen-doc) weakremover(ruby3.0-rubygem-rgen-testsuite) weakremover(ruby3.0-rubygem-rice) weakremover(ruby3.0-rubygem-rice-doc) weakremover(ruby3.0-rubygem-rice-testsuite) weakremover(ruby3.0-rubygem-ronn) weakremover(ruby3.0-rubygem-ronn-doc) weakremover(ruby3.0-rubygem-ronn-testsuite) weakremover(ruby3.0-rubygem-rouge) weakremover(ruby3.0-rubygem-rouge-1) weakremover(ruby3.0-rubygem-rouge-doc) weakremover(ruby3.0-rubygem-rouge-doc-1) weakremover(ruby3.0-rubygem-rpm) weakremover(ruby3.0-rubygem-rpm-doc) weakremover(ruby3.0-rubygem-rpm-testsuite) weakremover(ruby3.0-rubygem-rspec) weakremover(ruby3.0-rubygem-rspec-3_5) weakremover(ruby3.0-rubygem-rspec-core) weakremover(ruby3.0-rubygem-rspec-core-3_5) weakremover(ruby3.0-rubygem-rspec-core-doc) weakremover(ruby3.0-rubygem-rspec-core-doc-3_5) weakremover(ruby3.0-rubygem-rspec-doc) weakremover(ruby3.0-rubygem-rspec-doc-3_5) weakremover(ruby3.0-rubygem-rspec-expectations) weakremover(ruby3.0-rubygem-rspec-expectations-3_5) weakremover(ruby3.0-rubygem-rspec-expectations-doc) weakremover(ruby3.0-rubygem-rspec-expectations-doc-3_5) weakremover(ruby3.0-rubygem-rspec-its) weakremover(ruby3.0-rubygem-rspec-its-doc) weakremover(ruby3.0-rubygem-rspec-its-testsuite) weakremover(ruby3.0-rubygem-rspec-mocks) weakremover(ruby3.0-rubygem-rspec-mocks-3_5) weakremover(ruby3.0-rubygem-rspec-mocks-doc) weakremover(ruby3.0-rubygem-rspec-mocks-doc-3_5) weakremover(ruby3.0-rubygem-rspec-rails) weakremover(ruby3.0-rubygem-rspec-rails-3.9) weakremover(ruby3.0-rubygem-rspec-rails-4.0) weakremover(ruby3.0-rubygem-rspec-rails-doc) weakremover(ruby3.0-rubygem-rspec-rails-doc-3.9) weakremover(ruby3.0-rubygem-rspec-support) weakremover(ruby3.0-rubygem-rspec-support-3_5) weakremover(ruby3.0-rubygem-rspec-support-doc) weakremover(ruby3.0-rubygem-rspec-support-doc-3_5) weakremover(ruby3.0-rubygem-rubocop) weakremover(ruby3.0-rubygem-rubocop-ast) weakremover(ruby3.0-rubygem-rubocop-ast-doc) weakremover(ruby3.0-rubygem-rubocop-doc) weakremover(ruby3.0-rubygem-ruby-augeas) weakremover(ruby3.0-rubygem-ruby-augeas-doc) weakremover(ruby3.0-rubygem-ruby-dbus) weakremover(ruby3.0-rubygem-ruby-filemagic) weakremover(ruby3.0-rubygem-ruby-filemagic-doc) weakremover(ruby3.0-rubygem-ruby-filemagic-testsuite) weakremover(ruby3.0-rubygem-ruby-libvirt) weakremover(ruby3.0-rubygem-ruby-libvirt-doc) weakremover(ruby3.0-rubygem-ruby-openid) weakremover(ruby3.0-rubygem-ruby-openid-doc) weakremover(ruby3.0-rubygem-ruby-openid-testsuite) weakremover(ruby3.0-rubygem-ruby-progressbar) weakremover(ruby3.0-rubygem-ruby-progressbar-doc) weakremover(ruby3.0-rubygem-ruby-rc4) weakremover(ruby3.0-rubygem-ruby-rc4-doc) weakremover(ruby3.0-rubygem-ruby-rc4-testsuite) weakremover(ruby3.0-rubygem-ruby2_keywords) weakremover(ruby3.0-rubygem-ruby2_keywords-doc) weakremover(ruby3.0-rubygem-ruby_dig) weakremover(ruby3.0-rubygem-ruby_dig-doc) weakremover(ruby3.0-rubygem-ruby_dig-testsuite) weakremover(ruby3.0-rubygem-ruby_parser) weakremover(ruby3.0-rubygem-ruby_parser-doc) weakremover(ruby3.0-rubygem-ruby_parser-testsuite) weakremover(ruby3.0-rubygem-rubyforge) weakremover(ruby3.0-rubygem-rubyforge-doc) weakremover(ruby3.0-rubygem-rubyforge-testsuite) weakremover(ruby3.0-rubygem-rubyntlm) weakremover(ruby3.0-rubygem-rubyntlm-doc) weakremover(ruby3.0-rubygem-rubyntlm-testsuite) weakremover(ruby3.0-rubygem-rubyzip) weakremover(ruby3.0-rubygem-rubyzip-1.3) weakremover(ruby3.0-rubygem-rubyzip-doc) weakremover(ruby3.0-rubygem-rubyzip-doc-1.3) weakremover(ruby3.0-rubygem-rubyzip-testsuite-1.3) weakremover(ruby3.0-rubygem-safe_yaml) weakremover(ruby3.0-rubygem-safe_yaml-doc) weakremover(ruby3.0-rubygem-safe_yaml-testsuite) weakremover(ruby3.0-rubygem-sass) weakremover(ruby3.0-rubygem-sass-doc) weakremover(ruby3.0-rubygem-sass-listen) weakremover(ruby3.0-rubygem-sass-listen-doc) weakremover(ruby3.0-rubygem-sass-rails) weakremover(ruby3.0-rubygem-sass-rails-5.1) weakremover(ruby3.0-rubygem-sass-rails-doc) weakremover(ruby3.0-rubygem-sass-rails-doc-5.1) weakremover(ruby3.0-rubygem-sassc) weakremover(ruby3.0-rubygem-sassc-2.2) weakremover(ruby3.0-rubygem-sassc-doc) weakremover(ruby3.0-rubygem-sassc-doc-2.2) weakremover(ruby3.0-rubygem-sassc-rails) weakremover(ruby3.0-rubygem-sassc-rails-doc) weakremover(ruby3.0-rubygem-sassc-rails-testsuite) weakremover(ruby3.0-rubygem-sassc-testsuite) weakremover(ruby3.0-rubygem-sassc-testsuite-2.2) weakremover(ruby3.0-rubygem-sdoc) weakremover(ruby3.0-rubygem-sdoc-doc) weakremover(ruby3.0-rubygem-sdoc-testsuite) weakremover(ruby3.0-rubygem-securecompare) weakremover(ruby3.0-rubygem-securecompare-doc) weakremover(ruby3.0-rubygem-securecompare-testsuite) weakremover(ruby3.0-rubygem-semantic_range) weakremover(ruby3.0-rubygem-semantic_range-doc) weakremover(ruby3.0-rubygem-serverengine) weakremover(ruby3.0-rubygem-serverengine-doc) weakremover(ruby3.0-rubygem-serverengine-testsuite) weakremover(ruby3.0-rubygem-sexp_processor) weakremover(ruby3.0-rubygem-sexp_processor-doc) weakremover(ruby3.0-rubygem-sexp_processor-testsuite) weakremover(ruby3.0-rubygem-sigdump) weakremover(ruby3.0-rubygem-sigdump-doc) weakremover(ruby3.0-rubygem-simple_oauth) weakremover(ruby3.0-rubygem-simple_oauth-doc) weakremover(ruby3.0-rubygem-simplecov) weakremover(ruby3.0-rubygem-simplecov-doc) weakremover(ruby3.0-rubygem-simplecov-html) weakremover(ruby3.0-rubygem-simplecov-html-doc) weakremover(ruby3.0-rubygem-simplecov-html-testsuite) weakremover(ruby3.0-rubygem-simplecov_json_formatter) weakremover(ruby3.0-rubygem-simplecov_json_formatter-doc) weakremover(ruby3.0-rubygem-simpleidn) weakremover(ruby3.0-rubygem-simpleidn-doc) weakremover(ruby3.0-rubygem-sinatra) weakremover(ruby3.0-rubygem-sinatra-doc) weakremover(ruby3.0-rubygem-slim) weakremover(ruby3.0-rubygem-slim-doc) weakremover(ruby3.0-rubygem-slim-testsuite) weakremover(ruby3.0-rubygem-slop) weakremover(ruby3.0-rubygem-slop-3) weakremover(ruby3.0-rubygem-slop-3_3) weakremover(ruby3.0-rubygem-slop-doc) weakremover(ruby3.0-rubygem-slop-doc-3) weakremover(ruby3.0-rubygem-slop-doc-3_3) weakremover(ruby3.0-rubygem-slop-testsuite) weakremover(ruby3.0-rubygem-slop-testsuite-3) weakremover(ruby3.0-rubygem-slop-testsuite-3_3) weakremover(ruby3.0-rubygem-spring) weakremover(ruby3.0-rubygem-spring-doc) weakremover(ruby3.0-rubygem-spring-watcher-listen) weakremover(ruby3.0-rubygem-spring-watcher-listen-doc) weakremover(ruby3.0-rubygem-spring-watcher-listen-testsuite) weakremover(ruby3.0-rubygem-sprockets) weakremover(ruby3.0-rubygem-sprockets-2_1) weakremover(ruby3.0-rubygem-sprockets-2_2) weakremover(ruby3.0-rubygem-sprockets-3.7) weakremover(ruby3.0-rubygem-sprockets-doc) weakremover(ruby3.0-rubygem-sprockets-doc-2_1) weakremover(ruby3.0-rubygem-sprockets-doc-2_2) weakremover(ruby3.0-rubygem-sprockets-doc-3.7) weakremover(ruby3.0-rubygem-sprockets-helpers) weakremover(ruby3.0-rubygem-sprockets-helpers-doc) weakremover(ruby3.0-rubygem-sprockets-helpers-testsuite) weakremover(ruby3.0-rubygem-sprockets-rails) weakremover(ruby3.0-rubygem-sprockets-rails-doc) weakremover(ruby3.0-rubygem-sqlite3) weakremover(ruby3.0-rubygem-sqlite3-doc) weakremover(ruby3.0-rubygem-sqlite3-testsuite) weakremover(ruby3.0-rubygem-sshkit) weakremover(ruby3.0-rubygem-sshkit-doc) weakremover(ruby3.0-rubygem-sshkit-testsuite) weakremover(ruby3.0-rubygem-stackdeck) weakremover(ruby3.0-rubygem-stackdeck-doc) weakremover(ruby3.0-rubygem-stackdeck-testsuite) weakremover(ruby3.0-rubygem-stomp) weakremover(ruby3.0-rubygem-stomp-doc) weakremover(ruby3.0-rubygem-stomp-testsuite) weakremover(ruby3.0-rubygem-strptime) weakremover(ruby3.0-rubygem-strptime-doc) weakremover(ruby3.0-rubygem-swd) weakremover(ruby3.0-rubygem-swd-doc) weakremover(ruby3.0-rubygem-swd-testsuite) weakremover(ruby3.0-rubygem-sync) weakremover(ruby3.0-rubygem-systemu) weakremover(ruby3.0-rubygem-systemu-doc) weakremover(ruby3.0-rubygem-systemu-testsuite) weakremover(ruby3.0-rubygem-temple) weakremover(ruby3.0-rubygem-temple-doc) weakremover(ruby3.0-rubygem-temple-testsuite) weakremover(ruby3.0-rubygem-terminal-table) weakremover(ruby3.0-rubygem-terminal-table-doc) weakremover(ruby3.0-rubygem-text) weakremover(ruby3.0-rubygem-text-doc) weakremover(ruby3.0-rubygem-text-hyphen) weakremover(ruby3.0-rubygem-text-hyphen-doc) weakremover(ruby3.0-rubygem-text-hyphen-testsuite) weakremover(ruby3.0-rubygem-text-testsuite) weakremover(ruby3.0-rubygem-thor) weakremover(ruby3.0-rubygem-thor-0_19) weakremover(ruby3.0-rubygem-thor-doc) weakremover(ruby3.0-rubygem-thor-doc-0_19) weakremover(ruby3.0-rubygem-thread_safe) weakremover(ruby3.0-rubygem-thread_safe-doc) weakremover(ruby3.0-rubygem-thread_safe-testsuite) weakremover(ruby3.0-rubygem-tilt) weakremover(ruby3.0-rubygem-tilt-1_1) weakremover(ruby3.0-rubygem-tilt-1_4) weakremover(ruby3.0-rubygem-tilt-doc) weakremover(ruby3.0-rubygem-tilt-doc-1_1) weakremover(ruby3.0-rubygem-tilt-doc-1_4) weakremover(ruby3.0-rubygem-tilt-testsuite-1_1) weakremover(ruby3.0-rubygem-tilt-testsuite-1_4) weakremover(ruby3.0-rubygem-timers) weakremover(ruby3.0-rubygem-timers-doc) weakremover(ruby3.0-rubygem-tmuxinator) weakremover(ruby3.0-rubygem-tmuxinator-doc) weakremover(ruby3.0-rubygem-tmuxinator-testsuite) weakremover(ruby3.0-rubygem-tomlrb) weakremover(ruby3.0-rubygem-tomlrb-doc) weakremover(ruby3.0-rubygem-treetop) weakremover(ruby3.0-rubygem-treetop-1_4) weakremover(ruby3.0-rubygem-treetop-doc) weakremover(ruby3.0-rubygem-treetop-doc-1_4) weakremover(ruby3.0-rubygem-treetop-testsuite-1_4) weakremover(ruby3.0-rubygem-trollop) weakremover(ruby3.0-rubygem-trollop-doc) weakremover(ruby3.0-rubygem-trollop-testsuite) weakremover(ruby3.0-rubygem-ttfunk) weakremover(ruby3.0-rubygem-ttfunk-doc) weakremover(ruby3.0-rubygem-turbolinks) weakremover(ruby3.0-rubygem-turbolinks-doc) weakremover(ruby3.0-rubygem-turbolinks-source) weakremover(ruby3.0-rubygem-turbolinks-source-doc) weakremover(ruby3.0-rubygem-tzinfo) weakremover(ruby3.0-rubygem-tzinfo-0) weakremover(ruby3.0-rubygem-tzinfo-1.2) weakremover(ruby3.0-rubygem-tzinfo-data) weakremover(ruby3.0-rubygem-tzinfo-data-doc) weakremover(ruby3.0-rubygem-tzinfo-doc) weakremover(ruby3.0-rubygem-tzinfo-doc-0) weakremover(ruby3.0-rubygem-tzinfo-doc-1.2) weakremover(ruby3.0-rubygem-tzinfo-testsuite-0) weakremover(ruby3.0-rubygem-tzinfo-testsuite-1.2) weakremover(ruby3.0-rubygem-uglifier) weakremover(ruby3.0-rubygem-uglifier-doc) weakremover(ruby3.0-rubygem-unf) weakremover(ruby3.0-rubygem-unf-doc) weakremover(ruby3.0-rubygem-unf-testsuite) weakremover(ruby3.0-rubygem-unf_ext) weakremover(ruby3.0-rubygem-unf_ext-doc) weakremover(ruby3.0-rubygem-unf_ext-testsuite) weakremover(ruby3.0-rubygem-unicode-display_width) weakremover(ruby3.0-rubygem-unicode-display_width-1) weakremover(ruby3.0-rubygem-unicode-display_width-doc) weakremover(ruby3.0-rubygem-unicode-display_width-doc-1) weakremover(ruby3.0-rubygem-unicorn-worker-killer) weakremover(ruby3.0-rubygem-unicorn-worker-killer-doc) weakremover(ruby3.0-rubygem-url_safe_base64) weakremover(ruby3.0-rubygem-url_safe_base64-doc) weakremover(ruby3.0-rubygem-url_safe_base64-testsuite) weakremover(ruby3.0-rubygem-vagrant-spec) weakremover(ruby3.0-rubygem-vagrant-spec-doc) weakremover(ruby3.0-rubygem-vagrant-spec-testsuite) weakremover(ruby3.0-rubygem-vagrant_cloud) weakremover(ruby3.0-rubygem-vagrant_cloud-doc) weakremover(ruby3.0-rubygem-validate_email) weakremover(ruby3.0-rubygem-validate_email-doc) weakremover(ruby3.0-rubygem-validate_url) weakremover(ruby3.0-rubygem-validate_url-doc) weakremover(ruby3.0-rubygem-virtus) weakremover(ruby3.0-rubygem-virtus-doc) weakremover(ruby3.0-rubygem-virtus-testsuite) weakremover(ruby3.0-rubygem-warden) weakremover(ruby3.0-rubygem-warden-doc) weakremover(ruby3.0-rubygem-web-console) weakremover(ruby3.0-rubygem-web-console-2) weakremover(ruby3.0-rubygem-web-console-doc) weakremover(ruby3.0-rubygem-web-console-doc-2) weakremover(ruby3.0-rubygem-webfinger) weakremover(ruby3.0-rubygem-webfinger-doc) weakremover(ruby3.0-rubygem-webfinger-testsuite) weakremover(ruby3.0-rubygem-webmock-1_2) weakremover(ruby3.0-rubygem-webmock-2_3) weakremover(ruby3.0-rubygem-webmock-doc-1_2) weakremover(ruby3.0-rubygem-webmock-doc-2_3) weakremover(ruby3.0-rubygem-webmock-testsuite-1_2) weakremover(ruby3.0-rubygem-webmock-testsuite-2_3) weakremover(ruby3.0-rubygem-webpacker) weakremover(ruby3.0-rubygem-webpacker-4.0) weakremover(ruby3.0-rubygem-webpacker-doc) weakremover(ruby3.0-rubygem-webpacker-testsuite) weakremover(ruby3.0-rubygem-webrick) weakremover(ruby3.0-rubygem-websocket) weakremover(ruby3.0-rubygem-websocket-doc) weakremover(ruby3.0-rubygem-websocket-driver) weakremover(ruby3.0-rubygem-websocket-driver-0_6) weakremover(ruby3.0-rubygem-websocket-driver-doc) weakremover(ruby3.0-rubygem-websocket-driver-doc-0_6) weakremover(ruby3.0-rubygem-websocket-extensions) weakremover(ruby3.0-rubygem-websocket-extensions-doc) weakremover(ruby3.0-rubygem-websocket-testsuite) weakremover(ruby3.0-rubygem-winrm) weakremover(ruby3.0-rubygem-winrm-2_1) weakremover(ruby3.0-rubygem-winrm-doc) weakremover(ruby3.0-rubygem-winrm-doc-2_1) weakremover(ruby3.0-rubygem-winrm-elevated) weakremover(ruby3.0-rubygem-winrm-elevated-doc) weakremover(ruby3.0-rubygem-winrm-fs) weakremover(ruby3.0-rubygem-winrm-fs-doc) weakremover(ruby3.0-rubygem-xdg) weakremover(ruby3.0-rubygem-xdg-2) weakremover(ruby3.0-rubygem-xdg-doc) weakremover(ruby3.0-rubygem-xdg-doc-2) weakremover(ruby3.0-rubygem-xdg-testsuite-2) weakremover(ruby3.0-rubygem-xml-simple) weakremover(ruby3.0-rubygem-xml-simple-doc) weakremover(ruby3.0-rubygem-xmlhash) weakremover(ruby3.0-rubygem-yajl-ruby) weakremover(ruby3.0-rubygem-yajl-ruby-doc) weakremover(ruby3.0-rubygem-yajl-ruby-testsuite) weakremover(ruby3.0-rubygem-yard) weakremover(ruby3.0-rubygem-yast-rake) weakremover(ruby3.0-rubygem-zeitwerk) weakremover(ruby3.0-rubygem-zeitwerk-doc) weakremover(ruby3.1) weakremover(ruby3.1-devel) weakremover(ruby3.1-devel-extra) weakremover(ruby3.1-doc) weakremover(ruby3.1-doc-ri) weakremover(ruby3.1-rubygem-Ascii85) weakremover(ruby3.1-rubygem-abstract_method) weakremover(ruby3.1-rubygem-actioncable-6.0) weakremover(ruby3.1-rubygem-actioncable-7.0) weakremover(ruby3.1-rubygem-actionmailbox-6.0) weakremover(ruby3.1-rubygem-actionmailbox-7.0) weakremover(ruby3.1-rubygem-actionmailer-6.0) weakremover(ruby3.1-rubygem-actionmailer-7.0) weakremover(ruby3.1-rubygem-actionpack-6.0) weakremover(ruby3.1-rubygem-actionpack-7.0) weakremover(ruby3.1-rubygem-actiontext-6.0) weakremover(ruby3.1-rubygem-actiontext-7.0) weakremover(ruby3.1-rubygem-actionview-6.0) weakremover(ruby3.1-rubygem-actionview-7.0) weakremover(ruby3.1-rubygem-activejob-6.0) weakremover(ruby3.1-rubygem-activejob-7.0) weakremover(ruby3.1-rubygem-activemodel-6.0) weakremover(ruby3.1-rubygem-activemodel-7.0) weakremover(ruby3.1-rubygem-activerecord-6.0) weakremover(ruby3.1-rubygem-activerecord-7.0) weakremover(ruby3.1-rubygem-activestorage-6.0) weakremover(ruby3.1-rubygem-activestorage-7.0) weakremover(ruby3.1-rubygem-activesupport-6.0) weakremover(ruby3.1-rubygem-activesupport-7.0) weakremover(ruby3.1-rubygem-addressable) weakremover(ruby3.1-rubygem-aes_key_wrap) weakremover(ruby3.1-rubygem-afm) weakremover(ruby3.1-rubygem-airbrussh) weakremover(ruby3.1-rubygem-amq-protocol) weakremover(ruby3.1-rubygem-archive-tar-minitar) weakremover(ruby3.1-rubygem-arel) weakremover(ruby3.1-rubygem-asciidoctor) weakremover(ruby3.1-rubygem-ast) weakremover(ruby3.1-rubygem-attr_required) weakremover(ruby3.1-rubygem-autoprefixer-rails) weakremover(ruby3.1-rubygem-axiom-types) weakremover(ruby3.1-rubygem-backport) weakremover(ruby3.1-rubygem-base32) weakremover(ruby3.1-rubygem-bcrypt) weakremover(ruby3.1-rubygem-bcrypt_pbkdf) weakremover(ruby3.1-rubygem-benchmark) weakremover(ruby3.1-rubygem-bindata) weakremover(ruby3.1-rubygem-bindex) weakremover(ruby3.1-rubygem-binding_of_caller) weakremover(ruby3.1-rubygem-bootsnap) weakremover(ruby3.1-rubygem-builder) weakremover(ruby3.1-rubygem-bundler) weakremover(ruby3.1-rubygem-bundler-audit) weakremover(ruby3.1-rubygem-byebug) weakremover(ruby3.1-rubygem-capistrano) weakremover(ruby3.1-rubygem-celluloid) weakremover(ruby3.1-rubygem-cfa) weakremover(ruby3.1-rubygem-cfa_grub2) weakremover(ruby3.1-rubygem-changelog_generator) weakremover(ruby3.1-rubygem-cheetah) weakremover(ruby3.1-rubygem-chef-utils) weakremover(ruby3.1-rubygem-childprocess) weakremover(ruby3.1-rubygem-coderay) weakremover(ruby3.1-rubygem-coercible) weakremover(ruby3.1-rubygem-coffee-rails) weakremover(ruby3.1-rubygem-coffee-script) weakremover(ruby3.1-rubygem-coffee-script-source) weakremover(ruby3.1-rubygem-colorator) weakremover(ruby3.1-rubygem-commander) weakremover(ruby3.1-rubygem-concurrent-ruby) weakremover(ruby3.1-rubygem-cool.io) weakremover(ruby3.1-rubygem-crack) weakremover(ruby3.1-rubygem-crass) weakremover(ruby3.1-rubygem-cri) weakremover(ruby3.1-rubygem-css_parser) weakremover(ruby3.1-rubygem-csv) weakremover(ruby3.1-rubygem-d-installer) weakremover(ruby3.1-rubygem-d-installer-cli) weakremover(ruby3.1-rubygem-debase-ruby_core_source) weakremover(ruby3.1-rubygem-debug_inspector) weakremover(ruby3.1-rubygem-delayed_job) weakremover(ruby3.1-rubygem-delayed_job_active_record) weakremover(ruby3.1-rubygem-descendants_tracker) weakremover(ruby3.1-rubygem-devise) weakremover(ruby3.1-rubygem-devise-i18n) weakremover(ruby3.1-rubygem-devise_ldap_authenticatable) weakremover(ruby3.1-rubygem-diff-lcs) weakremover(ruby3.1-rubygem-diffy) weakremover(ruby3.1-rubygem-docile) weakremover(ruby3.1-rubygem-docker-api) weakremover(ruby3.1-rubygem-domain_name) weakremover(ruby3.1-rubygem-down) weakremover(ruby3.1-rubygem-dry-configurable) weakremover(ruby3.1-rubygem-dry-container) weakremover(ruby3.1-rubygem-dry-core) weakremover(ruby3.1-rubygem-dry-equalizer) weakremover(ruby3.1-rubygem-dry-inflector) weakremover(ruby3.1-rubygem-dry-logic) weakremover(ruby3.1-rubygem-dry-types) weakremover(ruby3.1-rubygem-ed25519) weakremover(ruby3.1-rubygem-em-websocket) weakremover(ruby3.1-rubygem-equalizer) weakremover(ruby3.1-rubygem-erubi) weakremover(ruby3.1-rubygem-erubis) weakremover(ruby3.1-rubygem-eventmachine) weakremover(ruby3.1-rubygem-exception_notification) weakremover(ruby3.1-rubygem-excon) weakremover(ruby3.1-rubygem-execjs) weakremover(ruby3.1-rubygem-fake_ftp) weakremover(ruby3.1-rubygem-fake_ftp-0_1) weakremover(ruby3.1-rubygem-faraday) weakremover(ruby3.1-rubygem-faraday-follow_redirects) weakremover(ruby3.1-rubygem-faraday-net_http) weakremover(ruby3.1-rubygem-faraday_middleware) weakremover(ruby3.1-rubygem-fast_gettext) weakremover(ruby3.1-rubygem-fast_gettext-1.1) weakremover(ruby3.1-rubygem-ffi) weakremover(ruby3.1-rubygem-ffi-compiler) weakremover(ruby3.1-rubygem-flog) weakremover(ruby3.1-rubygem-fluentd) weakremover(ruby3.1-rubygem-fog-core) weakremover(ruby3.1-rubygem-fog-json) weakremover(ruby3.1-rubygem-fog-libvirt) weakremover(ruby3.1-rubygem-fog-xml) weakremover(ruby3.1-rubygem-font-awesome-rails) weakremover(ruby3.1-rubygem-formatador) weakremover(ruby3.1-rubygem-forwardable-extended) weakremover(ruby3.1-rubygem-gem2rpm) weakremover(ruby3.1-rubygem-get_process_mem) weakremover(ruby3.1-rubygem-gettext) weakremover(ruby3.1-rubygem-gettext-setup) weakremover(ruby3.1-rubygem-gettext_i18n_rails) weakremover(ruby3.1-rubygem-gettext_i18n_rails_js) weakremover(ruby3.1-rubygem-gli) weakremover(ruby3.1-rubygem-globalid) weakremover(ruby3.1-rubygem-google-protobuf) weakremover(ruby3.1-rubygem-googleapis-common-protos-types) weakremover(ruby3.1-rubygem-gpgme) weakremover(ruby3.1-rubygem-grape) weakremover(ruby3.1-rubygem-grpc) weakremover(ruby3.1-rubygem-gssapi) weakremover(ruby3.1-rubygem-gyoku) weakremover(ruby3.1-rubygem-haml) weakremover(ruby3.1-rubygem-haml-rails) weakremover(ruby3.1-rubygem-hashdiff) weakremover(ruby3.1-rubygem-hashery) weakremover(ruby3.1-rubygem-hashicorp-checkpoint) weakremover(ruby3.1-rubygem-hashie) weakremover(ruby3.1-rubygem-highline) weakremover(ruby3.1-rubygem-hitimes) weakremover(ruby3.1-rubygem-hoe) weakremover(ruby3.1-rubygem-hpricot) weakremover(ruby3.1-rubygem-html2haml) weakremover(ruby3.1-rubygem-http) weakremover(ruby3.1-rubygem-http-cookie) weakremover(ruby3.1-rubygem-http-form_data) weakremover(ruby3.1-rubygem-http_parser.rb) weakremover(ruby3.1-rubygem-httpclient) weakremover(ruby3.1-rubygem-i18n) weakremover(ruby3.1-rubygem-ice_nine) weakremover(ruby3.1-rubygem-importmap-rails) weakremover(ruby3.1-rubygem-inifile) weakremover(ruby3.1-rubygem-jaro_winkler) weakremover(ruby3.1-rubygem-jbuilder) weakremover(ruby3.1-rubygem-jekyll) weakremover(ruby3.1-rubygem-jekyll-sass-converter) weakremover(ruby3.1-rubygem-jekyll-watch) weakremover(ruby3.1-rubygem-jquery-rails) weakremover(ruby3.1-rubygem-js-routes) weakremover(ruby3.1-rubygem-json) weakremover(ruby3.1-rubygem-json-jwt) weakremover(ruby3.1-rubygem-json-schema) weakremover(ruby3.1-rubygem-json_pure) weakremover(ruby3.1-rubygem-jwt) weakremover(ruby3.1-rubygem-kgio) weakremover(ruby3.1-rubygem-kramdown) weakremover(ruby3.1-rubygem-kramdown-parser-gfm) weakremover(ruby3.1-rubygem-launchy) weakremover(ruby3.1-rubygem-libyui-rake) weakremover(ruby3.1-rubygem-lightbox2) weakremover(ruby3.1-rubygem-liquid) weakremover(ruby3.1-rubygem-liquid-4) weakremover(ruby3.1-rubygem-listen) weakremover(ruby3.1-rubygem-little-plugger) weakremover(ruby3.1-rubygem-llhttp-ffi) weakremover(ruby3.1-rubygem-locale) weakremover(ruby3.1-rubygem-log4r) weakremover(ruby3.1-rubygem-logging) weakremover(ruby3.1-rubygem-lolcat) weakremover(ruby3.1-rubygem-loofah) weakremover(ruby3.1-rubygem-mail) weakremover(ruby3.1-rubygem-manpages) weakremover(ruby3.1-rubygem-marcel) weakremover(ruby3.1-rubygem-mercenary) weakremover(ruby3.1-rubygem-method_source) weakremover(ruby3.1-rubygem-micromachine) weakremover(ruby3.1-rubygem-mime) weakremover(ruby3.1-rubygem-mime-types) weakremover(ruby3.1-rubygem-mime-types-data) weakremover(ruby3.1-rubygem-mimemagic) weakremover(ruby3.1-rubygem-mini_magick) weakremover(ruby3.1-rubygem-mini_mime) weakremover(ruby3.1-rubygem-mini_portile2) weakremover(ruby3.1-rubygem-minitar) weakremover(ruby3.1-rubygem-mixlib-authentication) weakremover(ruby3.1-rubygem-mixlib-cli) weakremover(ruby3.1-rubygem-mixlib-config) weakremover(ruby3.1-rubygem-mixlib-log) weakremover(ruby3.1-rubygem-mixlib-shellout) weakremover(ruby3.1-rubygem-mocha) weakremover(ruby3.1-rubygem-moneta) weakremover(ruby3.1-rubygem-msgpack) weakremover(ruby3.1-rubygem-multi_json) weakremover(ruby3.1-rubygem-multi_xml) weakremover(ruby3.1-rubygem-multipart-post) weakremover(ruby3.1-rubygem-mustache) weakremover(ruby3.1-rubygem-mustermann) weakremover(ruby3.1-rubygem-mustermann-grape) weakremover(ruby3.1-rubygem-mysql2) weakremover(ruby3.1-rubygem-net-ldap) weakremover(ruby3.1-rubygem-net-scp) weakremover(ruby3.1-rubygem-net-sftp) weakremover(ruby3.1-rubygem-net-ssh) weakremover(ruby3.1-rubygem-net-ssh-6.1) weakremover(ruby3.1-rubygem-netrc) weakremover(ruby3.1-rubygem-nio4r) weakremover(ruby3.1-rubygem-nokogiri) weakremover(ruby3.1-rubygem-nori) weakremover(ruby3.1-rubygem-oauth2) weakremover(ruby3.1-rubygem-omniauth) weakremover(ruby3.1-rubygem-omniauth-github) weakremover(ruby3.1-rubygem-omniauth-google-oauth2) weakremover(ruby3.1-rubygem-omniauth-oauth2) weakremover(ruby3.1-rubygem-openid_connect) weakremover(ruby3.1-rubygem-optimist) weakremover(ruby3.1-rubygem-orm_adapter) weakremover(ruby3.1-rubygem-os) weakremover(ruby3.1-rubygem-packaging_rake_tasks) weakremover(ruby3.1-rubygem-paint) weakremover(ruby3.1-rubygem-pairing_heap) weakremover(ruby3.1-rubygem-parallel) weakremover(ruby3.1-rubygem-parallel_tests) weakremover(ruby3.1-rubygem-parser) weakremover(ruby3.1-rubygem-passenger) weakremover(ruby3.1-rubygem-path_expander) weakremover(ruby3.1-rubygem-pathutil) weakremover(ruby3.1-rubygem-pdf-core) weakremover(ruby3.1-rubygem-pdf-reader) weakremover(ruby3.1-rubygem-pg) weakremover(ruby3.1-rubygem-pkg-config) weakremover(ruby3.1-rubygem-po_to_json) weakremover(ruby3.1-rubygem-polyglot) weakremover(ruby3.1-rubygem-prawn) weakremover(ruby3.1-rubygem-prawn-core) weakremover(ruby3.1-rubygem-prawn-icon) weakremover(ruby3.1-rubygem-prawn-svg) weakremover(ruby3.1-rubygem-prawn-table) weakremover(ruby3.1-rubygem-prawn-templates) weakremover(ruby3.1-rubygem-pry) weakremover(ruby3.1-rubygem-pry-doc) weakremover(ruby3.1-rubygem-public_suffix) weakremover(ruby3.1-rubygem-public_suffix-3.1) weakremover(ruby3.1-rubygem-puma) weakremover(ruby3.1-rubygem-puma-4) weakremover(ruby3.1-rubygem-puma-4.1) weakremover(ruby3.1-rubygem-puma-5) weakremover(ruby3.1-rubygem-puma_worker_killer) weakremover(ruby3.1-rubygem-pundit) weakremover(ruby3.1-rubygem-rack) weakremover(ruby3.1-rubygem-rack-2.2) weakremover(ruby3.1-rubygem-rack-accept) weakremover(ruby3.1-rubygem-rack-oauth2) weakremover(ruby3.1-rubygem-rack-protection) weakremover(ruby3.1-rubygem-rack-proxy) weakremover(ruby3.1-rubygem-rack-test-0_6) weakremover(ruby3.1-rubygem-rails-6.0) weakremover(ruby3.1-rubygem-rails-7.0) weakremover(ruby3.1-rubygem-rails-dom-testing) weakremover(ruby3.1-rubygem-rails-html-sanitizer) weakremover(ruby3.1-rubygem-rails-i18n) weakremover(ruby3.1-rubygem-railties-6.0) weakremover(ruby3.1-rubygem-railties-7.0) weakremover(ruby3.1-rubygem-rainbow) weakremover(ruby3.1-rubygem-raindrops) weakremover(ruby3.1-rubygem-rake-compiler) weakremover(ruby3.1-rubygem-rb-fsevent) weakremover(ruby3.1-rubygem-rb-inotify) weakremover(ruby3.1-rubygem-rb-kqueue) weakremover(ruby3.1-rubygem-rdiscount) weakremover(ruby3.1-rubygem-red-datasets) weakremover(ruby3.1-rubygem-regexp_parser) weakremover(ruby3.1-rubygem-responders) weakremover(ruby3.1-rubygem-reverse_markdown) weakremover(ruby3.1-rubygem-rgl) weakremover(ruby3.1-rubygem-rice) weakremover(ruby3.1-rubygem-ronn) weakremover(ruby3.1-rubygem-rouge) weakremover(ruby3.1-rubygem-rpm) weakremover(ruby3.1-rubygem-rspec) weakremover(ruby3.1-rubygem-rspec-3_5) weakremover(ruby3.1-rubygem-rspec-core) weakremover(ruby3.1-rubygem-rspec-core-3_5) weakremover(ruby3.1-rubygem-rspec-expectations) weakremover(ruby3.1-rubygem-rspec-expectations-3_5) weakremover(ruby3.1-rubygem-rspec-its) weakremover(ruby3.1-rubygem-rspec-mocks) weakremover(ruby3.1-rubygem-rspec-mocks-3_5) weakremover(ruby3.1-rubygem-rspec-rails) weakremover(ruby3.1-rubygem-rspec-rails-3.9) weakremover(ruby3.1-rubygem-rspec-rails-4.0) weakremover(ruby3.1-rubygem-rspec-support) weakremover(ruby3.1-rubygem-rspec-support-3_5) weakremover(ruby3.1-rubygem-rubocop) weakremover(ruby3.1-rubygem-rubocop-ast) weakremover(ruby3.1-rubygem-ruby-augeas) weakremover(ruby3.1-rubygem-ruby-dbus) weakremover(ruby3.1-rubygem-ruby-libvirt) weakremover(ruby3.1-rubygem-ruby-openid) weakremover(ruby3.1-rubygem-ruby-progressbar) weakremover(ruby3.1-rubygem-ruby-rc4) weakremover(ruby3.1-rubygem-ruby2_keywords) weakremover(ruby3.1-rubygem-ruby_parser) weakremover(ruby3.1-rubygem-rubyntlm) weakremover(ruby3.1-rubygem-rubyzip) weakremover(ruby3.1-rubygem-safe_yaml) weakremover(ruby3.1-rubygem-sass) weakremover(ruby3.1-rubygem-sass-listen) weakremover(ruby3.1-rubygem-sass-rails) weakremover(ruby3.1-rubygem-sass-rails-5.1) weakremover(ruby3.1-rubygem-sassc) weakremover(ruby3.1-rubygem-sassc-2.2) weakremover(ruby3.1-rubygem-sassc-rails) weakremover(ruby3.1-rubygem-sdoc) weakremover(ruby3.1-rubygem-semantic_range) weakremover(ruby3.1-rubygem-serverengine) weakremover(ruby3.1-rubygem-sexp_processor) weakremover(ruby3.1-rubygem-sigdump) weakremover(ruby3.1-rubygem-simplecov) weakremover(ruby3.1-rubygem-simplecov-html) weakremover(ruby3.1-rubygem-simplecov_json_formatter) weakremover(ruby3.1-rubygem-simpleidn) weakremover(ruby3.1-rubygem-sinatra) weakremover(ruby3.1-rubygem-slim) weakremover(ruby3.1-rubygem-slop) weakremover(ruby3.1-rubygem-snaky_hash) weakremover(ruby3.1-rubygem-spring) weakremover(ruby3.1-rubygem-spring-watcher-listen) weakremover(ruby3.1-rubygem-sprockets) weakremover(ruby3.1-rubygem-sprockets-3.7) weakremover(ruby3.1-rubygem-sprockets-helpers) weakremover(ruby3.1-rubygem-sprockets-rails) weakremover(ruby3.1-rubygem-sqlite3) weakremover(ruby3.1-rubygem-sshkit) weakremover(ruby3.1-rubygem-stimulus-rails) weakremover(ruby3.1-rubygem-stomp) weakremover(ruby3.1-rubygem-stream) weakremover(ruby3.1-rubygem-strptime) weakremover(ruby3.1-rubygem-swd) weakremover(ruby3.1-rubygem-sync) weakremover(ruby3.1-rubygem-temple) weakremover(ruby3.1-rubygem-terminal-table) weakremover(ruby3.1-rubygem-terminal-table-2) weakremover(ruby3.1-rubygem-text) weakremover(ruby3.1-rubygem-thor) weakremover(ruby3.1-rubygem-thor-0_19) weakremover(ruby3.1-rubygem-thread_safe) weakremover(ruby3.1-rubygem-tilt) weakremover(ruby3.1-rubygem-timers) weakremover(ruby3.1-rubygem-tmuxinator) weakremover(ruby3.1-rubygem-tomlrb) weakremover(ruby3.1-rubygem-treetop) weakremover(ruby3.1-rubygem-trollop) weakremover(ruby3.1-rubygem-ttfunk) weakremover(ruby3.1-rubygem-turbo-rails) weakremover(ruby3.1-rubygem-turbolinks) weakremover(ruby3.1-rubygem-turbolinks-source) weakremover(ruby3.1-rubygem-tzinfo) weakremover(ruby3.1-rubygem-tzinfo-1.2) weakremover(ruby3.1-rubygem-tzinfo-data) weakremover(ruby3.1-rubygem-uglifier) weakremover(ruby3.1-rubygem-unf) weakremover(ruby3.1-rubygem-unf_ext) weakremover(ruby3.1-rubygem-unicode-display_width) weakremover(ruby3.1-rubygem-unicode-display_width-1) weakremover(ruby3.1-rubygem-vagrant-spec) weakremover(ruby3.1-rubygem-vagrant_cloud) weakremover(ruby3.1-rubygem-validate_email) weakremover(ruby3.1-rubygem-validate_url) weakremover(ruby3.1-rubygem-version_gem) weakremover(ruby3.1-rubygem-virtus) weakremover(ruby3.1-rubygem-warden) weakremover(ruby3.1-rubygem-web-console) weakremover(ruby3.1-rubygem-webfinger) weakremover(ruby3.1-rubygem-webpacker) weakremover(ruby3.1-rubygem-webrick) weakremover(ruby3.1-rubygem-websocket) weakremover(ruby3.1-rubygem-websocket-driver) weakremover(ruby3.1-rubygem-websocket-extensions) weakremover(ruby3.1-rubygem-winrm) weakremover(ruby3.1-rubygem-winrm-elevated) weakremover(ruby3.1-rubygem-winrm-fs) weakremover(ruby3.1-rubygem-xdg) weakremover(ruby3.1-rubygem-xdg-2) weakremover(ruby3.1-rubygem-xml-simple) weakremover(ruby3.1-rubygem-xmlhash) weakremover(ruby3.1-rubygem-xmlrpc) weakremover(ruby3.1-rubygem-yajl-ruby) weakremover(ruby3.1-rubygem-yard) weakremover(ruby3.1-rubygem-yast-rake) weakremover(ruby3.1-rubygem-zeitwerk) weakremover(ruby3.2) weakremover(ruby3.2-devel) weakremover(ruby3.2-devel-extra) weakremover(ruby3.2-doc) weakremover(ruby3.2-rubygem-Ascii85) weakremover(ruby3.2-rubygem-abstract_method) weakremover(ruby3.2-rubygem-actioncable-7.0) weakremover(ruby3.2-rubygem-actionmailbox-7.0) weakremover(ruby3.2-rubygem-actionmailer-7.0) weakremover(ruby3.2-rubygem-actionpack-7.0) weakremover(ruby3.2-rubygem-actiontext-7.0) weakremover(ruby3.2-rubygem-actionview-7.0) weakremover(ruby3.2-rubygem-activejob-7.0) weakremover(ruby3.2-rubygem-activemodel-7.0) weakremover(ruby3.2-rubygem-activerecord-7.0) weakremover(ruby3.2-rubygem-activestorage-7.0) weakremover(ruby3.2-rubygem-activesupport-7.0) weakremover(ruby3.2-rubygem-addressable) weakremover(ruby3.2-rubygem-aes_key_wrap) weakremover(ruby3.2-rubygem-afm) weakremover(ruby3.2-rubygem-airbrussh) weakremover(ruby3.2-rubygem-amq-protocol) weakremover(ruby3.2-rubygem-arel) weakremover(ruby3.2-rubygem-asciidoctor) weakremover(ruby3.2-rubygem-ast) weakremover(ruby3.2-rubygem-attr_required) weakremover(ruby3.2-rubygem-autoprefixer-rails) weakremover(ruby3.2-rubygem-axiom-types) weakremover(ruby3.2-rubygem-backport) weakremover(ruby3.2-rubygem-base32) weakremover(ruby3.2-rubygem-bcrypt) weakremover(ruby3.2-rubygem-bcrypt_pbkdf) weakremover(ruby3.2-rubygem-benchmark) weakremover(ruby3.2-rubygem-bindata) weakremover(ruby3.2-rubygem-bindex) weakremover(ruby3.2-rubygem-binding_of_caller) weakremover(ruby3.2-rubygem-bootsnap) weakremover(ruby3.2-rubygem-builder) weakremover(ruby3.2-rubygem-bundler) weakremover(ruby3.2-rubygem-bundler-audit) weakremover(ruby3.2-rubygem-byebug) weakremover(ruby3.2-rubygem-capistrano) weakremover(ruby3.2-rubygem-celluloid) weakremover(ruby3.2-rubygem-cfa) weakremover(ruby3.2-rubygem-cfa_grub2) weakremover(ruby3.2-rubygem-changelog_generator) weakremover(ruby3.2-rubygem-cheetah) weakremover(ruby3.2-rubygem-chef-utils) weakremover(ruby3.2-rubygem-childprocess) weakremover(ruby3.2-rubygem-coderay) weakremover(ruby3.2-rubygem-coercible) weakremover(ruby3.2-rubygem-coffee-rails) weakremover(ruby3.2-rubygem-coffee-script) weakremover(ruby3.2-rubygem-coffee-script-source) weakremover(ruby3.2-rubygem-colorator) weakremover(ruby3.2-rubygem-commander) weakremover(ruby3.2-rubygem-concurrent-ruby) weakremover(ruby3.2-rubygem-cool.io) weakremover(ruby3.2-rubygem-crack) weakremover(ruby3.2-rubygem-crass) weakremover(ruby3.2-rubygem-cri) weakremover(ruby3.2-rubygem-css_parser) weakremover(ruby3.2-rubygem-csv) weakremover(ruby3.2-rubygem-d-installer) weakremover(ruby3.2-rubygem-d-installer-cli) weakremover(ruby3.2-rubygem-debase-ruby_core_source) weakremover(ruby3.2-rubygem-debug_inspector) weakremover(ruby3.2-rubygem-delayed_job) weakremover(ruby3.2-rubygem-delayed_job_active_record) weakremover(ruby3.2-rubygem-descendants_tracker) weakremover(ruby3.2-rubygem-devise) weakremover(ruby3.2-rubygem-devise-i18n) weakremover(ruby3.2-rubygem-devise_ldap_authenticatable) weakremover(ruby3.2-rubygem-diff-lcs) weakremover(ruby3.2-rubygem-diffy) weakremover(ruby3.2-rubygem-docile) weakremover(ruby3.2-rubygem-docker-api) weakremover(ruby3.2-rubygem-domain_name) weakremover(ruby3.2-rubygem-down) weakremover(ruby3.2-rubygem-dry-configurable) weakremover(ruby3.2-rubygem-dry-container) weakremover(ruby3.2-rubygem-dry-core) weakremover(ruby3.2-rubygem-dry-equalizer) weakremover(ruby3.2-rubygem-dry-inflector) weakremover(ruby3.2-rubygem-dry-logic) weakremover(ruby3.2-rubygem-dry-types) weakremover(ruby3.2-rubygem-ed25519) weakremover(ruby3.2-rubygem-em-websocket) weakremover(ruby3.2-rubygem-equalizer) weakremover(ruby3.2-rubygem-erubi) weakremover(ruby3.2-rubygem-erubis) weakremover(ruby3.2-rubygem-eventmachine) weakremover(ruby3.2-rubygem-exception_notification) weakremover(ruby3.2-rubygem-excon) weakremover(ruby3.2-rubygem-execjs) weakremover(ruby3.2-rubygem-fake_ftp) weakremover(ruby3.2-rubygem-fake_ftp-0_1) weakremover(ruby3.2-rubygem-faraday) weakremover(ruby3.2-rubygem-faraday-follow_redirects) weakremover(ruby3.2-rubygem-faraday-net_http) weakremover(ruby3.2-rubygem-fast_gettext) weakremover(ruby3.2-rubygem-fast_gettext-1.1) weakremover(ruby3.2-rubygem-ffi) weakremover(ruby3.2-rubygem-ffi-compiler) weakremover(ruby3.2-rubygem-flog) weakremover(ruby3.2-rubygem-fluentd) weakremover(ruby3.2-rubygem-fog-core) weakremover(ruby3.2-rubygem-fog-json) weakremover(ruby3.2-rubygem-fog-libvirt) weakremover(ruby3.2-rubygem-fog-xml) weakremover(ruby3.2-rubygem-font-awesome-rails) weakremover(ruby3.2-rubygem-formatador) weakremover(ruby3.2-rubygem-forwardable-extended) weakremover(ruby3.2-rubygem-gem2rpm) weakremover(ruby3.2-rubygem-get_process_mem) weakremover(ruby3.2-rubygem-gettext) weakremover(ruby3.2-rubygem-gettext_i18n_rails) weakremover(ruby3.2-rubygem-gettext_i18n_rails_js) weakremover(ruby3.2-rubygem-gli) weakremover(ruby3.2-rubygem-globalid) weakremover(ruby3.2-rubygem-google-protobuf) weakremover(ruby3.2-rubygem-googleapis-common-protos-types) weakremover(ruby3.2-rubygem-gpgme) weakremover(ruby3.2-rubygem-grape) weakremover(ruby3.2-rubygem-grpc) weakremover(ruby3.2-rubygem-gssapi) weakremover(ruby3.2-rubygem-gyoku) weakremover(ruby3.2-rubygem-haml) weakremover(ruby3.2-rubygem-haml-rails) weakremover(ruby3.2-rubygem-hashdiff) weakremover(ruby3.2-rubygem-hashery) weakremover(ruby3.2-rubygem-hashicorp-checkpoint) weakremover(ruby3.2-rubygem-hashie) weakremover(ruby3.2-rubygem-highline) weakremover(ruby3.2-rubygem-hitimes) weakremover(ruby3.2-rubygem-hoe) weakremover(ruby3.2-rubygem-hpricot) weakremover(ruby3.2-rubygem-html2haml) weakremover(ruby3.2-rubygem-http) weakremover(ruby3.2-rubygem-http-cookie) weakremover(ruby3.2-rubygem-http-form_data) weakremover(ruby3.2-rubygem-http_parser.rb) weakremover(ruby3.2-rubygem-httpclient) weakremover(ruby3.2-rubygem-i18n) weakremover(ruby3.2-rubygem-ice_nine) weakremover(ruby3.2-rubygem-importmap-rails) weakremover(ruby3.2-rubygem-inifile) weakremover(ruby3.2-rubygem-jaro_winkler) weakremover(ruby3.2-rubygem-jbuilder) weakremover(ruby3.2-rubygem-jekyll) weakremover(ruby3.2-rubygem-jekyll-sass-converter) weakremover(ruby3.2-rubygem-jekyll-watch) weakremover(ruby3.2-rubygem-jquery-rails) weakremover(ruby3.2-rubygem-js-routes) weakremover(ruby3.2-rubygem-json) weakremover(ruby3.2-rubygem-json-jwt) weakremover(ruby3.2-rubygem-json-schema) weakremover(ruby3.2-rubygem-json_pure) weakremover(ruby3.2-rubygem-jwt) weakremover(ruby3.2-rubygem-kgio) weakremover(ruby3.2-rubygem-kramdown) weakremover(ruby3.2-rubygem-kramdown-parser-gfm) weakremover(ruby3.2-rubygem-launchy) weakremover(ruby3.2-rubygem-libyui-rake) weakremover(ruby3.2-rubygem-lightbox2) weakremover(ruby3.2-rubygem-liquid) weakremover(ruby3.2-rubygem-liquid-4) weakremover(ruby3.2-rubygem-listen) weakremover(ruby3.2-rubygem-little-plugger) weakremover(ruby3.2-rubygem-llhttp-ffi) weakremover(ruby3.2-rubygem-locale) weakremover(ruby3.2-rubygem-log4r) weakremover(ruby3.2-rubygem-logging) weakremover(ruby3.2-rubygem-lolcat) weakremover(ruby3.2-rubygem-loofah) weakremover(ruby3.2-rubygem-mail) weakremover(ruby3.2-rubygem-manpages) weakremover(ruby3.2-rubygem-marcel) weakremover(ruby3.2-rubygem-mercenary) weakremover(ruby3.2-rubygem-method_source) weakremover(ruby3.2-rubygem-micromachine) weakremover(ruby3.2-rubygem-mime) weakremover(ruby3.2-rubygem-mime-types) weakremover(ruby3.2-rubygem-mime-types-data) weakremover(ruby3.2-rubygem-mimemagic) weakremover(ruby3.2-rubygem-mini_magick) weakremover(ruby3.2-rubygem-mini_mime) weakremover(ruby3.2-rubygem-mini_portile2) weakremover(ruby3.2-rubygem-minitar) weakremover(ruby3.2-rubygem-mixlib-authentication) weakremover(ruby3.2-rubygem-mixlib-cli) weakremover(ruby3.2-rubygem-mixlib-config) weakremover(ruby3.2-rubygem-mixlib-log) weakremover(ruby3.2-rubygem-mixlib-shellout) weakremover(ruby3.2-rubygem-mocha) weakremover(ruby3.2-rubygem-moneta) weakremover(ruby3.2-rubygem-msgpack) weakremover(ruby3.2-rubygem-multi_json) weakremover(ruby3.2-rubygem-multi_xml) weakremover(ruby3.2-rubygem-multipart-post) weakremover(ruby3.2-rubygem-mustache) weakremover(ruby3.2-rubygem-mustermann) weakremover(ruby3.2-rubygem-mustermann-grape) weakremover(ruby3.2-rubygem-mysql2) weakremover(ruby3.2-rubygem-net-ldap) weakremover(ruby3.2-rubygem-net-scp) weakremover(ruby3.2-rubygem-net-sftp) weakremover(ruby3.2-rubygem-net-ssh) weakremover(ruby3.2-rubygem-net-ssh-6.1) weakremover(ruby3.2-rubygem-netrc) weakremover(ruby3.2-rubygem-nio4r) weakremover(ruby3.2-rubygem-nokogiri) weakremover(ruby3.2-rubygem-nori) weakremover(ruby3.2-rubygem-oauth2) weakremover(ruby3.2-rubygem-omniauth) weakremover(ruby3.2-rubygem-omniauth-oauth2) weakremover(ruby3.2-rubygem-openid_connect) weakremover(ruby3.2-rubygem-optimist) weakremover(ruby3.2-rubygem-orm_adapter) weakremover(ruby3.2-rubygem-os) weakremover(ruby3.2-rubygem-packaging_rake_tasks) weakremover(ruby3.2-rubygem-paint) weakremover(ruby3.2-rubygem-pairing_heap) weakremover(ruby3.2-rubygem-parallel) weakremover(ruby3.2-rubygem-parallel_tests) weakremover(ruby3.2-rubygem-parser) weakremover(ruby3.2-rubygem-passenger) weakremover(ruby3.2-rubygem-path_expander) weakremover(ruby3.2-rubygem-pathutil) weakremover(ruby3.2-rubygem-pdf-core) weakremover(ruby3.2-rubygem-pdf-reader) weakremover(ruby3.2-rubygem-pg) weakremover(ruby3.2-rubygem-pkg-config) weakremover(ruby3.2-rubygem-po_to_json) weakremover(ruby3.2-rubygem-polyglot) weakremover(ruby3.2-rubygem-prawn) weakremover(ruby3.2-rubygem-prawn-core) weakremover(ruby3.2-rubygem-prawn-icon) weakremover(ruby3.2-rubygem-prawn-svg) weakremover(ruby3.2-rubygem-prawn-table) weakremover(ruby3.2-rubygem-prawn-templates) weakremover(ruby3.2-rubygem-pry) weakremover(ruby3.2-rubygem-pry-doc) weakremover(ruby3.2-rubygem-public_suffix) weakremover(ruby3.2-rubygem-public_suffix-3.1) weakremover(ruby3.2-rubygem-puma) weakremover(ruby3.2-rubygem-puma-5) weakremover(ruby3.2-rubygem-puma_worker_killer) weakremover(ruby3.2-rubygem-pundit) weakremover(ruby3.2-rubygem-rack) weakremover(ruby3.2-rubygem-rack-2.2) weakremover(ruby3.2-rubygem-rack-accept) weakremover(ruby3.2-rubygem-rack-oauth2) weakremover(ruby3.2-rubygem-rack-protection) weakremover(ruby3.2-rubygem-rack-proxy) weakremover(ruby3.2-rubygem-rack-test-0_6) weakremover(ruby3.2-rubygem-rails-7.0) weakremover(ruby3.2-rubygem-rails-dom-testing) weakremover(ruby3.2-rubygem-rails-html-sanitizer) weakremover(ruby3.2-rubygem-rails-i18n) weakremover(ruby3.2-rubygem-railties-7.0) weakremover(ruby3.2-rubygem-rainbow) weakremover(ruby3.2-rubygem-raindrops) weakremover(ruby3.2-rubygem-rake-compiler) weakremover(ruby3.2-rubygem-rb-fsevent) weakremover(ruby3.2-rubygem-rb-inotify) weakremover(ruby3.2-rubygem-rb-kqueue) weakremover(ruby3.2-rubygem-rdiscount) weakremover(ruby3.2-rubygem-red-datasets) weakremover(ruby3.2-rubygem-regexp_parser) weakremover(ruby3.2-rubygem-responders) weakremover(ruby3.2-rubygem-reverse_markdown) weakremover(ruby3.2-rubygem-rgl) weakremover(ruby3.2-rubygem-rice) weakremover(ruby3.2-rubygem-ronn) weakremover(ruby3.2-rubygem-rouge) weakremover(ruby3.2-rubygem-rpm) weakremover(ruby3.2-rubygem-rspec) weakremover(ruby3.2-rubygem-rspec-3_5) weakremover(ruby3.2-rubygem-rspec-core) weakremover(ruby3.2-rubygem-rspec-core-3_5) weakremover(ruby3.2-rubygem-rspec-expectations) weakremover(ruby3.2-rubygem-rspec-expectations-3_5) weakremover(ruby3.2-rubygem-rspec-its) weakremover(ruby3.2-rubygem-rspec-mocks) weakremover(ruby3.2-rubygem-rspec-mocks-3_5) weakremover(ruby3.2-rubygem-rspec-rails) weakremover(ruby3.2-rubygem-rspec-rails-4.0) weakremover(ruby3.2-rubygem-rspec-support) weakremover(ruby3.2-rubygem-rspec-support-3_5) weakremover(ruby3.2-rubygem-rubocop) weakremover(ruby3.2-rubygem-rubocop-ast) weakremover(ruby3.2-rubygem-ruby-augeas) weakremover(ruby3.2-rubygem-ruby-dbus) weakremover(ruby3.2-rubygem-ruby-libvirt) weakremover(ruby3.2-rubygem-ruby-openid) weakremover(ruby3.2-rubygem-ruby-progressbar) weakremover(ruby3.2-rubygem-ruby-rc4) weakremover(ruby3.2-rubygem-ruby2_keywords) weakremover(ruby3.2-rubygem-ruby_parser) weakremover(ruby3.2-rubygem-rubyntlm) weakremover(ruby3.2-rubygem-rubyzip) weakremover(ruby3.2-rubygem-safe_yaml) weakremover(ruby3.2-rubygem-sass) weakremover(ruby3.2-rubygem-sass-listen) weakremover(ruby3.2-rubygem-sass-rails) weakremover(ruby3.2-rubygem-sass-rails-5.1) weakremover(ruby3.2-rubygem-sassc) weakremover(ruby3.2-rubygem-sassc-2.2) weakremover(ruby3.2-rubygem-sassc-rails) weakremover(ruby3.2-rubygem-sdoc) weakremover(ruby3.2-rubygem-semantic_range) weakremover(ruby3.2-rubygem-serverengine) weakremover(ruby3.2-rubygem-sexp_processor) weakremover(ruby3.2-rubygem-sigdump) weakremover(ruby3.2-rubygem-simplecov) weakremover(ruby3.2-rubygem-simplecov-html) weakremover(ruby3.2-rubygem-simplecov_json_formatter) weakremover(ruby3.2-rubygem-simpleidn) weakremover(ruby3.2-rubygem-slim) weakremover(ruby3.2-rubygem-slop) weakremover(ruby3.2-rubygem-snaky_hash) weakremover(ruby3.2-rubygem-spring) weakremover(ruby3.2-rubygem-sprockets) weakremover(ruby3.2-rubygem-sprockets-3.7) weakremover(ruby3.2-rubygem-sprockets-helpers) weakremover(ruby3.2-rubygem-sprockets-rails) weakremover(ruby3.2-rubygem-sqlite3) weakremover(ruby3.2-rubygem-sshkit) weakremover(ruby3.2-rubygem-stimulus-rails) weakremover(ruby3.2-rubygem-stomp) weakremover(ruby3.2-rubygem-stream) weakremover(ruby3.2-rubygem-strptime) weakremover(ruby3.2-rubygem-swd) weakremover(ruby3.2-rubygem-sync) weakremover(ruby3.2-rubygem-temple) weakremover(ruby3.2-rubygem-terminal-table) weakremover(ruby3.2-rubygem-terminal-table-2) weakremover(ruby3.2-rubygem-text) weakremover(ruby3.2-rubygem-thor) weakremover(ruby3.2-rubygem-thread_safe) weakremover(ruby3.2-rubygem-tilt) weakremover(ruby3.2-rubygem-timers) weakremover(ruby3.2-rubygem-tmuxinator) weakremover(ruby3.2-rubygem-tomlrb) weakremover(ruby3.2-rubygem-treetop) weakremover(ruby3.2-rubygem-trollop) weakremover(ruby3.2-rubygem-ttfunk) weakremover(ruby3.2-rubygem-turbo-rails) weakremover(ruby3.2-rubygem-turbolinks) weakremover(ruby3.2-rubygem-turbolinks-source) weakremover(ruby3.2-rubygem-tzinfo) weakremover(ruby3.2-rubygem-tzinfo-1.2) weakremover(ruby3.2-rubygem-tzinfo-data) weakremover(ruby3.2-rubygem-uglifier) weakremover(ruby3.2-rubygem-unf) weakremover(ruby3.2-rubygem-unf_ext) weakremover(ruby3.2-rubygem-unicode-display_width) weakremover(ruby3.2-rubygem-unicode-display_width-1) weakremover(ruby3.2-rubygem-vagrant-spec) weakremover(ruby3.2-rubygem-vagrant_cloud) weakremover(ruby3.2-rubygem-validate_email) weakremover(ruby3.2-rubygem-validate_url) weakremover(ruby3.2-rubygem-version_gem) weakremover(ruby3.2-rubygem-virtus) weakremover(ruby3.2-rubygem-warden) weakremover(ruby3.2-rubygem-web-console) weakremover(ruby3.2-rubygem-webfinger) weakremover(ruby3.2-rubygem-webpacker) weakremover(ruby3.2-rubygem-webrick) weakremover(ruby3.2-rubygem-websocket) weakremover(ruby3.2-rubygem-websocket-driver) weakremover(ruby3.2-rubygem-websocket-extensions) weakremover(ruby3.2-rubygem-winrm) weakremover(ruby3.2-rubygem-winrm-elevated) weakremover(ruby3.2-rubygem-winrm-fs) weakremover(ruby3.2-rubygem-xdg) weakremover(ruby3.2-rubygem-xdg-2) weakremover(ruby3.2-rubygem-xml-simple) weakremover(ruby3.2-rubygem-xmlhash) weakremover(ruby3.2-rubygem-xmlrpc) weakremover(ruby3.2-rubygem-yajl-ruby) weakremover(ruby3.2-rubygem-yard) weakremover(ruby3.2-rubygem-yast-rake) weakremover(ruby3.2-rubygem-zeitwerk) weakremover(rubygem-amq-protocol) weakremover(rubygem-amq-protocol-doc) weakremover(rubygem-amq-protocol-testsuite) weakremover(rubygem-builder-3_0) weakremover(rubygem-builder-3_0-doc) weakremover(rubygem-builder-3_0-testsuite) weakremover(rubygem-cancan) weakremover(rubygem-cancan-doc) weakremover(rubygem-cancan-testsuite) weakremover(rubygem-devise_unix2_chkpwd_authenticatable) weakremover(rubygem-devise_unix2_chkpwd_authenticatable-doc) weakremover(rubygem-docker-api) weakremover(rubygem-docker-api-doc) weakremover(rubygem-docker-api-testsuite) weakremover(rubygem-facter) weakremover(rubygem-gettext_activerecord) weakremover(rubygem-gettext_activerecord-doc) weakremover(rubygem-gettext_activerecord-testsuite) weakremover(rubygem-hiera) weakremover(rubygem-hub) weakremover(rubygem-hub-bash-completion) weakremover(rubygem-hub-zsh-completion) weakremover(rubygem-libguestfs) weakremover(rubygem-libwebsocket) weakremover(rubygem-libwebsocket-doc) weakremover(rubygem-libwebsocket-testsuite) weakremover(rubygem-mail-2_4) weakremover(rubygem-mail-2_4-doc) weakremover(rubygem-mcollective) weakremover(rubygem-mcollective-bash-completion) weakremover(rubygem-mcollective-client) weakremover(rubygem-mcollective-server) weakremover(rubygem-mcollective-zsh-completion) weakremover(rubygem-orm_adapter) weakremover(rubygem-orm_adapter-doc) weakremover(rubygem-orm_adapter-testsuite) weakremover(rubygem-passenger) weakremover(rubygem-passenger-apache2) weakremover(rubygem-passenger-nginx) weakremover(rubygem-puppet) weakremover(rubygem-puppet-emacs) weakremover(rubygem-puppet-master) weakremover(rubygem-puppet-master-unicorn) weakremover(rubygem-puppet-vim) weakremover(rubygem-rice) weakremover(rubygem-rice-doc) weakremover(rubygem-ruby-fcgi) weakremover(rubygem-ruby-fcgi-doc) weakremover(rubygem-ruby-fcgi-testsuite) weakremover(rubygem-sexp_processor-3_2) weakremover(rubygem-sexp_processor-3_2-doc) weakremover(rubygem-sexp_processor-3_2-testsuite) weakremover(rubygem-shoes) weakremover(rubygem-shoes-doc) weakremover(rubygem-shoes-testsuite) weakremover(rubygem-taskjuggler) weakremover(rubygem-warden) weakremover(rubygem-warden-doc) weakremover(rubygem-warden-testsuite) weakremover(runawk) weakremover(runc) weakremover(runc-test) weakremover(rungetty) weakremover(runsc) weakremover(runsc-containerd) weakremover(runvdr-extreme-systemd) weakremover(ruqola) weakremover(rust) weakremover(rust-analysis) weakremover(rust-analyzer) weakremover(rust-bindgen) weakremover(rust-cbindgen) weakremover(rust-doc) weakremover(rust-gdb) weakremover(rust-keylime) weakremover(rust-src) weakremover(rust-std) weakremover(rust-std-static) weakremover(rust1.53) weakremover(rust1.53-analysis) weakremover(rust1.53-doc) weakremover(rust1.53-gdb) weakremover(rust1.53-src) weakremover(rust1.54) weakremover(rust1.54-analysis) weakremover(rust1.54-doc) weakremover(rust1.54-gdb) weakremover(rust1.54-src) weakremover(rust1.55) weakremover(rust1.55-analysis) weakremover(rust1.55-doc) weakremover(rust1.55-gdb) weakremover(rust1.55-src) weakremover(rust1.56) weakremover(rust1.57) weakremover(rust1.58) weakremover(rust1.59) weakremover(rust1.60) weakremover(rust1.61) weakremover(rust1.62) weakremover(rust1.63) weakremover(rust1.64) weakremover(rust1.65) weakremover(rust1.66) weakremover(rust1.67) weakremover(rust1.68) weakremover(rust1.69) weakremover(rustc-stage0) weakremover(rustfmt) weakremover(rustscan) weakremover(rustup) weakremover(rxp) weakremover(rxtx-java) weakremover(rxvt-unicode) weakremover(rygel) weakremover(rygel-devel) weakremover(rygel-plugin-gstreamer-renderer) weakremover(rygel-plugin-tracker) weakremover(rygel-plugin-zdf-mediathek) weakremover(rzip) weakremover(rzsz) weakremover(s2tc) weakremover(s2tc-devel) weakremover(s3backer) weakremover(s3fs) weakremover(sablot) weakremover(sablot-devel) weakremover(sad) weakremover(safte-monitor) weakremover(saidar) weakremover(sakura) weakremover(salt) weakremover(salt-api) weakremover(salt-cloud) weakremover(salt-doc) weakremover(salt-master) weakremover(salt-minion) weakremover(salt-proxy) weakremover(salt-raet) weakremover(salt-ssh) weakremover(salt-standalone-formulas-configuration) weakremover(salt-syndic) weakremover(salt-tests) weakremover(salt-transactional-update) weakremover(samba) weakremover(samba-ad-dc) weakremover(samba-ad-dc-libs) weakremover(samba-ceph) weakremover(samba-client) weakremover(samba-client-libs) weakremover(samba-core-devel) weakremover(samba-devel) weakremover(samba-dsdb-modules) weakremover(samba-gpupdate) weakremover(samba-kdc) weakremover(samba-krb-printing) weakremover(samba-ldb-ldap) weakremover(samba-libs) weakremover(samba-libs-python) weakremover(samba-libs-python3) weakremover(samba-pidl) weakremover(samba-python) weakremover(samba-python3) weakremover(samba-test) weakremover(samba-tool) weakremover(samba-winbind) weakremover(samba-winbind-libs) weakremover(sampler) weakremover(samplicator) weakremover(samtools) weakremover(samurai) weakremover(sandman) weakremover(sane-backends) weakremover(sane-backends-autoconfig) weakremover(sane-backends-devel) weakremover(sane-saned) weakremover(sanlk-reset) weakremover(sanlock) weakremover(sanlock-devel) weakremover(saphanabootstrap-formula-suma) weakremover(sar2) weakremover(sarg) weakremover(sash) weakremover(sasl2-kdexoauth2) weakremover(sassc) weakremover(sawfish) weakremover(sawfish-devel) weakremover(sawfish-pager) weakremover(sawfish-sounds) weakremover(sax3) weakremover(sbc) weakremover(sbc-devel) weakremover(sbcl) weakremover(sbd) weakremover(sbd-devel) weakremover(sbiload) weakremover(sbl) weakremover(sbl-orca) weakremover(sblim-cmpi-base) weakremover(sblim-cmpi-base-devel) weakremover(sblim-cmpi-base-testsuite) weakremover(sblim-cmpi-c++-devel) weakremover(sblim-cmpi-devel) weakremover(sblim-cmpi-dns) weakremover(sblim-cmpi-dns-devel) weakremover(sblim-cmpi-dns-test) weakremover(sblim-cmpi-ethport_profile) weakremover(sblim-cmpi-fsvol) weakremover(sblim-cmpi-fsvol-devel) weakremover(sblim-cmpi-fsvol-testsuite) weakremover(sblim-cmpi-network) weakremover(sblim-cmpi-network-devel) weakremover(sblim-cmpi-nfsv3) weakremover(sblim-cmpi-nfsv4) weakremover(sblim-cmpi-params) weakremover(sblim-cmpi-samba) weakremover(sblim-cmpi-samba-devel) weakremover(sblim-cmpi-samba-test) weakremover(sblim-cmpi-ssh_service_profile) weakremover(sblim-cmpi-sysfs) weakremover(sblim-cmpi-syslog) weakremover(sblim-cmpiutil-devel) weakremover(sblim-gather) weakremover(sblim-gather-devel) weakremover(sblim-gather-provider) weakremover(sblim-gather-test) weakremover(sblim-indication_helper) weakremover(sblim-indication_helper-devel) weakremover(sblim-sfcCommon-devel) weakremover(sblim-sfcb) weakremover(sblim-sfcc) weakremover(sblim-sfcc-devel) weakremover(sblim-smis-hba) weakremover(sblim-smis-hba-devel) weakremover(sblim-smis-hba-test) weakremover(sblim-tools-libra-devel) weakremover(sblim-wbemcli) weakremover(sbsigntools) weakremover(sc) weakremover(sc-controller) weakremover(sca-patterns-edir) weakremover(sca-patterns-filr) weakremover(sca-patterns-groupwise) weakremover(sca-patterns-oes) weakremover(sca-patterns-sle09) weakremover(sca-patterns-sle10) weakremover(scala) weakremover(scala-bootstrap) weakremover(scala-pickling) weakremover(scalapack-mvapich2-test) weakremover(scalapack-openmpi-test) weakremover(scalapack-openmpi1-test) weakremover(scalapack-openmpi2-test) weakremover(scalapack-openmpi3-test) weakremover(scalapack-openmpi4-test) weakremover(scalapack_2_0_2-gnu-mpich-hpc-module) weakremover(scalapack_2_0_2-gnu-mpich-hpc-test) weakremover(scalapack_2_0_2-gnu-mvapich2-hpc-module) weakremover(scalapack_2_0_2-gnu-mvapich2-hpc-test) weakremover(scalapack_2_0_2-gnu-openmpi1-hpc-module) weakremover(scalapack_2_0_2-gnu-openmpi1-hpc-test) weakremover(scalapack_2_0_2-gnu-openmpi2-hpc-module) weakremover(scalapack_2_0_2-gnu-openmpi2-hpc-test) weakremover(scalapack_2_0_2-gnu-openmpi3-hpc-module) weakremover(scalapack_2_0_2-gnu-openmpi3-hpc-test) weakremover(scalapack_2_1_0-gnu-mpich-hpc-module) weakremover(scalapack_2_1_0-gnu-mpich-hpc-test) weakremover(scalapack_2_1_0-gnu-mvapich2-hpc-module) weakremover(scalapack_2_1_0-gnu-mvapich2-hpc-test) weakremover(scalapack_2_1_0-gnu-openmpi1-hpc-module) weakremover(scalapack_2_1_0-gnu-openmpi1-hpc-test) weakremover(scalapack_2_1_0-gnu-openmpi2-hpc-module) weakremover(scalapack_2_1_0-gnu-openmpi2-hpc-test) weakremover(scalapack_2_1_0-gnu-openmpi3-hpc-module) weakremover(scalapack_2_1_0-gnu-openmpi3-hpc-test) weakremover(scalapack_2_1_0-gnu-openmpi4-hpc-module) weakremover(scalapack_2_1_0-gnu-openmpi4-hpc-test) weakremover(scalpel) weakremover(scamper) weakremover(scanmem) weakremover(scantailor) weakremover(scantailor-cli) weakremover(scap-workbench) weakremover(scap-workbench-doc) weakremover(sccache) weakremover(sccs) weakremover(scdoc) weakremover(schedtool) weakremover(schedtop) weakremover(scheme48) weakremover(scheme48-devel) weakremover(scheme48-doc) weakremover(scheme48-prescheme) weakremover(scheme48-vm) weakremover(schily-ctags) weakremover(schily-mt) weakremover(schily-rmt) weakremover(schismtracker) weakremover(schroedinger-devel) weakremover(schroedinger-doc) weakremover(scidavis) weakremover(scilab) weakremover(scilab-devel) weakremover(scilab-lang) weakremover(scilab-modules) weakremover(scilab-modules-doc) weakremover(scilab-modules-doc-lang) weakremover(scilab-tests) weakremover(scim) weakremover(scim-anthy) weakremover(scim-bridge) weakremover(scim-bridge-gtk2) weakremover(scim-bridge-qt4) weakremover(scim-canna) weakremover(scim-chewing) weakremover(scim-devel) weakremover(scim-gtk) weakremover(scim-gtk3) weakremover(scim-hangul) weakremover(scim-input-pad) weakremover(scim-m17n) weakremover(scim-pinyin) weakremover(scim-qt4) weakremover(scim-skk) weakremover(scim-sunpinyin) weakremover(scim-tables) weakremover(scim-tables-additional) weakremover(scim-tables-ja) weakremover(scim-tables-ko) weakremover(scim-tables-zh) weakremover(scim-tomoe) weakremover(scim-uim) weakremover(scim-unikey) weakremover(scite) weakremover(scitokens-cpp-devel) weakremover(scmon) weakremover(scons-test) weakremover(scotch) weakremover(scotch-devel) weakremover(scotch-devel-static) weakremover(scotch-metis-devel) weakremover(scotch_6_1_0-gnu-hpc) weakremover(scotch_6_1_0-gnu-hpc-devel) weakremover(scotch_6_1_0-gnu-hpc-devel-static) weakremover(scpm) weakremover(scpm-devel) weakremover(scpm-lang) weakremover(scratch) weakremover(scratch-devel) weakremover(scratch-lang) weakremover(screen) weakremover(screen-message) weakremover(screencast) weakremover(screengrab) weakremover(screenshot-tool) weakremover(screenshot-tool-lang) weakremover(scribus) weakremover(scribus-devel) weakremover(scribus-doc) weakremover(scrot) weakremover(scrub) weakremover(scrypt) weakremover(scs-devel) weakremover(scsh) weakremover(scsh-base) weakremover(scsirastools) weakremover(scsires) weakremover(scummvm) weakremover(scummvm-extra) weakremover(scummvm-tools) weakremover(sd) weakremover(sd-mux-ctrl) weakremover(sdbus-cpp-devel) weakremover(sdbus-cpp-xml2cpp) weakremover(sdcc) weakremover(sdcv) weakremover(sddm) weakremover(sddm-branding-openSUSE) weakremover(sddm-branding-upstream) weakremover(sdl-asylum) weakremover(sdl-ball) weakremover(sdl12_compat-devel) weakremover(sdl_bomber) weakremover(sdlpop) weakremover(sdlscavenger) weakremover(sdparm) weakremover(seadrive-fuse) weakremover(seadrive-gui) weakremover(seafile) weakremover(seafile-client) weakremover(seafile-devel) weakremover(seahorse) weakremover(seahorse-daemon) weakremover(seahorse-sharing) weakremover(seamonkey) weakremover(seamonkey-dom-inspector) weakremover(seamonkey-irc) weakremover(seamonkey-translations-common) weakremover(seamonkey-translations-other) weakremover(seatd) weakremover(seatd-devel) weakremover(secret-tool) weakremover(sed) weakremover(segv_handler) weakremover(seidl) weakremover(selinux-doc) weakremover(selinux-tools) weakremover(semantik) weakremover(semi-xemacs) weakremover(sendfax) weakremover(sendmail) weakremover(sendmail-devel) weakremover(sensord) weakremover(sensors) weakremover(seq24) weakremover(ser2net) weakremover(serd-devel) weakremover(serdi) weakremover(serialdv-devel) weakremover(sersniff) weakremover(servius) weakremover(servletapi3) weakremover(servletapi3-javadoc) weakremover(sessreg) weakremover(sethdlc) weakremover(setools-console) weakremover(setools-devel) weakremover(setools-gui) weakremover(setools-java) weakremover(setools-libs) weakremover(setools-tcl) weakremover(setroubleshoot) weakremover(setroubleshoot-server) weakremover(setserial) weakremover(setxkbmap) weakremover(sev-tool) weakremover(sfcgal) weakremover(sfcgal-devel) weakremover(sfftobmp) weakremover(sffview) weakremover(sfml2-devel) weakremover(sg3_utils) weakremover(sgmltool) weakremover(sgmltool-latex) weakremover(sgmltools-lite) weakremover(sgpio) weakremover(sgrep) weakremover(sgtk-menu) weakremover(sha1collisiondetection) weakremover(sha3sum) weakremover(shaderc) weakremover(shaderc-devel) weakremover(shadow) weakremover(shadowdive-devel) weakremover(shadowsocks-libev) weakremover(shadowsocks-libev-devel) weakremover(shadowsocks-v2ray-plugin) weakremover(shairport-sync) weakremover(shake) weakremover(shapelib) weakremover(shared-color-profiles) weakremover(shared-desktop-ontologies) weakremover(shared-desktop-ontologies-devel) weakremover(shared-mime-info) weakremover(sharutils) weakremover(shellementary) weakremover(shellinabox) weakremover(shells-cli) weakremover(shelltestrunner) weakremover(shepherd) weakremover(shepherd-bins) weakremover(shfmt) weakremover(shibboleth-sp) weakremover(shibboleth-sp-devel) weakremover(shigofumi) weakremover(shim) weakremover(shine) weakremover(shntool) weakremover(shotwell) weakremover(showfont) weakremover(showfoto) weakremover(shutdownscheduler) weakremover(shutdownscheduler-lang) weakremover(shutter) weakremover(shutter-lang) weakremover(sidplayfp) weakremover(siege) weakremover(sigil) weakremover(signify) weakremover(signing-party) weakremover(signon-kwallet-extension) weakremover(signon-plugin-oauth2) weakremover(signon-plugin-oauth2-devel) weakremover(signon-plugins) weakremover(signon-plugins-devel) weakremover(signon-ui) weakremover(signond) weakremover(signond-libs) weakremover(signond-libs-devel) weakremover(sigrok-cli) weakremover(silan) weakremover(silc-toolkit) weakremover(silc-toolkit-devel) weakremover(sile) weakremover(simh) weakremover(simple-mtpfs) weakremover(simple-multicast) weakremover(simple-obfs) weakremover(simple-scan) weakremover(simplescreenrecorder) weakremover(simtrace2) weakremover(simutrans) weakremover(simutrans-makeobj) weakremover(singular) weakremover(singularity) weakremover(singularity-ce) weakremover(singularity-devel) weakremover(sipcalc) weakremover(sipp) weakremover(siproxd) weakremover(siproxd-doc) weakremover(sipsak) weakremover(siril) weakremover(sirocco-devel) weakremover(sisctrl) weakremover(sispmctl) weakremover(sispmctl-devel) weakremover(site-config) weakremover(sitecopy) weakremover(sitecopy-lang) weakremover(sk1) weakremover(skaffold) weakremover(skanlite) weakremover(skanlite-doc) weakremover(skanpage) weakremover(skelcd-control-CAASP) weakremover(skelcd-control-Kubic) weakremover(skelcd-control-MicroOS) weakremover(skelcd-control-openSUSE) weakremover(skelcd-control-openSUSE-promo) weakremover(skelcd-fallbackrepo-Kubic) weakremover(skelcd-fallbackrepo-openSUSE) weakremover(skelcd-installer-Kubic) weakremover(skelcd-installer-MicroOS) weakremover(skelcd-installer-net-Kubic) weakremover(skelcd-installer-net-MicroOS) weakremover(skelcd-installer-net-openSUSE) weakremover(skelcd-installer-openSUSE) weakremover(skelcd-openSUSE) weakremover(skeletons) weakremover(skopeo) weakremover(skrooge) weakremover(sks) weakremover(sl) weakremover(slade) weakremover(slang-devel) weakremover(slang-slsh) weakremover(slapi-nis) weakremover(sleuthkit) weakremover(sleuthkit-devel) weakremover(slingshot) weakremover(slirp4netns) weakremover(slop) weakremover(slop-devel) weakremover(slrn) weakremover(sluice) weakremover(slurm) weakremover(slurm-auth-none) weakremover(slurm-cray) weakremover(slurm-devel) weakremover(slurm-hdf5) weakremover(slurm-lua) weakremover(slurm-munge) weakremover(slurm-node) weakremover(slurm-pam_slurm) weakremover(slurm-plugin-ext-sensors-rrd) weakremover(slurm-plugins) weakremover(slurm-rest) weakremover(slurm-sched-wiki) weakremover(slurm-slurmdb-direct) weakremover(slurm-slurmdbd) weakremover(slurm-sql) weakremover(slurm-sview) weakremover(slurm-testsuite) weakremover(slurm-torque) weakremover(slurp) weakremover(smake) weakremover(smartmontools) weakremover(smatch) weakremover(smb4k) weakremover(smb4k-doc) weakremover(smb4k-lang) weakremover(smbtad) weakremover(smc-tools) weakremover(smc-tools-completion) weakremover(smcroute) weakremover(smem) weakremover(smemstat) weakremover(smenu) weakremover(smenu-tests) weakremover(smillaenlarger) weakremover(smilutils) weakremover(smooth) weakremover(smooth-devel) weakremover(smp_utils) weakremover(smpeg-devel) weakremover(smplayer) weakremover(smproxy) weakremover(smssend) weakremover(smtpping) weakremover(smtube) weakremover(smtube-lang) weakremover(smugbatch) weakremover(smuxi) weakremover(smuxi-engine) weakremover(smuxi-engine-campfire) weakremover(smuxi-engine-campfire-lang) weakremover(smuxi-engine-irc) weakremover(smuxi-engine-irc-lang) weakremover(smuxi-engine-jabbr) weakremover(smuxi-engine-jabbr-lang) weakremover(smuxi-engine-lang) weakremover(smuxi-engine-twitter) weakremover(smuxi-engine-twitter-lang) weakremover(smuxi-engine-xmpp) weakremover(smuxi-engine-xmpp-lang) weakremover(smuxi-frontend) weakremover(smuxi-frontend-gnome) weakremover(smuxi-frontend-gnome-irc) weakremover(smuxi-frontend-gnome-irc-lang) weakremover(smuxi-frontend-gnome-lang) weakremover(smuxi-frontend-gnome-twitter) weakremover(smuxi-frontend-gnome-twitter-lang) weakremover(smuxi-frontend-gnome-xmpp) weakremover(smuxi-frontend-gnome-xmpp-lang) weakremover(smuxi-frontend-lang) weakremover(smuxi-frontend-stfl) weakremover(smuxi-message-buffer) weakremover(smuxi-message-buffer-lang) weakremover(smuxi-server) weakremover(smuxi-server-lang) weakremover(snack) weakremover(snap-photobooth) weakremover(snap-photobooth-lang) weakremover(snapper) weakremover(snapper-testsuite) weakremover(snapper-zypp-plugin) weakremover(snappy-devel) weakremover(snd) weakremover(sndio) weakremover(sndio-devel) weakremover(sndioctl) weakremover(sngrep) weakremover(sni-qt) weakremover(snmp-mibs) weakremover(snobol4) weakremover(snobol4-devel) weakremover(snorenotify-qt5) weakremover(snorenotify-qt5-devel) weakremover(snowball) weakremover(snowball-devel) weakremover(soapy-osmo-devel) weakremover(soapy-remote-server) weakremover(soapy-sdr) weakremover(soapy-sdr-devel) weakremover(soapysdr0.6-module-airspy) weakremover(soapysdr0.6-module-bladerf) weakremover(soapysdr0.6-module-freesrp) weakremover(soapysdr0.6-module-hackrf) weakremover(soapysdr0.6-module-lms7) weakremover(soapysdr0.6-module-mirisdr) weakremover(soapysdr0.6-module-osmosdr) weakremover(soapysdr0.6-module-remote) weakremover(soapysdr0.6-module-rfspace) weakremover(soapysdr0.6-module-rtlsdr) weakremover(soapysdr0.6-module-uhd) weakremover(soapysdr0.6-module-xtrx) weakremover(soapysdr0.7-module-airspy) weakremover(soapysdr0.7-module-bladerf) weakremover(soapysdr0.7-module-freesrp) weakremover(soapysdr0.7-module-hackrf) weakremover(soapysdr0.7-module-lms7) weakremover(soapysdr0.7-module-mirisdr) weakremover(soapysdr0.7-module-osmosdr) weakremover(soapysdr0.7-module-remote) weakremover(soapysdr0.7-module-rfspace) weakremover(soapysdr0.7-module-rtlsdr) weakremover(soapysdr0.7-module-uhd) weakremover(soapysdr0.7-module-xtrx) weakremover(soapysdr0.8-module-airspy) weakremover(soapysdr0.8-module-bladerf) weakremover(soapysdr0.8-module-freesrp) weakremover(soapysdr0.8-module-hackrf) weakremover(soapysdr0.8-module-lms7) weakremover(soapysdr0.8-module-mirisdr) weakremover(soapysdr0.8-module-osmosdr) weakremover(soapysdr0.8-module-remote) weakremover(soapysdr0.8-module-rtlsdr) weakremover(soapysdr0.8-module-uhd) weakremover(soapysdr0.8-module-xtrx) weakremover(sobby) weakremover(socat) weakremover(soci-devel) weakremover(soci-empty-devel) weakremover(soci-mysql-devel) weakremover(soci-odbc-devel) weakremover(soci-postgresql-devel) weakremover(soci-sqlite3-devel) weakremover(socket_wrapper) weakremover(sofia-sip) weakremover(sofia-sip-devel) weakremover(softhsm) weakremover(softhsm-devel) weakremover(solanum) weakremover(solarfighter) weakremover(solarus) weakremover(solarus-devel) weakremover(solarus-gui) weakremover(solarus-quest-editor) weakremover(solarwolf) weakremover(solarwolf_we) weakremover(solfege) weakremover(solid-devel) weakremover(solid-imports) weakremover(solid-tools) weakremover(sonic-pi) weakremover(sonic-visualiser) weakremover(sonivox-devel) weakremover(sonnet) weakremover(sonnet-devel) weakremover(sonnet-imports) weakremover(sonnet-voikko) weakremover(sonobuoy) weakremover(soprano) weakremover(soprano-backend-redland) weakremover(soprano-backend-sesame) weakremover(soprano-backend-virtuoso) weakremover(sops) weakremover(sopwith) weakremover(sord) weakremover(sord-devel) weakremover(sound-juicer) weakremover(soundconverter) weakremover(soundkonverter) weakremover(soundtouch) weakremover(soundtouch-devel) weakremover(soup-sharp) weakremover(soup-sharp-devel) weakremover(source-highlight) weakremover(source-highlight-cgi) weakremover(sox) weakremover(sox-devel) weakremover(soxr-devel) weakremover(spacefm) weakremover(spacenavd) weakremover(spamass-milter) weakremover(spamassassin) weakremover(spamassassin-spamc) weakremover(spandsp-devel) weakremover(sparse) weakremover(sparse-devel) weakremover(sparse-inspect) weakremover(sparse-llvm) weakremover(sparsehash-devel) weakremover(spatialindex-devel) weakremover(spawn-fcgi) weakremover(spax) weakremover(spdlog-devel) weakremover(spdx-sbom-generator) weakremover(spdylay) weakremover(spdylay-devel) weakremover(spectacle) weakremover(spectacle-doc) weakremover(spectator) weakremover(speech-dispatcher) weakremover(speech-dispatcher-configure) weakremover(speech-dispatcher-module-espeak) weakremover(speedcrunch) weakremover(speex) weakremover(speex-devel) weakremover(speexdsp-devel) weakremover(spek) weakremover(spew) weakremover(spglib-devel) weakremover(sphinx) weakremover(sphinxbase) weakremover(sphinxbase-devel) weakremover(sphinxbase5) weakremover(sphinxbase5-devel) weakremover(spi-tools) weakremover(spice-gtk) weakremover(spice-gtk-devel) weakremover(spice-up) weakremover(spice-vdagent) weakremover(spice-webdavd) weakremover(spindle) weakremover(spindle-devel) weakremover(spirv-cross) weakremover(spirv-cross-devel) weakremover(spirv-tools) weakremover(spirv-tools-devel) weakremover(splashy) weakremover(splashy-branding-openSUSE) weakremover(splashy-devel) weakremover(splashy-mkinitrd) weakremover(splashy-themes) weakremover(splint) weakremover(splinter-devel) weakremover(splix) weakremover(spooles-devel) weakremover(spooles-openmpi1-devel) weakremover(spooles-openmpi2-devel) weakremover(spotify-qt) weakremover(spotifyd) weakremover(spread-sheet-widget-devel) weakremover(spu-tools) weakremover(spyder-breakpoints) weakremover(spyder-breakpoints-lang) weakremover(spyder-doc) weakremover(spyder-line-profiler) weakremover(spyder-memory-profiler) weakremover(spyder-notebook) weakremover(spyder-profiler) weakremover(spyder-profiler-lang) weakremover(spyder-pylint) weakremover(spyder-pylint-lang) weakremover(spyder-unittest) weakremover(spyder3-breakpoints-lang) weakremover(spyder3-doc) weakremover(spyder3-line-profiler) weakremover(spyder3-memory-profiler) weakremover(spyder3-notebook) weakremover(spyder3-profiler-lang) weakremover(spyder3-pylint-lang) weakremover(spyder3-reports) weakremover(spyder3-unittest) weakremover(sql-parser-devel) weakremover(sqlcipher) weakremover(sqlcipher-devel) weakremover(sqlcipher-tcl) weakremover(sqlite-jdbc) weakremover(sqlite2) weakremover(sqlite2-devel) weakremover(sqlite3) weakremover(sqlite3-devel) weakremover(sqlite3-tcl) weakremover(sqlitebrowser) weakremover(sqliteman) weakremover(sqliteodbc) weakremover(sqliteodbc-doc) weakremover(sqtop) weakremover(squashfs) weakremover(squid) weakremover(squidGuard) weakremover(squidGuard-doc) weakremover(squidview) weakremover(squirrel) weakremover(squirrel-devel) weakremover(squirrel-devel-static) weakremover(sratom-devel) weakremover(src_vipa) weakremover(srecord) weakremover(srecord-devel) weakremover(srm) weakremover(srp_daemon) weakremover(srptools) weakremover(srt) weakremover(srt-devel) weakremover(sscep) weakremover(ssdeep) weakremover(ssdp-responder) weakremover(ssh-contact) weakremover(ssh-contact-client) weakremover(ssh-contact-service) weakremover(sshfp) weakremover(sshfs) weakremover(sshguard) weakremover(sshpass) weakremover(sshping) weakremover(ssldump) weakremover(sslh) weakremover(sslscan) weakremover(sssd) weakremover(sssd-ad) weakremover(sssd-dbus) weakremover(sssd-ipa) weakremover(sssd-kcm) weakremover(sssd-krb5) weakremover(sssd-krb5-common) weakremover(sssd-ldap) weakremover(sssd-proxy) weakremover(sssd-tools) weakremover(sssd-wbclient) weakremover(sssd-wbclient-devel) weakremover(sssd-winbind-idmap) weakremover(st) weakremover(stack) weakremover(stalonetray) weakremover(stan) weakremover(star) weakremover(star-rmt) weakremover(starboard) weakremover(stardict) weakremover(stardict-tools) weakremover(starfighter) weakremover(starship) weakremover(startup-notification-devel) weakremover(statgrab) weakremover(statserial) weakremover(stellarbatchsolver) weakremover(stellarium) weakremover(stellarsolver-devel) weakremover(step) weakremover(stern) weakremover(stk-devel) weakremover(stl-thumb) weakremover(stl-thumb-devel) weakremover(stlink) weakremover(stlink-devel) weakremover(stlink-gui) weakremover(stm32flash) weakremover(stoken) weakremover(stoken-devel) weakremover(stoken-gui) weakremover(stonith-bladehpi) weakremover(stp) weakremover(stp-devel) weakremover(stp-python) weakremover(strace) weakremover(strawberry) weakremover(streamtuner) weakremover(streamtuner-devel) weakremover(streamtuner-doc) weakremover(stress-ng) weakremover(stressapptest) weakremover(strongswan) weakremover(strongswan-hmac) weakremover(strongswan-ipsec) weakremover(strongswan-libs0) weakremover(strongswan-mysql) weakremover(strongswan-nm) weakremover(strongswan-sqlite) weakremover(structured-haskell-mode) weakremover(stunnel) weakremover(stuntman) weakremover(stylish-haskell) weakremover(su-wrapper) weakremover(submin) weakremover(submin-apache) weakremover(submin-svn) weakremover(subnetcalc) weakremover(subtitlecomposer) weakremover(subtitleeditor) weakremover(subunit) weakremover(subunit-devel) weakremover(subversion) weakremover(subversion-devel) weakremover(subversion-perl) weakremover(subversion-python) weakremover(subversion-python-ctypes) weakremover(subversion-ruby) weakremover(subversion-server) weakremover(subversion-tools) weakremover(suck) weakremover(sudo) weakremover(sudo-devel) weakremover(sudo-plugin-python) weakremover(sudo-test) weakremover(sudoku-sensei) weakremover(suil-devel) weakremover(suil-plugin-gtk2-in-qt5) weakremover(suil-plugin-qt5-in-gtk2) weakremover(suil-plugin-qt5-in-gtk3) weakremover(suil-plugin-x11) weakremover(suil-plugin-x11-in-gtk2) weakremover(suil-plugin-x11-in-gtk3) weakremover(suil-plugin-x11-in-qt5) weakremover(suil-plugins) weakremover(suitesparse-devel) weakremover(suitesparse-devel-static) weakremover(sundials-devel) weakremover(sundials-mvapich2-devel) weakremover(sundials-openmpi1-devel) weakremover(sundials-openmpi2-devel) weakremover(sundials-openmpi3-devel) weakremover(sundials-openmpi4-devel) weakremover(sunpinyin-data) weakremover(sunpinyin-devel) weakremover(sunpinyin-tools) weakremover(sunwait) weakremover(sunxi-tools) weakremover(supercollider) weakremover(supercollider-devel) weakremover(supercollider-emacs) weakremover(supercollider-gedit) weakremover(supercollider-sc3-plugins) weakremover(supercollider-vim) weakremover(superlu-devel) weakremover(superlu_5_2_1-gnu-hpc-devel) weakremover(superlu_5_2_1-gnu-hpc-doc) weakremover(superlu_5_2_1-gnu-hpc-examples) weakremover(superlu_5_2_2-gnu-hpc-devel) weakremover(superlu_5_2_2-gnu-hpc-doc) weakremover(superlu_5_2_2-gnu-hpc-examples) weakremover(superlu_5_3_0-gnu-hpc-devel) weakremover(superlu_5_3_0-gnu-hpc-doc) weakremover(superlu_5_3_0-gnu-hpc-examples) weakremover(superlu_6_0_0-gnu-hpc-devel) weakremover(supermin) weakremover(supertux2) weakremover(supertuxkart) weakremover(surf) weakremover(surfraw-woffle) weakremover(surgescript) weakremover(surgescript-devel) weakremover(suse-hpc) weakremover(suse-module-tools) weakremover(suse-module-tools-legacy) weakremover(suse-module-tools-scriptlets) weakremover(suseconnect-ng) weakremover(suseconnect-ruby-bindings) weakremover(susedoc-buildbook) weakremover(susegreeter-branding-openSUSE) weakremover(susehelp) weakremover(susehelp_cz) weakremover(susehelp_de) weakremover(susehelp_en) weakremover(susehelp_es) weakremover(susehelp_fr) weakremover(susehelp_hu) weakremover(susehelp_it) weakremover(sushi) weakremover(svgcleaner) weakremover(svgcleaner-cli) weakremover(svgcleaner-gui) weakremover(svgpart) weakremover(svm-tools) weakremover(svn2git) weakremover(svrcore-devel) weakremover(svxlink-server) weakremover(swappy) weakremover(sway) weakremover(sway-contrib) weakremover(sway-marker) weakremover(swaybar) weakremover(swaybg) weakremover(swayidle) weakremover(swaylock) weakremover(swaynag) weakremover(sweeper) weakremover(swell-foop) weakremover(swftools) weakremover(swift-im) weakremover(swiften-devel) weakremover(swig) weakremover(swig-examples) weakremover(swipl) weakremover(switchboard) weakremover(switchboard-devel) weakremover(switchboard-lang) weakremover(switchboard-plug-a11y) weakremover(switchboard-plug-a11y-lang) weakremover(switchboard-plug-about) weakremover(switchboard-plug-about-lang) weakremover(switchboard-plug-applications) weakremover(switchboard-plug-applications-lang) weakremover(switchboard-plug-datetime) weakremover(switchboard-plug-datetime-lang) weakremover(switchboard-plug-display) weakremover(switchboard-plug-display-lang) weakremover(switchboard-plug-keyboard) weakremover(switchboard-plug-keyboard-lang) weakremover(switchboard-plug-locale) weakremover(switchboard-plug-locale-lang) weakremover(switchboard-plug-mouse-touchpad) weakremover(switchboard-plug-mouse-touchpad-lang) weakremover(switchboard-plug-networking) weakremover(switchboard-plug-networking-lang) weakremover(switchboard-plug-notifications) weakremover(switchboard-plug-notifications-lang) weakremover(switchboard-plug-pantheon-shell) weakremover(switchboard-plug-pantheon-shell-lang) weakremover(switchboard-plug-printers) weakremover(switchboard-plug-printers-lang) weakremover(switchboard-plug-security-privacy) weakremover(switchboard-plug-security-privacy-lang) weakremover(switchboard-plug-sharing) weakremover(switchboard-plug-sharing-lang) weakremover(switchboard-plug-useraccounts) weakremover(switchboard-plug-useraccounts-lang) weakremover(switcheroo-control) weakremover(sword) weakremover(sword-devel) weakremover(swtchart) weakremover(swtchart-javadoc) weakremover(swtpm) weakremover(swtpm-devel) weakremover(swww) weakremover(sxhkd) weakremover(sxiv) weakremover(syft) weakremover(symmetrica-devel) weakremover(sympol) weakremover(sympol-devel) weakremover(sympow) weakremover(synapse) weakremover(synapse-lang) weakremover(synaptiks) weakremover(syncplay-client) weakremover(syncplay-common) weakremover(syncplay-server) weakremover(syncthing) weakremover(syncthing-gtk) weakremover(syncthing-gtk-lang) weakremover(syncthing-relaysrv) weakremover(syndication-devel) weakremover(synergy) weakremover(synnefo) weakremover(syntax-highlighting) weakremover(syntax-highlighting-devel) weakremover(syntax-highlighting-imports) weakremover(sysbench) weakremover(sysconfig) weakremover(sysconfig-netconfig) weakremover(sysfsutils) weakremover(sysfsutils-devel) weakremover(sysinfo) weakremover(syslog-ng) weakremover(syslog-ng-curl) weakremover(syslog-ng-devel) weakremover(syslog-ng-geoip) weakremover(syslog-ng-java) weakremover(syslog-ng-mqtt) weakremover(syslog-ng-python) weakremover(syslog-ng-redis) weakremover(syslog-ng-smtp) weakremover(syslog-ng-snmp) weakremover(syslog-ng-sql) weakremover(syslogd) weakremover(sysprof) weakremover(sysprof-capture-devel-static) weakremover(sysprof-devel) weakremover(sysprof-ui) weakremover(sysprof-ui-devel) weakremover(sysstat) weakremover(sysstat-isag) weakremover(system-config-printer) weakremover(system-group-audit) weakremover(system-group-ne) weakremover(system-group-s390-tools) weakremover(systemd) weakremover(systemd-bash-completion) weakremover(systemd-container) weakremover(systemd-coredump) weakremover(systemd-devel) weakremover(systemd-doc) weakremover(systemd-experimental) weakremover(systemd-journal-remote) weakremover(systemd-logger) weakremover(systemd-mini) weakremover(systemd-mini-bash-completion) weakremover(systemd-mini-container) weakremover(systemd-mini-container-mini) weakremover(systemd-mini-coredump-mini) weakremover(systemd-mini-devel) weakremover(systemd-mini-doc) weakremover(systemd-mini-sysvinit) weakremover(systemd-network) weakremover(systemd-portable) weakremover(systemd-sysvcompat) weakremover(systemd-sysvinit) weakremover(systemd-tests) weakremover(systemd-testsuite) weakremover(systemd-ui) weakremover(systemsettings5) weakremover(systemsettings5-devel) weakremover(systemtap) weakremover(systemtap-headers) weakremover(systemtap-runtime) weakremover(systemtap-sdt-devel) weakremover(systemtap-server) weakremover(sysvinit-tools) weakremover(syzkaller) weakremover(sz2-devel) weakremover(t1utils) weakremover(t38modem) weakremover(tabix) weakremover(tachyon) weakremover(tachyon-devel) weakremover(tack) weakremover(taglib) weakremover(taglib-extras-devel) weakremover(taglib-sharp) weakremover(taglib-sharp-devel) weakremover(taigo) weakremover(taisei) weakremover(tali) weakremover(talk) weakremover(talk-server) weakremover(talloc-man) weakremover(tallow) weakremover(tamil-gtk2im) weakremover(tanukiwrapper) weakremover(tanukiwrapper-javadoc) weakremover(tanukiwrapper-manual) weakremover(tar) weakremover(tar-rmt) weakremover(tar-tests) weakremover(tardy) weakremover(target-isns) weakremover(tarix) weakremover(taskwarrior) weakremover(tasque) weakremover(tasque-lang) weakremover(tayga) weakremover(tbb-devel) weakremover(tcd) weakremover(tcl) weakremover(tcl-Hamlib) weakremover(tcl-brlapi) weakremover(tcl-devel) weakremover(tcl-rrdtool) weakremover(tcl-sqlcipher) weakremover(tcl-tktray) weakremover(tcl8-xapian) weakremover(tclap) weakremover(tclcurl) weakremover(tclplug) weakremover(tcludp) weakremover(tclx) weakremover(tcmu-runner) weakremover(tcmu-runner-devel) weakremover(tcmu-runner-handler-glusterfs) weakremover(tcmu-runner-handler-rbd) weakremover(tcmu-runner-handler-zbc) weakremover(tcpd) weakremover(tcpd-devel) weakremover(tcpdump) weakremover(tcpflow) weakremover(tcping) weakremover(tcpreplay) weakremover(tcpser) weakremover(tcptraceroute) weakremover(tcsh) weakremover(tdb-tools) weakremover(tdfiglet) weakremover(tdiff) weakremover(tdom) weakremover(tdom-devel) weakremover(tea) weakremover(tealdeer) weakremover(tecla) weakremover(tecla-devel) weakremover(tecnoballz) weakremover(tectonic) weakremover(teeworlds) weakremover(telegraf) weakremover(telegram-desktop) weakremover(telegram-purple) weakremover(telegram-theme-adapta) weakremover(telegram-theme-plata) weakremover(telemetrics-client) weakremover(telemetrics-client-devel) weakremover(telepathy-accounts-signon) weakremover(telepathy-farstream-devel) weakremover(telepathy-gabble) weakremover(telepathy-gabble-xmpp-console) weakremover(telepathy-glib-devel) weakremover(telepathy-glib-doc) weakremover(telepathy-haze) weakremover(telepathy-idle) weakremover(telepathy-kde) weakremover(telepathy-logger) weakremover(telepathy-logger-devel) weakremover(telepathy-logger-qt5-devel) weakremover(telepathy-mission-control) weakremover(telepathy-mission-control-devel) weakremover(telepathy-mission-control-plugin-goa) weakremover(telepathy-phoney) weakremover(telepathy-plugin-sipe) weakremover(telepathy-qt4-devel) weakremover(telepathy-qt5-devel) weakremover(telepathy-rakia) weakremover(telepathy-rakia-devel) weakremover(telepathy-salut) weakremover(telepathy-sipe) weakremover(teleport) weakremover(teleport-tbot) weakremover(teleport-tctl) weakremover(teleport-tsh) weakremover(tellico) weakremover(telly-skout) weakremover(telnet) weakremover(telnet-server) weakremover(template-glib-devel) weakremover(tensorflow) weakremover(tensorflow-devel) weakremover(tensorflow-doc) weakremover(tensorflow-gnu-hpc) weakremover(tensorflow-gnu-mvapich2-hpc) weakremover(tensorflow-gnu-openmpi2-hpc) weakremover(tensorflow-lite) weakremover(tensorflow-lite-devel) weakremover(tensorflow2) weakremover(tensorflow2-devel) weakremover(tensorflow2-doc) weakremover(tensorflow2-gnu-hpc) weakremover(tensorflow2-gnu-mvapich2-hpc) weakremover(tensorflow2-gnu-openmpi2-hpc) weakremover(tensorflow2-lite) weakremover(tensorflow2-lite-devel) weakremover(tensorflow2_2_1_0-gnu-hpc) weakremover(tensorflow2_2_1_0-gnu-hpc-devel) weakremover(tensorflow2_2_1_0-gnu-hpc-doc) weakremover(tensorflow2_2_1_0-gnu-mvapich2-hpc) weakremover(tensorflow2_2_1_0-gnu-mvapich2-hpc-devel) weakremover(tensorflow2_2_1_0-gnu-mvapich2-hpc-doc) weakremover(tensorflow2_2_1_0-gnu-openmpi2-hpc) weakremover(tensorflow2_2_1_0-gnu-openmpi2-hpc-devel) weakremover(tensorflow2_2_1_0-gnu-openmpi2-hpc-doc) weakremover(tensorflow2_2_1_1-gnu-hpc) weakremover(tensorflow2_2_1_1-gnu-hpc-devel) weakremover(tensorflow2_2_1_1-gnu-hpc-doc) weakremover(tensorflow2_2_1_1-gnu-openmpi2-hpc) weakremover(tensorflow2_2_1_1-gnu-openmpi2-hpc-devel) weakremover(tensorflow2_2_1_1-gnu-openmpi2-hpc-doc) weakremover(tensorflow2_2_4_0-gnu-hpc) weakremover(tensorflow2_2_4_0-gnu-hpc-devel) weakremover(tensorflow2_2_4_0-gnu-hpc-doc) weakremover(tensorflow2_2_4_0-gnu-openmpi2-hpc) weakremover(tensorflow2_2_4_0-gnu-openmpi2-hpc-devel) weakremover(tensorflow2_2_4_0-gnu-openmpi2-hpc-doc) weakremover(tensorflow2_2_4_1-gnu-hpc) weakremover(tensorflow2_2_4_1-gnu-hpc-devel) weakremover(tensorflow2_2_4_1-gnu-hpc-doc) weakremover(tensorflow2_2_4_1-gnu-openmpi2-hpc) weakremover(tensorflow2_2_4_1-gnu-openmpi2-hpc-devel) weakremover(tensorflow2_2_4_1-gnu-openmpi2-hpc-doc) weakremover(tensorflow2_2_6_0-gnu-hpc) weakremover(tensorflow2_2_6_0-gnu-hpc-devel) weakremover(tensorflow2_2_6_0-gnu-hpc-doc) weakremover(tensorflow2_2_6_0-gnu-openmpi2-hpc) weakremover(tensorflow2_2_6_0-gnu-openmpi2-hpc-devel) weakremover(tensorflow2_2_6_0-gnu-openmpi2-hpc-doc) weakremover(tensorflow2_2_6_2-gnu-hpc) weakremover(tensorflow2_2_6_2-gnu-hpc-devel) weakremover(tensorflow2_2_6_2-gnu-hpc-doc) weakremover(tensorflow2_2_6_2-gnu-openmpi2-hpc) weakremover(tensorflow2_2_6_2-gnu-openmpi2-hpc-devel) weakremover(tensorflow2_2_6_2-gnu-openmpi2-hpc-doc) weakremover(tensorflow2_2_7_1-gnu-hpc) weakremover(tensorflow2_2_7_1-gnu-hpc-devel) weakremover(tensorflow2_2_7_1-gnu-hpc-doc) weakremover(tensorflow2_2_7_1-gnu-openmpi2-hpc) weakremover(tensorflow2_2_7_1-gnu-openmpi2-hpc-devel) weakremover(tensorflow2_2_7_1-gnu-openmpi2-hpc-doc) weakremover(tensorflow_1_10_10-gnu-hpc) weakremover(tensorflow_1_10_10-gnu-hpc-devel) weakremover(tensorflow_1_10_10-gnu-hpc-doc) weakremover(tensorflow_1_10_10-gnu-mvapich2-hpc) weakremover(tensorflow_1_10_10-gnu-mvapich2-hpc-devel) weakremover(tensorflow_1_10_10-gnu-mvapich2-hpc-doc) weakremover(tensorflow_1_10_10-gnu-openmpi2-hpc) weakremover(tensorflow_1_10_10-gnu-openmpi2-hpc-devel) weakremover(tensorflow_1_10_10-gnu-openmpi2-hpc-doc) weakremover(tensorflow_1_13_1-gnu-hpc) weakremover(tensorflow_1_13_1-gnu-hpc-devel) weakremover(tensorflow_1_13_1-gnu-hpc-doc) weakremover(tensorflow_1_13_1-gnu-mvapich2-hpc) weakremover(tensorflow_1_13_1-gnu-mvapich2-hpc-devel) weakremover(tensorflow_1_13_1-gnu-mvapich2-hpc-doc) weakremover(tensorflow_1_13_1-gnu-openmpi2-hpc) weakremover(tensorflow_1_13_1-gnu-openmpi2-hpc-devel) weakremover(tensorflow_1_13_1-gnu-openmpi2-hpc-doc) weakremover(tensorflow_1_13_2-gnu-hpc) weakremover(tensorflow_1_13_2-gnu-hpc-devel) weakremover(tensorflow_1_13_2-gnu-hpc-doc) weakremover(tensorflow_1_13_2-gnu-mvapich2-hpc) weakremover(tensorflow_1_13_2-gnu-mvapich2-hpc-devel) weakremover(tensorflow_1_13_2-gnu-mvapich2-hpc-doc) weakremover(tensorflow_1_13_2-gnu-openmpi2-hpc) weakremover(tensorflow_1_13_2-gnu-openmpi2-hpc-devel) weakremover(tensorflow_1_13_2-gnu-openmpi2-hpc-doc) weakremover(tensorflow_1_15_2-gnu-hpc) weakremover(tensorflow_1_15_2-gnu-hpc-devel) weakremover(tensorflow_1_15_2-gnu-mvapich2-hpc) weakremover(tensorflow_1_15_2-gnu-mvapich2-hpc-devel) weakremover(tensorflow_1_15_2-gnu-openmpi2-hpc) weakremover(tensorflow_1_15_2-gnu-openmpi2-hpc-devel) weakremover(tensorflow_1_15_3-gnu-hpc) weakremover(tensorflow_1_15_3-gnu-hpc-devel) weakremover(tensorflow_1_15_3-gnu-openmpi2-hpc) weakremover(tensorflow_1_15_3-gnu-openmpi2-hpc-devel) weakremover(tepl-3-lang) weakremover(tepl-4-lang) weakremover(tepl-5-lang) weakremover(tepl-devel) weakremover(termcap) weakremover(terminfo) weakremover(terminfo-base) weakremover(terminfo-iterm) weakremover(terminfo-screen) weakremover(terminology) weakremover(terminology-theme-Flat) weakremover(terminology-theme-misc) weakremover(terminology-theme-upstream) weakremover(terminus) weakremover(termit) weakremover(termrec) weakremover(terraform) weakremover(terraform-provider-aws) weakremover(terraform-provider-azurerm) weakremover(terraform-provider-helm) weakremover(terraform-provider-libvirt) weakremover(terraform-provider-null) weakremover(terraform-provider-openstack) weakremover(terraform-provider-template) weakremover(terraform-provider-vsphere) weakremover(terragrunt) weakremover(teseq) weakremover(tesla-polyglot) weakremover(tesla-polyglot-atom) weakremover(tesla-polyglot-groovy) weakremover(tesla-polyglot-java) weakremover(tesla-polyglot-javadoc) weakremover(tesla-polyglot-maven-plugin) weakremover(tesla-polyglot-translate-plugin) weakremover(tesla-polyglot-xml) weakremover(tesla-polyglot-yaml) weakremover(tesseract) weakremover(tesseract-ocr) weakremover(tesseract-ocr-devel) weakremover(tesseract-ocr-traineddata-kurdish) weakremover(tesseract-ocr-traineddata-tagalog) weakremover(tesseract-server) weakremover(testdisk) weakremover(testrec0) weakremover(tetrinet-server) weakremover(tevent-man) weakremover(texi2roff) weakremover(texinfo) weakremover(texinfo4) weakremover(texinfo4-links) weakremover(texlab) weakremover(texlive) weakremover(texlive-Asana-Math-fonts) weakremover(texlive-FAQ-en) weakremover(texlive-Type1fonts) weakremover(texlive-a2ping-bin) weakremover(texlive-accfonts-bin) weakremover(texlive-adhocfilelist-bin) weakremover(texlive-aecc) weakremover(texlive-aecc-doc) weakremover(texlive-afm2pl-bin) weakremover(texlive-albatross-bin) weakremover(texlive-aleph-bin) weakremover(texlive-ametsoc) weakremover(texlive-ametsoc-doc) weakremover(texlive-amstex-bin) weakremover(texlive-arara-bin) weakremover(texlive-asymptote-bin) weakremover(texlive-attachfile2-bin) weakremover(texlive-authorindex-bin) weakremover(texlive-autosp-bin) weakremover(texlive-axodraw2-bin) weakremover(texlive-babel-bahasa) weakremover(texlive-babel-bahasa-doc) weakremover(texlive-babel-spanglish) weakremover(texlive-babel-spanglish-doc) weakremover(texlive-babel-ukraineb) weakremover(texlive-babel-ukraineb-doc) weakremover(texlive-beamer-FUBerlin) weakremover(texlive-beamer-FUBerlin-doc) weakremover(texlive-beamerthemephnompenh) weakremover(texlive-beamerthemephnompenh-doc) weakremover(texlive-bezos) weakremover(texlive-bezos-doc) weakremover(texlive-bgreek) weakremover(texlive-bgreek-doc) weakremover(texlive-bib2gls-bin) weakremover(texlive-bibcop-bin) weakremover(texlive-bibexport-bin) weakremover(texlive-bibtex-bin) weakremover(texlive-bibtex8-bin) weakremover(texlive-bibtexperllibs-doc) weakremover(texlive-bibtexu-bin) weakremover(texlive-bin-devel) weakremover(texlive-boxedminipage2e) weakremover(texlive-boxedminipage2e-doc) weakremover(texlive-bundledoc-bin) weakremover(texlive-cachepic-bin) weakremover(texlive-checkcites-bin) weakremover(texlive-checklistings-bin) weakremover(texlive-chklref-bin) weakremover(texlive-chktex-bin) weakremover(texlive-citation-style-language-bin) weakremover(texlive-cjk-gs-integrate-bin) weakremover(texlive-cjkutils-bin) weakremover(texlive-clojure-pamphlet-bin) weakremover(texlive-cluttex-bin) weakremover(texlive-collection-genericextra) weakremover(texlive-collection-genericrecommended) weakremover(texlive-collection-htmlxml) weakremover(texlive-collection-langafrican) weakremover(texlive-collection-langindic) weakremover(texlive-collection-mathextra) weakremover(texlive-collection-omega) weakremover(texlive-collection-plainextra) weakremover(texlive-collection-science) weakremover(texlive-components-of-TeX) weakremover(texlive-context-bin) weakremover(texlive-context-fixme) weakremover(texlive-context-games) weakremover(texlive-context-games-doc) weakremover(texlive-context-inifile) weakremover(texlive-context-inifile-doc) weakremover(texlive-context-lilypond) weakremover(texlive-context-lilypond-doc) weakremover(texlive-context-notes-zh-cn) weakremover(texlive-convbkmk-bin) weakremover(texlive-crossrefware-bin) weakremover(texlive-cslatex-bin) weakremover(texlive-csplain-bin) weakremover(texlive-ctan-o-mat-bin) weakremover(texlive-ctanbib-bin) weakremover(texlive-ctanify-bin) weakremover(texlive-ctanupload-bin) weakremover(texlive-ctie-bin) weakremover(texlive-cweb-bin) weakremover(texlive-cyrillic-bin-bin) weakremover(texlive-de-macro-bin) weakremover(texlive-detex-bin) weakremover(texlive-detlev-cm) weakremover(texlive-detlev-cm-doc) weakremover(texlive-devnag) weakremover(texlive-devnag-bin) weakremover(texlive-digestif-bin) weakremover(texlive-dosepsbin-bin) weakremover(texlive-dtl-bin) weakremover(texlive-dtxgen-bin) weakremover(texlive-dviasm-bin) weakremover(texlive-dvicopy-bin) weakremover(texlive-dvidvi-bin) weakremover(texlive-dviinfox-bin) weakremover(texlive-dviljk-bin) weakremover(texlive-dviout-util-bin) weakremover(texlive-dvipdfmx-bin) weakremover(texlive-dvipdfmx-def) weakremover(texlive-dvipdfmx-def-doc) weakremover(texlive-dvipng-bin) weakremover(texlive-dvipos-bin) weakremover(texlive-dvips-bin) weakremover(texlive-dvisvgm-bin) weakremover(texlive-dvisvgm-def) weakremover(texlive-dvisvgm-def-doc) weakremover(texlive-ebong) weakremover(texlive-ebong-bin) weakremover(texlive-ebong-doc) weakremover(texlive-ednotes) weakremover(texlive-ednotes-doc) weakremover(texlive-einfuehrung) weakremover(texlive-einfuehrung2) weakremover(texlive-elegantbook) weakremover(texlive-elegantbook-doc) weakremover(texlive-elegantnote) weakremover(texlive-elegantnote-doc) weakremover(texlive-elegantpaper) weakremover(texlive-elegantpaper-doc) weakremover(texlive-eplain-bin) weakremover(texlive-epspdf-bin) weakremover(texlive-epstopdf-bin) weakremover(texlive-epyt) weakremover(texlive-epyt-doc) weakremover(texlive-exceltex-bin) weakremover(texlive-expkv) weakremover(texlive-expkv-cs) weakremover(texlive-expkv-cs-doc) weakremover(texlive-expkv-def) weakremover(texlive-expkv-def-doc) weakremover(texlive-expkv-doc) weakremover(texlive-expkv-opt) weakremover(texlive-expkv-opt-doc) weakremover(texlive-fibeamer) weakremover(texlive-fibeamer-doc) weakremover(texlive-fig4latex-bin) weakremover(texlive-findhyph-bin) weakremover(texlive-fontinst-bin) weakremover(texlive-fontloader-luaotfload) weakremover(texlive-fontloader-luaotfload-doc) weakremover(texlive-fontools-bin) weakremover(texlive-fontware-bin) weakremover(texlive-fragmaster-bin) weakremover(texlive-frenchle) weakremover(texlive-frenchle-doc) weakremover(texlive-gatech-thesis) weakremover(texlive-gatech-thesis-doc) weakremover(texlive-genmisc) weakremover(texlive-geometry-de) weakremover(texlive-getmap-bin) weakremover(texlive-git-latexdiff-bin) weakremover(texlive-glossaries-bin) weakremover(texlive-gregoriotex-bin) weakremover(texlive-gsftopk-bin) weakremover(texlive-guide-latex-fr) weakremover(texlive-hitex-bin) weakremover(texlive-hyperref-docsrc) weakremover(texlive-hyperxmp-bin) weakremover(texlive-hyphen-bulgarian-doc) weakremover(texlive-ifetex) weakremover(texlive-ifetex-doc) weakremover(texlive-ifluatex) weakremover(texlive-ifluatex-doc) weakremover(texlive-ifxetex) weakremover(texlive-ifxetex-doc) weakremover(texlive-jadetex-bin) weakremover(texlive-japanese) weakremover(texlive-japanese-doc) weakremover(texlive-japanese-otf-uptex) weakremover(texlive-japanese-otf-uptex-doc) weakremover(texlive-jfmutil-bin) weakremover(texlive-jfontmaps) weakremover(texlive-jfontmaps-bin) weakremover(texlive-jfontmaps-doc) weakremover(texlive-ketcindy-bin) weakremover(texlive-knuth) weakremover(texlive-knuth-doc) weakremover(texlive-knuthotherfonts) weakremover(texlive-kotex-utils-bin) weakremover(texlive-kpathsea-bin) weakremover(texlive-kpathsea-devel) weakremover(texlive-l3build-bin) weakremover(texlive-labelcas) weakremover(texlive-labelcas-doc) weakremover(texlive-lacheck-bin) weakremover(texlive-latex-bib-ex) weakremover(texlive-latex-bib2-ex) weakremover(texlive-latex-bin-bin) weakremover(texlive-latex-bin-dev-bin) weakremover(texlive-latex-git-log-bin) weakremover(texlive-latex-papersize-bin) weakremover(texlive-latex-referenz) weakremover(texlive-latex-tabellen) weakremover(texlive-latex-tds) weakremover(texlive-latex-tds-doc) weakremover(texlive-latex2man-bin) weakremover(texlive-latex2nemeth-bin) weakremover(texlive-latexdiff-bin) weakremover(texlive-latexfileversion-bin) weakremover(texlive-latexindent-bin) weakremover(texlive-latexmk-bin) weakremover(texlive-latexpand-bin) weakremover(texlive-lcdftypetools-bin) weakremover(texlive-libertinus-otf-fonts) weakremover(texlive-light-latex-make-bin) weakremover(texlive-lilyglyphs-bin) weakremover(texlive-linearA) weakremover(texlive-linearA-doc) weakremover(texlive-linearA-fonts) weakremover(texlive-linenoamsmath) weakremover(texlive-linenoamsmath-doc) weakremover(texlive-listbib-bin) weakremover(texlive-listings-ext-bin) weakremover(texlive-lollipop-bin) weakremover(texlive-ltxfileinfo-bin) weakremover(texlive-ltximg-bin) weakremover(texlive-ltxindex) weakremover(texlive-ltxindex-doc) weakremover(texlive-lua2dox) weakremover(texlive-lua2dox-bin) weakremover(texlive-lua2dox-doc) weakremover(texlive-luafindfont-bin) weakremover(texlive-luahbtex-bin) weakremover(texlive-luajittex-bin) weakremover(texlive-luaotfload-bin) weakremover(texlive-luatex-bin) weakremover(texlive-luatex-def) weakremover(texlive-luatex-def-doc) weakremover(texlive-lwarp-bin) weakremover(texlive-m-tx-bin) weakremover(texlive-make4ht-bin) weakremover(texlive-makedtx-bin) weakremover(texlive-makeindex-bin) weakremover(texlive-match_parens-bin) weakremover(texlive-math-e) weakremover(texlive-mathalfa) weakremover(texlive-mathalfa-doc) weakremover(texlive-mathspic-bin) weakremover(texlive-mbenotes) weakremover(texlive-mbenotes-doc) weakremover(texlive-mcf2graph-doc) weakremover(texlive-metafont-bin) weakremover(texlive-metapost-bin) weakremover(texlive-mex-bin) weakremover(texlive-mf2pt1-bin) weakremover(texlive-mflua-bin) weakremover(texlive-mfware-bin) weakremover(texlive-mil3) weakremover(texlive-mkgrkindex-bin) weakremover(texlive-mkjobtexmf-bin) weakremover(texlive-mkpic-bin) weakremover(texlive-mltex-bin) weakremover(texlive-mptopdf-bin) weakremover(texlive-multibibliography-bin) weakremover(texlive-musixtex-bin) weakremover(texlive-musixtnt-bin) weakremover(texlive-mychemistry) weakremover(texlive-mychemistry-doc) weakremover(texlive-npp-for-context) weakremover(texlive-omegaware-bin) weakremover(texlive-optex-bin) weakremover(texlive-optexcount-bin) weakremover(texlive-pagelayout-bin) weakremover(texlive-patgen-bin) weakremover(texlive-pax-bin) weakremover(texlive-pdfbook2-bin) weakremover(texlive-pdfcrop-bin) weakremover(texlive-pdfjam-bin) weakremover(texlive-pdflatexpicscale-bin) weakremover(texlive-pdftex-bin) weakremover(texlive-pdftex-def) weakremover(texlive-pdftex-quiet-bin) weakremover(texlive-pdftools-bin) weakremover(texlive-pdftosrc-bin) weakremover(texlive-pdfxup-bin) weakremover(texlive-pedigree-perl-bin) weakremover(texlive-perltex-bin) weakremover(texlive-petri-nets-bin) weakremover(texlive-pfarrei-bin) weakremover(texlive-pgf-cmykshadings) weakremover(texlive-pgf-cmykshadings-doc) weakremover(texlive-pkfix-bin) weakremover(texlive-pkfix-helper-bin) weakremover(texlive-platex-bin) weakremover(texlive-pmx-bin) weakremover(texlive-pmxchords-bin) weakremover(texlive-powerdot-FUBerlin) weakremover(texlive-powerdot-FUBerlin-doc) weakremover(texlive-presentations) weakremover(texlive-presentations-en) weakremover(texlive-procIAGssymp) weakremover(texlive-procIAGssymp-doc) weakremover(texlive-ps2eps-bin) weakremover(texlive-ps2pk-bin) weakremover(texlive-pst-pdf-bin) weakremover(texlive-pst-spirograph) weakremover(texlive-pst-spirograph-doc) weakremover(texlive-pst-vue3d) weakremover(texlive-pst-vue3d-doc) weakremover(texlive-pst2pdf-bin) weakremover(texlive-pstools-bin) weakremover(texlive-pstricks-examples) weakremover(texlive-pstricks-examples-en) weakremover(texlive-psu-thesis) weakremover(texlive-psu-thesis-doc) weakremover(texlive-ptex-bin) weakremover(texlive-ptex-fontmaps-bin) weakremover(texlive-ptex-fonts-fonts) weakremover(texlive-ptex-manual-doc) weakremover(texlive-ptex2pdf-bin) weakremover(texlive-ptexenc-devel) weakremover(texlive-purifyeps-bin) weakremover(texlive-pygmentex-bin) weakremover(texlive-pythontex-bin) weakremover(texlive-rotating) weakremover(texlive-rotating-doc) weakremover(texlive-rputover) weakremover(texlive-rputover-doc) weakremover(texlive-rubik-bin) weakremover(texlive-scheme-xml) weakremover(texlive-scripts-bin) weakremover(texlive-scripts-extra-bin) weakremover(texlive-seetexk-bin) weakremover(texlive-showhyphens) weakremover(texlive-showhyphens-doc) weakremover(texlive-soulutf8) weakremover(texlive-soulutf8-doc) weakremover(texlive-spanish-mx) weakremover(texlive-spanish-mx-doc) weakremover(texlive-spix-bin) weakremover(texlive-splitindex-bin) weakremover(texlive-srcredact-bin) weakremover(texlive-startlatex2e) weakremover(texlive-sty2dtx-bin) weakremover(texlive-svn-multi-bin) weakremover(texlive-sympytexpackage) weakremover(texlive-sympytexpackage-doc) weakremover(texlive-synctex-bin) weakremover(texlive-synctex-devel) weakremover(texlive-tablestyles) weakremover(texlive-tablestyles-doc) weakremover(texlive-tabulars-e) weakremover(texlive-tetex-bin) weakremover(texlive-tex-bin) weakremover(texlive-tex4ebook-bin) weakremover(texlive-tex4ht-bin) weakremover(texlive-texaccents-bin) weakremover(texlive-texconfig-bin) weakremover(texlive-texcount-bin) weakremover(texlive-texdef-bin) weakremover(texlive-texdiff-bin) weakremover(texlive-texdirflatten-bin) weakremover(texlive-texdoc-bin) weakremover(texlive-texdoctk-bin) weakremover(texlive-texfot-bin) weakremover(texlive-texliveonfly-bin) weakremover(texlive-texloganalyser-bin) weakremover(texlive-texlogfilter-bin) weakremover(texlive-texlogsieve-bin) weakremover(texlive-texlua-devel) weakremover(texlive-texluajit-devel) weakremover(texlive-texosquery-bin) weakremover(texlive-texplate-bin) weakremover(texlive-texsis-bin) weakremover(texlive-texware-bin) weakremover(texlive-thumbpdf-bin) weakremover(texlive-tie-bin) weakremover(texlive-tikztosvg-bin) weakremover(texlive-tkz-doc-doc) weakremover(texlive-tkz-kiviat) weakremover(texlive-tkz-kiviat-doc) weakremover(texlive-tkz-linknodes) weakremover(texlive-tkz-linknodes-doc) weakremover(texlive-tlcockpit) weakremover(texlive-tlcockpit-bin) weakremover(texlive-tlcockpit-doc) weakremover(texlive-tlshell) weakremover(texlive-tlshell-bin) weakremover(texlive-tlshell-doc) weakremover(texlive-tpic2pdftex-bin) weakremover(texlive-ttfutils-bin) weakremover(texlive-typeoutfileinfo-bin) weakremover(texlive-uadocs) weakremover(texlive-uadocs-doc) weakremover(texlive-ulqda-bin) weakremover(texlive-uplatex-bin) weakremover(texlive-upmendex-bin) weakremover(texlive-uptex-bin) weakremover(texlive-uptex-doc) weakremover(texlive-urlbst-bin) weakremover(texlive-velthuis-bin) weakremover(texlive-vlna-bin) weakremover(texlive-voss-mathmode) weakremover(texlive-vpe-bin) weakremover(texlive-wasy2-ps) weakremover(texlive-wasy2-ps-doc) weakremover(texlive-wasy2-ps-fonts) weakremover(texlive-web-bin) weakremover(texlive-webquiz-bin) weakremover(texlive-wordcount-bin) weakremover(texlive-xdvi-bin) weakremover(texlive-xelatex-dev-bin) weakremover(texlive-xetex-bin) weakremover(texlive-xetex-def) weakremover(texlive-xetex-def-doc) weakremover(texlive-xindex-bin) weakremover(texlive-xml2pmx-bin) weakremover(texlive-xmltex-bin) weakremover(texlive-xpdfopen-bin) weakremover(texlive-yplan-bin) weakremover(texmaker) weakremover(texmath) weakremover(texstudio) weakremover(texworks) weakremover(texworks-plugin-lua) weakremover(texworks-plugin-python) weakremover(tftp) weakremover(tftpboot-installation-openSUSE-Kubic-aarch64) weakremover(tftpboot-installation-openSUSE-Leap-15.0-aarch64) weakremover(tftpboot-installation-openSUSE-Leap-15.0-ppc64le) weakremover(tftpboot-installation-openSUSE-Leap-15.1--aarch64) weakremover(tftpboot-installation-openSUSE-Leap-15.1-aarch64) weakremover(tftpboot-installation-openSUSE-Leap-15.1-ppc64le) weakremover(tftpboot-installation-openSUSE-Leap-42.3-aarch64) weakremover(tftpboot-installation-openSUSE-Tumbleweed-Kubic-aarch64) weakremover(tgt) weakremover(the_silver_searcher) weakremover(thin-provisioning-tools) weakremover(thinkfan) weakremover(threadweaver-devel) weakremover(thrift) weakremover(thttpd) weakremover(thunar) weakremover(thunar-devel) weakremover(thunar-font-manager) weakremover(thunar-plugin-archive) weakremover(thunar-plugin-dropbox) weakremover(thunar-plugin-media-tags) weakremover(thunar-plugin-shares) weakremover(thunar-plugin-vcs) weakremover(thunar-volman) weakremover(thunarx-python) weakremover(thunarx-python-doc) weakremover(thunderbolt-user-space) weakremover(tidy) weakremover(tidyp) weakremover(tiff) weakremover(tig) weakremover(tigervnc) weakremover(tilda) weakremover(tilde) weakremover(tiled) weakremover(tilix) weakremover(time) weakremover(timeshift) weakremover(timewarrior) weakremover(timezone) weakremover(timezonemap-devel) weakremover(timidity) weakremover(tinc) weakremover(tini) weakremover(tini-static) weakremover(tint) weakremover(tint2) weakremover(tintii) weakremover(tiny) weakremover(tinyb-devel) weakremover(tinyca2) weakremover(tinyfecvpn) weakremover(tinygettext-devel) weakremover(tinyobjloader-devel) weakremover(tinyproxy) weakremover(tinyssh) weakremover(tinyxml-devel) weakremover(tinyxml-docs) weakremover(tinyxml2-devel) weakremover(tio) weakremover(tiobench) weakremover(tipcutils) weakremover(tiptop) weakremover(titlecase) weakremover(tix) weakremover(tj) weakremover(tk) weakremover(tk-devel) weakremover(tkimg) weakremover(tkimg-devel) weakremover(tkirc) weakremover(tkman) weakremover(tktable) weakremover(tllist-devel) weakremover(tls) weakremover(tls-debug) weakremover(tlswrap) weakremover(tmate) weakremover(tmon) weakremover(tmpwatch) weakremover(tmux) weakremover(tmxtools) weakremover(tn5250) weakremover(tn5250-devel) weakremover(tnef) weakremover(tnftp) weakremover(tntdb-mysql) weakremover(tntdb-postgresql) weakremover(tntdb-replicate) weakremover(tntdb-sqlite) weakremover(tog-pegasus) weakremover(tog-pegasus-devel) weakremover(tog-pegasus-libs) weakremover(tog-pegasus-test) weakremover(toilet) weakremover(toipe) weakremover(tokei) weakremover(tokodon) weakremover(tokyocabinet) weakremover(tokyocabinet-cgi) weakremover(tokyocabinet-testsuite) weakremover(tolua) weakremover(tolua++) weakremover(toluapp-5.1) weakremover(toluapp-5.3) weakremover(toluapp-5.4) weakremover(tomahawk) weakremover(tomahawk-kde) weakremover(tomatoes) weakremover(tomboy) weakremover(tomboy-lang) weakremover(tomoe) weakremover(tomoe-devel) weakremover(tomoe-doc) weakremover(tomoe-gtk) weakremover(tomoe-gtk-devel) weakremover(tomoe-gtk-doc) weakremover(tomoyo-tools) weakremover(tomsfastmath-devel) weakremover(tor) weakremover(torsocks) weakremover(totem) weakremover(totem-devel) weakremover(totem-pl-parser) weakremover(totem-pl-parser-devel) weakremover(totem-plugin-brasero) weakremover(totem-plugin-gnome-dvb-daemon) weakremover(totem-plugin-zeitgeist) weakremover(totem-plugins) weakremover(touchegg) weakremover(touchegg-gui) weakremover(tpm-quote-tools) weakremover(tpm-tools) weakremover(tpm-tools-devel) weakremover(tpm-tools-pkcs11) weakremover(tpm2-0-tss) weakremover(tpm2-0-tss-devel) weakremover(tpm2-pkcs11) weakremover(tpm2-pkcs11-devel) weakremover(tpm2-tss-engine) weakremover(tpm2-tss-engine-devel) weakremover(tpm2.0-abrmd) weakremover(tpm2.0-abrmd-devel) weakremover(tpm2.0-tools) weakremover(trace-cmd) weakremover(trace-cmd-python3) weakremover(traceroute) weakremover(trackballs) weakremover(tracker) weakremover(tracker-data-files) weakremover(tracker-devel) weakremover(tracker-gui) weakremover(tracker-miner-files) weakremover(tracker-miner-rss) weakremover(tracker-miners) weakremover(tracker2) weakremover(tracker2-devel) weakremover(tracker2-lang) weakremover(tracker2-miner-files) weakremover(tracker2-miners) weakremover(tracker2-miners-lang) weakremover(trader) weakremover(traefik) weakremover(traefik1.7) weakremover(transactional-update) weakremover(transactional-update-notifier) weakremover(transconnect) weakremover(transfig) weakremover(translation-update-caValencia) weakremover(translation-update-srLatin) weakremover(translator) weakremover(transmission) weakremover(transmission-daemon) weakremover(transmission-gtk) weakremover(transmission-qt) weakremover(transporter) weakremover(transporter-lang) weakremover(transset) weakremover(tre) weakremover(tre-devel) weakremover(tree) weakremover(tree-sitter) weakremover(tree-sitter-devel) weakremover(treefetch) weakremover(trigger-rally) weakremover(triggerhappy) weakremover(trilinos) weakremover(trilinos-devel) weakremover(trilinos-openmpi2) weakremover(trilinos-openmpi2-devel) weakremover(trilinos-openmpi4-devel) weakremover(trilinos_12_10_1-gnu-mpich-hpc) weakremover(trilinos_12_10_1-gnu-mpich-hpc-devel) weakremover(trilinos_12_10_1-gnu-mvapich2-hpc) weakremover(trilinos_12_10_1-gnu-mvapich2-hpc-devel) weakremover(trilinos_12_10_1-gnu-openmpi2-hpc) weakremover(trilinos_12_10_1-gnu-openmpi2-hpc-devel) weakremover(trilinos_12_10_1-hpc-doc) weakremover(trilinos_12_14_1-gnu-mpich-hpc) weakremover(trilinos_12_14_1-gnu-mpich-hpc-devel) weakremover(trilinos_12_14_1-gnu-mvapich2-hpc) weakremover(trilinos_12_14_1-gnu-mvapich2-hpc-devel) weakremover(trilinos_12_14_1-gnu-openmpi2-hpc) weakremover(trilinos_12_14_1-gnu-openmpi2-hpc-devel) weakremover(trilinos_12_14_1-gnu-openmpi3-hpc) weakremover(trilinos_12_14_1-gnu-openmpi3-hpc-devel) weakremover(trilinos_12_14_1-gnu-openmpi4-hpc-devel) weakremover(trilinos_12_14_1-hpc-doc) weakremover(trilinos_13_0_0-gnu-mpich-hpc-devel) weakremover(trilinos_13_0_0-gnu-mvapich2-hpc-devel) weakremover(trilinos_13_0_0-gnu-openmpi2-hpc-devel) weakremover(trilinos_13_0_0-gnu-openmpi3-hpc-devel) weakremover(trilinos_13_0_0-gnu-openmpi4-hpc-devel) weakremover(trilinos_13_0_0-hpc-doc) weakremover(trilinos_13_0_1-gnu-mpich-hpc-devel) weakremover(trilinos_13_0_1-gnu-mvapich2-hpc-devel) weakremover(trilinos_13_0_1-gnu-openmpi2-hpc-devel) weakremover(trilinos_13_0_1-gnu-openmpi3-hpc-devel) weakremover(trilinos_13_0_1-gnu-openmpi4-hpc-devel) weakremover(trilinos_13_0_1-hpc-doc) weakremover(trilinos_13_2_0-gnu-mpich-hpc-devel) weakremover(trilinos_13_2_0-gnu-mvapich2-hpc-devel) weakremover(trilinos_13_2_0-gnu-openmpi2-hpc-devel) weakremover(trilinos_13_2_0-gnu-openmpi3-hpc-devel) weakremover(trilinos_13_2_0-gnu-openmpi4-hpc-devel) weakremover(trilinos_13_2_0-hpc-doc) weakremover(trilinos_14_0_0-gnu-mvapich2-hpc-devel) weakremover(trilinos_14_0_0-gnu-openmpi2-hpc-devel) weakremover(trilinos_14_0_0-gnu-openmpi3-hpc-devel) weakremover(trilinos_14_0_0-gnu-openmpi4-hpc-devel) weakremover(trinity) weakremover(tripwire) weakremover(trivy) weakremover(trng-devel) weakremover(trojan) weakremover(trojita) weakremover(trousers) weakremover(trousers-devel) weakremover(trurl) weakremover(trytond_calendar) weakremover(tsctp) weakremover(tse3) weakremover(tse3-devel) weakremover(tslib) weakremover(tslib-devel) weakremover(tslib-plugins) weakremover(tsung) weakremover(ttf2pt1) weakremover(ttyd) weakremover(ttynvt) weakremover(tudu) weakremover(tuigreet) weakremover(tukit) weakremover(tukitd) weakremover(tumbler) weakremover(tumbler-devel) weakremover(tumbler-folder-thumbnailer) weakremover(tumbler-webp-thumbnailer) weakremover(tunctl) weakremover(tuner) weakremover(tup) weakremover(tupitube) weakremover(tupitube-plugins) weakremover(turnpike) weakremover(turpial) weakremover(tut) weakremover(tuxguitar) weakremover(tuxpaint) weakremover(tuxpaint-config) weakremover(tuxpaint-devel) weakremover(tv-common) weakremover(tvflash) weakremover(tvheadend) weakremover(tvm) weakremover(tvm-devel) weakremover(tvmc) weakremover(tvtime) weakremover(twilio-utils) weakremover(twin) weakremover(twind) weakremover(twinkle) weakremover(twm) weakremover(twolame) weakremover(twups) weakremover(typelib-1_0-Accounts-1_0) weakremover(typelib-1_0-AccountsService-1_0) weakremover(typelib-1_0-Adw-1) weakremover(typelib-1_0-Amtk-3_0) weakremover(typelib-1_0-Amtk-5) weakremover(typelib-1_0-Anjuta-3_0) weakremover(typelib-1_0-AppIndicator-0_1) weakremover(typelib-1_0-AppIndicator3-0_1) weakremover(typelib-1_0-AppStream-1.0) weakremover(typelib-1_0-AppStream-compose-1.0) weakremover(typelib-1_0-AppStreamBuilder-1_0) weakremover(typelib-1_0-AppStreamGlib-1_0) weakremover(typelib-1_0-Aravis-0.8) weakremover(typelib-1_0-Atk-1_0) weakremover(typelib-1_0-AtrilDocument-1_5_0) weakremover(typelib-1_0-AtrilView-1_5_0) weakremover(typelib-1_0-Atspi-2_0) weakremover(typelib-1_0-Avahi-0_6) weakremover(typelib-1_0-AyatanaAppIndicator-0_1) weakremover(typelib-1_0-AyatanaAppIndicator3-0_1) weakremover(typelib-1_0-AyatanaIdo3-0_4) weakremover(typelib-1_0-Babl-0_1) weakremover(typelib-1_0-Bamf-3_0) weakremover(typelib-1_0-BlockDev-2_0) weakremover(typelib-1_0-BraseroBurn-3_2_0) weakremover(typelib-1_0-BraseroMedia-3_2_0) weakremover(typelib-1_0-Budgie-1_0) weakremover(typelib-1_0-BudgieRaven-1_0) weakremover(typelib-1_0-BuzztraxCore-1_1) weakremover(typelib-1_0-BuzztraxIc-1_1) weakremover(typelib-1_0-CMenu-3_0) weakremover(typelib-1_0-Caja-2_0) weakremover(typelib-1_0-Camel-1_2) weakremover(typelib-1_0-Caribou-1_0) weakremover(typelib-1_0-Champlain-0_12) weakremover(typelib-1_0-Cheese-3_0) weakremover(typelib-1_0-Cheese-41_0) weakremover(typelib-1_0-CinnamonDesktop-3_0) weakremover(typelib-1_0-CinnamonMenu-3_0) weakremover(typelib-1_0-CjsPrivate-1_0) weakremover(typelib-1_0-CloudProviders-0_3_0) weakremover(typelib-1_0-Clutter-1_0) weakremover(typelib-1_0-ClutterGst-2_0) weakremover(typelib-1_0-ClutterGst-3_0) weakremover(typelib-1_0-Cogl-1_0) weakremover(typelib-1_0-Cogl-2_0) weakremover(typelib-1_0-CoglGst-2_0) weakremover(typelib-1_0-CoglPango-1_0) weakremover(typelib-1_0-CoglPango-2_0) weakremover(typelib-1_0-ColorHug-1_0) weakremover(typelib-1_0-Colord-1_0) weakremover(typelib-1_0-ColordGtk-1_0) weakremover(typelib-1_0-Colorhug-1_0) weakremover(typelib-1_0-CryptUI-0_0) weakremover(typelib-1_0-CudaGst-1_0) weakremover(typelib-1_0-Cvc-1_0) weakremover(typelib-1_0-Dbusmenu-0_4) weakremover(typelib-1_0-DbusmenuGtk-0_4) weakremover(typelib-1_0-DbusmenuGtk3-0_4) weakremover(typelib-1_0-Dee-1_0) weakremover(typelib-1_0-Devhelp-3_0) weakremover(typelib-1_0-Dex-1_0) weakremover(typelib-1_0-Dmap-4_0) weakremover(typelib-1_0-Dnf-1_0) weakremover(typelib-1_0-EBackend-1_2) weakremover(typelib-1_0-EBook-1_2) weakremover(typelib-1_0-EBookContacts-1_2) weakremover(typelib-1_0-ECal-2_0) weakremover(typelib-1_0-EDataBook-1_2) weakremover(typelib-1_0-EDataCal-2_0) weakremover(typelib-1_0-EDataServer-1_2) weakremover(typelib-1_0-EDataServerUI-1_2) weakremover(typelib-1_0-EDataServerUI4-1_0) weakremover(typelib-1_0-Eek-0_90) weakremover(typelib-1_0-Entangle-0_1) weakremover(typelib-1_0-Eom-1_0) weakremover(typelib-1_0-EvinceDocument-3_0) weakremover(typelib-1_0-EvinceView-3_0) weakremover(typelib-1_0-FPrint-2_0) weakremover(typelib-1_0-Farstream-0_2) weakremover(typelib-1_0-Fcitx-1_0) weakremover(typelib-1_0-FcitxG-1_0) weakremover(typelib-1_0-Flatpak-1_0) weakremover(typelib-1_0-Folks-0_6) weakremover(typelib-1_0-Folks-0_7) weakremover(typelib-1_0-FolksEds-0_6) weakremover(typelib-1_0-FolksEds-0_7) weakremover(typelib-1_0-FolksTelepathy-0_6) weakremover(typelib-1_0-FolksTelepathy-0_7) weakremover(typelib-1_0-FolksTracker-0_6) weakremover(typelib-1_0-Fwupd-2_0) weakremover(typelib-1_0-FwupdPlugin-1_0) weakremover(typelib-1_0-GCab-1_0) weakremover(typelib-1_0-GData-0_0) weakremover(typelib-1_0-GES-1_0) weakremover(typelib-1_0-GExiv2-0_10) weakremover(typelib-1_0-GFBGraph-0_2) weakremover(typelib-1_0-GMenu-3_0) weakremover(typelib-1_0-GMime-2_6) weakremover(typelib-1_0-GMime-3_0) weakremover(typelib-1_0-GOffice-0_10) weakremover(typelib-1_0-GPaste-1_0) weakremover(typelib-1_0-GPaste-2) weakremover(typelib-1_0-GPasteGtk-3) weakremover(typelib-1_0-GPasteGtk-4) weakremover(typelib-1_0-GSSDP-1_0) weakremover(typelib-1_0-GSound-1_0) weakremover(typelib-1_0-GSystem-1_0) weakremover(typelib-1_0-GTop-2_0) weakremover(typelib-1_0-GUPnP-1_0) weakremover(typelib-1_0-GUPnPAV-1_0) weakremover(typelib-1_0-GUPnPDLNA-2_0) weakremover(typelib-1_0-GUPnPDLNAGst-2_0) weakremover(typelib-1_0-GUPnPIgd-1_0) weakremover(typelib-1_0-GUPnPIgd-1_6) weakremover(typelib-1_0-GUdev-1_0) weakremover(typelib-1_0-GUsb-1_0) weakremover(typelib-1_0-GVnc-1_0) weakremover(typelib-1_0-GVncPulse-1_0) weakremover(typelib-1_0-GWeather-3_0) weakremover(typelib-1_0-GWeather-4_0) weakremover(typelib-1_0-GXPS-0_1) weakremover(typelib-1_0-Gck-1) weakremover(typelib-1_0-Gck-2) weakremover(typelib-1_0-Gcr-3) weakremover(typelib-1_0-Gcr-4) weakremover(typelib-1_0-GcrUi-3) weakremover(typelib-1_0-Gda-5_0) weakremover(typelib-1_0-Gda-6_0) weakremover(typelib-1_0-Gdaui-5_0) weakremover(typelib-1_0-Gdaui-6_0) weakremover(typelib-1_0-GdkPixbuf-2_0) weakremover(typelib-1_0-GdkPixdata-2_0) weakremover(typelib-1_0-Gdl-3) weakremover(typelib-1_0-Gdm-1_0) weakremover(typelib-1_0-Gee-0_8) weakremover(typelib-1_0-Gee-1_0) weakremover(typelib-1_0-Gegl-0_3) weakremover(typelib-1_0-Gegl-0_4) weakremover(typelib-1_0-Geoclue-2_0) weakremover(typelib-1_0-GeocodeGlib-1_0) weakremover(typelib-1_0-GeocodeGlib-2_0) weakremover(typelib-1_0-Gepub-0_5) weakremover(typelib-1_0-Gepub-0_6) weakremover(typelib-1_0-Gepub-0_7) weakremover(typelib-1_0-Ggit-1_0) weakremover(typelib-1_0-Gitg-1_0) weakremover(typelib-1_0-GitgExt-1_0) weakremover(typelib-1_0-GjsPrivate-1_0) weakremover(typelib-1_0-Gkbd-3_0) weakremover(typelib-1_0-Gladeui-2_0) weakremover(typelib-1_0-GnomeAutoar-0_1) weakremover(typelib-1_0-GnomeAutoarGtk-0_1) weakremover(typelib-1_0-GnomeBG-4_0) weakremover(typelib-1_0-GnomeBluetooth-1_0) weakremover(typelib-1_0-GnomeBluetooth-3_0) weakremover(typelib-1_0-GnomeDesktop-3_0) weakremover(typelib-1_0-GnomeDesktop-4_0) weakremover(typelib-1_0-GnomeKeyring-1_0) weakremover(typelib-1_0-GnomeRR-4_0) weakremover(typelib-1_0-GoVirt-1_0) weakremover(typelib-1_0-Goa-1_0) weakremover(typelib-1_0-Gom-1_0) weakremover(typelib-1_0-GooCanvas-2_0) weakremover(typelib-1_0-GooCanvas-3_0) weakremover(typelib-1_0-Govf-0_1) weakremover(typelib-1_0-Granite-1_0) weakremover(typelib-1_0-Graphene-1_0) weakremover(typelib-1_0-Grl-0_3) weakremover(typelib-1_0-GrlNet-0_3) weakremover(typelib-1_0-GrlPls-0_3) weakremover(typelib-1_0-Grss-0_7) weakremover(typelib-1_0-Gsf-1) weakremover(typelib-1_0-Gspell-1) weakremover(typelib-1_0-Gspell-1_0) weakremover(typelib-1_0-Gst-0_10) weakremover(typelib-1_0-Gst-1_0) weakremover(typelib-1_0-GstAllocators-1_0) weakremover(typelib-1_0-GstApp-0_10) weakremover(typelib-1_0-GstApp-1_0) weakremover(typelib-1_0-GstAudio-1_0) weakremover(typelib-1_0-GstBadAllocators-1_0) weakremover(typelib-1_0-GstBadAudio-1_0) weakremover(typelib-1_0-GstClapper-1) weakremover(typelib-1_0-GstCodecs-1_0) weakremover(typelib-1_0-GstCuda-1_0) weakremover(typelib-1_0-GstFft-1_0) weakremover(typelib-1_0-GstGL-1_0) weakremover(typelib-1_0-GstGLEGL-1_0) weakremover(typelib-1_0-GstGLWayland-1_0) weakremover(typelib-1_0-GstGLX11-1_0) weakremover(typelib-1_0-GstInsertBin-1_0) weakremover(typelib-1_0-GstInterfaces-0_10) weakremover(typelib-1_0-GstMpegts-1_0) weakremover(typelib-1_0-GstPbutils-1_0) weakremover(typelib-1_0-GstPlay-1_0) weakremover(typelib-1_0-GstPlayer-1_0) weakremover(typelib-1_0-GstRtp-1_0) weakremover(typelib-1_0-GstRtsp-1_0) weakremover(typelib-1_0-GstRtspServer-1_0) weakremover(typelib-1_0-GstSdp-1_0) weakremover(typelib-1_0-GstTag-1_0) weakremover(typelib-1_0-GstTranscoder-1_0) weakremover(typelib-1_0-GstVa-1_0) weakremover(typelib-1_0-GstValidate-1_0) weakremover(typelib-1_0-GstVideo-1_0) weakremover(typelib-1_0-GstVulkan-1_0) weakremover(typelib-1_0-GstVulkanWayland-1_0) weakremover(typelib-1_0-GstVulkanXCB-1_0) weakremover(typelib-1_0-GstWebRTC-1_0) weakremover(typelib-1_0-Gtd-1_0) weakremover(typelib-1_0-Gtef-2_0) weakremover(typelib-1_0-Gtk-2_0) weakremover(typelib-1_0-Gtk-3_0) weakremover(typelib-1_0-Gtk-4_0) weakremover(typelib-1_0-GtkClutter-1_0) weakremover(typelib-1_0-GtkFrdp-0_1) weakremover(typelib-1_0-GtkLayerShell-0_1) weakremover(typelib-1_0-GtkSource-3_0) weakremover(typelib-1_0-GtkSource-4) weakremover(typelib-1_0-GtkSource-5) weakremover(typelib-1_0-GtkSpell-3_0) weakremover(typelib-1_0-GtkVnc-1_0) weakremover(typelib-1_0-GtkVnc-2_0) weakremover(typelib-1_0-Gucharmap-2_90) weakremover(typelib-1_0-Handy-0_0) weakremover(typelib-1_0-Handy-1_0) weakremover(typelib-1_0-HarfBuzz-0_0) weakremover(typelib-1_0-Hex-4) weakremover(typelib-1_0-Hinawa-2_0) weakremover(typelib-1_0-IBus-1_0) weakremover(typelib-1_0-ICal-3_0) weakremover(typelib-1_0-ICalGLib-3_0) weakremover(typelib-1_0-Ido3-0_1) weakremover(typelib-1_0-JavaScriptCore-1_0) weakremover(typelib-1_0-JavaScriptCore-3_0) weakremover(typelib-1_0-JavaScriptCore-4_0) weakremover(typelib-1_0-JavaScriptCore-4_1) weakremover(typelib-1_0-JavaScriptCore-5_0) weakremover(typelib-1_0-JavaScriptCore-6_0) weakremover(typelib-1_0-Jcat-1_0) weakremover(typelib-1_0-Json-1_0) weakremover(typelib-1_0-Jsonrpc-1.0) weakremover(typelib-1_0-Jsonrpc-1_0) weakremover(typelib-1_0-Keybinder-0_0) weakremover(typelib-1_0-Keybinder-3_0) weakremover(typelib-1_0-Lfb-0_0) weakremover(typelib-1_0-Libags-3_0) weakremover(typelib-1_0-Libags-4_0) weakremover(typelib-1_0-Libinsane-1_0) weakremover(typelib-1_0-Libmsi-1_0) weakremover(typelib-1_0-Libosinfo-1_0) weakremover(typelib-1_0-LibvirtGConfig-1_0) weakremover(typelib-1_0-LibvirtGLib-1_0) weakremover(typelib-1_0-LibvirtGObject-1_0) weakremover(typelib-1_0-LibvirtSandbox-1_0) weakremover(typelib-1_0-Libxfce4panel-2_0) weakremover(typelib-1_0-Libxfce4ui-2_0) weakremover(typelib-1_0-Libxfce4util-1_0) weakremover(typelib-1_0-LightDM-1) weakremover(typelib-1_0-LunarCalendar-3_0) weakremover(typelib-1_0-LunarDate-3_0) weakremover(typelib-1_0-Malcontent-0) weakremover(typelib-1_0-MalcontentUi-0) weakremover(typelib-1_0-Manette-0_2) weakremover(typelib-1_0-Manette-0_2-0) weakremover(typelib-1_0-MateDesktop-2_0) weakremover(typelib-1_0-MateMenu-2_0) weakremover(typelib-1_0-MatePanelApplet-4_0) weakremover(typelib-1_0-Matekbd-1_0) weakremover(typelib-1_0-Mbim-1_0) weakremover(typelib-1_0-MediaArt-1_0) weakremover(typelib-1_0-MediaArt-2_0) weakremover(typelib-1_0-Memphis-0_2) weakremover(typelib-1_0-Meta-3_0) weakremover(typelib-1_0-MetaMuffin-0_0) weakremover(typelib-1_0-Midori-0_6) weakremover(typelib-1_0-ModemManager-1_0) weakremover(typelib-1_0-Modulemd-1_0) weakremover(typelib-1_0-Modulemd-2_0) weakremover(typelib-1_0-Muffin-0_0) weakremover(typelib-1_0-MyPaint-1.6) weakremover(typelib-1_0-MyPaint-1_5) weakremover(typelib-1_0-MyPaint-1_6) weakremover(typelib-1_0-MyPaintGegl-1.6) weakremover(typelib-1_0-MyPaintGegl-1_5) weakremover(typelib-1_0-MyPaintGegl-1_6) weakremover(typelib-1_0-NM-1_0) weakremover(typelib-1_0-NMA-1_0) weakremover(typelib-1_0-NMA4-1_0) weakremover(typelib-1_0-NMClient-1_0) weakremover(typelib-1_0-NMGtk-1_0) weakremover(typelib-1_0-Nautilus-3_0) weakremover(typelib-1_0-Nautilus-4_0) weakremover(typelib-1_0-Nemo-3_0) weakremover(typelib-1_0-NetworkManager-1_0) weakremover(typelib-1_0-Nice-0_1) weakremover(typelib-1_0-Notify-0_7) weakremover(typelib-1_0-OSTree-1_0) weakremover(typelib-1_0-OsmGpsMap-1_0) weakremover(typelib-1_0-PackageKitGlib-1_0) weakremover(typelib-1_0-Panel-1) weakremover(typelib-1_0-Pango-1_0) weakremover(typelib-1_0-Peas-1_0) weakremover(typelib-1_0-PeasGtk-1_0) weakremover(typelib-1_0-Playerctl-1_0) weakremover(typelib-1_0-Playerctl-2_0) weakremover(typelib-1_0-Playerctl-2_0_1) weakremover(typelib-1_0-Pluma-1_0) weakremover(typelib-1_0-Polari-1_0) weakremover(typelib-1_0-Polkit-1_0) weakremover(typelib-1_0-PolkitGtkMate-1.0) weakremover(typelib-1_0-Poppler-0_18) weakremover(typelib-1_0-Qmi-1_0) weakremover(typelib-1_0-Qrtr-1_0) weakremover(typelib-1_0-Rest-0_7) weakremover(typelib-1_0-Rest-1_0) weakremover(typelib-1_0-Retro-0_12) weakremover(typelib-1_0-Retro-0_14-0) weakremover(typelib-1_0-Retro-1-0) weakremover(typelib-1_0-Rsvg-2_0) weakremover(typelib-1_0-RygelCore-2_6) weakremover(typelib-1_0-RygelCore-2_8) weakremover(typelib-1_0-RygelRenderer-2_6) weakremover(typelib-1_0-RygelRenderer-2_8) weakremover(typelib-1_0-RygelRendererGst-2_6) weakremover(typelib-1_0-RygelRendererGst-2_8) weakremover(typelib-1_0-RygelServer-2_6) weakremover(typelib-1_0-RygelServer-2_8) weakremover(typelib-1_0-Secret-1) weakremover(typelib-1_0-Shumate-1_0) weakremover(typelib-1_0-Signon-1_0) weakremover(typelib-1_0-Signon-2_0) weakremover(typelib-1_0-Skk-1_0) weakremover(typelib-1_0-SocialWebClient-0_25) weakremover(typelib-1_0-Soup-2_4) weakremover(typelib-1_0-Soup-3_0) weakremover(typelib-1_0-SpiceClientGlib-2_0) weakremover(typelib-1_0-SpiceClientGtk-2_0) weakremover(typelib-1_0-SpiceClientGtk-3_0) weakremover(typelib-1_0-TelepathyFarstream-0_6) weakremover(typelib-1_0-TelepathyGlib-0_12) weakremover(typelib-1_0-TelepathyLogger-0_2) weakremover(typelib-1_0-Template-1_0) weakremover(typelib-1_0-Tepl-3_0) weakremover(typelib-1_0-Tepl-4) weakremover(typelib-1_0-Tepl-5) weakremover(typelib-1_0-Tepl-6) weakremover(typelib-1_0-Thunarx-3_0) weakremover(typelib-1_0-TimezoneMap-1_0) weakremover(typelib-1_0-TotemPlParser-1_0) weakremover(typelib-1_0-Tracker-1_0) weakremover(typelib-1_0-Tracker-2_0) weakremover(typelib-1_0-Tracker-3_0) weakremover(typelib-1_0-TrackerControl-1_0) weakremover(typelib-1_0-TrackerControl-2_0) weakremover(typelib-1_0-TrackerMiner-1_0) weakremover(typelib-1_0-TrackerMiner-2_0) weakremover(typelib-1_0-UDisks-2_0) weakremover(typelib-1_0-UMockdev-1_0) weakremover(typelib-1_0-Uhm-0_0) weakremover(typelib-1_0-Uhm-1_0) weakremover(typelib-1_0-Unique-1_0) weakremover(typelib-1_0-Unique-3_0) weakremover(typelib-1_0-Unity-7_0) weakremover(typelib-1_0-UnityExtras-7_0) weakremover(typelib-1_0-UpowerGlib-1_0) weakremover(typelib-1_0-Urfkill-0_0) weakremover(typelib-1_0-Vips-8_0) weakremover(typelib-1_0-Vips-8_10) weakremover(typelib-1_0-Vips-8_12) weakremover(typelib-1_0-Vips-8_13) weakremover(typelib-1_0-Vips-8_5) weakremover(typelib-1_0-Vips-8_9) weakremover(typelib-1_0-Vte-2.91) weakremover(typelib-1_0-Vte-2_91) weakremover(typelib-1_0-Vte-3_91) weakremover(typelib-1_0-WebKit-1_0) weakremover(typelib-1_0-WebKit-3_0) weakremover(typelib-1_0-WebKit-6_0) weakremover(typelib-1_0-WebKit2-4_0) weakremover(typelib-1_0-WebKit2-4_1) weakremover(typelib-1_0-WebKit2-5_0) weakremover(typelib-1_0-WebKit2WebExtension-4_0) weakremover(typelib-1_0-WebKit2WebExtension-4_1) weakremover(typelib-1_0-WebKit2WebExtension-5_0) weakremover(typelib-1_0-WebKitWebProcessExtension-6_0) weakremover(typelib-1_0-Wnck-1_0) weakremover(typelib-1_0-Wnck-3_0) weakremover(typelib-1_0-Workrave-1_0) weakremover(typelib-1_0-Wp-0_4) weakremover(typelib-1_0-XApp-1_0) weakremover(typelib-1_0-XdgApp-1_0) weakremover(typelib-1_0-Xdp-1_0) weakremover(typelib-1_0-XdpGtk3-1_0) weakremover(typelib-1_0-XdpGtk4-1_0) weakremover(typelib-1_0-Xfconf-0) weakremover(typelib-1_0-Xkl-1_0) weakremover(typelib-1_0-Xmlb-1_0) weakremover(typelib-1_0-XplayerPlParser-1_0) weakremover(typelib-1_0-XreaderDocument-1_5) weakremover(typelib-1_0-XreaderDocument-1_5_0) weakremover(typelib-1_0-XreaderView-1_5) weakremover(typelib-1_0-XreaderView-1_5_0) weakremover(typelib-1_0-Zeitgeist-2_0) weakremover(typelib-1_0-Zpj-0_0) weakremover(typelib-1_0-gSignon-1_0) weakremover(typelib-1_0-gSignond-1_0) weakremover(typelib-1_0-kkc-1_0) weakremover(typelib-1_0-libdazzle-1_0) weakremover(typelib-1_0-libmirage-3_0) weakremover(typelib-1_0-libmirage-3_1) weakremover(typelib-1_0-libmirage-3_2) weakremover(typelib-1_0-libxfce4util-1_0) weakremover(typelib_1_0-Budgie-0_1) weakremover(typesafe-config-javadoc) weakremover(typst) weakremover(u-boot-avnetultra96rev1) weakremover(u-boot-avnetultra96rev1-doc) weakremover(u-boot-bananapim64) weakremover(u-boot-bananapim64-doc) weakremover(u-boot-dragonboard410c) weakremover(u-boot-dragonboard410c-doc) weakremover(u-boot-dragonboard820c) weakremover(u-boot-dragonboard820c-doc) weakremover(u-boot-evb-rk3399) weakremover(u-boot-evb-rk3399-doc) weakremover(u-boot-firefly-rk3399) weakremover(u-boot-firefly-rk3399-doc) weakremover(u-boot-geekbox) weakremover(u-boot-geekbox-doc) weakremover(u-boot-hikey) weakremover(u-boot-hikey-doc) weakremover(u-boot-khadas-vim) weakremover(u-boot-khadas-vim-doc) weakremover(u-boot-khadas-vim2) weakremover(u-boot-khadas-vim2-doc) weakremover(u-boot-libretech-ac) weakremover(u-boot-libretech-ac-doc) weakremover(u-boot-libretech-cc) weakremover(u-boot-libretech-cc-doc) weakremover(u-boot-ls1012afrdmqspi) weakremover(u-boot-ls1012afrdmqspi-doc) weakremover(u-boot-mvebudb-88f3720) weakremover(u-boot-mvebudb-88f3720-doc) weakremover(u-boot-mvebudb-88f7040) weakremover(u-boot-mvebudb-88f7040-doc) weakremover(u-boot-mvebudb-88f8040) weakremover(u-boot-mvebudb-88f8040-doc) weakremover(u-boot-mvebudbarmada8k) weakremover(u-boot-mvebudbarmada8k-doc) weakremover(u-boot-mvebuespressobin-88f3720) weakremover(u-boot-mvebuespressobin-88f3720-doc) weakremover(u-boot-mvebumcbin-88f8040) weakremover(u-boot-mvebumcbin-88f8040-doc) weakremover(u-boot-nanopc-t4-rk3399) weakremover(u-boot-nanopc-t4-rk3399-doc) weakremover(u-boot-nanopi-m4b-rk3399) weakremover(u-boot-nanopi-m4b-rk3399-doc) weakremover(u-boot-nanopia64) weakremover(u-boot-nanopia64-doc) weakremover(u-boot-odroid-c2) weakremover(u-boot-odroid-c2-doc) weakremover(u-boot-odroid-c4) weakremover(u-boot-odroid-c4-doc) weakremover(u-boot-odroid-n2) weakremover(u-boot-odroid-n2-doc) weakremover(u-boot-orangepipc2) weakremover(u-boot-orangepipc2-doc) weakremover(u-boot-orangepizero2) weakremover(u-boot-orangepizero2-doc) weakremover(u-boot-p2371-2180) weakremover(u-boot-p2371-2180-doc) weakremover(u-boot-p2771-0000-500) weakremover(u-boot-p2771-0000-500-doc) weakremover(u-boot-p3450-0000) weakremover(u-boot-p3450-0000-doc) weakremover(u-boot-pine64plus) weakremover(u-boot-pine64plus-doc) weakremover(u-boot-pinebook) weakremover(u-boot-pinebook-doc) weakremover(u-boot-pinebook-pro-rk3399) weakremover(u-boot-pinebook-pro-rk3399-doc) weakremover(u-boot-pineh64) weakremover(u-boot-pineh64-doc) weakremover(u-boot-pinephone) weakremover(u-boot-pinephone-doc) weakremover(u-boot-poplar) weakremover(u-boot-poplar-doc) weakremover(u-boot-rock-pi-4-rk3399) weakremover(u-boot-rock-pi-4-rk3399-doc) weakremover(u-boot-rock-pi-n10-rk3399pro) weakremover(u-boot-rock-pi-n10-rk3399pro-doc) weakremover(u-boot-rock64-rk3328) weakremover(u-boot-rock64-rk3328-doc) weakremover(u-boot-rock960-rk3399) weakremover(u-boot-rock960-rk3399-doc) weakremover(u-boot-rockpro64-rk3399) weakremover(u-boot-rockpro64-rk3399-doc) weakremover(u-boot-rpi3) weakremover(u-boot-rpi3-doc) weakremover(u-boot-rpi4) weakremover(u-boot-rpi4-doc) weakremover(u-boot-rpiarm64) weakremover(u-boot-rpiarm64-doc) weakremover(u-boot-tools) weakremover(u-boot-xilinxzynqmpgeneric) weakremover(u-boot-xilinxzynqmpgeneric-doc) weakremover(u-boot-xilinxzynqmpvirt) weakremover(u-boot-xilinxzynqmpvirt-doc) weakremover(u-boot-xilinxzynqmpzcu102rev10) weakremover(u-boot-xilinxzynqmpzcu102rev10-doc) weakremover(u2f-host) weakremover(u2f-server) weakremover(u3-tool) weakremover(uacme) weakremover(uasm) weakremover(ubridge) weakremover(ucblogo) weakremover(uchardet) weakremover(ucl-devel) weakremover(ucm) weakremover(ucommon) weakremover(ucommon-devel) weakremover(ucpp) weakremover(ucpp-devel) weakremover(udav) weakremover(udev) weakremover(udev-browse) weakremover(udev-configure-printer) weakremover(udev-mini) weakremover(udftools) weakremover(udhcp) weakremover(udisks2) weakremover(udisks2-devel) weakremover(udisks2-qt5-devel) weakremover(udns) weakremover(udns-devel) weakremover(udp2raw-tunnel) weakremover(udpspeeder) weakremover(udtrace) weakremover(udunits-compat) weakremover(udunits-compat-devel) weakremover(udunits2) weakremover(udunits2-devel) weakremover(ufiformat) weakremover(ufraw) weakremover(uftpd) weakremover(ufw) weakremover(ufw-lang) weakremover(uget) weakremover(uget-integrator) weakremover(ugrep) weakremover(uhd-devel) weakremover(uhd-udev) weakremover(uhd-utils) weakremover(uhttpmock-devel) weakremover(uhubctl) weakremover(uid_wrapper) weakremover(uim) weakremover(uim-devel) weakremover(uim-gtk2) weakremover(uim-gtk3) weakremover(uim-qt4) weakremover(uim-qt5) weakremover(uimaj) weakremover(uisp) weakremover(ulfius-devel) weakremover(ullae-veliyae) weakremover(ulogd) weakremover(ulogd-mysql) weakremover(ulogd-pcap) weakremover(ulogd-pgsql) weakremover(ulogd-sqlite3) weakremover(ultimatestunts) weakremover(umbrello) weakremover(umoci) weakremover(umockdev) weakremover(umockdev-devel) weak