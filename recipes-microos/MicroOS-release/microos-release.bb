SUMMARY = "openSUSE MicroOS"
DESCRIPTION = "openSUSE MicroOS combines the benefits of a rolling OS with a read-only root filesystem with transactional updates. It is a modern Linux Operating System, designed for single-service installations, such as container hosts. It is optimized for large, clustered deployments. \
        It inherits the benefits of openSUSE Tumbleweed while redefining the operating system into a small, efficient and reliable distribution."
LICENSE = "GPL-2.0-or-later"

PV = "20230509"

RPM_NAME = "MicroOS-release-20230509-1651.1.aarch64.rpm"
RPM_HASH = "a72736ff125fc417900aa8747fe0dd480f9a7592807d6798814bceb9c1a71bd7888270d53577e323b6002231b91f1318393ea6b1a5f7a09b578fbf732cf8c010"

