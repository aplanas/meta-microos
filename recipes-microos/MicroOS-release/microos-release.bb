RPROVIDES:${PN} += "MicroOS-release MicroOS-release(aarch-64) MicroOS-release-20230509 distribution-release openSUSE-MicroOS-release openSUSE-Tumbleweed-Kubic-release product() product(MicroOS) product-cpeid() product-endoflife() product-label() product-update() product-url(releasenotes) suse-release suse-release-oss system-installation() weakremover(0ad) weakremover(2048-cli) weakremover(389-ds) weakremover(389-ds-devel) weakremover(389-ds-snmp) weakremover(3omns) weakremover(4pane) weakremover(4store) weakremover(4ti2) weakremover(4ti2-devel) weakremover(6tunnel) weakremover(7kaa) weakremover(7zip) weakremover(96BoardsGPIO-common) weakremover(96BoardsGPIO-devel) weakremover(ART) weakremover(ASL) weakremover(ASL-devel) weakremover(ASL-doc) weakremover(Agda) weakremover(AppCSXCAD) weakremover(AppStream) weakremover(AppStream-compose) weakremover(AppStream-compose-devel) weakremover(AppStream-devel) weakremover(AppStream-doc) weakremover(AusweisApp2) weakremover(BNFC) weakremover(Bear) weakremover(Botan) weakremover(Box2D-doc) weakremover(CSXCAD-devel) weakremover(Cadence) weakremover(CastXML-devel) weakremover(Catch2-2-devel) weakremover(Catch2-devel) weakremover(CharLS-devel) weakremover(Coin-devel) weakremover(Coin4-devel) weakremover(Coin4-devel-doc) weakremover(ColPack-devel) weakremover(ColorFull-devel) weakremover(ComputeLibrary) weakremover(ComputeLibrary-devel) weakremover(ComputeLibrary-sample-data) weakremover(ConsoleKit) weakremover(ConsoleKit-devel) weakremover(ConsoleKit-doc) weakremover(ConsoleKit-x11) weakremover(CorsixTH) weakremover(DSView) weakremover(DVDStyler) weakremover(DevIL-devel) weakremover(DirectFB) weakremover(DirectFB-Mesa) weakremover(DirectFB-devel) weakremover(DirectFB-doc) weakremover(DirectFB-libSDL) weakremover(DirectFB-libvncclient) weakremover(DisplayCAL) weakremover(Ebnf2ps) weakremover(ElectricFence) weakremover(EternalTerminal) weakremover(FAudio-devel) weakremover(FastCGI) weakremover(FastCGI-devel) weakremover(FlightGear) weakremover(Fragments) weakremover(FreeCAD) weakremover(FreeFileSync) weakremover(GeoIP) weakremover(GeoIP-data) weakremover(GraphicsMagick) weakremover(GraphicsMagick-devel) weakremover(H2rename) weakremover(HSAIL-Tools) weakremover(HaXml) weakremover(Hawck) weakremover(HepMC-devel) weakremover(HepMC-doc) weakremover(HepMC2-devel) weakremover(IPython) weakremover(IPython-doc) weakremover(IccXML) weakremover(ImageMagick) weakremover(ImageMagick-config-6-SUSE) weakremover(ImageMagick-config-6-upstream) weakremover(ImageMagick-config-7-SUSE) weakremover(ImageMagick-config-7-upstream) weakremover(ImageMagick-devel) weakremover(ImageMagick-extra) weakremover(Imath-devel) weakremover(Ipopt-devel) weakremover(Jamulus) weakremover(KEALib-devel) weakremover(LHAPDF-devel) weakremover(LiE) weakremover(LiE-doc) weakremover(LibVNCServer-devel) weakremover(Mesa) weakremover(Mesa-KHR-devel) weakremover(Mesa-demo) weakremover(Mesa-demo-egl) weakremover(Mesa-demo-es) weakremover(Mesa-demo-x) weakremover(Mesa-devel) weakremover(Mesa-dri) weakremover(Mesa-dri-devel) weakremover(Mesa-dri-nouveau) weakremover(Mesa-dri-vc4) weakremover(Mesa-gallium) weakremover(Mesa-libEGL-devel) weakremover(Mesa-libEGL1) weakremover(Mesa-libGL-devel) weakremover(Mesa-libGL1) weakremover(Mesa-libGLESv1_CM-devel) weakremover(Mesa-libGLESv1_CM1) weakremover(Mesa-libGLESv2-2) weakremover(Mesa-libGLESv2-devel) weakremover(Mesa-libGLESv3-devel) weakremover(Mesa-libOpenCL) weakremover(Mesa-libRusticlOpenCL) weakremover(Mesa-libVulkan-devel) weakremover(Mesa-libd3d) weakremover(Mesa-libd3d-devel) weakremover(Mesa-libglapi-devel) weakremover(Mesa-libglapi0) weakremover(Mesa-libva) weakremover(Mesa-vulkan-device-select) weakremover(Mesa-vulkan-overlay) weakremover(MicroOS-release) weakremover(MicroOS-release-appliance) weakremover(MicroOS-release-appliance-kubic) weakremover(MicroOS-release-dvd) weakremover(MicroOS-release-kubic-dvd) weakremover(ModemManager) weakremover(ModemManager-devel) weakremover(Modules) weakremover(MozillaFirefox) weakremover(MozillaFirefox-branding-openSUSE) weakremover(MozillaFirefox-branding-upstream) weakremover(MozillaFirefox-translations-common) weakremover(MozillaFirefox-translations-other) weakremover(MozillaThunderbird) weakremover(MozillaThunderbird-devel) weakremover(MozillaThunderbird-translations-common) weakremover(MozillaThunderbird-translations-other) weakremover(MultiMarkdown-5) weakremover(MultiMarkdown-6) weakremover(MyGUI) weakremover(MyGUI-demo) weakremover(MyGUI-devel) weakremover(MyGUI-tools) weakremover(MyODBC-unixODBC) weakremover(Ne10-devel) weakremover(NetworkManager) weakremover(NetworkManager-appindicator) weakremover(NetworkManager-applet) weakremover(NetworkManager-bluetooth) weakremover(NetworkManager-cloud-setup) weakremover(NetworkManager-connection-editor) weakremover(NetworkManager-devel) weakremover(NetworkManager-fortisslvpn) weakremover(NetworkManager-fortisslvpn-gnome) weakremover(NetworkManager-gnome) weakremover(NetworkManager-gnome-lang) weakremover(NetworkManager-iodine) weakremover(NetworkManager-iodine-gnome) weakremover(NetworkManager-l2tp) weakremover(NetworkManager-l2tp-gnome) weakremover(NetworkManager-libreswan) weakremover(NetworkManager-libreswan-gnome) weakremover(NetworkManager-novellvpn) weakremover(NetworkManager-novellvpn-gnome) weakremover(NetworkManager-novellvpn-lang) weakremover(NetworkManager-openconnect) weakremover(NetworkManager-openconnect-gnome) weakremover(NetworkManager-openswan) weakremover(NetworkManager-openswan-gnome) weakremover(NetworkManager-openswan-lang) weakremover(NetworkManager-openvpn) weakremover(NetworkManager-openvpn-gnome) weakremover(NetworkManager-ovs) weakremover(NetworkManager-pppoe) weakremover(NetworkManager-pptp) weakremover(NetworkManager-pptp-gnome) weakremover(NetworkManager-strongswan) weakremover(NetworkManager-strongswan-gnome) weakremover(NetworkManager-tui) weakremover(NetworkManager-vpnc) weakremover(NetworkManager-vpnc-gnome) weakremover(NetworkManager-wifi) weakremover(NetworkManager-wwan) weakremover(NsCDE) weakremover(OOKiedokie) weakremover(OpenBoard) weakremover(OpenCSD) weakremover(OpenCSD-devel) weakremover(OpenColorIO) weakremover(OpenColorIO-devel) weakremover(OpenColorIO-tools) weakremover(OpenIPMI) weakremover(OpenIPMI-devel) weakremover(OpenIPMI-python) weakremover(OpenIPMI-python3) weakremover(OpenImageIO) weakremover(OpenImageIO-devel) weakremover(OpenImageIO-plugin-osl) weakremover(OpenRGB) weakremover(OpenSceneGraph) weakremover(OpenSceneGraph-examples) weakremover(OpenSceneGraph-plugin-gdal) weakremover(OpenSceneGraph-plugin-gstreamer) weakremover(OpenSceneGraph-plugin-opencascade) weakremover(OpenSceneGraph-plugin-pdf) weakremover(OpenSceneGraph-plugins) weakremover(OpenSceneGraph34) weakremover(OpenSceneGraph34-examples) weakremover(OpenSceneGraph34-plugins) weakremover(OpenShadingLanguage) weakremover(OpenShadingLanguage-MaterialX-shaders-source) weakremover(OpenShadingLanguage-common-headers) weakremover(OpenShadingLanguage-devel) weakremover(OpenShadingLanguage-doc) weakremover(OpenShadingLanguage-example-shaders-source) weakremover(OpenShadingLanguage-shaders-devel) weakremover(OpenSubdiv-devel) weakremover(PDAL) weakremover(PDAL-devel) weakremover(PackageKit) weakremover(PackageKit-Qt-devel) weakremover(PackageKit-Qt5-devel) weakremover(PackageKit-backend-dnf) weakremover(PackageKit-backend-zypp) weakremover(PackageKit-devel) weakremover(PackageKit-gstreamer-plugin) weakremover(PackageKit-gtk3-module) weakremover(PgTcl) weakremover(PlatformFolders) weakremover(PlatformFolders-devel) weakremover(Play) weakremover(PlotDigitizer) weakremover(Printrun) weakremover(Printrun-common) weakremover(PrusaSlicer) weakremover(PyGreSQL) weakremover(QCSXCAD-devel) weakremover(QGnomePlatform) weakremover(QGnomePlatform-qt5) weakremover(QGnomePlatform-qt6) weakremover(QMPlay2) weakremover(QR-Code-generator-devel) weakremover(QTalarm) weakremover(Qross-devel) weakremover(QtAV) weakremover(QtAV-devel) weakremover(QtAV-players) weakremover(QtAV-qml) weakremover(QtDMM) weakremover(QtPass) weakremover(R-BH) weakremover(R-KernSmooth) weakremover(R-MASS) weakremover(R-Matrix) weakremover(R-Matrix-devel) weakremover(R-PKI) weakremover(R-R6) weakremover(R-RCurl) weakremover(R-RJSONIO) weakremover(R-Rcpp) weakremover(R-Rcpp-devel) weakremover(R-Rcpp-doc) weakremover(R-base) weakremover(R-base-devel) weakremover(R-base64enc) weakremover(R-bitops) weakremover(R-boot) weakremover(R-class) weakremover(R-cluster) weakremover(R-codetools) weakremover(R-compiler) weakremover(R-core) weakremover(R-core-devel) weakremover(R-core-doc) weakremover(R-core-libs) weakremover(R-core-packages) weakremover(R-crayon) weakremover(R-curl) weakremover(R-datasets) weakremover(R-digest) weakremover(R-digest-devel) weakremover(R-foreign) weakremover(R-grDevices) weakremover(R-graphics) weakremover(R-grid) weakremover(R-httpuv) weakremover(R-jsonlite) weakremover(R-later) weakremover(R-lattice) weakremover(R-magrittr) weakremover(R-methods) weakremover(R-mgcv) weakremover(R-nlme) weakremover(R-nnet) weakremover(R-openssl) weakremover(R-openssl-doc) weakremover(R-packrat) weakremover(R-parallel) weakremover(R-plumber) weakremover(R-praise) weakremover(R-promises) weakremover(R-recommended-packages) weakremover(R-rlang) weakremover(R-rpart) weakremover(R-rsconnect) weakremover(R-rstudioapi) weakremover(R-spatial) weakremover(R-splines) weakremover(R-stats) weakremover(R-stats4) weakremover(R-stringi) weakremover(R-stringi-devel) weakremover(R-survival) weakremover(R-tcltk) weakremover(R-tools) weakremover(R-utils) weakremover(R-yaml) weakremover(RealtimeSync) weakremover(Regina-REXX) weakremover(Regina-REXX-devel) weakremover(Regina-REXX-doc) weakremover(RigelEngine) weakremover(Rivet-devel) weakremover(Rivet-plugins) weakremover(SDL-devel) weakremover(SDL-devel-doc) weakremover(SDL2-devel) weakremover(SDL2_Pango-devel) weakremover(SDL2_image-devel) weakremover(SDL2_mixer-devel) weakremover(SDL2_net-devel) weakremover(SDL2_sound-devel) weakremover(SDL2_ttf-devel) weakremover(SDL_Pango-devel) weakremover(SDL_sound-devel) weakremover(SDLmm-devel) weakremover(SHERPA-MC-devel) weakremover(SUSEConnect) weakremover(SVT-AV1) weakremover(SVT-AV1-devel) weakremover(SampleICC) weakremover(SecLists) weakremover(ShellCheck) weakremover(SimGear-devel) weakremover(SoQt) weakremover(SoQt-devel) weakremover(SpeedTest++) weakremover(Srain) weakremover(StyLua) weakremover(SuSEfirewall2) weakremover(SuSEfirewall2-fail2ban) weakremover(SwayNotificationCenter) weakremover(ThePEG-devel) weakremover(ThePEG-libs) weakremover(TreeMaker) weakremover(UEFITool) weakremover(UltimateDailyWallpaper) weakremover(VFlib3) weakremover(VFlib3-devel) weakremover(Vc-devel) weakremover(Vc-devel-static) weakremover(VecCore-devel) weakremover(VirtualGL) weakremover(VirtualGL-devel) weakremover(WebKit2GTK-4.0-lang) weakremover(WebKit2GTK-4.1-lang) weakremover(WebKit2GTK-5.0-lang) weakremover(WindowMaker) weakremover(WindowMaker-applets) weakremover(WindowMaker-devel) weakremover(XyGrib) weakremover(YODA-devel) weakremover(YampaSynth) weakremover(ZArchive) weakremover(ZArchive-devel) weakremover(a2jmidid) weakremover(a2ps) weakremover(a2ps-devel) weakremover(a52dec) weakremover(aaa_base) weakremover(aaa_base-extras) weakremover(aaa_base-malloccheck) weakremover(aaa_base-wsl) weakremover(aalib) weakremover(aalib-devel) weakremover(aardvark-dns) weakremover(abcm2ps) weakremover(abiword) weakremover(abook) weakremover(abootimg) weakremover(abseil-cpp) weakremover(abseil-cpp-devel) weakremover(abseil-cpp-source) weakremover(abxtest) weakremover(acars-examples) weakremover(acars2-examples) weakremover(acarsdec) weakremover(acbuild) weakremover(accel-config) weakremover(accel-config-devel) weakremover(accounts-qml-module) weakremover(accountsservice) weakremover(accountsservice-devel) weakremover(accountsservice-vala) weakremover(acct) weakremover(acl) weakremover(acpi) weakremover(acpica) weakremover(acpid) weakremover(act) weakremover(actkbd) weakremover(adcli) weakremover(addrwatch) weakremover(ade-devel) weakremover(adios-openmpi1) weakremover(adios-openmpi1-devel) weakremover(adios-openmpi1-devel-static) weakremover(adios-openmpi2) weakremover(adios-openmpi2-devel) weakremover(adios-openmpi2-devel-static) weakremover(adios-openmpi3) weakremover(adios-openmpi3-devel) weakremover(adios-openmpi3-devel-static) weakremover(adios-openmpi4) weakremover(adios-openmpi4-devel) weakremover(adios-openmpi4-devel-static) weakremover(adios_1_13_1-gnu-mpich-hpc) weakremover(adios_1_13_1-gnu-mpich-hpc-devel) weakremover(adios_1_13_1-gnu-mpich-hpc-devel-static) weakremover(adios_1_13_1-gnu-mvapich2-hpc) weakremover(adios_1_13_1-gnu-mvapich2-hpc-devel) weakremover(adios_1_13_1-gnu-mvapich2-hpc-devel-static) weakremover(adios_1_13_1-gnu-openmpi1-hpc) weakremover(adios_1_13_1-gnu-openmpi1-hpc-devel) weakremover(adios_1_13_1-gnu-openmpi1-hpc-devel-static) weakremover(adios_1_13_1-gnu-openmpi2-hpc) weakremover(adios_1_13_1-gnu-openmpi2-hpc-devel) weakremover(adios_1_13_1-gnu-openmpi2-hpc-devel-static) weakremover(adios_1_13_1-gnu-openmpi3-hpc) weakremover(adios_1_13_1-gnu-openmpi3-hpc-devel) weakremover(adios_1_13_1-gnu-openmpi3-hpc-devel-static) weakremover(adios_1_13_1-gnu-openmpi4-hpc) weakremover(adios_1_13_1-gnu-openmpi4-hpc-devel) weakremover(adios_1_13_1-gnu-openmpi4-hpc-devel-static) weakremover(adjtimex) weakremover(adlmidi) weakremover(adlmidi-tools) weakremover(adminer-elasticsearch) weakremover(adminer-firebird) weakremover(adminer-mssql) weakremover(adms) weakremover(adms-devel) weakremover(adns) weakremover(adobe-cid-keyed-moe-fonts) weakremover(adobe-cid-keyed-munhwa-fonts) weakremover(adobe-cid-keyed-wada-fonts) weakremover(adobe-cid-keyed-wadah-fonts) weakremover(adolc-devel) weakremover(adplugdb) weakremover(adriconf) weakremover(adwaita-qt4) weakremover(adwaita-qt5) weakremover(adwaita-qt6) weakremover(aegisub) weakremover(aer-inject) weakremover(aerc) weakremover(aespipe) weakremover(afl) weakremover(afterburn) weakremover(afterburn-dracut) weakremover(age) weakremover(agenda) weakremover(agg-devel) weakremover(agrep) weakremover(aha) weakremover(ahx2play) weakremover(aiccu) weakremover(aide) weakremover(aide-test) weakremover(aircrack-ng) weakremover(airspy) weakremover(airspy-devel) weakremover(airspy-udev) weakremover(airspyhf) weakremover(airspyhf-devel) weakremover(airspyhf-udev) weakremover(aisleriot) weakremover(akonadi) weakremover(akonadi-calendar) weakremover(akonadi-calendar-devel) weakremover(akonadi-calendar-lang) weakremover(akonadi-calendar-tools) weakremover(akonadi-contact) weakremover(akonadi-contact-devel) weakremover(akonadi-import-wizard) weakremover(akonadi-import-wizard-devel) weakremover(akonadi-mime) weakremover(akonadi-mime-devel) weakremover(akonadi-mime-lang) weakremover(akonadi-notes-devel) weakremover(akonadi-notes-lang) weakremover(akonadi-plugin-calendar) weakremover(akonadi-plugin-contacts) weakremover(akonadi-plugin-kalarmcal) weakremover(akonadi-plugin-mime) weakremover(akonadi-runtime) weakremover(akonadi-search) weakremover(akonadi-search-devel) weakremover(akonadi-server) weakremover(akonadi-server-apparmor) weakremover(akonadi-server-devel) weakremover(akonadi-server-sqlite) weakremover(akonadi_resources) weakremover(akonadiconsole) weakremover(akregator) weakremover(akregator5) weakremover(alac) weakremover(alac-devel) weakremover(alacritty) weakremover(albert) weakremover(albumshaper) weakremover(alembic-devel) weakremover(alevt) weakremover(alevtd) weakremover(alex) weakremover(alkimia) weakremover(allegro) weakremover(allegro-dga2-plugin) weakremover(allegro-jack-plugin) weakremover(allegro-tools) weakremover(allegro44) weakremover(allegro44-dga2-plugin) weakremover(allegro44-jack-plugin) weakremover(allegro44-tools) weakremover(alligator) weakremover(almanah) weakremover(alpine) weakremover(alsa) weakremover(alsa-devel) weakremover(alsa-oss) weakremover(alsa-plugins) weakremover(alsa-plugins-a52) weakremover(alsa-plugins-aaf) weakremover(alsa-plugins-arcam-av) weakremover(alsa-plugins-jack) weakremover(alsa-plugins-lavcrate) weakremover(alsa-plugins-lavrate) weakremover(alsa-plugins-maemo) weakremover(alsa-plugins-oss) weakremover(alsa-plugins-pulse) weakremover(alsa-plugins-samplerate) weakremover(alsa-plugins-speex) weakremover(alsa-plugins-speexrate) weakremover(alsa-plugins-upmix) weakremover(alsa-plugins-usb-stream) weakremover(alsa-plugins-vdownmix) weakremover(alsa-topology-devel) weakremover(alsa-utils) weakremover(alsabat) weakremover(alsaequal) weakremover(alts) weakremover(alttab) weakremover(alure) weakremover(alure-devel) weakremover(amanda) weakremover(amarok) weakremover(amavisd-milter) weakremover(amazon-ecs-init) weakremover(amazon-ssm-agent) weakremover(amfora) weakremover(aml-devel) weakremover(amsynth) weakremover(amsynth-plugin-dssi) weakremover(amsynth-plugin-lv2) weakremover(amsynth-plugin-vst) weakremover(amtk-devel) weakremover(amtterm) weakremover(amtterm-gtk) weakremover(analitza) weakremover(analitza-devel) weakremover(analyzeMFT) weakremover(ancient) weakremover(ancient-devel) weakremover(android-file-transfer-linux) weakremover(android-tools) weakremover(android-tools-partition) weakremover(android-tools-python3) weakremover(angelfish) weakremover(angelscript) weakremover(angelscript-devel) weakremover(anjuta) weakremover(anjuta-devel) weakremover(anjuta-extras) weakremover(anjuta-extras-lang) weakremover(anki) weakremover(ansible-doc) weakremover(ansifilter) weakremover(ansifilter-gui) weakremover(ansilove) weakremover(ansilove-term) weakremover(ant-phone) weakremover(anthy) weakremover(anthy-devel) weakremover(antic-devel) weakremover(antimicro) weakremover(antimicrox) weakremover(antimicrox-devel) weakremover(antlr) weakremover(antlr-devel) weakremover(antlr-javadoc) weakremover(antlr3c-devel) weakremover(aom-tools) weakremover(aop) weakremover(apache-arrow) weakremover(apache-arrow-dataset-devel-static) weakremover(apache-arrow-devel) weakremover(apache-arrow-devel-static) weakremover(apache-commons-daemon) weakremover(apache-commons-daemon-jsvc) weakremover(apache-parquet-devel) weakremover(apache-parquet-devel-static) weakremover(apache-parquet-utils) weakremover(apache-plasma-devel) weakremover(apache-plasma-devel-static) weakremover(apache-plasma-server) weakremover(apache-rpm-macros) weakremover(apache-rpm-macros-control) weakremover(apache2) weakremover(apache2-devel) weakremover(apache2-event) weakremover(apache2-example-pages) weakremover(apache2-mod_apparmor) weakremover(apache2-mod_auth_gssapi) weakremover(apache2-mod_auth_kerb) weakremover(apache2-mod_auth_mellon) weakremover(apache2-mod_auth_mellon-diagnostics) weakremover(apache2-mod_auth_mellon-doc) weakremover(apache2-mod_auth_openidc) weakremover(apache2-mod_authn_otp) weakremover(apache2-mod_dnssd) weakremover(apache2-mod_encoding) weakremover(apache2-mod_evasive) weakremover(apache2-mod_fastcgi) weakremover(apache2-mod_fcgid) weakremover(apache2-mod_jk) weakremover(apache2-mod_maxminddb) weakremover(apache2-mod_mono) weakremover(apache2-mod_nss) weakremover(apache2-mod_perl) weakremover(apache2-mod_perl-devel) weakremover(apache2-mod_php5) weakremover(apache2-mod_php7) weakremover(apache2-mod_php8) weakremover(apache2-mod_python) weakremover(apache2-mod_scgi) weakremover(apache2-mod_security2) weakremover(apache2-mod_tidy) weakremover(apache2-mod_uwsgi) weakremover(apache2-mod_wsgi) weakremover(apache2-mod_wsgi-python3) weakremover(apache2-prefork) weakremover(apache2-utils) weakremover(apache2-worker) weakremover(apcupsd) weakremover(apcupsd-cgi) weakremover(apcupsd-gui) weakremover(apfel-devel) weakremover(apfel-doc) weakremover(apg) weakremover(apitrace) weakremover(apitrace-wrappers) weakremover(app-builder) weakremover(apparmor-parser) weakremover(appcenter) weakremover(appcenter-lang) weakremover(appeditor) weakremover(appimaged) weakremover(appindicator-sharp) weakremover(appindicator-sharp-devel) weakremover(applet-window-appmenu) weakremover(applet-window-buttons) weakremover(appmenu-gtk2-module) weakremover(appmenu-gtk3-module) weakremover(appmenu-qt) weakremover(appmenu-qt5) weakremover(appmenu-registrar) weakremover(appres) weakremover(appstream-glib) weakremover(appstream-glib-devel) weakremover(apptainer) weakremover(appx-util) weakremover(apr-devel) weakremover(apr-util-devel) weakremover(apt-cacher-ng) weakremover(apulse) weakremover(aqbanking) weakremover(aqbanking-devel) weakremover(aqbanking-doc) weakremover(aqbanking-ebics) weakremover(aqbanking-ofx) weakremover(aranym) weakremover(aravis) weakremover(aravis-viewer) weakremover(arb-devel) weakremover(arc) weakremover(archivemail) weakremover(archivemount) weakremover(archmage) weakremover(ardour) weakremover(argon2) weakremover(argon2-devel) weakremover(argus) weakremover(argus-client) weakremover(argus-server) weakremover(argyllcms) weakremover(argyllcms-doc) weakremover(aria2) weakremover(aria2-devel) weakremover(arianna) weakremover(arj) weakremover(ark) weakremover(arkade) weakremover(arm-ml-examples) weakremover(arm-trusted-firmware) weakremover(arm-trusted-firmware-tools) weakremover(armadillo-devel) weakremover(armagetron) weakremover(armnn) weakremover(armnn-devel) weakremover(armnn-extratests) weakremover(armnn-opencl) weakremover(armnn-opencl-devel) weakremover(armnn-opencl-extratests) weakremover(arp-scan) weakremover(arpack-ng-devel) weakremover(arping2) weakremover(arprec-devel) weakremover(arptables) weakremover(arpwatch) weakremover(arpwatch-ethercodes-build) weakremover(art-sharp2) weakremover(artha) weakremover(artikulate) weakremover(arts) weakremover(arts-devel) weakremover(arts-gmcop) weakremover(as10k1) weakremover(asciidiagram) weakremover(asclock) weakremover(asco) weakremover(aseprite) weakremover(aseqview) weakremover(asio-devel) weakremover(asl) weakremover(asl-doc) weakremover(asm) weakremover(asm-javadoc) weakremover(asm2) weakremover(asm2-examples) weakremover(asm2-javadoc) weakremover(asm3) weakremover(asm3-examples) weakremover(asm3-javadoc) weakremover(asm5) weakremover(asm5-examples) weakremover(asm5-javadoc) weakremover(asn1c) weakremover(aspell) weakremover(aspell-af) weakremover(aspell-agal) weakremover(aspell-am) weakremover(aspell-ar) weakremover(aspell-ast) weakremover(aspell-az) weakremover(aspell-be) weakremover(aspell-bg) weakremover(aspell-bn) weakremover(aspell-br) weakremover(aspell-ca) weakremover(aspell-cs) weakremover(aspell-csb) weakremover(aspell-cy) weakremover(aspell-da) weakremover(aspell-de) weakremover(aspell-devel) weakremover(aspell-el) weakremover(aspell-en) weakremover(aspell-eo) weakremover(aspell-es) weakremover(aspell-et) weakremover(aspell-fa) weakremover(aspell-fi) weakremover(aspell-fo) weakremover(aspell-fr) weakremover(aspell-fy) weakremover(aspell-ga) weakremover(aspell-gd) weakremover(aspell-gl) weakremover(aspell-grc) weakremover(aspell-gu) weakremover(aspell-gv) weakremover(aspell-he) weakremover(aspell-hi) weakremover(aspell-hil) weakremover(aspell-hr) weakremover(aspell-hsb) weakremover(aspell-hu) weakremover(aspell-hus) weakremover(aspell-hy) weakremover(aspell-ia) weakremover(aspell-id) weakremover(aspell-is) weakremover(aspell-ispell) weakremover(aspell-it) weakremover(aspell-kn) weakremover(aspell-ku) weakremover(aspell-ky) weakremover(aspell-la) weakremover(aspell-lt) weakremover(aspell-lv) weakremover(aspell-mg) weakremover(aspell-mi) weakremover(aspell-mk) weakremover(aspell-ml) weakremover(aspell-mn) weakremover(aspell-mr) weakremover(aspell-ms) weakremover(aspell-mt) weakremover(aspell-nb) weakremover(aspell-nds) weakremover(aspell-nl) weakremover(aspell-nn) weakremover(aspell-ny) weakremover(aspell-or) weakremover(aspell-pa) weakremover(aspell-pl) weakremover(aspell-pt_BR) weakremover(aspell-pt_PT) weakremover(aspell-qu) weakremover(aspell-ro) weakremover(aspell-ru) weakremover(aspell-rw) weakremover(aspell-sc) weakremover(aspell-sk) weakremover(aspell-sl) weakremover(aspell-spell) weakremover(aspell-sr) weakremover(aspell-sv) weakremover(aspell-sw) weakremover(aspell-ta) weakremover(aspell-te) weakremover(aspell-tet) weakremover(aspell-tk) weakremover(aspell-tl) weakremover(aspell-tn) weakremover(aspell-tr) weakremover(aspell-uk) weakremover(aspell-uz) weakremover(aspell-vi) weakremover(aspell-wa) weakremover(aspell-yi) weakremover(aspell-zu) weakremover(assimp-devel) weakremover(asteroid) weakremover(asteroids3D) weakremover(astyle) weakremover(asymptote) weakremover(at) weakremover(at-spi2-atk-common) weakremover(at-spi2-atk-devel) weakremover(at-spi2-atk-gtk2) weakremover(at-spi2-core) weakremover(at-spi2-core-devel) weakremover(atftp) weakremover(atheme) weakremover(atheme-devel) weakremover(atinout) weakremover(atk-devel) weakremover(atk-doc) weakremover(atk-lang) weakremover(atkmm-devel) weakremover(atkmm1_6-devel) weakremover(atkmm1_6-doc) weakremover(atlascpp-devel) weakremover(atomiks) weakremover(atomix) weakremover(atop) weakremover(atop-daemon) weakremover(atril) weakremover(atril-backends) weakremover(atril-devel) weakremover(atril-thumbnailer) weakremover(attica-qt5) weakremover(attica-qt5-devel) weakremover(attr) weakremover(attractmode) weakremover(atuin) weakremover(aubio-tools) weakremover(audacious) weakremover(audacious-devel) weakremover(audacious-plugins) weakremover(audacious-plugins-extra) weakremover(audacity) weakremover(audacity-plugins) weakremover(audaspace) weakremover(audaspace-devel) weakremover(audaspace-plugin-ffmpeg) weakremover(audaspace-plugin-jack) weakremover(audaspace-plugin-openal) weakremover(audaspace-plugin-pulse) weakremover(audaspace-plugin-sdl2) weakremover(audaspace-plugin-sndfile) weakremover(audaspace-plugins) weakremover(audex) weakremover(audex-lang) weakremover(audience) weakremover(audience-lang) weakremover(audio-recorder) weakremover(audiofile) weakremover(audiofile-devel) weakremover(audiofile-doc) weakremover(audit) weakremover(audit-audispd-plugins) weakremover(audit-devel) weakremover(audit-libs-python) weakremover(augeas) weakremover(augeas-devel) weakremover(augeas-lense-tests) weakremover(augeas-lenses) weakremover(authbind) weakremover(authselect) weakremover(authselect-compat) weakremover(authselect-lang) weakremover(autobench) weakremover(autobuild) weakremover(autocutsel) weakremover(autofdo) weakremover(autofs) weakremover(autogen) weakremover(automoc4) weakremover(autoopts) weakremover(autossh) weakremover(autotrace) weakremover(autotrace-devel) weakremover(avahi) weakremover(avahi-autoipd) weakremover(avahi-compat-howl-devel) weakremover(avahi-compat-mDNSResponder-devel) weakremover(avahi-mono) weakremover(avahi-utils) weakremover(avahi-utils-gtk) weakremover(avfs) weakremover(avfs-devel) weakremover(avgtime) weakremover(avif-tools) weakremover(avocado-vt-common) weakremover(avogadro) weakremover(avogadro-devel) weakremover(avogadrolibs) weakremover(avogadrolibs-devel) weakremover(avogadrolibs-plugins) weakremover(avrdude) weakremover(avrdude-devel) weakremover(awesfx) weakremover(awesome) weakremover(awf-gtk2) weakremover(awf-gtk3) weakremover(awf-gtk4) weakremover(awkward-devel) weakremover(aws-nitro-enclaves-binaryblobs-upstream) weakremover(aws-nitro-enclaves-cli) weakremover(aws-vpc-move-ip) weakremover(ax25-tools) weakremover(axel) weakremover(ayatana-appindicator-sharp) weakremover(ayatana-appindicator-sharp-devel) weakremover(ayatana-ido-devel) weakremover(azove) weakremover(azure-cli-acr) weakremover(azure-cli-acs) weakremover(azure-cli-advisor) weakremover(azure-cli-ams) weakremover(azure-cli-appservice) weakremover(azure-cli-backup) weakremover(azure-cli-batch) weakremover(azure-cli-batchai) weakremover(azure-cli-billing) weakremover(azure-cli-botservice) weakremover(azure-cli-cdn) weakremover(azure-cli-cloud) weakremover(azure-cli-cognitiveservices) weakremover(azure-cli-component) weakremover(azure-cli-configure) weakremover(azure-cli-consumption) weakremover(azure-cli-container) weakremover(azure-cli-cosmosdb) weakremover(azure-cli-deploymentmanager) weakremover(azure-cli-dla) weakremover(azure-cli-dls) weakremover(azure-cli-dms) weakremover(azure-cli-eventgrid) weakremover(azure-cli-eventhubs) weakremover(azure-cli-extension) weakremover(azure-cli-feedback) weakremover(azure-cli-find) weakremover(azure-cli-hdinsight) weakremover(azure-cli-interactive) weakremover(azure-cli-iot) weakremover(azure-cli-iotcentral) weakremover(azure-cli-keyvault) weakremover(azure-cli-kusto) weakremover(azure-cli-lab) weakremover(azure-cli-maps) weakremover(azure-cli-monitor) weakremover(azure-cli-natgateway) weakremover(azure-cli-network) weakremover(azure-cli-policyinsights) weakremover(azure-cli-privatedns) weakremover(azure-cli-profile) weakremover(azure-cli-rdbms) weakremover(azure-cli-redis) weakremover(azure-cli-relay) weakremover(azure-cli-reservations) weakremover(azure-cli-resource) weakremover(azure-cli-role) weakremover(azure-cli-search) weakremover(azure-cli-security) weakremover(azure-cli-servicebus) weakremover(azure-cli-servicefabric) weakremover(azure-cli-signalr) weakremover(azure-cli-sql) weakremover(azure-cli-sqlvm) weakremover(azure-cli-storage) weakremover(azure-cli-taskhelp) weakremover(azure-cli-test) weakremover(azure-cli-vm) weakremover(azure-storage-cpp-devel) weakremover(b43-fwcutter) weakremover(babe) weakremover(babeltrace) weakremover(babeltrace-devel) weakremover(babeltrace2) weakremover(babeltrace2-devel) weakremover(babl-devel) weakremover(backupninja) weakremover(backward-cpp) weakremover(baka-mplayer) weakremover(ballerburg) weakremover(baloo-core) weakremover(baloo-devel) weakremover(baloo-file) weakremover(baloo-kioslaves) weakremover(baloo-pim) weakremover(baloo-tools) weakremover(baloo5) weakremover(baloo5-devel) weakremover(baloo5-file) weakremover(baloo5-imports) weakremover(baloo5-imports-lang) weakremover(baloo5-kioslaves) weakremover(baloo5-lang) weakremover(baloo5-tools) weakremover(baloo5-widgets) weakremover(baloo5-widgets-devel) weakremover(balsa) weakremover(bam) weakremover(bamf-daemon) weakremover(bamf-devel) weakremover(baobab) weakremover(barbie_seahorse_adventures) weakremover(barcode) weakremover(barcode-devel) weakremover(bareftp) weakremover(baresip) weakremover(baresip-devel) weakremover(baresip-video) weakremover(barrel) weakremover(barrier) weakremover(barvinok) weakremover(barvinok-devel) weakremover(bash) weakremover(bash-devel) weakremover(bash-loadables) weakremover(bat) weakremover(batctl) weakremover(bazel) weakremover(bazel-gazelle) weakremover(bazel-gazelle-source) weakremover(bazel0.19) weakremover(bazel0.24) weakremover(bazel0.25) weakremover(bazel0.26) weakremover(bazel0.29) weakremover(bazel1.2) weakremover(bazel2.0) weakremover(bazel3.4) weakremover(bazel3.7) weakremover(bb) weakremover(bbe) weakremover(bc) weakremover(bcache-tools) weakremover(bcal) weakremover(bcc-devel) weakremover(bcc-tools) weakremover(bcftools) weakremover(bcg729-devel) weakremover(bchunk) weakremover(bcmatroska2-devel) weakremover(bctoolbox-devel) weakremover(bcunit-devel) weakremover(bcunit-doc) weakremover(bdfresize) weakremover(bdftopcf) weakremover(beaver) weakremover(bees) weakremover(beforelight) weakremover(belcard-devel) weakremover(belle-sip-devel) weakremover(belr-devel) weakremover(bemenu) weakremover(bemenu-devel) weakremover(benchdnn) weakremover(benchmark-devel) weakremover(benzene) weakremover(bestplugins) weakremover(bff) weakremover(bff4) weakremover(bgzip) weakremover(biblesync-devel) weakremover(bibletime) weakremover(biboumi) weakremover(bibtool) weakremover(bibtool-doc) weakremover(bibview) weakremover(bijiben) weakremover(bind) weakremover(bind-chrootenv) weakremover(bind-devel) weakremover(bind-libs) weakremover(bind-lwresd) weakremover(bind-modules-bdbhpt) weakremover(bind-modules-generic) weakremover(bind-modules-ldap) weakremover(bind-modules-mysql) weakremover(bind-modules-perl) weakremover(bind-modules-sqlite3) weakremover(bind-utils) weakremover(bindfs) weakremover(bing) weakremover(binutils) weakremover(binutils-devel) weakremover(binutils-gold) weakremover(bird) weakremover(bird-common) weakremover(bird-doc) weakremover(bird6) weakremover(birdie) weakremover(birdie-lang) weakremover(bison) weakremover(bitcoin-qt5) weakremover(bitcoin-test) weakremover(bitcoin-utils) weakremover(bitcoind) weakremover(bitlbee) weakremover(bitlbee-devel) weakremover(bitlbee-discord) weakremover(bitlbee-doc) weakremover(bitlbee-facebook) weakremover(bitlbee-mastodon) weakremover(bitlbee-steam) weakremover(bitmap) weakremover(bittwist) weakremover(bitwarden) weakremover(bitwise) weakremover(black-hole-solver) weakremover(black-hole-solver-devel) weakremover(blacs-devel-headers) weakremover(bladeRF) weakremover(bladeRF-devel) weakremover(bladeRF-udev) weakremover(blas-devel) weakremover(blas-devel-static) weakremover(blender) weakremover(bless) weakremover(bless-doc) weakremover(blinken) weakremover(bliss) weakremover(bliss-devel) weakremover(blitz-devel) weakremover(blktests) weakremover(blktrace) weakremover(bloaty) weakremover(blobAndConquer) weakremover(blobby) weakremover(blobwars) weakremover(blockout) weakremover(blog) weakremover(blog-devel) weakremover(blog-plymouth) weakremover(blogbench) weakremover(blogc) weakremover(blogilo5) weakremover(blosc-devel) weakremover(blosc2-devel) weakremover(blueberry) weakremover(blueberry-lang) weakremover(bluedevil5) weakremover(bluefish) weakremover(blueman) weakremover(bluemoon) weakremover(blueproximity) weakremover(blueproximity-lang) weakremover(bluetuith) weakremover(bluez) weakremover(bluez-cups) weakremover(bluez-deprecated) weakremover(bluez-devel) weakremover(bluez-firmware) weakremover(bluez-obexd) weakremover(bluez-qt-devel) weakremover(bluez-qt-imports) weakremover(bluez-qt-udev) weakremover(bluez-test) weakremover(bluez-tools) weakremover(bmake) weakremover(bmkdep) weakremover(bmon) weakremover(bogofilter-db) weakremover(bogofilter-kyotocabinet) weakremover(bogofilter-sqlite3) weakremover(boinc-client) weakremover(boinc-client-devel) weakremover(boinc-client-doc) weakremover(boinc-manager) weakremover(bolt) weakremover(bolt-tools) weakremover(bom) weakremover(bomber) weakremover(bomberclone) weakremover(bomns) weakremover(bonk) weakremover(bonnie) weakremover(bonnie++) weakremover(boo) weakremover(boo-2_0_9_3) weakremover(boo-devel) weakremover(bookworm) weakremover(boomaga) weakremover(boost-doc-html) weakremover(boost-doc-man) weakremover(boost-doc-pdf) weakremover(boost-gnu-mpich-hpc-python2) weakremover(boost-gnu-mvapich2-hpc-python2) weakremover(boost-gnu-openmpi2-hpc-python2) weakremover(boost-gnu-openmpi3-hpc-python2) weakremover(boost-license1_54_0) weakremover(boost-license1_56_0) weakremover(boost-license1_58_0) weakremover(boost-license1_59_0) weakremover(boost-license1_61_0) weakremover(boost-license1_66_0) weakremover(boost-license1_68_0) weakremover(boost-license1_69_0) weakremover(boost-license1_71_0) weakremover(boost-license1_74_0) weakremover(boost-license1_75_0) weakremover(boost-license1_76_0) weakremover(boost-license1_77_0) weakremover(boost-license1_78_0) weakremover(boost-license1_79_0) weakremover(boost-license1_80_0) weakremover(boost-license1_81_0) weakremover(boost1_69_0-doc-html) weakremover(boost1_69_0-doc-pdf) weakremover(boost1_69_0-jam) weakremover(boost1_69_0-quickbook) weakremover(boost1_71_0-doc-html) weakremover(boost1_71_0-doc-pdf) weakremover(boost1_71_0-jam) weakremover(boost1_71_0-quickbook) weakremover(boost1_74_0-doc-html) weakremover(boost1_74_0-doc-pdf) weakremover(boost1_74_0-jam) weakremover(boost1_74_0-quickbook) weakremover(boost1_75_0-doc-html) weakremover(boost1_75_0-doc-pdf) weakremover(boost1_75_0-jam) weakremover(boost1_75_0-quickbook) weakremover(boost1_76_0-doc-html) weakremover(boost1_76_0-doc-pdf) weakremover(boost1_76_0-jam) weakremover(boost1_76_0-quickbook) weakremover(boost1_77_0-doc-html) weakremover(boost1_77_0-doc-pdf) weakremover(boost1_77_0-jam) weakremover(boost1_77_0-quickbook) weakremover(boost1_78_0-doc-html) weakremover(boost1_78_0-doc-pdf) weakremover(boost1_78_0-jam) weakremover(boost1_78_0-quickbook) weakremover(boost1_79_0-doc-html) weakremover(boost1_79_0-doc-pdf) weakremover(boost1_79_0-jam) weakremover(boost1_79_0-quickbook) weakremover(boost1_80_0-doc-html) weakremover(boost1_80_0-doc-pdf) weakremover(boost1_80_0-jam) weakremover(boost1_80_0-quickbook) weakremover(boost1_81_0-doc-html) weakremover(boost1_81_0-doc-pdf) weakremover(boost1_81_0-jam) weakremover(boost1_81_0-quickbook) weakremover(boost1_82_0-jam) weakremover(boost1_82_0-quickbook) weakremover(boost_1_58_0-devel) weakremover(boost_1_58_0-doc-html) weakremover(boost_1_58_0-doc-pdf) weakremover(boost_1_61-devel) weakremover(boost_1_61-doc-html) weakremover(boost_1_61-doc-pdf) weakremover(boost_1_61-quickbook) weakremover(boost_1_66-doc-html) weakremover(boost_1_66-doc-pdf) weakremover(boost_1_66-jam) weakremover(boost_1_66-quickbook) weakremover(boost_1_68-doc-html) weakremover(boost_1_68-doc-pdf) weakremover(boost_1_68-jam) weakremover(boost_1_68-quickbook) weakremover(boost_1_69_0-gnu-hpc) weakremover(boost_1_69_0-gnu-hpc-devel) weakremover(boost_1_69_0-gnu-hpc-jam) weakremover(boost_1_69_0-gnu-mvapich2-hpc) weakremover(boost_1_69_0-gnu-mvapich2-hpc-devel) weakremover(boost_1_69_0-gnu-mvapich2-hpc-python2) weakremover(boost_1_69_0-gnu-mvapich2-hpc-python3) weakremover(boost_1_69_0-gnu-openmpi2-hpc) weakremover(boost_1_69_0-gnu-openmpi2-hpc-devel) weakremover(boost_1_69_0-gnu-openmpi2-hpc-python2) weakremover(boost_1_69_0-gnu-openmpi2-hpc-python3) weakremover(boost_1_71_0-gnu-hpc) weakremover(boost_1_71_0-gnu-hpc-devel) weakremover(boost_1_71_0-gnu-hpc-jam) weakremover(boost_1_71_0-gnu-mpich-hpc) weakremover(boost_1_71_0-gnu-mpich-hpc-devel) weakremover(boost_1_71_0-gnu-mpich-hpc-python2) weakremover(boost_1_71_0-gnu-mpich-hpc-python3) weakremover(boost_1_71_0-gnu-mvapich2-hpc) weakremover(boost_1_71_0-gnu-mvapich2-hpc-devel) weakremover(boost_1_71_0-gnu-mvapich2-hpc-python2) weakremover(boost_1_71_0-gnu-mvapich2-hpc-python3) weakremover(boost_1_71_0-gnu-openmpi2-hpc) weakremover(boost_1_71_0-gnu-openmpi2-hpc-devel) weakremover(boost_1_71_0-gnu-openmpi2-hpc-python2) weakremover(boost_1_71_0-gnu-openmpi2-hpc-python3) weakremover(boost_1_71_0-gnu-openmpi3-hpc) weakremover(boost_1_71_0-gnu-openmpi3-hpc-devel) weakremover(boost_1_71_0-gnu-openmpi3-hpc-python2) weakremover(boost_1_71_0-gnu-openmpi3-hpc-python3) weakremover(boost_1_74_0-gnu-hpc) weakremover(boost_1_74_0-gnu-hpc-devel) weakremover(boost_1_74_0-gnu-mpich-hpc) weakremover(boost_1_74_0-gnu-mpich-hpc-devel) weakremover(boost_1_74_0-gnu-mpich-hpc-python3) weakremover(boost_1_74_0-gnu-mvapich2-hpc) weakremover(boost_1_74_0-gnu-mvapich2-hpc-devel) weakremover(boost_1_74_0-gnu-mvapich2-hpc-python3) weakremover(boost_1_74_0-gnu-openmpi2-hpc) weakremover(boost_1_74_0-gnu-openmpi2-hpc-devel) weakremover(boost_1_74_0-gnu-openmpi2-hpc-python3) weakremover(boost_1_74_0-gnu-openmpi3-hpc) weakremover(boost_1_74_0-gnu-openmpi3-hpc-devel) weakremover(boost_1_74_0-gnu-openmpi3-hpc-python3) weakremover(boost_1_75_0-gnu-hpc) weakremover(boost_1_75_0-gnu-hpc-devel) weakremover(boost_1_75_0-gnu-mpich-hpc) weakremover(boost_1_75_0-gnu-mpich-hpc-devel) weakremover(boost_1_75_0-gnu-mpich-hpc-python3) weakremover(boost_1_75_0-gnu-mvapich2-hpc) weakremover(boost_1_75_0-gnu-mvapich2-hpc-devel) weakremover(boost_1_75_0-gnu-mvapich2-hpc-python3) weakremover(boost_1_75_0-gnu-openmpi2-hpc) weakremover(boost_1_75_0-gnu-openmpi2-hpc-devel) weakremover(boost_1_75_0-gnu-openmpi2-hpc-python3) weakremover(boost_1_75_0-gnu-openmpi3-hpc) weakremover(boost_1_75_0-gnu-openmpi3-hpc-devel) weakremover(boost_1_75_0-gnu-openmpi3-hpc-python3) weakremover(boost_1_75_0-gnu-openmpi4-hpc) weakremover(boost_1_75_0-gnu-openmpi4-hpc-devel) weakremover(boost_1_75_0-gnu-openmpi4-hpc-python3) weakremover(boost_1_76_0-gnu-hpc) weakremover(boost_1_76_0-gnu-hpc-devel) weakremover(boost_1_76_0-gnu-mpich-hpc) weakremover(boost_1_76_0-gnu-mpich-hpc-devel) weakremover(boost_1_76_0-gnu-mpich-hpc-python3) weakremover(boost_1_76_0-gnu-mvapich2-hpc) weakremover(boost_1_76_0-gnu-mvapich2-hpc-devel) weakremover(boost_1_76_0-gnu-mvapich2-hpc-python3) weakremover(boost_1_76_0-gnu-openmpi2-hpc) weakremover(boost_1_76_0-gnu-openmpi2-hpc-devel) weakremover(boost_1_76_0-gnu-openmpi2-hpc-python3) weakremover(boost_1_76_0-gnu-openmpi3-hpc) weakremover(boost_1_76_0-gnu-openmpi3-hpc-devel) weakremover(boost_1_76_0-gnu-openmpi3-hpc-python3) weakremover(boost_1_76_0-gnu-openmpi4-hpc) weakremover(boost_1_76_0-gnu-openmpi4-hpc-devel) weakremover(boost_1_76_0-gnu-openmpi4-hpc-python3) weakremover(boost_1_77_0-gnu-hpc) weakremover(boost_1_77_0-gnu-hpc-devel) weakremover(boost_1_77_0-gnu-mpich-hpc) weakremover(boost_1_77_0-gnu-mpich-hpc-devel) weakremover(boost_1_77_0-gnu-mpich-hpc-python3) weakremover(boost_1_77_0-gnu-mvapich2-hpc) weakremover(boost_1_77_0-gnu-mvapich2-hpc-devel) weakremover(boost_1_77_0-gnu-mvapich2-hpc-python3) weakremover(boost_1_77_0-gnu-openmpi2-hpc) weakremover(boost_1_77_0-gnu-openmpi2-hpc-devel) weakremover(boost_1_77_0-gnu-openmpi2-hpc-python3) weakremover(boost_1_77_0-gnu-openmpi3-hpc) weakremover(boost_1_77_0-gnu-openmpi3-hpc-devel) weakremover(boost_1_77_0-gnu-openmpi3-hpc-python3) weakremover(boost_1_77_0-gnu-openmpi4-hpc) weakremover(boost_1_77_0-gnu-openmpi4-hpc-devel) weakremover(boost_1_77_0-gnu-openmpi4-hpc-python3) weakremover(boost_1_78_0-gnu-hpc) weakremover(boost_1_78_0-gnu-hpc-devel) weakremover(boost_1_78_0-gnu-mpich-hpc) weakremover(boost_1_78_0-gnu-mpich-hpc-devel) weakremover(boost_1_78_0-gnu-mpich-hpc-python3) weakremover(boost_1_78_0-gnu-mvapich2-hpc) weakremover(boost_1_78_0-gnu-mvapich2-hpc-devel) weakremover(boost_1_78_0-gnu-mvapich2-hpc-python3) weakremover(boost_1_78_0-gnu-openmpi2-hpc) weakremover(boost_1_78_0-gnu-openmpi2-hpc-devel) weakremover(boost_1_78_0-gnu-openmpi2-hpc-python3) weakremover(boost_1_78_0-gnu-openmpi3-hpc) weakremover(boost_1_78_0-gnu-openmpi3-hpc-devel) weakremover(boost_1_78_0-gnu-openmpi3-hpc-python3) weakremover(boost_1_78_0-gnu-openmpi4-hpc) weakremover(boost_1_78_0-gnu-openmpi4-hpc-devel) weakremover(boost_1_78_0-gnu-openmpi4-hpc-python3) weakremover(boost_1_79_0-gnu-hpc) weakremover(boost_1_79_0-gnu-hpc-devel) weakremover(boost_1_79_0-gnu-mpich-hpc) weakremover(boost_1_79_0-gnu-mpich-hpc-devel) weakremover(boost_1_79_0-gnu-mpich-hpc-python3) weakremover(boost_1_79_0-gnu-mvapich2-hpc) weakremover(boost_1_79_0-gnu-mvapich2-hpc-devel) weakremover(boost_1_79_0-gnu-mvapich2-hpc-python3) weakremover(boost_1_79_0-gnu-openmpi2-hpc) weakremover(boost_1_79_0-gnu-openmpi2-hpc-devel) weakremover(boost_1_79_0-gnu-openmpi2-hpc-python3) weakremover(boost_1_79_0-gnu-openmpi3-hpc) weakremover(boost_1_79_0-gnu-openmpi3-hpc-devel) weakremover(boost_1_79_0-gnu-openmpi3-hpc-python3) weakremover(boost_1_79_0-gnu-openmpi4-hpc) weakremover(boost_1_79_0-gnu-openmpi4-hpc-devel) weakremover(boost_1_79_0-gnu-openmpi4-hpc-python3) weakremover(boost_1_80_0-gnu-hpc) weakremover(boost_1_80_0-gnu-hpc-devel) weakremover(boost_1_80_0-gnu-mpich-hpc) weakremover(boost_1_80_0-gnu-mpich-hpc-devel) weakremover(boost_1_80_0-gnu-mpich-hpc-python3) weakremover(boost_1_80_0-gnu-mvapich2-hpc) weakremover(boost_1_80_0-gnu-mvapich2-hpc-devel) weakremover(boost_1_80_0-gnu-mvapich2-hpc-python3) weakremover(boost_1_80_0-gnu-openmpi2-hpc) weakremover(boost_1_80_0-gnu-openmpi2-hpc-devel) weakremover(boost_1_80_0-gnu-openmpi2-hpc-python3) weakremover(boost_1_80_0-gnu-openmpi3-hpc) weakremover(boost_1_80_0-gnu-openmpi3-hpc-devel) weakremover(boost_1_80_0-gnu-openmpi3-hpc-python3) weakremover(boost_1_80_0-gnu-openmpi4-hpc) weakremover(boost_1_80_0-gnu-openmpi4-hpc-devel) weakremover(boost_1_80_0-gnu-openmpi4-hpc-python3) weakremover(boost_1_81_0-gnu-hpc) weakremover(boost_1_81_0-gnu-hpc-devel) weakremover(boost_1_81_0-gnu-mpich-hpc) weakremover(boost_1_81_0-gnu-mpich-hpc-devel) weakremover(boost_1_81_0-gnu-mpich-hpc-python3) weakremover(boost_1_81_0-gnu-mvapich2-hpc) weakremover(boost_1_81_0-gnu-mvapich2-hpc-devel) weakremover(boost_1_81_0-gnu-mvapich2-hpc-python3) weakremover(boost_1_81_0-gnu-openmpi2-hpc) weakremover(boost_1_81_0-gnu-openmpi2-hpc-devel) weakremover(boost_1_81_0-gnu-openmpi2-hpc-python3) weakremover(boost_1_81_0-gnu-openmpi3-hpc) weakremover(boost_1_81_0-gnu-openmpi3-hpc-devel) weakremover(boost_1_81_0-gnu-openmpi3-hpc-python3) weakremover(boost_1_81_0-gnu-openmpi4-hpc) weakremover(boost_1_81_0-gnu-openmpi4-hpc-devel) weakremover(boost_1_81_0-gnu-openmpi4-hpc-python3) weakremover(boost_1_82_0-gnu-hpc) weakremover(boost_1_82_0-gnu-hpc-devel) weakremover(boost_1_82_0-gnu-mpich-hpc) weakremover(boost_1_82_0-gnu-mpich-hpc-devel) weakremover(boost_1_82_0-gnu-mpich-hpc-python3) weakremover(boost_1_82_0-gnu-mvapich2-hpc) weakremover(boost_1_82_0-gnu-mvapich2-hpc-devel) weakremover(boost_1_82_0-gnu-mvapich2-hpc-python3) weakremover(boost_1_82_0-gnu-openmpi2-hpc) weakremover(boost_1_82_0-gnu-openmpi2-hpc-devel) weakremover(boost_1_82_0-gnu-openmpi2-hpc-python3) weakremover(boost_1_82_0-gnu-openmpi3-hpc) weakremover(boost_1_82_0-gnu-openmpi3-hpc-devel) weakremover(boost_1_82_0-gnu-openmpi3-hpc-python3) weakremover(boost_1_82_0-gnu-openmpi4-hpc) weakremover(boost_1_82_0-gnu-openmpi4-hpc-devel) weakremover(boost_1_82_0-gnu-openmpi4-hpc-python3) weakremover(bootchart) weakremover(bootcycle) weakremover(booth) weakremover(booth-test) weakremover(bootp-DD2) weakremover(borgbackup) weakremover(boringssl-devel) weakremover(bosh) weakremover(bottom) weakremover(bovo) weakremover(bowtie) weakremover(bowtie2) weakremover(boxfort) weakremover(boxfort-devel) weakremover(bpfmon) weakremover(bpftool) weakremover(bpftool-bash-completion) weakremover(bpftool-rebuild) weakremover(bpftrace) weakremover(bpm-tools) weakremover(bpython) weakremover(bpython-doc) weakremover(brasero) weakremover(brasero-devel) weakremover(brasero-nautilus) weakremover(breeze) weakremover(breeze4-style) weakremover(breeze5-decoration) weakremover(breeze5-style) weakremover(breezy) weakremover(brevity) weakremover(brial-devel) weakremover(brickd) weakremover(bridge-utils) weakremover(bridge-utils-devel) weakremover(brightnessctl) weakremover(brisk-menu) weakremover(brlapi-devel) weakremover(brlapi-java) weakremover(brlemu) weakremover(brltty) weakremover(brltty-driver-at-spi2) weakremover(brltty-driver-brlapi) weakremover(brltty-driver-espeak) weakremover(brltty-driver-libbraille) weakremover(brltty-driver-speech-dispatcher) weakremover(brltty-driver-xwindow) weakremover(brltty-udev-generic) weakremover(brltty-utils) weakremover(broadvoice16) weakremover(broadvoice16-devel) weakremover(broadvoice32) weakremover(broadvoice32-devel) weakremover(broot) weakremover(brotli) weakremover(browserpass-native) weakremover(brp-check-suse) weakremover(brp-extract-appdata) weakremover(brp-trim-desktopfiles) weakremover(bs) weakremover(bs1770gain) weakremover(bs2b-tools) weakremover(bsd-games) weakremover(bsdiff) weakremover(bsdtar) weakremover(bsh) weakremover(bsh-demo) weakremover(bsh-javadoc) weakremover(bsh-manual) weakremover(bsh2-src) weakremover(bspwm) weakremover(bssl_wrapper-devel) weakremover(bstone) weakremover(btar) weakremover(btcflash) weakremover(btfs) weakremover(btop) weakremover(btrfs-extent-same) weakremover(btrfsprogs) weakremover(btrfsprogs-bash-completion) weakremover(btrfsprogs-static) weakremover(bubblewrap) weakremover(bubblewrap-zsh-completion) weakremover(bucklespring) weakremover(buckygen) weakremover(budgie-app-launcher-applet) weakremover(budgie-applications-menu-applet) weakremover(budgie-appmenu-applet) weakremover(budgie-brightness-controller-applet) weakremover(budgie-calendar-applet) weakremover(budgie-clockworks-applet) weakremover(budgie-control-center) weakremover(budgie-control-center-bash-completion) weakremover(budgie-control-center-devel) weakremover(budgie-countdown-applet) weakremover(budgie-desktop) weakremover(budgie-desktop-devel) weakremover(budgie-desktop-doc) weakremover(budgie-desktop-docs) weakremover(budgie-desktop-view) weakremover(budgie-dropby-applet) weakremover(budgie-extras) weakremover(budgie-extras-daemon) weakremover(budgie-fuzzyclock-applet) weakremover(budgie-haste-applet) weakremover(budgie-hotcorners-applet) weakremover(budgie-kangaroo-applet) weakremover(budgie-keyboard-autoswitch-applet) weakremover(budgie-network-manager-applet) weakremover(budgie-previews) weakremover(budgie-quickchar) weakremover(budgie-quicknote-applet) weakremover(budgie-recentlyused-applet) weakremover(budgie-rotation-lock-applet) weakremover(budgie-screensaver) weakremover(budgie-screenshot-applet) weakremover(budgie-showtime-applet) weakremover(budgie-takeabreak-applet) weakremover(budgie-trash-applet) weakremover(budgie-visualspace-applet) weakremover(budgie-wallstreet) weakremover(budgie-weathershow-applet) weakremover(budgie-window-mover-applet) weakremover(budgie-window-shuffler) weakremover(budgie-workspace-overview-applet) weakremover(budgie-workspace-stopwatch-applet) weakremover(budgie-workspace-wallpaper-applet) weakremover(buffer) weakremover(bugreporter) weakremover(build-initvm-armv7hl) weakremover(build-initvm-powerpc64le) weakremover(buildah) weakremover(buildkit) weakremover(bulk_extractor) weakremover(bumblebee) weakremover(bumblebee-status) weakremover(bumblebee-status-module-deadbeef) weakremover(bumblebee-status-module-hddtemp) weakremover(bup) weakremover(bustle) weakremover(busybox) weakremover(busybox-container) weakremover(busybox-static) weakremover(busybox-testsuite) weakremover(busybox-warewulf3) weakremover(butane) weakremover(buzztrax) weakremover(buzztrax-lang) weakremover(buzztrax-plugins) weakremover(bvi) weakremover(bwbar) weakremover(bwm-ng) weakremover(byacc) weakremover(byaccj) weakremover(byzanz) weakremover(bzflag) weakremover(bzip2) weakremover(bzip3) weakremover(bzip3-devel) weakremover(bzr) weakremover(bzr-lang) weakremover(bzr-test) weakremover(bzrtp-devel) weakremover(c-ares-devel) weakremover(c-ares-utils) weakremover(c-dvar-devel) weakremover(c-list-devel) weakremover(c-rbtree-devel) weakremover(c-sundry-devel) weakremover(c-toxcore) weakremover(c-toxcore-daemon) weakremover(c-toxcore-devel) weakremover(c2hs) weakremover(cJSON-devel) weakremover(c_count) weakremover(caasp-cli) weakremover(caasp-container-manifests) weakremover(caasp-dex) weakremover(caasp-tools) weakremover(cab) weakremover(cabal-install) weakremover(cabal-install-bash-completion) weakremover(cabal-plan) weakremover(cabal-rpm) weakremover(cabal2spec) weakremover(cabextract) weakremover(caca-utils) weakremover(cachefilesd) weakremover(cacti-doc) weakremover(cacti-spine) weakremover(cadabra2) weakremover(cadabra2-doc) weakremover(cadabra2-examples) weakremover(cadabra2-gui) weakremover(cadaver) weakremover(caddy) weakremover(cadvisor) weakremover(caffe) weakremover(caffe-devel) weakremover(caffe-examples) weakremover(caffe-gnu-hpc) weakremover(caffe-gnu-hpc-devel) weakremover(caffe-gnu-hpc-examples) weakremover(caffe_1_0-gnu-hpc) weakremover(caffe_1_0-gnu-hpc-devel) weakremover(caffe_1_0-gnu-hpc-examples) weakremover(cage) weakremover(cairo-clock) weakremover(cairo-devel) weakremover(cairo-tools) weakremover(cairomm-devel) weakremover(cairomm-doc) weakremover(cairomm1_0-devel) weakremover(cairomm1_0-doc) weakremover(caja) weakremover(caja-devel) weakremover(caja-engrampa) weakremover(caja-extension-actions) weakremover(caja-extension-actions-devel) weakremover(caja-extension-actions-doc) weakremover(caja-extension-actions-lang) weakremover(caja-extension-atril) weakremover(caja-extension-dropbox) weakremover(caja-extension-eiciel) weakremover(caja-extension-gksu) weakremover(caja-extension-image-converter) weakremover(caja-extension-nitroshare) weakremover(caja-extension-open-terminal) weakremover(caja-extension-sendto) weakremover(caja-extension-sendto-devel) weakremover(caja-extension-sendto-gajim) weakremover(caja-extension-sendto-pidgin) weakremover(caja-extension-sendto-upnp) weakremover(caja-extension-share) weakremover(caja-extension-wallpaper) weakremover(caja-extension-xattr-tags) weakremover(caja-extension-xreader) weakremover(caja-gschemas) weakremover(cal3d) weakremover(cal3d-devel) weakremover(cal3d-doc) weakremover(calamares) weakremover(calamares-webview) weakremover(calc) weakremover(calc-devel) weakremover(calcium-devel) weakremover(calcurse) weakremover(calendarsupport) weakremover(calendarsupport-devel) weakremover(calendarsupport-lang) weakremover(calibre) weakremover(calindori) weakremover(callaudiod) weakremover(callaudiod-devel) weakremover(calligra) weakremover(calligra-active) weakremover(calligra-author) weakremover(calligra-braindump) weakremover(calligra-devel) weakremover(calligra-extras-converter) weakremover(calligra-extras-dolphin) weakremover(calligra-extras-filemanagertemplates) weakremover(calligra-extras-okular) weakremover(calligra-flow) weakremover(calligra-gemini) weakremover(calligra-karbon) weakremover(calligra-kexi) weakremover(calligra-kexi-mssql-driver) weakremover(calligra-kexi-mysql-driver) weakremover(calligra-kexi-postgresql-driver) weakremover(calligra-kexi-spreadsheet-import) weakremover(calligra-kexi-sqlite3-driver) weakremover(calligra-kexi-xbase-driver) weakremover(calligra-krita) weakremover(calligra-l10n-bs) weakremover(calligra-l10n-ca) weakremover(calligra-l10n-ca-doc) weakremover(calligra-l10n-caValencia) weakremover(calligra-l10n-cs) weakremover(calligra-l10n-da) weakremover(calligra-l10n-de) weakremover(calligra-l10n-de-doc) weakremover(calligra-l10n-el) weakremover(calligra-l10n-en_GB) weakremover(calligra-l10n-es) weakremover(calligra-l10n-es-doc) weakremover(calligra-l10n-et) weakremover(calligra-l10n-et-doc) weakremover(calligra-l10n-fi) weakremover(calligra-l10n-fr) weakremover(calligra-l10n-fr-doc) weakremover(calligra-l10n-gl) weakremover(calligra-l10n-hu) weakremover(calligra-l10n-it) weakremover(calligra-l10n-it-doc) weakremover(calligra-l10n-ja) weakremover(calligra-l10n-kk) weakremover(calligra-l10n-nb) weakremover(calligra-l10n-nl) weakremover(calligra-l10n-nl-doc) weakremover(calligra-l10n-pl) weakremover(calligra-l10n-pt) weakremover(calligra-l10n-pt-doc) weakremover(calligra-l10n-pt_BR) weakremover(calligra-l10n-pt_BR-doc) weakremover(calligra-l10n-ru) weakremover(calligra-l10n-ru-doc) weakremover(calligra-l10n-sk) weakremover(calligra-l10n-sv) weakremover(calligra-l10n-sv-doc) weakremover(calligra-l10n-tr) weakremover(calligra-l10n-uk) weakremover(calligra-l10n-uk-doc) weakremover(calligra-l10n-zh_CN) weakremover(calligra-l10n-zh_TW) weakremover(calligra-lang) weakremover(calligra-plan) weakremover(calligra-sheets) weakremover(calligra-stage) weakremover(calligra-tools) weakremover(calligra-words) weakremover(calligra-words-common) weakremover(calls) weakremover(calls-ofono) weakremover(camlistore-daemon) weakremover(camlistore-utils) weakremover(camsource) weakremover(camsource-devel) weakremover(canberra-gtk-play) weakremover(canberra-gtk-play-gnome) weakremover(canlock) weakremover(canna) weakremover(canna-devel) weakremover(canna-libs) weakremover(canna-yubin) weakremover(cannadic) weakremover(cantata) weakremover(cantor) weakremover(cantor-devel) weakremover(canutils) weakremover(canutils-linuxcan) weakremover(canutils-pengutronix) weakremover(capi4hylafax) weakremover(capi4linux) weakremover(capi4linux-devel) weakremover(capnet-assist) weakremover(capnproto) weakremover(capstone) weakremover(cardpeek) weakremover(cargo) weakremover(cargo-audit) weakremover(cargo-audit-advisory-db) weakremover(cargo-auditable) weakremover(cargo-c) weakremover(cargo-doc) weakremover(cargo-packaging) weakremover(cargo-vendor) weakremover(cargo1.53) weakremover(cargo1.53-doc) weakremover(cargo1.54) weakremover(cargo1.54-doc) weakremover(cargo1.55) weakremover(cargo1.55-doc) weakremover(cargo1.56) weakremover(cargo1.57) weakremover(cargo1.58) weakremover(cargo1.59) weakremover(cargo1.60) weakremover(cargo1.61) weakremover(cargo1.62) weakremover(cargo1.63) weakremover(cargo1.64) weakremover(cargo1.65) weakremover(cargo1.66) weakremover(cargo1.67) weakremover(cargo1.68) weakremover(cargo1.69) weakremover(caribou) weakremover(caribou-common) weakremover(caribou-devel) weakremover(caribou-gtk-module-common) weakremover(caribou-gtk2-module) weakremover(caribou-gtk3-module) weakremover(casacore) weakremover(casacore-devel) weakremover(casacore-openmpi1) weakremover(casacore-openmpi1-devel) weakremover(casacore-openmpi2) weakremover(casacore-openmpi2-devel) weakremover(casacore-openmpi3) weakremover(casacore-openmpi3-devel) weakremover(casacore-openmpi4) weakremover(casacore-openmpi4-devel) weakremover(casarest) weakremover(casarest-devel) weakremover(casarest-libs) weakremover(castor) weakremover(castor-demo) weakremover(castor-doc) weakremover(castor-test) weakremover(castor-xml) weakremover(casync) weakremover(catatonit) weakremover(catcodec) weakremover(catdoc) weakremover(catimg) weakremover(cava) weakremover(cblas-devel) weakremover(cblas-devel-static) weakremover(cbonsai) weakremover(cc-tool) weakremover(ccache) weakremover(ccaudio2) weakremover(ccaudio2-devel) weakremover(ccaudio2-doc) weakremover(ccd2cue) weakremover(ccgfs) weakremover(ccls) weakremover(ccrtp-devel) weakremover(ccrypt) weakremover(ccrypt-emacs) weakremover(ccrypt-lang) weakremover(ccscript3-devel) weakremover(ccscript3-modules) weakremover(ccx) weakremover(ccze) weakremover(ccze-devel) weakremover(cd-discid) weakremover(cd-paranoia) weakremover(cdda2wav) weakremover(cddlib-devel) weakremover(cddlib-tools) weakremover(cdecl) weakremover(cdemu-daemon) weakremover(cdio-utils) weakremover(cdk-devel) weakremover(cdogs-sdl) weakremover(cdparanoia) weakremover(cdparanoia-devel) weakremover(cdrdao) weakremover(cdrecord) weakremover(cdrkit-cdrtools-compat) weakremover(cdrkit-devel-static) weakremover(cdrskin) weakremover(cdrtools) weakremover(cec-client) weakremover(ceferino) weakremover(cegui-demos-devel) weakremover(cegui-devel) weakremover(celluloid) weakremover(cellwriter) weakremover(celt) weakremover(celt051) weakremover(celt051-devel) weakremover(ceph) weakremover(ceph-base) weakremover(ceph-common) weakremover(ceph-csi) weakremover(ceph-dashboard-e2e) weakremover(ceph-deploy) weakremover(ceph-fuse) weakremover(ceph-immutable-object-cache) weakremover(ceph-iscsi) weakremover(ceph-mds) weakremover(ceph-mgr) weakremover(ceph-mgr-diskprediction-cloud) weakremover(ceph-mgr-ssh) weakremover(ceph-mon) weakremover(ceph-osd) weakremover(ceph-radosgw) weakremover(ceph-resource-agents) weakremover(ceph-test) weakremover(cephfs-mirror) weakremover(cephfs-shell) weakremover(cerbere) weakremover(cereal-devel) weakremover(cert-manager) weakremover(cert-manager-cainjector) weakremover(cert-manager-controller) weakremover(cert-manager-webhook) weakremover(certbot-doc) weakremover(certmonger) weakremover(certstrap) weakremover(cervisia) weakremover(cetcd-devel) weakremover(cf-cli) weakremover(cf-cli-test) weakremover(cfengine) weakremover(cfengine-doc) weakremover(cfitsio) weakremover(cfitsio-devel) weakremover(cfitsio-devel-doc) weakremover(cfityk) weakremover(cflow) weakremover(cfssl) weakremover(cg3) weakremover(cg3-devel) weakremover(cgal-devel) weakremover(cgdb) weakremover(cgdcbxd) weakremover(cgit) weakremover(cglm-devel) weakremover(cgns) weakremover(cgns-devel) weakremover(cgns-devel-static) weakremover(ch341eepromtool) weakremover(chafa) weakremover(chafa-devel) weakremover(chameleon) weakremover(charliecloud) weakremover(chart-testing) weakremover(chartmuseum) weakremover(charybdis) weakremover(chasen) weakremover(chasen-devel) weakremover(chck-devel) weakremover(chealpix-devel) weakremover(cheat) weakremover(check-devel) weakremover(checkmedia) weakremover(checkpolicy) weakremover(cheese) weakremover(cheese-devel) weakremover(cherrytree) weakremover(chessx) weakremover(chewing-data) weakremover(chewing-utils) weakremover(chezdav) weakremover(chezmoi) weakremover(chkstat) weakremover(chmlib-devel) weakremover(chmlib-examples) weakremover(chntpw) weakremover(chocolate-doom) weakremover(choose) weakremover(choqok) weakremover(choqok-devel) weakremover(chromaprint-fpcalc) weakremover(chrome-gnome-shell) weakremover(chrome-uget-integrator) weakremover(chromedriver) weakremover(chromium) weakremover(chromium-bsu) weakremover(chromium-uget-integrator) weakremover(chrony) weakremover(chrpath) weakremover(ciano) weakremover(cifs-utils) weakremover(cifs-utils-devel) weakremover(cil) weakremover(cilium) weakremover(cilium-cli) weakremover(cilium-cni) weakremover(cilium-devel) weakremover(cilium-docker) weakremover(cilium-etcd-operator) weakremover(cilium-init) weakremover(cilium-k8s-yaml) weakremover(cilium-microscope) weakremover(cilium-operator) weakremover(cilium-proxy) weakremover(cimple) weakremover(cimple-cmpi-adapter) weakremover(cimple-devel) weakremover(cimple-pegasus-adapter) weakremover(cinema) weakremover(cinnamon) weakremover(cinnamon-control-center) weakremover(cinnamon-control-center-devel) weakremover(cinnamon-devel-doc) weakremover(cinnamon-gschemas) weakremover(cinnamon-screensaver) weakremover(cinnamon-session) weakremover(cinnamon-settings-daemon) weakremover(cinnamon-settings-daemon-devel) weakremover(cinnamon-theme-plata) weakremover(cint-devel) weakremover(circuslinux) weakremover(civetweb) weakremover(civetweb-devel) weakremover(cjs) weakremover(cjs-devel) weakremover(cjs-tests) weakremover(ck-devel) weakremover(ckb-next) weakremover(ckermit) weakremover(clFFT) weakremover(clFFT-devel) weakremover(clack) weakremover(clamav) weakremover(clamav-database) weakremover(clamav-devel) weakremover(clamav-milter) weakremover(clamav-nodb) weakremover(clamz) weakremover(clang) weakremover(clang-checker) weakremover(clang-devel) weakremover(clang-doc) weakremover(clang-tools) weakremover(clang10) weakremover(clang10-devel) weakremover(clang10-doc) weakremover(clang11) weakremover(clang11-devel) weakremover(clang12) weakremover(clang12-devel) weakremover(clang13) weakremover(clang13-devel) weakremover(clang14) weakremover(clang14-devel) weakremover(clang15) weakremover(clang15-devel) weakremover(clang16) weakremover(clang16-devel) weakremover(clang4) weakremover(clang4-checker) weakremover(clang4-devel) weakremover(clang5) weakremover(clang5-checker) weakremover(clang5-devel) weakremover(clang6) weakremover(clang6-checker) weakremover(clang6-devel) weakremover(clang7) weakremover(clang7-checker) weakremover(clang7-devel) weakremover(clang8) weakremover(clang8-checker) weakremover(clang8-devel) weakremover(clang9) weakremover(clang9-checker) weakremover(clang9-devel) weakremover(clang9-doc) weakremover(clanlib) weakremover(clanlib-devel) weakremover(clap-lsp-plugins) weakremover(clapper) weakremover(clapper-devel) weakremover(clash) weakremover(classpathx-mail) weakremover(classpathx-mail-javadoc) weakremover(classworlds-javadoc) weakremover(claws-mail) weakremover(claws-mail-devel) weakremover(clazy) weakremover(cld2-devel) weakremover(clementine) weakremover(clevis) weakremover(clevis-bash-completion) weakremover(clevis-dracut) weakremover(clevis-luks) weakremover(clevis-systemd) weakremover(clevis-udisks2) weakremover(clicfs) weakremover(clinfo) weakremover(clingo) weakremover(clingo-devel) weakremover(clipboard) weakremover(clipgrab) weakremover(clipit) weakremover(clipman) weakremover(clipped) weakremover(clippy) weakremover(cliquer) weakremover(cliquer-devel) weakremover(clisp) weakremover(cln) weakremover(cln-devel) weakremover(cloog-isl) weakremover(cloog-isl-devel) weakremover(cloud-init) weakremover(cloud-init-config-suse) weakremover(cloud-init-doc) weakremover(cloud-init-test) weakremover(cloud-init-vmware-guestinfo) weakremover(clpeak) weakremover(clthreads-devel) weakremover(clucene-core-devel) weakremover(clustduct) weakremover(cluster-glue) weakremover(cluster-glue-devel) weakremover(cluster-glue-libs) weakremover(clutter-devel) weakremover(clutter-gst-devel) weakremover(clutter-gst2-devel) weakremover(clutter-gtk-devel) weakremover(clxclient-devel) weakremover(clzip) weakremover(cm) weakremover(cm-devel) weakremover(cmake) weakremover(cmake-doc-qhelp) weakremover(cmake-full) weakremover(cmake-gui) weakremover(cmake-man) weakremover(cmake-mini) weakremover(cmark) weakremover(cmark-devel) weakremover(cmctl) weakremover(cmh) weakremover(cmh-devel) weakremover(cmis-client) weakremover(cmpi-bindings-perl) weakremover(cmpi-bindings-py3wbem) weakremover(cmpi-bindings-pywbem) weakremover(cmpi-bindings-ruby) weakremover(cmpi-bindings-ruby-doc) weakremover(cmpi-pywbem-base) weakremover(cmpi-pywbem-power-management) weakremover(cmpi-pywbem-software) weakremover(cmuclmtk) weakremover(cmus) weakremover(cmus-plugin-cdio) weakremover(cmus-plugin-cue) weakremover(cmus-plugin-ffmpeg) weakremover(cmus-plugin-flac) weakremover(cmus-plugin-jack) weakremover(cmus-plugin-libao) weakremover(cmus-plugin-mikmod) weakremover(cmus-plugin-modplug) weakremover(cmus-plugin-mpc) weakremover(cmus-plugin-opus) weakremover(cmus-plugin-pulse) weakremover(cmus-plugin-sndio) weakremover(cmus-plugin-vorbis) weakremover(cmus-plugin-wavpack) weakremover(cmus-plugins-all) weakremover(cni) weakremover(cni-plugin-dnsname) weakremover(cni-plugin-flannel) weakremover(cni-plugins) weakremover(cntlm) weakremover(cobbler-web) weakremover(coccinelle) weakremover(cockpit) weakremover(cockpit-bridge) weakremover(cockpit-d-installer) weakremover(cockpit-devel) weakremover(cockpit-docker) weakremover(cockpit-pcp) weakremover(cockpit-suse-theme) weakremover(cockpit-tests) weakremover(cockpit-ws) weakremover(codec2) weakremover(codec2-devel) weakremover(codelite) weakremover(codenarc) weakremover(codenarc-javadoc) weakremover(cogl-devel) weakremover(coin-or-Cbc) weakremover(coin-or-Cbc-devel) weakremover(coin-or-Cgl-devel) weakremover(coin-or-Clp) weakremover(coin-or-Clp-devel) weakremover(coin-or-CoinUtils-devel) weakremover(coin-or-Osi-devel) weakremover(colcmp) weakremover(collectd) weakremover(collectd-plugin-amqp) weakremover(collectd-plugin-buddyinfo) weakremover(collectd-plugin-connectivity) weakremover(collectd-plugin-dbi) weakremover(collectd-plugin-dpdk) weakremover(collectd-plugin-gps) weakremover(collectd-plugin-ipmi) weakremover(collectd-plugin-java) weakremover(collectd-plugin-logparser) weakremover(collectd-plugin-lua) weakremover(collectd-plugin-lvm) weakremover(collectd-plugin-mcelog) weakremover(collectd-plugin-memcachec) weakremover(collectd-plugin-modbus) weakremover(collectd-plugin-mqtt) weakremover(collectd-plugin-mysql) weakremover(collectd-plugin-notify-desktop) weakremover(collectd-plugin-nut) weakremover(collectd-plugin-openldap) weakremover(collectd-plugin-ovs) weakremover(collectd-plugin-pcie) weakremover(collectd-plugin-pinba) weakremover(collectd-plugin-postgresql) weakremover(collectd-plugin-procevent) weakremover(collectd-plugin-python) weakremover(collectd-plugin-python3) weakremover(collectd-plugin-sigrok) weakremover(collectd-plugin-smart) weakremover(collectd-plugin-snmp) weakremover(collectd-plugin-synproxy) weakremover(collectd-plugin-sysevent) weakremover(collectd-plugin-ubi) weakremover(collectd-plugin-uptime) weakremover(collectd-plugin-virt) weakremover(collectd-plugin-write_influxdb_udp) weakremover(collectd-plugin-write_stackdriver) weakremover(collectd-plugin-write_syslog) weakremover(colm-devel) weakremover(colorblind-devel) weakremover(colord) weakremover(colord-color-profiles) weakremover(colord-gtk) weakremover(colord-kde) weakremover(colorhug-client) weakremover(colorpicker) weakremover(comix) weakremover(comix-lang) weakremover(commandergenius) weakremover(commoncpp2-devel) weakremover(commoncpp2-doc) weakremover(compartm) weakremover(compat-readline4) weakremover(compat-usrmerge) weakremover(compat-usrmerge-build) weakremover(compat-usrmerge-tools) weakremover(compcache) weakremover(compface) weakremover(compface-devel) weakremover(compicc) weakremover(compiz) weakremover(compiz-branding-SLED) weakremover(compiz-branding-openSUSE) weakremover(compiz-branding-upstream) weakremover(compiz-devel) weakremover(compiz-emerald) weakremover(compiz-emerald-devel) weakremover(compiz-emerald-theme-manager) weakremover(compiz-gnome) weakremover(compiz-plugins) weakremover(compiz-plugins-experimental) weakremover(compiz-plugins-experimental-devel) weakremover(compiz-plugins-extra) weakremover(compiz-plugins-extra-devel) weakremover(compiz-plugins-main) weakremover(compiz-plugins-main-devel) weakremover(compleat) weakremover(complexity) weakremover(compsize) weakremover(compton) weakremover(compton-conf) weakremover(conauto) weakremover(concurrent) weakremover(concurrent-javadoc) weakremover(conduit) weakremover(conduit-lang) weakremover(conftest) weakremover(conglomerate) weakremover(conglomerate-doc) weakremover(conglomerate-lang) weakremover(conkeror) weakremover(conky) weakremover(conky-doc) weakremover(conman) weakremover(conmon) weakremover(connman) weakremover(connman-client) weakremover(connman-devel) weakremover(connman-doc) weakremover(connman-nmcompat) weakremover(connman-plugin-hh2serial-gps) weakremover(connman-plugin-iospm) weakremover(connman-plugin-l2tp) weakremover(connman-plugin-openconnect) weakremover(connman-plugin-openvpn) weakremover(connman-plugin-polkit) weakremover(connman-plugin-pptp) weakremover(connman-plugin-tist) weakremover(connman-plugin-vpnc) weakremover(connman-plugin-wireguard) weakremover(connman-test) weakremover(conntrack-tools) weakremover(conntrackd) weakremover(console) weakremover(consoleet-utils) weakremover(container-diff) weakremover(container-feeder) weakremover(container-support-utils) weakremover(container-suseconnect) weakremover(containerd) weakremover(containerd-ctr) weakremover(containerd-devel) weakremover(containerd-kubic) weakremover(containerd-kubic-ctr) weakremover(containerd-kubic-test) weakremover(containerd-test) weakremover(containerized-data-importer-api) weakremover(containerized-data-importer-cloner) weakremover(containerized-data-importer-controller) weakremover(containerized-data-importer-importer) weakremover(containerized-data-importer-manifests) weakremover(containerized-data-importer-operator) weakremover(containerized-data-importer-uploadproxy) weakremover(containerized-data-importer-uploadserver) weakremover(containment-rpm-docker) weakremover(contractor) weakremover(converseen) weakremover(cool-retro-term) weakremover(coolkey) weakremover(coolkey-devel) weakremover(coq) weakremover(coq-devel) weakremover(coq-ide) weakremover(corebird) weakremover(corebird-lang) weakremover(coredns) weakremover(coredns-for-k8s1.18) weakremover(coredns-for-k8s1.18-extras) weakremover(coredns-for-k8s1.19) weakremover(coredns-for-k8s1.19-extras) weakremover(coredns-for-k8s1.21) weakremover(coredns-for-k8s1.22) weakremover(coredns-for-k8s1.23) weakremover(coredns-for-k8s1.24) weakremover(coredns-for-k8s1.25) weakremover(coredns-for-k8s1.26) weakremover(coredns-for-k8s1.27) weakremover(corepack16) weakremover(corepack17) weakremover(corepack18) weakremover(corepack19) weakremover(coreutils) weakremover(coreutils-single) weakremover(coreutils-testsuite) weakremover(corosync) weakremover(corosync-qdevice) weakremover(corosync-qnetd) weakremover(corosync-testagents) weakremover(cosign) weakremover(coturn) weakremover(coturn-devel) weakremover(coturn-utils) weakremover(courier-authlib) weakremover(courier-authlib-devel) weakremover(courier-authlib-ldap) weakremover(courier-authlib-mysql) weakremover(courier-authlib-pgsql) weakremover(courier-authlib-pipe) weakremover(courier-authlib-sqlite) weakremover(courier-authlib-userdb) weakremover(courier-imap) weakremover(courier-unicode-devel) weakremover(coxeter) weakremover(cp437) weakremover(cpio) weakremover(cpio-mt) weakremover(cpluff) weakremover(cpp) weakremover(cpp-httplib-devel) weakremover(cpp10) weakremover(cpp11) weakremover(cpp12) weakremover(cpp13) weakremover(cpp48) weakremover(cpp5) weakremover(cpp6) weakremover(cpp7) weakremover(cpp8) weakremover(cpp9) weakremover(cppcheck) weakremover(cppcheck-gui) weakremover(cppdb-devel) weakremover(cppdb-doc) weakremover(cpphs) weakremover(cppi) weakremover(cpprest-devel) weakremover(cpptoml-devel) weakremover(cppunit-devel) weakremover(cppzmq-devel) weakremover(cpu-x) weakremover(cpulimit) weakremover(cpuminer) weakremover(cpupower) weakremover(cpupower-bench) weakremover(cpupower-devel) weakremover(cpupower-rebuild) weakremover(cpustat) weakremover(cracklib) weakremover(cracklib-devel) weakremover(cracklib-dict-full) weakremover(cracklib-dict-small) weakremover(cram) weakremover(cram-common) weakremover(cramfs-tools) weakremover(cramfsswap) weakremover(crane) weakremover(crash) weakremover(crash-devel) weakremover(crash-doc) weakremover(crash-eppic) weakremover(crash-kmp-64kb) weakremover(crash-kmp-default) weakremover(crash-trace) weakremover(crawl) weakremover(crawl-sdl) weakremover(crazydiskinfo) weakremover(crc32csum) weakremover(crda) weakremover(create-resources) weakremover(createrepo) weakremover(createrepo_c) weakremover(creduce) weakremover(cri-o) weakremover(cri-o-kubeadm-criconfig) weakremover(cri-tools) weakremover(crispy-doom) weakremover(criterion) weakremover(criu) weakremover(criu-devel) weakremover(criu-plugin-amdgpu) weakremover(cron) weakremover(cronie) weakremover(cronie-anacron) weakremover(cross-arm-binutils) weakremover(cross-arm-gcc10) weakremover(cross-arm-gcc10-icecream-backend) weakremover(cross-arm-gcc11) weakremover(cross-arm-gcc11-icecream-backend) weakremover(cross-arm-gcc12) weakremover(cross-arm-gcc12-icecream-backend) weakremover(cross-arm-gcc13) weakremover(cross-arm-gcc13-icecream-backend) weakremover(cross-arm-gcc6) weakremover(cross-arm-gcc7) weakremover(cross-arm-gcc8) weakremover(cross-arm-gcc9) weakremover(cross-arm-gcc9-icecream-backend) weakremover(cross-arm-none-gcc10) weakremover(cross-arm-none-gcc10-bootstrap) weakremover(cross-arm-none-gcc11) weakremover(cross-arm-none-gcc11-bootstrap) weakremover(cross-arm-none-gcc12) weakremover(cross-arm-none-gcc12-bootstrap) weakremover(cross-arm-none-gcc13) weakremover(cross-arm-none-gcc13-bootstrap) weakremover(cross-arm-none-gcc7) weakremover(cross-arm-none-gcc7-bootstrap) weakremover(cross-arm-none-gcc8) weakremover(cross-arm-none-gcc8-bootstrap) weakremover(cross-arm-none-gcc9) weakremover(cross-arm-none-gcc9-bootstrap) weakremover(cross-arm-none-newlib-devel) weakremover(cross-armv6hl-gcc48-icecream-backend) weakremover(cross-armv6hl-gcc6) weakremover(cross-armv6hl-gcc6-icecream-backend) weakremover(cross-armv7hl-gcc48-icecream-backend) weakremover(cross-armv7hl-gcc6) weakremover(cross-armv7hl-gcc6-icecream-backend) weakremover(cross-avr-binutils) weakremover(cross-avr-gcc10) weakremover(cross-avr-gcc10-bootstrap) weakremover(cross-avr-gcc11) weakremover(cross-avr-gcc11-bootstrap) weakremover(cross-avr-gcc12) weakremover(cross-avr-gcc12-bootstrap) weakremover(cross-avr-gcc13) weakremover(cross-avr-gcc13-bootstrap) weakremover(cross-avr-gcc6) weakremover(cross-avr-gcc6-icecream-backend) weakremover(cross-avr-gcc7) weakremover(cross-avr-gcc7-bootstrap) weakremover(cross-avr-gcc8) weakremover(cross-avr-gcc8-bootstrap) weakremover(cross-avr-gcc9) weakremover(cross-avr-gcc9-bootstrap) weakremover(cross-bpf-binutils) weakremover(cross-bpf-gcc13) weakremover(cross-epiphany-binutils) weakremover(cross-epiphany-gcc10) weakremover(cross-epiphany-gcc10-bootstrap) weakremover(cross-epiphany-gcc11) weakremover(cross-epiphany-gcc11-bootstrap) weakremover(cross-epiphany-gcc12) weakremover(cross-epiphany-gcc12-bootstrap) weakremover(cross-epiphany-gcc13) weakremover(cross-epiphany-gcc13-bootstrap) weakremover(cross-epiphany-gcc7) weakremover(cross-epiphany-gcc7-bootstrap) weakremover(cross-epiphany-gcc8) weakremover(cross-epiphany-gcc8-bootstrap) weakremover(cross-epiphany-gcc9) weakremover(cross-epiphany-gcc9-bootstrap) weakremover(cross-epiphany-newlib-devel) weakremover(cross-hppa-binutils) weakremover(cross-hppa-gcc10) weakremover(cross-hppa-gcc10-icecream-backend) weakremover(cross-hppa-gcc11) weakremover(cross-hppa-gcc11-icecream-backend) weakremover(cross-hppa-gcc12) weakremover(cross-hppa-gcc12-bootstrap) weakremover(cross-hppa-gcc12-icecream-backend) weakremover(cross-hppa-gcc13) weakremover(cross-hppa-gcc13-bootstrap) weakremover(cross-hppa-gcc13-icecream-backend) weakremover(cross-hppa-gcc48-icecream-backend) weakremover(cross-hppa-gcc7) weakremover(cross-hppa-gcc7-icecream-backend) weakremover(cross-hppa-gcc8) weakremover(cross-hppa-gcc8-icecream-backend) weakremover(cross-hppa-gcc9) weakremover(cross-hppa-gcc9-icecream-backend) weakremover(cross-hppa64-binutils) weakremover(cross-i386-binutils) weakremover(cross-i386-gcc10) weakremover(cross-i386-gcc10-icecream-backend) weakremover(cross-i386-gcc11) weakremover(cross-i386-gcc11-icecream-backend) weakremover(cross-i386-gcc48-icecream-backend) weakremover(cross-i386-gcc6) weakremover(cross-i386-gcc6-icecream-backend) weakremover(cross-i386-gcc7) weakremover(cross-i386-gcc7-icecream-backend) weakremover(cross-i386-gcc8) weakremover(cross-i386-gcc8-icecream-backend) weakremover(cross-i386-gcc9) weakremover(cross-i386-gcc9-icecream-backend) weakremover(cross-ia64-binutils) weakremover(cross-ia64-gcc48-icecream-backend) weakremover(cross-m68k-binutils) weakremover(cross-m68k-gcc10) weakremover(cross-m68k-gcc10-icecream-backend) weakremover(cross-m68k-gcc11) weakremover(cross-m68k-gcc11-icecream-backend) weakremover(cross-m68k-gcc12) weakremover(cross-m68k-gcc12-icecream-backend) weakremover(cross-m68k-gcc13) weakremover(cross-m68k-gcc13-icecream-backend) weakremover(cross-m68k-gcc6) weakremover(cross-m68k-gcc6-icecream-backend) weakremover(cross-m68k-gcc7) weakremover(cross-m68k-gcc7-icecream-backend) weakremover(cross-m68k-gcc8) weakremover(cross-m68k-gcc8-icecream-backend) weakremover(cross-m68k-gcc9) weakremover(cross-m68k-gcc9-icecream-backend) weakremover(cross-mips-binutils) weakremover(cross-mips-gcc10) weakremover(cross-mips-gcc10-icecream-backend) weakremover(cross-mips-gcc11) weakremover(cross-mips-gcc11-icecream-backend) weakremover(cross-mips-gcc12) weakremover(cross-mips-gcc12-icecream-backend) weakremover(cross-mips-gcc13) weakremover(cross-mips-gcc13-icecream-backend) weakremover(cross-mips-gcc7) weakremover(cross-mips-gcc7-icecream-backend) weakremover(cross-mips-gcc8) weakremover(cross-mips-gcc8-icecream-backend) weakremover(cross-mips-gcc9) weakremover(cross-mips-gcc9-icecream-backend) weakremover(cross-nvptx-gcc10) weakremover(cross-nvptx-gcc11) weakremover(cross-nvptx-newlib10-devel) weakremover(cross-nvptx-newlib11-devel) weakremover(cross-ppc-binutils) weakremover(cross-ppc-gcc48-icecream-backend) weakremover(cross-ppc64-binutils) weakremover(cross-ppc64-gcc10) weakremover(cross-ppc64-gcc10-icecream-backend) weakremover(cross-ppc64-gcc11) weakremover(cross-ppc64-gcc11-icecream-backend) weakremover(cross-ppc64-gcc12) weakremover(cross-ppc64-gcc12-icecream-backend) weakremover(cross-ppc64-gcc13) weakremover(cross-ppc64-gcc13-icecream-backend) weakremover(cross-ppc64-gcc48-icecream-backend) weakremover(cross-ppc64-gcc6) weakremover(cross-ppc64-gcc6-icecream-backend) weakremover(cross-ppc64-gcc7) weakremover(cross-ppc64-gcc7-icecream-backend) weakremover(cross-ppc64-gcc8) weakremover(cross-ppc64-gcc8-icecream-backend) weakremover(cross-ppc64-gcc9) weakremover(cross-ppc64-gcc9-icecream-backend) weakremover(cross-ppc64le-binutils) weakremover(cross-ppc64le-gcc10) weakremover(cross-ppc64le-gcc10-icecream-backend) weakremover(cross-ppc64le-gcc11) weakremover(cross-ppc64le-gcc11-icecream-backend) weakremover(cross-ppc64le-gcc12) weakremover(cross-ppc64le-gcc12-icecream-backend) weakremover(cross-ppc64le-gcc13) weakremover(cross-ppc64le-gcc13-icecream-backend) weakremover(cross-ppc64le-gcc48-icecream-backend) weakremover(cross-ppc64le-gcc6) weakremover(cross-ppc64le-gcc6-icecream-backend) weakremover(cross-ppc64le-gcc7) weakremover(cross-ppc64le-gcc7-icecream-backend) weakremover(cross-ppc64le-gcc8) weakremover(cross-ppc64le-gcc8-icecream-backend) weakremover(cross-ppc64le-gcc9) weakremover(cross-ppc64le-gcc9-icecream-backend) weakremover(cross-pru-binutils) weakremover(cross-pru-gcc12) weakremover(cross-pru-gcc12-bootstrap) weakremover(cross-pru-gcc13) weakremover(cross-pru-gcc13-bootstrap) weakremover(cross-pru-newlib-devel) weakremover(cross-riscv64-binutils) weakremover(cross-riscv64-elf-gcc10) weakremover(cross-riscv64-elf-gcc10-bootstrap) weakremover(cross-riscv64-elf-gcc11) weakremover(cross-riscv64-elf-gcc11-bootstrap) weakremover(cross-riscv64-elf-gcc12) weakremover(cross-riscv64-elf-gcc12-bootstrap) weakremover(cross-riscv64-elf-gcc13) weakremover(cross-riscv64-elf-gcc13-bootstrap) weakremover(cross-riscv64-elf-gcc8) weakremover(cross-riscv64-elf-gcc8-bootstrap) weakremover(cross-riscv64-elf-gcc9) weakremover(cross-riscv64-elf-gcc9-bootstrap) weakremover(cross-riscv64-gcc10) weakremover(cross-riscv64-gcc10-icecream-backend) weakremover(cross-riscv64-gcc11) weakremover(cross-riscv64-gcc11-bootstrap) weakremover(cross-riscv64-gcc11-icecream-backend) weakremover(cross-riscv64-gcc12) weakremover(cross-riscv64-gcc12-bootstrap) weakremover(cross-riscv64-gcc13) weakremover(cross-riscv64-gcc13-bootstrap) weakremover(cross-riscv64-gcc8) weakremover(cross-riscv64-gcc8-icecream-backend) weakremover(cross-riscv64-gcc9) weakremover(cross-riscv64-gcc9-icecream-backend) weakremover(cross-riscv64-newlib-devel) weakremover(cross-rx-binutils) weakremover(cross-rx-gcc10) weakremover(cross-rx-gcc10-bootstrap) weakremover(cross-rx-gcc11) weakremover(cross-rx-gcc11-bootstrap) weakremover(cross-rx-gcc12) weakremover(cross-rx-gcc12-bootstrap) weakremover(cross-rx-gcc13) weakremover(cross-rx-gcc13-bootstrap) weakremover(cross-rx-gcc7) weakremover(cross-rx-gcc7-bootstrap) weakremover(cross-rx-gcc8) weakremover(cross-rx-gcc8-bootstrap) weakremover(cross-rx-gcc9) weakremover(cross-rx-gcc9-bootstrap) weakremover(cross-rx-newlib-devel) weakremover(cross-s390-binutils) weakremover(cross-s390-gcc48-icecream-backend) weakremover(cross-s390x-binutils) weakremover(cross-s390x-gcc10) weakremover(cross-s390x-gcc10-icecream-backend) weakremover(cross-s390x-gcc11) weakremover(cross-s390x-gcc11-icecream-backend) weakremover(cross-s390x-gcc12) weakremover(cross-s390x-gcc12-icecream-backend) weakremover(cross-s390x-gcc13) weakremover(cross-s390x-gcc13-icecream-backend) weakremover(cross-s390x-gcc48-icecream-backend) weakremover(cross-s390x-gcc6) weakremover(cross-s390x-gcc6-icecream-backend) weakremover(cross-s390x-gcc7) weakremover(cross-s390x-gcc7-icecream-backend) weakremover(cross-s390x-gcc8) weakremover(cross-s390x-gcc8-icecream-backend) weakremover(cross-s390x-gcc9) weakremover(cross-s390x-gcc9-icecream-backend) weakremover(cross-sparc-binutils) weakremover(cross-sparc-gcc10) weakremover(cross-sparc-gcc11) weakremover(cross-sparc-gcc12) weakremover(cross-sparc-gcc13) weakremover(cross-sparc-gcc6) weakremover(cross-sparc-gcc7) weakremover(cross-sparc-gcc8) weakremover(cross-sparc-gcc9) weakremover(cross-sparc64-binutils) weakremover(cross-sparc64-gcc10) weakremover(cross-sparc64-gcc10-icecream-backend) weakremover(cross-sparc64-gcc11) weakremover(cross-sparc64-gcc11-icecream-backend) weakremover(cross-sparc64-gcc12) weakremover(cross-sparc64-gcc12-icecream-backend) weakremover(cross-sparc64-gcc13) weakremover(cross-sparc64-gcc13-icecream-backend) weakremover(cross-sparc64-gcc6) weakremover(cross-sparc64-gcc6-icecream-backend) weakremover(cross-sparc64-gcc7) weakremover(cross-sparc64-gcc7-icecream-backend) weakremover(cross-sparc64-gcc8) weakremover(cross-sparc64-gcc8-icecream-backend) weakremover(cross-sparc64-gcc9) weakremover(cross-sparc64-gcc9-icecream-backend) weakremover(cross-sparcv9-gcc10-icecream-backend) weakremover(cross-sparcv9-gcc11-icecream-backend) weakremover(cross-sparcv9-gcc12-icecream-backend) weakremover(cross-sparcv9-gcc13-icecream-backend) weakremover(cross-sparcv9-gcc6-icecream-backend) weakremover(cross-sparcv9-gcc7-icecream-backend) weakremover(cross-sparcv9-gcc8-icecream-backend) weakremover(cross-sparcv9-gcc9-icecream-backend) weakremover(cross-spu-binutils) weakremover(cross-x86_64-binutils) weakremover(cross-x86_64-gcc10) weakremover(cross-x86_64-gcc10-icecream-backend) weakremover(cross-x86_64-gcc11) weakremover(cross-x86_64-gcc11-icecream-backend) weakremover(cross-x86_64-gcc12) weakremover(cross-x86_64-gcc12-icecream-backend) weakremover(cross-x86_64-gcc13) weakremover(cross-x86_64-gcc13-icecream-backend) weakremover(cross-x86_64-gcc48-icecream-backend) weakremover(cross-x86_64-gcc6) weakremover(cross-x86_64-gcc6-icecream-backend) weakremover(cross-x86_64-gcc7) weakremover(cross-x86_64-gcc7-icecream-backend) weakremover(cross-x86_64-gcc8) weakremover(cross-x86_64-gcc8-icecream-backend) weakremover(cross-x86_64-gcc9) weakremover(cross-x86_64-gcc9-icecream-backend) weakremover(cross-xtensa-binutils) weakremover(crossc-devel) weakremover(crossguid-devel) weakremover(crosstool-ng) weakremover(crow-translate) weakremover(crun) weakremover(cryfs) weakremover(cryptconfig) weakremover(cryptsetup) weakremover(cryptsetup-doc) weakremover(cryptsetup-ssh) weakremover(cscope) weakremover(csi-external-attacher) weakremover(csi-external-provisioner) weakremover(csi-external-resizer) weakremover(csi-external-snapshotter) weakremover(csi-livenessprobe) weakremover(csi-node-driver-registrar) weakremover(csindex) weakremover(csmash) weakremover(csmith) weakremover(csound) weakremover(csound-devel) weakremover(csound-java-bindings) weakremover(csound-plugins) weakremover(csvprintf) weakremover(csync) weakremover(csync2) weakremover(ctags) weakremover(ctdb) weakremover(ctdb-pcp-pmda) weakremover(ctdb-tests) weakremover(ctris) weakremover(cttop) weakremover(cudd-devel) weakremover(cuishark) weakremover(cunit-devel) weakremover(cunit-doc) weakremover(cups) weakremover(cups-client) weakremover(cups-config) weakremover(cups-ddk) weakremover(cups-devel) weakremover(cups-filters) weakremover(cups-filters-cups-browsed) weakremover(cups-filters-devel) weakremover(cups-filters-foomatic-rip) weakremover(cups-filters-ghostscript) weakremover(cups-libs) weakremover(cups-pdf) weakremover(cups-pk-helper) weakremover(cups-rpm-helper) weakremover(cura-engine) weakremover(cura-engine-lulzbot) weakremover(cura1-lulzbot) weakremover(curl) weakremover(curl-mini) weakremover(curlftpfs) weakremover(curlie) weakremover(cutecom) weakremover(cutmp3) weakremover(cutmp3-doc) weakremover(cutterff) weakremover(cv) weakremover(cvise) weakremover(cvs) weakremover(cvs2svn) weakremover(cvsps) weakremover(cwstudio) weakremover(cxref) weakremover(cxsc) weakremover(cxsc-devel) weakremover(cxxopts-devel) weakremover(cxxtools-devel) weakremover(cyradm) weakremover(cyrus-imapd) weakremover(cyrus-imapd-devel) weakremover(cyrus-imapd-snmp) weakremover(cyrus-imapd-snmp-mibs) weakremover(cyrus-imapd-utils) weakremover(cyrus-sasl) weakremover(cyrus-sasl-bdb) weakremover(cyrus-sasl-bdb-crammd5) weakremover(cyrus-sasl-bdb-devel) weakremover(cyrus-sasl-bdb-digestmd5) weakremover(cyrus-sasl-bdb-gs2) weakremover(cyrus-sasl-bdb-gssapi) weakremover(cyrus-sasl-bdb-ntlm) weakremover(cyrus-sasl-bdb-otp) weakremover(cyrus-sasl-bdb-plain) weakremover(cyrus-sasl-bdb-scram) weakremover(cyrus-sasl-crammd5) weakremover(cyrus-sasl-devel) weakremover(cyrus-sasl-digestmd5) weakremover(cyrus-sasl-gs2) weakremover(cyrus-sasl-gssapi) weakremover(cyrus-sasl-ldap-auxprop) weakremover(cyrus-sasl-ldap-auxprop-bdb) weakremover(cyrus-sasl-ntlm) weakremover(cyrus-sasl-otp) weakremover(cyrus-sasl-plain) weakremover(cyrus-sasl-saslauthd) weakremover(cyrus-sasl-saslauthd-bdb) weakremover(cyrus-sasl-scram) weakremover(cyrus-sasl-sqlauxprop) weakremover(cyrus-sasl-sqlauxprop-bdb) weakremover(czmq) weakremover(czmq-devel) weakremover(d-spy) weakremover(d-spy-devel) weakremover(d0_blind_id) weakremover(d0_blind_id-devel) weakremover(dLeyna) weakremover(dLeyna-devel) weakremover(dMagnetic) weakremover(dSFMT-devel) weakremover(dagger) weakremover(dante) weakremover(dante-devel) weakremover(dante-server) weakremover(dapl) weakremover(dapl-debug) weakremover(dapl-debug-devel) weakremover(dapl-debug-libs) weakremover(dapl-debug-utils) weakremover(dapl-devel) weakremover(dapl-doc) weakremover(dapl-utils) weakremover(dapper) weakremover(dar) weakremover(dar-doc) weakremover(darcs) weakremover(dareader-devel) weakremover(darktable) weakremover(darktable-doc) weakremover(darktable-tools-basecurve) weakremover(darktable-tools-noise) weakremover(darts) weakremover(dash) weakremover(dasher) weakremover(dasher-data-extras) weakremover(dasher-data-recommended) weakremover(data-partition-service) weakremover(datamash) weakremover(dataquay-devel) weakremover(datefudge) weakremover(dateutils) weakremover(dateutils-octave) weakremover(datovka) weakremover(dav1d) weakremover(dav1d-devel) weakremover(davfs2) weakremover(davix) weakremover(davix-devel) weakremover(dazzle-list-counters) weakremover(db45-doc) weakremover(db45-utils) weakremover(db45-utils-doc) weakremover(db48-utils) weakremover(dbench) weakremover(dbench4) weakremover(dbh-devel) weakremover(dbus-1) weakremover(dbus-1-daemon) weakremover(dbus-1-devel) weakremover(dbus-1-glib) weakremover(dbus-1-glib-bash-completion) weakremover(dbus-1-glib-devel) weakremover(dbus-1-glib-tool) weakremover(dbus-1-mono) weakremover(dbus-1-presage) weakremover(dbus-1-python) weakremover(dbus-1-python-devel) weakremover(dbus-1-python3) weakremover(dbus-1-python3-devel) weakremover(dbus-1-qt3) weakremover(dbus-1-qt3-devel) weakremover(dbus-1-tools) weakremover(dbus-1-x11) weakremover(dbus-broker) weakremover(dbusxml2qt3) weakremover(dbview) weakremover(dbxtool) weakremover(dc3dd) weakremover(dcatools) weakremover(dcmtk) weakremover(dcmtk-devel) weakremover(dconf) weakremover(dconf-devel) weakremover(dconf-editor) weakremover(dcraw) weakremover(dd-opentracing-cpp-devel) weakremover(dd_rescue) weakremover(dd_rescue-crypt) weakremover(dd_rescue-lzo) weakremover(ddccontrol) weakremover(ddccontrol-devel) weakremover(ddccontrol-gtk) weakremover(ddcutil) weakremover(ddd) weakremover(ddd-doc) weakremover(ddnet) weakremover(ddnet-server) weakremover(ddpt) weakremover(ddrescueview) weakremover(dds2tar) weakremover(deadbeef) weakremover(deadbeef-devel) weakremover(deadbeef-plugin-mpris2) weakremover(deal_II-devel) weakremover(deal_II-openmpi2-devel) weakremover(deal_II-openmpi3-devel) weakremover(deal_II-openmpi4-devel) weakremover(debianutils) weakremover(debugedit) weakremover(debuginfod-client) weakremover(debuginfod-dummy-client) weakremover(debuginfod-profile) weakremover(deco) weakremover(dee-devel) weakremover(deepin-api) weakremover(deepin-api-dbus) weakremover(deepin-api-polkit) weakremover(deepin-calculator) weakremover(deepin-calendar) weakremover(deepin-compressor) weakremover(deepin-control-center) weakremover(deepin-control-center-devel) weakremover(deepin-daemon) weakremover(deepin-daemon-lang) weakremover(deepin-daemon-lightdm) weakremover(deepin-desktop) weakremover(deepin-desktop-base) weakremover(deepin-dock) weakremover(deepin-dock-devel) weakremover(deepin-dock-plugin-screen-recorder) weakremover(deepin-dock-plugin-shot-start) weakremover(deepin-dock-plugin-system-monitor) weakremover(deepin-draw) weakremover(deepin-editor) weakremover(deepin-feature-enable) weakremover(deepin-file-manager) weakremover(deepin-file-manager-devel) weakremover(deepin-gir-generator) weakremover(deepin-gsettings) weakremover(deepin-image-editor) weakremover(deepin-image-viewer) weakremover(deepin-kwin) weakremover(deepin-kwin-devel) weakremover(deepin-launcher) weakremover(deepin-launcher-devel) weakremover(deepin-manual) weakremover(deepin-menu) weakremover(deepin-movie) weakremover(deepin-movie-devel) weakremover(deepin-music-libnetease-meta-search) weakremover(deepin-music-player) weakremover(deepin-network-utils) weakremover(deepin-network-utils-devel) weakremover(deepin-override-tool) weakremover(deepin-polkit-agent) weakremover(deepin-polkit-agent-devel) weakremover(deepin-pw-check) weakremover(deepin-pw-check-devel) weakremover(deepin-reader) weakremover(deepin-screen-recorder) weakremover(deepin-screenshot) weakremover(deepin-screenshot-lang) weakremover(deepin-session-shell) weakremover(deepin-session-shell-devel) weakremover(deepin-session-ui) weakremover(deepin-shortcut-viewer) weakremover(deepin-start) weakremover(deepin-start-lang) weakremover(deepin-system-monitor) weakremover(deepin-terminal) weakremover(deepin-terminal-devel) weakremover(deepin-tool-kit) weakremover(deepin-turbo) weakremover(deepin-turbo-devel) weakremover(deepin-ui) weakremover(deepin-utils) weakremover(deepin-voice-note) weakremover(deepin-wayland-devel) weakremover(deepin-wayland-protocols) weakremover(deepin-x11-client) weakremover(deja-dup) weakremover(delayacct-utils) weakremover(delayacct-utils-rebuild) weakremover(delta) weakremover(deltafs) weakremover(deltarpm) weakremover(delve) weakremover(demumble) weakremover(deno) weakremover(derive) weakremover(desktop-file-utils) weakremover(desktopfolder) weakremover(deutex) weakremover(devhelp) weakremover(devhelp-devel) weakremover(device-mapper) weakremover(device-mapper-devel) weakremover(devilspie2) weakremover(devmem2) weakremover(devscripts) weakremover(dex-oidc) weakremover(dfc) weakremover(dfu-programmer) weakremover(dfu-tool) weakremover(dfu-util) weakremover(dhall-json) weakremover(dhall-yaml) weakremover(dhcp) weakremover(dhcp-client) weakremover(dhcp-devel) weakremover(dhcp-doc) weakremover(dhcp-relay) weakremover(dhcp-server) weakremover(dhcp-tools) weakremover(dhcpd-pools) weakremover(dhewm3) weakremover(dhex) weakremover(dhtest) weakremover(dia) weakremover(dialog) weakremover(dialog-devel) weakremover(dianara) weakremover(dico) weakremover(dico-devel) weakremover(dico-modules) weakremover(dictd) weakremover(dictd-devel) weakremover(diff-pdf) weakremover(diffstat) weakremover(diffutils) weakremover(digikam) weakremover(digikam-devel) weakremover(digikam-doc) weakremover(digikam-libs) weakremover(digikam-plugin-color) weakremover(digikam-plugin-decorate) weakremover(digikam-plugin-enhance) weakremover(digikam-plugin-fxfilters) weakremover(digikam-plugin-gmic) weakremover(digikam-plugin-transform) weakremover(digikam-plugins) weakremover(dino) weakremover(dino-devel) weakremover(diod) weakremover(dippi) weakremover(dirac) weakremover(dirac-devel) weakremover(dirac-doc) weakremover(dirdiff) weakremover(direnv) weakremover(direvent) weakremover(dirmngr) weakremover(dirmngr-lang) weakremover(discord-rpc-devel) weakremover(discount) weakremover(discover) weakremover(discover-backend-flatpak) weakremover(discover-backend-fwupd) weakremover(discover-backend-packagekit) weakremover(discover-notifier) weakremover(discover-plasmoid) weakremover(diskmonitor) weakremover(diskscan) weakremover(disomaster-devel) weakremover(disorderfs) weakremover(distcc) weakremover(distcc-gui) weakremover(distcc-server) weakremover(distribution-logos-openSUSE-Leap) weakremover(distribution-registry) weakremover(dita-ot) weakremover(djvulibre) weakremover(djvulibre-djview4) weakremover(djvusmooth) weakremover(djvusmooth-lang) weakremover(dkgpg) weakremover(dleyna-connector-dbus) weakremover(dleyna-core-devel) weakremover(dleyna-renderer) weakremover(dleyna-renderer-devel) weakremover(dleyna-server) weakremover(dleyna-server-devel) weakremover(dlpack-devel) weakremover(dlt-daemon) weakremover(dlt-examples) weakremover(dlt-libs) weakremover(dlt-libs-devel) weakremover(dlt-tools) weakremover(dlt-viewer) weakremover(dm-zoned-tools) weakremover(dmapi-devel) weakremover(dmenu) weakremover(dmidecode) weakremover(dmlc-core-devel) weakremover(dmraid) weakremover(dmraid-devel) weakremover(dnscrypt-proxy) weakremover(dnscrypt-proxy-devel) weakremover(dnsdist) weakremover(dnsmasq) weakremover(dnsmasq-utils) weakremover(dnsmeter) weakremover(dnstracer) weakremover(doc-gnu-ko) weakremover(docbook-xsl-stylesheets-scripts) weakremover(docbook2x) weakremover(docbook2x-doc) weakremover(docker) weakremover(docker-buildx) weakremover(docker-compose) weakremover(docker-compose-switch) weakremover(docker-credential-secretservice) weakremover(docker-distribution-registry) weakremover(docker-img-store-setup) weakremover(docker-kubic) weakremover(docker-kubic-bash-completion) weakremover(docker-kubic-fish-completion) weakremover(docker-kubic-kubeadm-criconfig) weakremover(docker-kubic-test) weakremover(docker-kubic-zsh-completion) weakremover(docker-libnetwork) weakremover(docker-libnetwork-kubic) weakremover(docker-lock) weakremover(docker-machine-driver-kvm2) weakremover(docker-runc) weakremover(docker-runc-kubic) weakremover(docker-runc-kubic-test) weakremover(docker-runc-test) weakremover(docker-test) weakremover(docker_auth) weakremover(docky) weakremover(docky-devel) weakremover(docky-lang) weakremover(docparser-devel) weakremover(docserv-auxserver) weakremover(docserv-minisrv) weakremover(docserv-sitemap) weakremover(doctest) weakremover(doctest-devel) weakremover(doctest-discover) weakremover(dog) weakremover(doh) weakremover(dolly) weakremover(dolphin) weakremover(dolphin-devel) weakremover(dolphin-emu) weakremover(dolphin-part) weakremover(dolphin-plugins) weakremover(doomsday) weakremover(doomsday-launcher) weakremover(dos2unix) weakremover(dosbox) weakremover(dosbox-translations) weakremover(dosfstools) weakremover(dotconf) weakremover(dotconf-devel) weakremover(double-conversion-devel) weakremover(double-cross) weakremover(dovecot22) weakremover(dovecot22-backend-mysql) weakremover(dovecot22-backend-pgsql) weakremover(dovecot22-backend-sqlite) weakremover(dovecot22-devel) weakremover(dovecot22-fts) weakremover(dovecot22-fts-lucene) weakremover(dovecot22-fts-solr) weakremover(dovecot22-fts-squat) weakremover(dovecot23) weakremover(dovecot23-backend-mysql) weakremover(dovecot23-backend-pgsql) weakremover(dovecot23-backend-sqlite) weakremover(dovecot23-devel) weakremover(dovecot23-fts) weakremover(dovecot23-fts-lucene) weakremover(dovecot23-fts-solr) weakremover(dovecot23-fts-squat) weakremover(doxygen) weakremover(doxygen-doc) weakremover(doxygen2man) weakremover(doxywizard) weakremover(dpdk) weakremover(dpdk-devel) weakremover(dpdk-devel-static) weakremover(dpdk-examples) weakremover(dpdk-kmp-default) weakremover(dpdk-thunderx) weakremover(dpdk-thunderx-devel) weakremover(dpdk-thunderx-devel-static) weakremover(dpdk-thunderx-examples) weakremover(dpdk-thunderx-kmp-default) weakremover(dpdk-thunderx-tools) weakremover(dpdk-tools) weakremover(dpic) weakremover(dpkg) weakremover(dpkg-devel) weakremover(dqlite-devel) weakremover(drac) weakremover(dracut) weakremover(dracut-extra) weakremover(dracut-fips) weakremover(dracut-ima) weakremover(dracut-kiwi-lib) weakremover(dracut-kiwi-live) weakremover(dracut-kiwi-oem-dump) weakremover(dracut-kiwi-oem-repart) weakremover(dracut-kiwi-overlay) weakremover(dracut-mkinitrd-deprecated) weakremover(dracut-tools) weakremover(dragonbox-devel) weakremover(dragonplayer) weakremover(drbd) weakremover(drbd-kmp-64kb) weakremover(drbd-kmp-default) weakremover(drbd-utils) weakremover(drbdmanage) weakremover(drc) weakremover(drc-doc) weakremover(dreampie) weakremover(driconf) weakremover(drkonqi5) weakremover(drm_info) weakremover(droidcam) weakremover(droidcam-cli) weakremover(dropbox) weakremover(dropbox-cli) weakremover(drops) weakremover(dropwatch) weakremover(drumstick) weakremover(drumstick-mimetypes) weakremover(drwright) weakremover(drwright-lang) weakremover(dsda-doom) weakremover(dssi) weakremover(dssi-devel) weakremover(dssim) weakremover(dsvpn) weakremover(dt) weakremover(dtach) weakremover(dtb-al) weakremover(dtb-allwinner) weakremover(dtb-altera) weakremover(dtb-amazon) weakremover(dtb-amd) weakremover(dtb-amlogic) weakremover(dtb-apm) weakremover(dtb-apple) weakremover(dtb-arm) weakremover(dtb-broadcom) weakremover(dtb-cavium) weakremover(dtb-exynos) weakremover(dtb-freescale) weakremover(dtb-hisilicon) weakremover(dtb-lg) weakremover(dtb-marvell) weakremover(dtb-mediatek) weakremover(dtb-nvidia) weakremover(dtb-qcom) weakremover(dtb-renesas) weakremover(dtb-rockchip) weakremover(dtb-socionext) weakremover(dtb-source) weakremover(dtb-sprd) weakremover(dtb-xilinx) weakremover(dtb-zte) weakremover(dtc) weakremover(dtkcommon) weakremover(dtkcore) weakremover(dtkcore-devel) weakremover(dtkgui) weakremover(dtkgui-devel) weakremover(dtksettings) weakremover(dtkwidget) weakremover(dtkwidget-devel) weakremover(dtkwm-devel) weakremover(dub) weakremover(duc) weakremover(duktape-devel) weakremover(dumb) weakremover(dumb-devel) weakremover(dumb-devel-doc) weakremover(dumb-doc) weakremover(dump) weakremover(dump-rmt) weakremover(dump1090) weakremover(dump1090-fa) weakremover(dumpvdl2) weakremover(dunelegacy) weakremover(dunst) weakremover(duperemove) weakremover(duplicity) weakremover(dust) weakremover(dustrac) weakremover(dvb) weakremover(dvb-devel) weakremover(dvb-utils) weakremover(dvbcut) weakremover(dvbsnoop) weakremover(dvbstream) weakremover(dvd+rw-tools) weakremover(dvdauthor) weakremover(dvdisaster) weakremover(dvgrab) weakremover(dvgt) weakremover(dwarf2json) weakremover(dwarves) weakremover(dwayland-devel) weakremover(dwz) weakremover(dwz-testsuite) weakremover(dx) weakremover(dx-data) weakremover(dx-devel) weakremover(dx-doc) weakremover(dxflib-devel) weakremover(dyff) weakremover(dynamips) weakremover(dynare) weakremover(dzen2) weakremover(e-antic-devel) weakremover(e16) weakremover(e2fsprogs) weakremover(e2fsprogs-devel) weakremover(e2fsprogs-scrub) weakremover(e3) weakremover(eaglemode) weakremover(earlyoom) weakremover(easyeffects) weakremover(easyloggingpp-devel) weakremover(easytag) weakremover(eatmydata) weakremover(eb) weakremover(eb-devel) weakremover(ebiso) weakremover(ebizzy) weakremover(eblook) weakremover(ebook-tools) weakremover(ebtables) weakremover(ebumeter) weakremover(echomixer) weakremover(eciadsl-usermode) weakremover(ecj-bootstrap) weakremover(eclipse-contributor-tools) weakremover(eclipse-ecf-core) weakremover(eclipse-ecf-core-bootstrap) weakremover(eclipse-emf-core) weakremover(eclipse-emf-core-bootstrap) weakremover(eclipse-equinox-osgi) weakremover(eclipse-pde) weakremover(eclipse-platform) weakremover(eclipse-swt) weakremover(eclipse-tests) weakremover(ecore_imf-module-scim) weakremover(ecryptfs-utils) weakremover(ecryptfs-utils-devel) weakremover(ecwolf) weakremover(ed) weakremover(edgar) weakremover(edge-addition-planarity-suite) weakremover(edge-addition-planarity-suite-devel) weakremover(editorconfig) weakremover(editres) weakremover(edje) weakremover(edk2-ArmVExpress-FVP-AArch64) weakremover(edk2-Armada80x0McBin) weakremover(edk2-Overdrive1000Board) weakremover(edk2-RPi3) weakremover(edk2-RPi4) weakremover(edk2-SbsaQemu) weakremover(edk2-hikey) weakremover(edk2-hikey960) weakremover(eekboard) weakremover(eekboard-devel) weakremover(efibootmgr) weakremover(efitools) weakremover(efivar) weakremover(efivar-devel) weakremover(efl) weakremover(efl-devel) weakremover(efl-examples) weakremover(efl-testsuite) weakremover(eiciel) weakremover(eid-mw) weakremover(eid-mw-devel) weakremover(eid-mw-firefox) weakremover(eid-mw-libs) weakremover(eid-viewer) weakremover(eiskaltdcpp-cli) weakremover(eiskaltdcpp-daemon) weakremover(eiskaltdcpp-qt) weakremover(ekiga) weakremover(ekiga-lang) weakremover(ekiga-plugins-evolution) weakremover(elektra) weakremover(elektra-qt-gui) weakremover(elementary) weakremover(elementary-appcenter) weakremover(elementary-appcenter-lang) weakremover(elementary-examples) weakremover(elemines) weakremover(elftoaout) weakremover(elfutils) weakremover(elfutils-debuginfod) weakremover(elib) weakremover(elinks) weakremover(elisa) weakremover(elixir-ex_doc) weakremover(elk) weakremover(elk-openmpi1) weakremover(elk-openmpi2) weakremover(elk-openmpi3) weakremover(elk-openmpi4) weakremover(elk-openmpi5) weakremover(ell-devel) weakremover(elpa-devel) weakremover(elpa-devel-static) weakremover(elpa-tests) weakremover(elpa-tools) weakremover(elua) weakremover(emacs) weakremover(emacs-completion-golang) weakremover(emacs-dash) weakremover(emacs-eln) weakremover(emacs-haskell-mode) weakremover(emacs-magit) weakremover(emacs-nox) weakremover(emacs-plugin-devhelp) weakremover(emacs-scheme48) weakremover(emacs-vm) weakremover(emacs-w3) weakremover(emacs-with-editor) weakremover(emacs-x11) weakremover(embree-devel) weakremover(embree-devel-static) weakremover(embryo) weakremover(emf2svg-conv) weakremover(emil) weakremover(empathy) weakremover(empathy-lang) weakremover(enblend-enfuse) weakremover(enblend-enfuse-doc) weakremover(enc) weakremover(enca) weakremover(enca-devel) weakremover(encfs) weakremover(enchant-1-backend-voikko) weakremover(enchant-1-backend-zemberek) weakremover(enchant-1-backends) weakremover(enchant-1-data) weakremover(enchant-1-devel) weakremover(enchant-1-tools) weakremover(enchant-2-backend-aspell) weakremover(enchant-2-backend-hunspell) weakremover(enchant-2-backend-nuspell) weakremover(enchant-2-backend-voikko) weakremover(enchant-data) weakremover(enchant-devel) weakremover(enchant-tools) weakremover(enchant-voikko) weakremover(enchive) weakremover(endeavour) weakremover(endeavour-devel) weakremover(endless-sky) weakremover(enet-devel) weakremover(engauge-digitizer) weakremover(engine_pkcs11) weakremover(engrampa) weakremover(enigma) weakremover(enigmail) weakremover(enlightenment) weakremover(enlightenment-branding-openSUSE) weakremover(enlightenment-branding-upstream) weakremover(enlightenment-devel) weakremover(enlightenment-doc-html) weakremover(enlightenment-theme-Flat) weakremover(enlightenment-theme-cerium2) weakremover(enlightenment-theme-upstream) weakremover(enlightenment-x-Flat-icon-theme) weakremover(enlightenment-x-dark-icon-theme) weakremover(enscript) weakremover(ensmallen-devel) weakremover(entangle) weakremover(entangle-plugin-eclipse) weakremover(entangle-plugin-photobox) weakremover(entangle-plugin-shooter) weakremover(entr) weakremover(envoy) weakremover(envoy-protoc-gen-validate) weakremover(envoy-protoc-gen-validate-source) weakremover(envoy-proxy) weakremover(envoy-proxy-source) weakremover(envy24control) weakremover(eog) weakremover(eog-devel) weakremover(eog-plugin-exif-display) weakremover(eog-plugin-export-to-folder) weakremover(eog-plugin-fit-to-width) weakremover(eog-plugin-fullscreenbg) weakremover(eog-plugin-hide-titlebar) weakremover(eog-plugin-light-theme) weakremover(eog-plugin-map) weakremover(eog-plugin-maximize-windows) weakremover(eog-plugin-postasa) weakremover(eog-plugin-pythonconsole) weakremover(eog-plugin-send-by-mail) weakremover(eog-plugin-slideshowshuffle) weakremover(eog-plugins) weakremover(eom) weakremover(eom-devel) weakremover(eperiodique) weakremover(ephoto) weakremover(epic) weakremover(epiphany) weakremover(epour) weakremover(epplet-base) weakremover(epson-inkjet-printer-escpr) weakremover(epub2txt2) weakremover(epydoc) weakremover(equalx) weakremover(erdtree) weakremover(erfa-devel) weakremover(erfa-devel-static) weakremover(erlang) weakremover(erlang-cf) weakremover(erlang-debugger) weakremover(erlang-debugger-src) weakremover(erlang-dialyzer) weakremover(erlang-dialyzer-src) weakremover(erlang-diameter) weakremover(erlang-diameter-src) weakremover(erlang-doc) weakremover(erlang-epmd) weakremover(erlang-erlware_commons) weakremover(erlang-et) weakremover(erlang-et-src) weakremover(erlang-getopt) weakremover(erlang-gs) weakremover(erlang-gs-src) weakremover(erlang-jinterface) weakremover(erlang-jinterface-src) weakremover(erlang-observer) weakremover(erlang-observer-src) weakremover(erlang-providers) weakremover(erlang-rabbitmq-client) weakremover(erlang-rebar) weakremover(erlang-rebar-src) weakremover(erlang-rebar3) weakremover(erlang-reltool) weakremover(erlang-reltool-src) weakremover(erlang-retest) weakremover(erlang-retest-src) weakremover(erlang-sd_notify) weakremover(erlang-src) weakremover(erlang-wx) weakremover(erlang-wx-src) weakremover(erldash) weakremover(erofs-utils) weakremover(esbuild) weakremover(esc) weakremover(esound-daemon) weakremover(esound-utils) weakremover(espeak) weakremover(espeak-devel) weakremover(espeak-gui) weakremover(espeak-gui-lang) weakremover(espeak-ng) weakremover(espeak-ng-compat) weakremover(espeak-ng-compat-devel) weakremover(espeak-ng-devel) weakremover(espeakedit) weakremover(espresso) weakremover(espresso-common) weakremover(espresso-doc) weakremover(espresso-openmpi) weakremover(etags) weakremover(etcd) weakremover(etcd-for-k8s-image) weakremover(etcd-for-k8s1.18) weakremover(etcd-for-k8s1.19) weakremover(etcd-for-k8s1.22) weakremover(etcd-for-k8s1.23) weakremover(etcd-for-k8s1.24) weakremover(etcd-for-k8s1.25) weakremover(etcd-for-k8s1.26) weakremover(etcd-for-k8s1.27) weakremover(etcdctl) weakremover(etcdutl) weakremover(etckeeper-cron) weakremover(etherape) weakremover(ethtool) weakremover(ethtool-bash-completion) weakremover(etrophy) weakremover(etrophy-devel) weakremover(euca2ools) weakremover(evas-generic-loaders) weakremover(evemu) weakremover(evemu-devel) weakremover(eventstat) weakremover(eventviews) weakremover(eventviews-devel) weakremover(eventviews-lang) weakremover(evieproto-devel) weakremover(evince) weakremover(evince-browser-plugin) weakremover(evince-devel) weakremover(evince-plugin-comicsdocument) weakremover(evince-plugin-djvudocument) weakremover(evince-plugin-dvidocument) weakremover(evince-plugin-pdfdocument) weakremover(evince-plugin-psdocument) weakremover(evince-plugin-tiffdocument) weakremover(evince-plugin-xpsdocument) weakremover(evmctl) weakremover(evolution) weakremover(evolution-data-server) weakremover(evolution-data-server-devel) weakremover(evolution-data-server-doc) weakremover(evolution-devel) weakremover(evolution-ews) weakremover(evolution-ews-devel) weakremover(evolution-plugin-bogofilter) weakremover(evolution-plugin-pst-import) weakremover(evolution-plugin-rss) weakremover(evolution-plugin-rss-lang) weakremover(evolution-plugin-spamassassin) weakremover(evolution-plugin-text-highlight) weakremover(evtest) weakremover(exa) weakremover(execstack) weakremover(exempi-tools) weakremover(exercism) weakremover(exfat-utils) weakremover(exfatprogs) weakremover(exif) weakremover(exiftran) weakremover(exim) weakremover(eximon) weakremover(eximstats-html) weakremover(exiv2) weakremover(exo-branding-openSUSE) weakremover(exo-branding-upstream) weakremover(exo-data) weakremover(exo-devel) weakremover(exo-helpers) weakremover(exo-tools) weakremover(exodusii-devel) weakremover(expat) weakremover(expect) weakremover(expect-devel) weakremover(explain) weakremover(ext3grep) weakremover(ext4magic) weakremover(extrace) weakremover(extract-appdata-icons) weakremover(extractpdfmark) weakremover(extreme-tuxracer) weakremover(extundelete) weakremover(ez-ipupdate) weakremover(ezstream) weakremover(f2c) weakremover(f2c-devel) weakremover(f2fs-tools) weakremover(f2fs-tools-compat) weakremover(f2fs-tools-devel) weakremover(f3) weakremover(fIcy) weakremover(fabtests) weakremover(facetimehd-kmp-64kb) weakremover(facetimehd-kmp-default) weakremover(fairymax) weakremover(fake-gcs-server) weakremover(fakechroot) weakremover(fakeroot) weakremover(falkon) weakremover(falkon-gnome-keyring) weakremover(falkon-kde) weakremover(falkon-kwallet) weakremover(farbfeld) weakremover(farstream-devel) weakremover(fastfetch) weakremover(fastjar) weakremover(fastjet-contrib-devel) weakremover(fastjet-contrib-devel-static) weakremover(fastjet-devel) weakremover(fastjet-plugin-siscone) weakremover(fastjet-plugin-siscone-devel) weakremover(fastlzlib) weakremover(fastlzlib-devel) weakremover(fate) weakremover(fatrace) weakremover(fatsort) weakremover(fb-util-for-appx) weakremover(fbcat) weakremover(fbi) weakremover(fbiterm) weakremover(fbpdf) weakremover(fbreader) weakremover(fbterm) weakremover(fcft-devel) weakremover(fcgiwrap) weakremover(fcgiwrap-nginx) weakremover(fcitx) weakremover(fcitx-anthy) weakremover(fcitx-chewing) weakremover(fcitx-cloudpinyin) weakremover(fcitx-config-gtk3) weakremover(fcitx-config-kde4) weakremover(fcitx-config-kde4-icons) weakremover(fcitx-devel) weakremover(fcitx-fbterm) weakremover(fcitx-googlepinyin) weakremover(fcitx-gtk2) weakremover(fcitx-gtk3) weakremover(fcitx-hangul) weakremover(fcitx-kkc) weakremover(fcitx-libpinyin) weakremover(fcitx-m17n) weakremover(fcitx-mozc) weakremover(fcitx-pinyin) weakremover(fcitx-pinyin-tools) weakremover(fcitx-pylogger) weakremover(fcitx-qt4) weakremover(fcitx-qt5) weakremover(fcitx-qt5-devel) weakremover(fcitx-qt6) weakremover(fcitx-quwei) weakremover(fcitx-rime) weakremover(fcitx-sayura) weakremover(fcitx-skk) weakremover(fcitx-sunpinyin) weakremover(fcitx-table) weakremover(fcitx-table-tools) weakremover(fcitx-ui-light) weakremover(fcitx-unikey) weakremover(fcitx-zhuyin) weakremover(fcitx5) weakremover(fcitx5-anthy) weakremover(fcitx5-chewing) weakremover(fcitx5-chinese-addons) weakremover(fcitx5-chinese-addons-devel) weakremover(fcitx5-configtool) weakremover(fcitx5-devel) weakremover(fcitx5-gtk2) weakremover(fcitx5-gtk3) weakremover(fcitx5-gtk4) weakremover(fcitx5-hangul) weakremover(fcitx5-kkc) weakremover(fcitx5-libthai) weakremover(fcitx5-lua) weakremover(fcitx5-lua-devel) weakremover(fcitx5-lua-migration-reminder) weakremover(fcitx5-m17n) weakremover(fcitx5-mozc) weakremover(fcitx5-pinyindictmanager) weakremover(fcitx5-qt-devel) weakremover(fcitx5-qt5) weakremover(fcitx5-qt6) weakremover(fcitx5-rime) weakremover(fcitx5-sayura) weakremover(fcitx5-skk) weakremover(fcitx5-unikey) weakremover(fcitx5-zhuyin) weakremover(fcoe-utils) weakremover(fcwnn) weakremover(fcwnn-devel) weakremover(fcwnncom) weakremover(fcwnndev) weakremover(fd) weakremover(fd0ssh) weakremover(fdo-client) weakremover(fdo-client-devel) weakremover(fdupes) weakremover(featherpad) weakremover(fec-devel) weakremover(fedfs-utils-admin) weakremover(fedfs-utils-client) weakremover(fedfs-utils-common) weakremover(fedfs-utils-devel) weakremover(fedfs-utils-nsdbparams) weakremover(fedfs-utils-server) weakremover(feedbackd) weakremover(feedbackd-devel) weakremover(feh) weakremover(felix-osgi-compendium) weakremover(felix-osgi-compendium-javadoc) weakremover(felix-osgi-core) weakremover(felix-osgi-core-javadoc) weakremover(felix-osgi-foundation) weakremover(felix-osgi-foundation-javadoc) weakremover(fence-agents) weakremover(fence-agents-amt_ws) weakremover(fence-agents-devel) weakremover(fence-sanlock) weakremover(festival) weakremover(festival-devel) weakremover(fetchmail) weakremover(fetchmailconf) weakremover(ffado) weakremover(ffado-doc) weakremover(ffcall) weakremover(fflas-ffpack-devel) weakremover(ffmpeg) weakremover(ffmpeg-2-libavcodec-devel) weakremover(ffmpeg-2-libavdevice-devel) weakremover(ffmpeg-2-libavfilter-devel) weakremover(ffmpeg-2-libavformat-devel) weakremover(ffmpeg-2-libavresample-devel) weakremover(ffmpeg-2-libavutil-devel) weakremover(ffmpeg-2-libpostproc-devel) weakremover(ffmpeg-2-libswresample-devel) weakremover(ffmpeg-2-libswscale-devel) weakremover(ffmpeg-3) weakremover(ffmpeg-3-libavcodec-devel) weakremover(ffmpeg-3-libavdevice-devel) weakremover(ffmpeg-3-libavfilter-devel) weakremover(ffmpeg-3-libavformat-devel) weakremover(ffmpeg-3-libavresample-devel) weakremover(ffmpeg-3-libavutil-devel) weakremover(ffmpeg-3-libpostproc-devel) weakremover(ffmpeg-3-libswresample-devel) weakremover(ffmpeg-3-libswscale-devel) weakremover(ffmpeg-3-private-devel) weakremover(ffmpeg-4) weakremover(ffmpeg-4-libavcodec-devel) weakremover(ffmpeg-4-libavdevice-devel) weakremover(ffmpeg-4-libavfilter-devel) weakremover(ffmpeg-4-libavformat-devel) weakremover(ffmpeg-4-libavresample-devel) weakremover(ffmpeg-4-libavutil-devel) weakremover(ffmpeg-4-libpostproc-devel) weakremover(ffmpeg-4-libswresample-devel) weakremover(ffmpeg-4-libswscale-devel) weakremover(ffmpeg-4-private-devel) weakremover(ffmpeg-5) weakremover(ffmpeg-5-libavcodec-devel) weakremover(ffmpeg-5-libavdevice-devel) weakremover(ffmpeg-5-libavfilter-devel) weakremover(ffmpeg-5-libavformat-devel) weakremover(ffmpeg-5-libavutil-devel) weakremover(ffmpeg-5-libpostproc-devel) weakremover(ffmpeg-5-libswresample-devel) weakremover(ffmpeg-5-libswscale-devel) weakremover(ffmpeg-5-mini-devel) weakremover(ffmpeg-5-mini-libs) weakremover(ffmpeg-5-private-devel) weakremover(ffmpeg-6) weakremover(ffmpeg-6-libavcodec-devel) weakremover(ffmpeg-6-libavdevice-devel) weakremover(ffmpeg-6-libavfilter-devel) weakremover(ffmpeg-6-libavformat-devel) weakremover(ffmpeg-6-libavutil-devel) weakremover(ffmpeg-6-libpostproc-devel) weakremover(ffmpeg-6-libswresample-devel) weakremover(ffmpeg-6-libswscale-devel) weakremover(ffmpeg-6-mini-devel) weakremover(ffmpeg-6-mini-libs) weakremover(ffmpeg-6-private-devel) weakremover(ffmpeg-private-devel) weakremover(ffmpeg2-devel) weakremover(ffmpegthumbnailer) weakremover(ffmpegthumbs) weakremover(ffmpegthumbs-lang) weakremover(ffmsindex) weakremover(ffnvcodec-devel) weakremover(ffsb) weakremover(fftw3-devel) weakremover(fftw3-gnu-hpc-devel) weakremover(fftw3-gnu-mpich-hpc-devel) weakremover(fftw3-gnu-mvapich2-hpc-devel) weakremover(fftw3-gnu-openmpi1-hpc-devel) weakremover(fftw3-gnu-openmpi2-hpc-devel) weakremover(fftw3-gnu-openmpi3-hpc-devel) weakremover(fftw3-gnu-openmpi4-hpc-devel) weakremover(fftw3-mpi-devel) weakremover(fftw3-openmp-devel) weakremover(fftw3-threads-devel) weakremover(fftw3_3_3_10-gnu-hpc-devel) weakremover(fftw3_3_3_10-gnu-hpc-devel-static) weakremover(fftw3_3_3_10-gnu-mpich-hpc-devel) weakremover(fftw3_3_3_10-gnu-mpich-hpc-devel-static) weakremover(fftw3_3_3_10-gnu-mvapich2-hpc-devel) weakremover(fftw3_3_3_10-gnu-mvapich2-hpc-devel-static) weakremover(fftw3_3_3_10-gnu-openmpi1-hpc-devel) weakremover(fftw3_3_3_10-gnu-openmpi1-hpc-devel-static) weakremover(fftw3_3_3_10-gnu-openmpi2-hpc-devel) weakremover(fftw3_3_3_10-gnu-openmpi2-hpc-devel-static) weakremover(fftw3_3_3_10-gnu-openmpi3-hpc-devel) weakremover(fftw3_3_3_10-gnu-openmpi3-hpc-devel-static) weakremover(fftw3_3_3_10-gnu-openmpi4-hpc-devel) weakremover(fftw3_3_3_10-gnu-openmpi4-hpc-devel-static) weakremover(fftw3_3_3_6-gnu-hpc-devel) weakremover(fftw3_3_3_6-gnu-hpc-devel-static) weakremover(fftw3_3_3_6-gnu-mpich-hpc-devel) weakremover(fftw3_3_3_6-gnu-mpich-hpc-devel-static) weakremover(fftw3_3_3_6-gnu-mvapich2-hpc-devel) weakremover(fftw3_3_3_6-gnu-mvapich2-hpc-devel-static) weakremover(fftw3_3_3_6-gnu-openmpi1-hpc-devel) weakremover(fftw3_3_3_6-gnu-openmpi1-hpc-devel-static) weakremover(fftw3_3_3_6-gnu-openmpi2-hpc-devel) weakremover(fftw3_3_3_6-gnu-openmpi2-hpc-devel-static) weakremover(fftw3_3_3_6-gnu-openmpi3-hpc-devel) weakremover(fftw3_3_3_6-gnu-openmpi3-hpc-devel-static) weakremover(fftw3_3_3_8-gnu-hpc-devel) weakremover(fftw3_3_3_8-gnu-hpc-devel-static) weakremover(fftw3_3_3_8-gnu-mpich-hpc-devel) weakremover(fftw3_3_3_8-gnu-mpich-hpc-devel-static) weakremover(fftw3_3_3_8-gnu-mvapich2-hpc-devel) weakremover(fftw3_3_3_8-gnu-mvapich2-hpc-devel-static) weakremover(fftw3_3_3_8-gnu-openmpi1-hpc-devel) weakremover(fftw3_3_3_8-gnu-openmpi1-hpc-devel-static) weakremover(fftw3_3_3_8-gnu-openmpi2-hpc-devel) weakremover(fftw3_3_3_8-gnu-openmpi2-hpc-devel-static) weakremover(fftw3_3_3_8-gnu-openmpi3-hpc-devel) weakremover(fftw3_3_3_8-gnu-openmpi3-hpc-devel-static) weakremover(fftw3_3_3_8-gnu-openmpi4-hpc-devel) weakremover(fftw3_3_3_8-gnu-openmpi4-hpc-devel-static) weakremover(fftw3_3_3_9-gnu-hpc-devel) weakremover(fftw3_3_3_9-gnu-hpc-devel-static) weakremover(fftw3_3_3_9-gnu-mpich-hpc-devel) weakremover(fftw3_3_3_9-gnu-mpich-hpc-devel-static) weakremover(fftw3_3_3_9-gnu-mvapich2-hpc-devel) weakremover(fftw3_3_3_9-gnu-mvapich2-hpc-devel-static) weakremover(fftw3_3_3_9-gnu-openmpi1-hpc-devel) weakremover(fftw3_3_3_9-gnu-openmpi1-hpc-devel-static) weakremover(fftw3_3_3_9-gnu-openmpi2-hpc-devel) weakremover(fftw3_3_3_9-gnu-openmpi2-hpc-devel-static) weakremover(fftw3_3_3_9-gnu-openmpi3-hpc-devel) weakremover(fftw3_3_3_9-gnu-openmpi3-hpc-devel-static) weakremover(fftw3_3_3_9-gnu-openmpi4-hpc-devel) weakremover(fftw3_3_3_9-gnu-openmpi4-hpc-devel-static) weakremover(fhourstones) weakremover(fife-devel) weakremover(fifechan-devel) weakremover(figlet) weakremover(file) weakremover(file-devel) weakremover(file-roller) weakremover(file-unpack) weakremover(fileb0x) weakremover(filebench) weakremover(filelight) weakremover(filemanager-actions) weakremover(filemanager-actions-devel) weakremover(filemanager-actions-lang) weakremover(filesystem) weakremover(filesystem-media) weakremover(filezilla) weakremover(filezilla-devel) weakremover(fillets-ng) weakremover(fillup) weakremover(filter_audio-devel) weakremover(finalcut-devel) weakremover(finalcut-examples) weakremover(finch) weakremover(finch-devel) weakremover(findutils) weakremover(finger) weakremover(finger-server) weakremover(fio) weakremover(fips) weakremover(fipscheck) weakremover(fipscheck-devel) weakremover(firebird) weakremover(firebird-classic) weakremover(firebird-devel) weakremover(firebird-doc) weakremover(firebird-examples) weakremover(firebird-server) weakremover(firebird-superserver) weakremover(firebird-utils) weakremover(firecracker) weakremover(firectl) weakremover(firefox-esr-branding-openSUSE) weakremover(firefox-uget-integrator) weakremover(firejail) weakremover(firejail-bash-completion) weakremover(firejail-zsh-completion) weakremover(firescope) weakremover(firetools) weakremover(fish) weakremover(fish-devel) weakremover(fish3) weakremover(fish3-devel) weakremover(fityk) weakremover(fityk-devel) weakremover(five-or-more) weakremover(fixmath) weakremover(fkwnn) weakremover(fkwnn-devel) weakremover(fkwnndev) weakremover(flac) weakremover(flac-devel) weakremover(flac-doc) weakremover(flacon) weakremover(flamerobin) weakremover(flameshot) weakremover(flann-devel) weakremover(flannel) weakremover(flare) weakremover(flarq) weakremover(flashrom) weakremover(flashrom-devel) weakremover(flatbuffers-devel) weakremover(flatpak) weakremover(flatpak-builder) weakremover(flatpak-devel) weakremover(flatpak-spawn) weakremover(flatpak-xdg-utils) weakremover(fldigi) weakremover(flex) weakremover(flex-old) weakremover(flexdock) weakremover(flickcurl) weakremover(flickcurl-doc) weakremover(flim-xemacs) weakremover(flint-devel) weakremover(flnews) weakremover(flocq) weakremover(flocq-devel) weakremover(flom) weakremover(flom-devel) weakremover(florence) weakremover(florence-devel) weakremover(flowgrind) weakremover(fltk-devel) weakremover(fltk-devel-static) weakremover(fluent-bit) weakremover(fluent-bit-devel) weakremover(fluidsynth) weakremover(fluidsynth-devel) weakremover(fluidsynth-dssi) weakremover(fluxbox) weakremover(flxmlrpc-devel) weakremover(fly) weakremover(fmt-devel) weakremover(fnotifystat) weakremover(fnott) weakremover(fntsample) weakremover(focuswriter) weakremover(folks-data) weakremover(folks-devel) weakremover(folks-tools) weakremover(folly-devel) weakremover(foma) weakremover(foma-devel) weakremover(fondu) weakremover(font-manager) weakremover(font-manager-common) weakremover(font-specimen) weakremover(font-specimen-devel) weakremover(font-util) weakremover(font-viewer) weakremover(fontcacheproto-devel) weakremover(fontconfig) weakremover(fontconfig-devel) weakremover(fontforge) weakremover(fontforge-devel) weakremover(fontinfo) weakremover(fontobene-qt5-devel) weakremover(fonttosfnt) weakremover(foot) weakremover(forkbomb) weakremover(forked-daapd) weakremover(forkstat) weakremover(form) weakremover(form-doc) weakremover(fortio) weakremover(fortune) weakremover(fossil) weakremover(fotowall) weakremover(four-in-a-row) weakremover(fox16-devel) weakremover(fox16-devel-static) weakremover(fox16-example-apps) weakremover(fparser-devel) weakremover(fpc) weakremover(fpc-doc) weakremover(fpc-src) weakremover(fping) weakremover(fplll) weakremover(fplll-devel) weakremover(fprintd) weakremover(fprintd-pam) weakremover(fq) weakremover(fractal) weakremover(fractal-lang) weakremover(frame) weakremover(frame-devel) weakremover(framel) weakremover(framel-devel) weakremover(frameworkintegration-devel) weakremover(frameworkintegration-plugin) weakremover(fred) weakremover(freealut-devel) weakremover(freecell-solver) weakremover(freecell-solver-devel) weakremover(freeciv) weakremover(freeciv-gtk3) weakremover(freeciv-qt) weakremover(freedup) weakremover(freeglut-demo) weakremover(freeglut-devel) weakremover(freeimage-devel) weakremover(freeipmi) weakremover(freeipmi-bmc-watchdog) weakremover(freeipmi-devel) weakremover(freeipmi-ipmidetectd) weakremover(freeipmi-ipmiseld) weakremover(freenx-client) weakremover(freeorion) weakremover(freeorion-data) weakremover(freeradius-client) weakremover(freeradius-client-devel) weakremover(freeradius-client-libs) weakremover(freeradius-server) weakremover(freeradius-server-devel) weakremover(freeradius-server-doc) weakremover(freeradius-server-krb5) weakremover(freeradius-server-ldap) weakremover(freeradius-server-ldap-schemas) weakremover(freeradius-server-libs) weakremover(freeradius-server-mysql) weakremover(freeradius-server-perl) weakremover(freeradius-server-postgresql) weakremover(freeradius-server-python) weakremover(freeradius-server-python3) weakremover(freeradius-server-sqlite) weakremover(freeradius-server-utils) weakremover(freerdp) weakremover(freerdp-devel) weakremover(freerdp-proxy) weakremover(freerdp-server) weakremover(freerdp-wayland) weakremover(freesrp-devel) weakremover(freesrp-udev) weakremover(freetds-config) weakremover(freetds-devel) weakremover(freetds-doc) weakremover(freetds-tools) weakremover(freetype) weakremover(freetype-devel) weakremover(freetype-tools) weakremover(freetype2-devel) weakremover(freexl-devel) weakremover(frei0r-plugins) weakremover(frei0r-plugins-devel) weakremover(frei0r-plugins-opencv) weakremover(freqtweak) weakremover(freshplayerplugin) weakremover(fribidi) weakremover(fribidi-devel) weakremover(frink) weakremover(fritzing) weakremover(frogr) weakremover(froxlor) weakremover(frozen-bubble) weakremover(frozen-bubble-server) weakremover(frr) weakremover(frr-devel) weakremover(fs-uae) weakremover(fs_mark) weakremover(fsarchiver) weakremover(fscrypt) weakremover(fsharp) weakremover(fslint) weakremover(fslsfonts) weakremover(fstobdf) weakremover(fstrcmp) weakremover(fstrcmp-devel) weakremover(fstrm) weakremover(fstrm-devel) weakremover(fsvs) weakremover(fswebcam) weakremover(ft2-clone) weakremover(ft2demos) weakremover(ft2play) weakremover(ftbench) weakremover(ftdiff) weakremover(ftdump) weakremover(ftgamma) weakremover(ftgl-demo) weakremover(ftgl-devel) weakremover(ftgrid) weakremover(ftinspect) weakremover(ftlint) weakremover(ftmulti) weakremover(ftop) weakremover(ftp) weakremover(ftsdf) weakremover(ftstring) weakremover(ftvalid) weakremover(ftview) weakremover(ftwnn) weakremover(ftxui-devel) weakremover(fuc) weakremover(funkload) weakremover(fuse) weakremover(fuse-devel) weakremover(fuse-devel-static) weakremover(fuse-doc) weakremover(fuse-exfat) weakremover(fuse-overlayfs) weakremover(fuse2fs) weakremover(fuse3) weakremover(fuse3-devel) weakremover(fuse3-doc) weakremover(fusecompress) weakremover(fuseiso) weakremover(fusepod) weakremover(fusesmb) weakremover(fuzzel) weakremover(fuzzel-zsh-completion) weakremover(fvwm2) weakremover(fwbuilder) weakremover(fwknop) weakremover(fwknop-gui) weakremover(fwknopd) weakremover(fwnn) weakremover(fwnn-devel) weakremover(fwnncom) weakremover(fwts) weakremover(fwupd) weakremover(fwupd-devel) weakremover(fwupd-efi) weakremover(fwupdate) weakremover(fwupdate-devel) weakremover(fwupdate-efi) weakremover(fwupdtpmevlog) weakremover(fwzs) weakremover(fx) weakremover(fxload) weakremover(fzf) weakremover(fzy) weakremover(g3utils) weakremover(g810-led) weakremover(gaa) weakremover(galaxis) weakremover(galculator) weakremover(galene) weakremover(galera-4) weakremover(galera-4-wsrep-provider) weakremover(gama) weakremover(gambas3) weakremover(gambas3-devel) weakremover(gambas3-gb-args) weakremover(gambas3-gb-cairo) weakremover(gambas3-gb-chart) weakremover(gambas3-gb-clipper) weakremover(gambas3-gb-complex) weakremover(gambas3-gb-compress) weakremover(gambas3-gb-compress-bzlib2) weakremover(gambas3-gb-compress-zlib) weakremover(gambas3-gb-crypt) weakremover(gambas3-gb-data) weakremover(gambas3-gb-db) weakremover(gambas3-gb-db-form) weakremover(gambas3-gb-db-mysql) weakremover(gambas3-gb-db-odbc) weakremover(gambas3-gb-db-postgresql) weakremover(gambas3-gb-db-sqlite2) weakremover(gambas3-gb-db-sqlite3) weakremover(gambas3-gb-dbus) weakremover(gambas3-gb-desktop) weakremover(gambas3-gb-eval-highlight) weakremover(gambas3-gb-form) weakremover(gambas3-gb-form-dialog) weakremover(gambas3-gb-form-editor) weakremover(gambas3-gb-form-mdi) weakremover(gambas3-gb-form-print) weakremover(gambas3-gb-form-stock) weakremover(gambas3-gb-form-terminal) weakremover(gambas3-gb-geom) weakremover(gambas3-gb-gmp) weakremover(gambas3-gb-gsl) weakremover(gambas3-gb-gtk) weakremover(gambas3-gb-gtk-opengl) weakremover(gambas3-gb-gtk3) weakremover(gambas3-gb-gui) weakremover(gambas3-gb-httpd) weakremover(gambas3-gb-image) weakremover(gambas3-gb-image-effect) weakremover(gambas3-gb-image-imlib) weakremover(gambas3-gb-image-io) weakremover(gambas3-gb-inotify) weakremover(gambas3-gb-jit) weakremover(gambas3-gb-libxml) weakremover(gambas3-gb-logging) weakremover(gambas3-gb-maps) weakremover(gambas3-gb-markdown) weakremover(gambas3-gb-media) weakremover(gambas3-gb-memcached) weakremover(gambas3-gb-mime) weakremover(gambas3-gb-mysql) weakremover(gambas3-gb-ncurses) weakremover(gambas3-gb-net) weakremover(gambas3-gb-net-curl) weakremover(gambas3-gb-net-pop3) weakremover(gambas3-gb-net-smtp) weakremover(gambas3-gb-openal) weakremover(gambas3-gb-opengl) weakremover(gambas3-gb-opengl-glsl) weakremover(gambas3-gb-opengl-glu) weakremover(gambas3-gb-opengl-sge) weakremover(gambas3-gb-openssl) weakremover(gambas3-gb-option) weakremover(gambas3-gb-pcre) weakremover(gambas3-gb-pdf) weakremover(gambas3-gb-qt4) weakremover(gambas3-gb-qt4-ext) weakremover(gambas3-gb-qt4-opengl) weakremover(gambas3-gb-qt4-webkit) weakremover(gambas3-gb-qt5) weakremover(gambas3-gb-qt5-ext) weakremover(gambas3-gb-qt5-opengl) weakremover(gambas3-gb-qt5-webkit) weakremover(gambas3-gb-report) weakremover(gambas3-gb-report2) weakremover(gambas3-gb-scanner) weakremover(gambas3-gb-sdl) weakremover(gambas3-gb-sdl-sound) weakremover(gambas3-gb-settings) weakremover(gambas3-gb-signal) weakremover(gambas3-gb-term) weakremover(gambas3-gb-term-form) weakremover(gambas3-gb-util) weakremover(gambas3-gb-util-web) weakremover(gambas3-gb-v4l) weakremover(gambas3-gb-vb) weakremover(gambas3-gb-web) weakremover(gambas3-gb-web-feed) weakremover(gambas3-gb-web-form) weakremover(gambas3-gb-xml) weakremover(gambas3-gb-xml-rpc) weakremover(gambas3-gb-xml-xslt) weakremover(gambas3-ide) weakremover(gambas3-runtime) weakremover(gambas3-script) weakremover(gamemoded) weakremover(gamin-devel) weakremover(gamin-server) weakremover(gammaray) weakremover(gammaray-devel) weakremover(gammastep) weakremover(gammastep-indicator) weakremover(gammu) weakremover(gammu-bash-completion) weakremover(gammu-devel) weakremover(gammu-smsd) weakremover(ganglia-devel) weakremover(ganglia-gmetad) weakremover(ganglia-gmetad-skip-bcheck) weakremover(ganglia-gmond) weakremover(ganglia-gmond-modules-python) weakremover(gangway) weakremover(gap) weakremover(gap-4ti2interface) weakremover(gap-ace) weakremover(gap-alnuth) weakremover(gap-atlasrep) weakremover(gap-autodoc) weakremover(gap-automata) weakremover(gap-automgrp) weakremover(gap-autpgrp) weakremover(gap-browse) weakremover(gap-cap) weakremover(gap-circle) weakremover(gap-cohomolo) weakremover(gap-congruence) weakremover(gap-convex) weakremover(gap-core) weakremover(gap-corelg) weakremover(gap-crime) weakremover(gap-crisp) weakremover(gap-cryst) weakremover(gap-crystcat) weakremover(gap-ctbllib) weakremover(gap-cvec) weakremover(gap-data) weakremover(gap-design) weakremover(gap-devel) weakremover(gap-digraphs) weakremover(gap-doc) weakremover(gap-edim) weakremover(gap-example) weakremover(gap-examplesforhomalg) weakremover(gap-factint) weakremover(gap-fga) weakremover(gap-fining) weakremover(gap-float) weakremover(gap-forms) weakremover(gap-fplsa) weakremover(gap-fr) weakremover(gap-full) weakremover(gap-gapdoc) weakremover(gap-gauss) weakremover(gap-gaussforhomalg) weakremover(gap-gbnp) weakremover(gap-generalizedmorphismsforcap) weakremover(gap-genss) weakremover(gap-gradedmodules) weakremover(gap-gradedringforhomalg) weakremover(gap-grape) weakremover(gap-groupoids) weakremover(gap-guarana) weakremover(gap-guava) weakremover(gap-hap) weakremover(gap-happrime) weakremover(gap-hecke) weakremover(gap-help) weakremover(gap-homalg) weakremover(gap-homalgtocas) weakremover(gap-idrel) weakremover(gap-intpic) weakremover(gap-io) weakremover(gap-io_forhomalg) weakremover(gap-irredsol) weakremover(gap-json) weakremover(gap-kan) weakremover(gap-kbmag) weakremover(gap-laguna) weakremover(gap-liepring) weakremover(gap-liering) weakremover(gap-localizeringforhomalg) weakremover(gap-loops) weakremover(gap-lpres) weakremover(gap-mapclass) weakremover(gap-matgrp) weakremover(gap-matricesforhomalg) weakremover(gap-modules) weakremover(gap-nilmat) weakremover(gap-normalizinterface) weakremover(gap-nq) weakremover(gap-numericalsgps) weakremover(gap-openmath) weakremover(gap-orb) weakremover(gap-patternclass) weakremover(gap-polenta) weakremover(gap-polycyclic) weakremover(gap-prim-groups) weakremover(gap-qaos) weakremover(gap-qpa) weakremover(gap-quagroup) weakremover(gap-radiroot) weakremover(gap-rcwa) weakremover(gap-rds) weakremover(gap-recog) weakremover(gap-recogbase) weakremover(gap-resclasses) weakremover(gap-ringsforhomalg) weakremover(gap-rpm-devel) weakremover(gap-sco) weakremover(gap-scscp) weakremover(gap-semigroups) weakremover(gap-sgpviz) weakremover(gap-simpcomp) weakremover(gap-sla) weakremover(gap-small-groups) weakremover(gap-smallsemi) weakremover(gap-sonata) weakremover(gap-spinsym) weakremover(gap-symbcompcc) weakremover(gap-toolsforhomalg) weakremover(gap-toric) weakremover(gap-toricvarieties) weakremover(gap-trans-groups) weakremover(gap-unitlib) weakremover(gap-utils) weakremover(gap-wedderga) weakremover(gap-xmod) weakremover(gap-xmodalg) weakremover(garlic) weakremover(gasnet) weakremover(gasnet-devel) weakremover(gasnet-doc) weakremover(gavl) weakremover(gawk) weakremover(gb) weakremover(gbdfed) weakremover(gc-devel) weakremover(gcab) weakremover(gcab-devel) weakremover(gcal) weakremover(gcc) weakremover(gcc-PIE) weakremover(gcc-ada) weakremover(gcc-c++) weakremover(gcc-d) weakremover(gcc-devel) weakremover(gcc-fortran) weakremover(gcc-gij) weakremover(gcc-go) weakremover(gcc-info) weakremover(gcc-java) weakremover(gcc-locale) weakremover(gcc-obj-c++) weakremover(gcc-objc) weakremover(gcc10) weakremover(gcc10-PIE) weakremover(gcc10-ada) weakremover(gcc10-c++) weakremover(gcc10-d) weakremover(gcc10-devel) weakremover(gcc10-fortran) weakremover(gcc10-go) weakremover(gcc10-info) weakremover(gcc10-locale) weakremover(gcc10-obj-c++) weakremover(gcc10-objc) weakremover(gcc10-testresults) weakremover(gcc11) weakremover(gcc11-PIE) weakremover(gcc11-ada) weakremover(gcc11-c++) weakremover(gcc11-d) weakremover(gcc11-devel) weakremover(gcc11-fortran) weakremover(gcc11-go) weakremover(gcc11-locale) weakremover(gcc11-obj-c++) weakremover(gcc11-objc) weakremover(gcc11-testresults) weakremover(gcc12) weakremover(gcc12-PIE) weakremover(gcc12-ada) weakremover(gcc12-c++) weakremover(gcc12-d) weakremover(gcc12-devel) weakremover(gcc12-fortran) weakremover(gcc12-go) weakremover(gcc12-locale) weakremover(gcc12-obj-c++) weakremover(gcc12-objc) weakremover(gcc12-testresults) weakremover(gcc13) weakremover(gcc13-PIE) weakremover(gcc13-ada) weakremover(gcc13-c++) weakremover(gcc13-d) weakremover(gcc13-devel) weakremover(gcc13-fortran) weakremover(gcc13-go) weakremover(gcc13-locale) weakremover(gcc13-m2) weakremover(gcc13-obj-c++) weakremover(gcc13-objc) weakremover(gcc13-rust) weakremover(gcc13-testresults) weakremover(gcc48) weakremover(gcc48-c++) weakremover(gcc48-fortran) weakremover(gcc48-gij) weakremover(gcc48-info) weakremover(gcc48-java) weakremover(gcc48-locale) weakremover(gcc48-obj-c++) weakremover(gcc48-objc) weakremover(gcc48-testresults) weakremover(gcc5) weakremover(gcc5-c++) weakremover(gcc5-fortran) weakremover(gcc5-go) weakremover(gcc5-info) weakremover(gcc5-locale) weakremover(gcc5-testresults) weakremover(gcc6) weakremover(gcc6-c++) weakremover(gcc6-fortran) weakremover(gcc6-gij) weakremover(gcc6-go) weakremover(gcc6-info) weakremover(gcc6-java) weakremover(gcc6-locale) weakremover(gcc6-obj-c++) weakremover(gcc6-objc) weakremover(gcc6-testresults) weakremover(gcc7) weakremover(gcc7-ada) weakremover(gcc7-c++) weakremover(gcc7-devel) weakremover(gcc7-fortran) weakremover(gcc7-go) weakremover(gcc7-locale) weakremover(gcc7-obj-c++) weakremover(gcc7-objc) weakremover(gcc7-testresults) weakremover(gcc8) weakremover(gcc8-ada) weakremover(gcc8-c++) weakremover(gcc8-devel) weakremover(gcc8-fortran) weakremover(gcc8-go) weakremover(gcc8-info) weakremover(gcc8-locale) weakremover(gcc8-obj-c++) weakremover(gcc8-objc) weakremover(gcc8-testresults) weakremover(gcc9) weakremover(gcc9-ada) weakremover(gcc9-c++) weakremover(gcc9-d) weakremover(gcc9-devel) weakremover(gcc9-fortran) weakremover(gcc9-go) weakremover(gcc9-info) weakremover(gcc9-locale) weakremover(gcc9-obj-c++) weakremover(gcc9-objc) weakremover(gcc9-testresults) weakremover(gcimagebundle) weakremover(gcimagebundle-test) weakremover(gcin) weakremover(gcin-anthy) weakremover(gcin-branding-upstream) weakremover(gcin-gtk2) weakremover(gcin-gtk3) weakremover(gcin-qt4) weakremover(gcin-qt5) weakremover(gcolor2) weakremover(gcolor3) weakremover(gcompris) weakremover(gcompris-devel) weakremover(gcompris-qt) weakremover(gcompris-voices-ar) weakremover(gcompris-voices-br) weakremover(gcompris-voices-cs) weakremover(gcompris-voices-da) weakremover(gcompris-voices-de) weakremover(gcompris-voices-el) weakremover(gcompris-voices-en) weakremover(gcompris-voices-es) weakremover(gcompris-voices-eu) weakremover(gcompris-voices-fi) weakremover(gcompris-voices-fr) weakremover(gcompris-voices-hi) weakremover(gcompris-voices-hu) weakremover(gcompris-voices-id) weakremover(gcompris-voices-it) weakremover(gcompris-voices-mr) weakremover(gcompris-voices-nb) weakremover(gcompris-voices-nl) weakremover(gcompris-voices-pt) weakremover(gcompris-voices-pt-br) weakremover(gcompris-voices-ru) weakremover(gcompris-voices-so) weakremover(gcompris-voices-sr) weakremover(gcompris-voices-sv) weakremover(gcompris-voices-tr) weakremover(gconf-editor) weakremover(gconf-editor-lang) weakremover(gconf-polkit) weakremover(gconf-sharp-peditors2) weakremover(gconf-sharp2) weakremover(gconf2) weakremover(gconf2-branding-openSUSE) weakremover(gconf2-devel) weakremover(gconf2-lang) weakremover(gconfmm-devel) weakremover(gcr-data) weakremover(gcr-prompter) weakremover(gcr-ssh-agent) weakremover(gcr-ssh-askpass) weakremover(gcr-viewer) weakremover(gcr3-data) weakremover(gcr3-prompter) weakremover(gcr3-ssh-agent) weakremover(gcr3-ssh-askpass) weakremover(gcr3-viewer) weakremover(gcrane) weakremover(gd) weakremover(gd-devel) weakremover(gdal) weakremover(gdal-devel) weakremover(gdb) weakremover(gdb-testresults) weakremover(gdbm-devel) weakremover(gdbserver) weakremover(gdcm) weakremover(gdcm-applications) weakremover(gdcm-devel) weakremover(gdcm-examples) weakremover(gdcm-libgdcm3_0) weakremover(gdk-pixbuf-devel) weakremover(gdk-pixbuf-loader-libavif) weakremover(gdk-pixbuf-loader-libheif) weakremover(gdk-pixbuf-loader-libopenraw) weakremover(gdk-pixbuf-loader-rsvg) weakremover(gdk-pixbuf-query-loaders) weakremover(gdk-pixbuf-thumbnailer) weakremover(gdk-pixbuf-xlib-devel) weakremover(gdl-devel) weakremover(gdlmm-devel) weakremover(gdm) weakremover(gdm-devel) weakremover(geany) weakremover(geany-devel) weakremover(geany-doc) weakremover(geany-plugins) weakremover(geary) weakremover(gebaar-libinput) weakremover(gecode-devel) weakremover(gecode-minizinc) weakremover(geda-base) weakremover(geda-doc) weakremover(geda-examples) weakremover(geda-gaf) weakremover(geda-gattrib) weakremover(geda-gnetlist) weakremover(geda-gschem) weakremover(geda-gsymcheck) weakremover(geda-symbols) weakremover(geda-utils) weakremover(geda-xgsch2pcb) weakremover(geda-xorn) weakremover(gede) weakremover(gedit) weakremover(gedit-devel) weakremover(gedit-plugin-bookmarks) weakremover(gedit-plugin-bracketcompletion) weakremover(gedit-plugin-charmap) weakremover(gedit-plugin-code-assistance) weakremover(gedit-plugin-codecomment) weakremover(gedit-plugin-colorpicker) weakremover(gedit-plugin-colorschemer) weakremover(gedit-plugin-commander) weakremover(gedit-plugin-dashboard) weakremover(gedit-plugin-devhelp) weakremover(gedit-plugin-drawspaces) weakremover(gedit-plugin-findinfiles) weakremover(gedit-plugin-git) weakremover(gedit-plugin-joinlines) weakremover(gedit-plugin-latex) weakremover(gedit-plugin-multiedit) weakremover(gedit-plugin-session-saver) weakremover(gedit-plugin-smartspaces) weakremover(gedit-plugin-synctex) weakremover(gedit-plugin-terminal) weakremover(gedit-plugin-textsize) weakremover(gedit-plugin-translate) weakremover(gedit-plugin-wordcompletion) weakremover(gedit-plugin-zeitgeist) weakremover(gedit-plugins) weakremover(gedit-plugins-data) weakremover(gedit-theme-plata) weakremover(geeqie) weakremover(gegl) weakremover(gegl-0_2) weakremover(gegl-0_2-lang) weakremover(gegl-0_3) weakremover(gegl-0_3-lang) weakremover(gegl-0_4) weakremover(gegl-devel) weakremover(gegl-doc) weakremover(gegl-unstable) weakremover(gegl-unstable-devel) weakremover(gegl-unstable-doc) weakremover(geis-devel) weakremover(geis-tools) weakremover(gemrb) weakremover(genders) weakremover(genders-base) weakremover(genders-devel) weakremover(genders-perl-compat) weakremover(geners-devel) weakremover(gengetopt) weakremover(genisoimage) weakremover(genius) weakremover(genius-devel) weakremover(genromfs) weakremover(gensio) weakremover(gensio-devel) weakremover(geoclue) weakremover(geoclue-example) weakremover(geoclue-gsmloc) weakremover(geoclue-recommended) weakremover(geoclue2) weakremover(geoclue2-devel) weakremover(geocode-glib) weakremover(geocode-glib-devel) weakremover(geocode-glib-soup2-devel) weakremover(geoipupdate) weakremover(geoipupdate-legacy) weakremover(geos) weakremover(geos-devel) weakremover(geos-doc) weakremover(geotiff) weakremover(geotiff-devel) weakremover(gerbera) weakremover(gerbv) weakremover(gerbv-devel) weakremover(geronimo-specs) weakremover(geronimo-specs-javadoc) weakremover(get-flash-videos) weakremover(getdata) weakremover(getdata-devel) weakremover(getdata-doc) weakremover(getdp) weakremover(getdp-devel) weakremover(getdp-doc) weakremover(getmail) weakremover(getmail-doc) weakremover(gettext-csharp) weakremover(gettext-its-gtk4) weakremover(gettext-java) weakremover(gettext-runtime) weakremover(gettext-runtime-mini) weakremover(gettext-tools) weakremover(gettext-tools-mini) weakremover(gexif) weakremover(gf2x-devel) weakremover(gfan) weakremover(gfbgraph-devel) weakremover(gfio) weakremover(gflags) weakremover(gflags-devel) weakremover(gflags-devel-static) weakremover(gfs2-utils) weakremover(gftp) weakremover(gftp-common) weakremover(gftp-common-lang) weakremover(gftp-text) weakremover(ggz-client-libs) weakremover(ggz-client-libs-devel) weakremover(ggz-client-libs-lang) weakremover(gh) weakremover(ghc) weakremover(ghc-AC-Vector) weakremover(ghc-AC-Vector-devel) weakremover(ghc-ALUT) weakremover(ghc-ALUT-devel) weakremover(ghc-Agda) weakremover(ghc-Agda-devel) weakremover(ghc-BNFC) weakremover(ghc-BNFC-devel) weakremover(ghc-BlastHTTP) weakremover(ghc-BlastHTTP-devel) weakremover(ghc-Boolean) weakremover(ghc-Boolean-devel) weakremover(ghc-BoundedChan) weakremover(ghc-BoundedChan-devel) weakremover(ghc-Cabal) weakremover(ghc-Cabal-devel) weakremover(ghc-Cabal-ide-backend) weakremover(ghc-Cabal-ide-backend-devel) weakremover(ghc-Cabal-prof) weakremover(ghc-Cabal-syntax) weakremover(ghc-Cabal-syntax-devel) weakremover(ghc-Cabal-syntax-prof) weakremover(ghc-ChannelT) weakremover(ghc-ChannelT-devel) weakremover(ghc-Chart) weakremover(ghc-Chart-cairo) weakremover(ghc-Chart-cairo-devel) weakremover(ghc-Chart-devel) weakremover(ghc-Chart-diagrams) weakremover(ghc-Chart-diagrams-devel) weakremover(ghc-ChasingBottoms) weakremover(ghc-ChasingBottoms-devel) weakremover(ghc-Clipboard) weakremover(ghc-Clipboard-devel) weakremover(ghc-ClustalParser) weakremover(ghc-ClustalParser-devel) weakremover(ghc-ConfigFile) weakremover(ghc-ConfigFile-devel) weakremover(ghc-DAV) weakremover(ghc-DAV-devel) weakremover(ghc-DAV-prof) weakremover(ghc-DRBG) weakremover(ghc-DRBG-devel) weakremover(ghc-Decimal) weakremover(ghc-Decimal-devel) weakremover(ghc-Decimal-prof) weakremover(ghc-Diff) weakremover(ghc-Diff-devel) weakremover(ghc-Diff-prof) weakremover(ghc-Earley) weakremover(ghc-Earley-devel) weakremover(ghc-EdisonAPI) weakremover(ghc-EdisonAPI-devel) weakremover(ghc-EdisonCore) weakremover(ghc-EdisonCore-devel) weakremover(ghc-EntrezHTTP) weakremover(ghc-EntrezHTTP-devel) weakremover(ghc-FenwickTree) weakremover(ghc-FenwickTree-devel) weakremover(ghc-FindBin) weakremover(ghc-FindBin-devel) weakremover(ghc-FloatingHex) weakremover(ghc-FloatingHex-devel) weakremover(ghc-FontyFruity) weakremover(ghc-FontyFruity-devel) weakremover(ghc-Frames) weakremover(ghc-Frames-devel) weakremover(ghc-GLFW-b) weakremover(ghc-GLFW-b-devel) weakremover(ghc-GLURaw) weakremover(ghc-GLURaw-devel) weakremover(ghc-GLUT) weakremover(ghc-GLUT-devel) weakremover(ghc-Genbank) weakremover(ghc-Genbank-devel) weakremover(ghc-GenericPretty) weakremover(ghc-GenericPretty-devel) weakremover(ghc-Glob) weakremover(ghc-Glob-devel) weakremover(ghc-Glob-prof) weakremover(ghc-GraphSCC) weakremover(ghc-GraphSCC-devel) weakremover(ghc-HCodecs) weakremover(ghc-HCodecs-devel) weakremover(ghc-HDBC) weakremover(ghc-HDBC-devel) weakremover(ghc-HDBC-session) weakremover(ghc-HDBC-session-devel) weakremover(ghc-HList) weakremover(ghc-HList-devel) weakremover(ghc-HPDF) weakremover(ghc-HPDF-devel) weakremover(ghc-HSet) weakremover(ghc-HSet-devel) weakremover(ghc-HStringTemplate) weakremover(ghc-HStringTemplate-devel) weakremover(ghc-HTF) weakremover(ghc-HTF-devel) weakremover(ghc-HTTP) weakremover(ghc-HTTP-devel) weakremover(ghc-HTTP-prof) weakremover(ghc-HUnit) weakremover(ghc-HUnit-approx) weakremover(ghc-HUnit-approx-devel) weakremover(ghc-HUnit-devel) weakremover(ghc-HUnit-prof) weakremover(ghc-HaTeX) weakremover(ghc-HaTeX-devel) weakremover(ghc-HaXml) weakremover(ghc-HaXml-devel) weakremover(ghc-HandsomeSoup) weakremover(ghc-HandsomeSoup-devel) weakremover(ghc-HaskellNet) weakremover(ghc-HaskellNet-SSL) weakremover(ghc-HaskellNet-SSL-devel) weakremover(ghc-HaskellNet-devel) weakremover(ghc-Hclip) weakremover(ghc-Hclip-devel) weakremover(ghc-HsOpenSSL) weakremover(ghc-HsOpenSSL-devel) weakremover(ghc-HsOpenSSL-x509-system) weakremover(ghc-HsOpenSSL-x509-system-devel) weakremover(ghc-HsSyck) weakremover(ghc-HsSyck-devel) weakremover(ghc-HsYAML) weakremover(ghc-HsYAML-aeson) weakremover(ghc-HsYAML-aeson-devel) weakremover(ghc-HsYAML-devel) weakremover(ghc-HsYAML-prof) weakremover(ghc-IPv6Addr) weakremover(ghc-IPv6Addr-devel) weakremover(ghc-IfElse) weakremover(ghc-IfElse-devel) weakremover(ghc-IfElse-prof) weakremover(ghc-IntervalMap) weakremover(ghc-IntervalMap-devel) weakremover(ghc-JuicyPixels) weakremover(ghc-JuicyPixels-devel) weakremover(ghc-JuicyPixels-extra) weakremover(ghc-JuicyPixels-extra-devel) weakremover(ghc-JuicyPixels-prof) weakremover(ghc-JuicyPixels-scale-dct) weakremover(ghc-JuicyPixels-scale-dct-devel) weakremover(ghc-LibZip) weakremover(ghc-LibZip-devel) weakremover(ghc-List) weakremover(ghc-List-devel) weakremover(ghc-ListLike) weakremover(ghc-ListLike-devel) weakremover(ghc-MFlow) weakremover(ghc-MFlow-devel) weakremover(ghc-MemoTrie) weakremover(ghc-MemoTrie-devel) weakremover(ghc-MissingH) weakremover(ghc-MissingH-devel) weakremover(ghc-MonadCatchIO-transformers) weakremover(ghc-MonadCatchIO-transformers-devel) weakremover(ghc-MonadPrompt) weakremover(ghc-MonadPrompt-devel) weakremover(ghc-MonadRandom) weakremover(ghc-MonadRandom-devel) weakremover(ghc-MusicBrainz) weakremover(ghc-MusicBrainz-devel) weakremover(ghc-Network-NineP) weakremover(ghc-Network-NineP-devel) weakremover(ghc-NineP) weakremover(ghc-NineP-devel) weakremover(ghc-NoTrace) weakremover(ghc-NoTrace-devel) weakremover(ghc-NumInstances) weakremover(ghc-NumInstances-devel) weakremover(ghc-ObjectName) weakremover(ghc-ObjectName-devel) weakremover(ghc-Octree) weakremover(ghc-Octree-devel) weakremover(ghc-OddWord) weakremover(ghc-OddWord-devel) weakremover(ghc-OneTuple) weakremover(ghc-OneTuple-devel) weakremover(ghc-OneTuple-prof) weakremover(ghc-Only) weakremover(ghc-Only-devel) weakremover(ghc-Only-prof) weakremover(ghc-OpenAL) weakremover(ghc-OpenAL-devel) weakremover(ghc-OpenGL) weakremover(ghc-OpenGL-devel) weakremover(ghc-OpenGLRaw) weakremover(ghc-OpenGLRaw-devel) weakremover(ghc-PSQueue) weakremover(ghc-PSQueue-devel) weakremover(ghc-ParsecTools) weakremover(ghc-ParsecTools-devel) weakremover(ghc-QuasiText) weakremover(ghc-QuasiText-devel) weakremover(ghc-QuickCheck) weakremover(ghc-QuickCheck-devel) weakremover(ghc-QuickCheck-prof) weakremover(ghc-RNAlien) weakremover(ghc-RNAlien-devel) weakremover(ghc-RSA) weakremover(ghc-RSA-devel) weakremover(ghc-Rasterific) weakremover(ghc-Rasterific-devel) weakremover(ghc-ReadArgs) weakremover(ghc-ReadArgs-devel) weakremover(ghc-RefSerialize) weakremover(ghc-RefSerialize-devel) weakremover(ghc-SDL) weakremover(ghc-SDL-devel) weakremover(ghc-SDL-image) weakremover(ghc-SDL-image-devel) weakremover(ghc-SDL-mixer) weakremover(ghc-SDL-mixer-devel) weakremover(ghc-SHA) weakremover(ghc-SHA-devel) weakremover(ghc-SHA-prof) weakremover(ghc-STMonadTrans) weakremover(ghc-STMonadTrans-devel) weakremover(ghc-SVGFonts) weakremover(ghc-SVGFonts-devel) weakremover(ghc-SafeSemaphore) weakremover(ghc-SafeSemaphore-devel) weakremover(ghc-SafeSemaphore-prof) weakremover(ghc-SegmentTree) weakremover(ghc-SegmentTree-devel) weakremover(ghc-ShellCheck) weakremover(ghc-ShellCheck-devel) weakremover(ghc-ShellCheck-prof) weakremover(ghc-Spintax) weakremover(ghc-Spintax-devel) weakremover(ghc-Spock) weakremover(ghc-Spock-api) weakremover(ghc-Spock-api-devel) weakremover(ghc-Spock-api-server) weakremover(ghc-Spock-api-server-devel) weakremover(ghc-Spock-core) weakremover(ghc-Spock-core-devel) weakremover(ghc-Spock-devel) weakremover(ghc-Spock-lucid) weakremover(ghc-Spock-lucid-devel) weakremover(ghc-Spock-worker) weakremover(ghc-Spock-worker-devel) weakremover(ghc-StateVar) weakremover(ghc-StateVar-devel) weakremover(ghc-StateVar-prof) weakremover(ghc-Strafunski-StrategyLib) weakremover(ghc-Strafunski-StrategyLib-devel) weakremover(ghc-Stream) weakremover(ghc-Stream-devel) weakremover(ghc-TCache) weakremover(ghc-TCache-devel) weakremover(ghc-Taxonomy) weakremover(ghc-Taxonomy-devel) weakremover(ghc-TypeCompose) weakremover(ghc-TypeCompose-devel) weakremover(ghc-Unique) weakremover(ghc-Unique-devel) weakremover(ghc-Unixutils) weakremover(ghc-Unixutils-devel) weakremover(ghc-ViennaRNAParser) weakremover(ghc-ViennaRNAParser-devel) weakremover(ghc-Workflow) weakremover(ghc-Workflow-devel) weakremover(ghc-X11) weakremover(ghc-X11-devel) weakremover(ghc-X11-prof) weakremover(ghc-X11-xft) weakremover(ghc-X11-xft-devel) weakremover(ghc-X11-xft-prof) weakremover(ghc-Xauth) weakremover(ghc-Xauth-devel) weakremover(ghc-Yampa) weakremover(ghc-Yampa-devel) weakremover(ghc-abstract-deque) weakremover(ghc-abstract-deque-devel) weakremover(ghc-abstract-par) weakremover(ghc-abstract-par-devel) weakremover(ghc-accelerate) weakremover(ghc-accelerate-devel) weakremover(ghc-accuerr) weakremover(ghc-accuerr-devel) weakremover(ghc-ace) weakremover(ghc-ace-devel) weakremover(ghc-acid-state) weakremover(ghc-acid-state-devel) weakremover(ghc-action-permutations) weakremover(ghc-action-permutations-devel) weakremover(ghc-active) weakremover(ghc-active-devel) weakremover(ghc-ad) weakremover(ghc-ad-devel) weakremover(ghc-adjunctions) weakremover(ghc-adjunctions-devel) weakremover(ghc-adjunctions-prof) weakremover(ghc-adler32) weakremover(ghc-adler32-devel) weakremover(ghc-aeson) weakremover(ghc-aeson-better-errors) weakremover(ghc-aeson-better-errors-devel) weakremover(ghc-aeson-casing) weakremover(ghc-aeson-casing-devel) weakremover(ghc-aeson-compat) weakremover(ghc-aeson-compat-devel) weakremover(ghc-aeson-devel) weakremover(ghc-aeson-extra) weakremover(ghc-aeson-extra-devel) weakremover(ghc-aeson-generic-compat) weakremover(ghc-aeson-generic-compat-devel) weakremover(ghc-aeson-injector) weakremover(ghc-aeson-injector-devel) weakremover(ghc-aeson-pretty) weakremover(ghc-aeson-pretty-devel) weakremover(ghc-aeson-pretty-prof) weakremover(ghc-aeson-prof) weakremover(ghc-aeson-qq) weakremover(ghc-aeson-qq-devel) weakremover(ghc-aeson-utils) weakremover(ghc-aeson-utils-devel) weakremover(ghc-aeson-yaml) weakremover(ghc-aeson-yaml-devel) weakremover(ghc-airship) weakremover(ghc-airship-devel) weakremover(ghc-alarmclock) weakremover(ghc-alarmclock-devel) weakremover(ghc-algebraic-graphs) weakremover(ghc-algebraic-graphs-devel) weakremover(ghc-alsa-core) weakremover(ghc-alsa-core-devel) weakremover(ghc-alsa-core-prof) weakremover(ghc-alsa-mixer) weakremover(ghc-alsa-mixer-devel) weakremover(ghc-alsa-mixer-prof) weakremover(ghc-alternators) weakremover(ghc-alternators-devel) weakremover(ghc-amazonka) weakremover(ghc-amazonka-apigateway) weakremover(ghc-amazonka-apigateway-devel) weakremover(ghc-amazonka-application-autoscaling) weakremover(ghc-amazonka-application-autoscaling-devel) weakremover(ghc-amazonka-appstream) weakremover(ghc-amazonka-appstream-devel) weakremover(ghc-amazonka-autoscaling) weakremover(ghc-amazonka-autoscaling-devel) weakremover(ghc-amazonka-budgets) weakremover(ghc-amazonka-budgets-devel) weakremover(ghc-amazonka-certificatemanager) weakremover(ghc-amazonka-certificatemanager-devel) weakremover(ghc-amazonka-cloudformation) weakremover(ghc-amazonka-cloudformation-devel) weakremover(ghc-amazonka-cloudfront) weakremover(ghc-amazonka-cloudfront-devel) weakremover(ghc-amazonka-cloudhsm) weakremover(ghc-amazonka-cloudhsm-devel) weakremover(ghc-amazonka-cloudsearch) weakremover(ghc-amazonka-cloudsearch-devel) weakremover(ghc-amazonka-cloudsearch-domains) weakremover(ghc-amazonka-cloudsearch-domains-devel) weakremover(ghc-amazonka-cloudtrail) weakremover(ghc-amazonka-cloudtrail-devel) weakremover(ghc-amazonka-cloudwatch) weakremover(ghc-amazonka-cloudwatch-devel) weakremover(ghc-amazonka-cloudwatch-events) weakremover(ghc-amazonka-cloudwatch-events-devel) weakremover(ghc-amazonka-cloudwatch-logs) weakremover(ghc-amazonka-cloudwatch-logs-devel) weakremover(ghc-amazonka-codebuild) weakremover(ghc-amazonka-codebuild-devel) weakremover(ghc-amazonka-codecommit) weakremover(ghc-amazonka-codecommit-devel) weakremover(ghc-amazonka-codedeploy) weakremover(ghc-amazonka-codedeploy-devel) weakremover(ghc-amazonka-codepipeline) weakremover(ghc-amazonka-codepipeline-devel) weakremover(ghc-amazonka-cognito-identity) weakremover(ghc-amazonka-cognito-identity-devel) weakremover(ghc-amazonka-cognito-idp) weakremover(ghc-amazonka-cognito-idp-devel) weakremover(ghc-amazonka-cognito-sync) weakremover(ghc-amazonka-cognito-sync-devel) weakremover(ghc-amazonka-config) weakremover(ghc-amazonka-config-devel) weakremover(ghc-amazonka-core) weakremover(ghc-amazonka-core-devel) weakremover(ghc-amazonka-datapipeline) weakremover(ghc-amazonka-datapipeline-devel) weakremover(ghc-amazonka-devel) weakremover(ghc-amazonka-devicefarm) weakremover(ghc-amazonka-devicefarm-devel) weakremover(ghc-amazonka-directconnect) weakremover(ghc-amazonka-directconnect-devel) weakremover(ghc-amazonka-discovery) weakremover(ghc-amazonka-discovery-devel) weakremover(ghc-amazonka-dms) weakremover(ghc-amazonka-dms-devel) weakremover(ghc-amazonka-ds) weakremover(ghc-amazonka-ds-devel) weakremover(ghc-amazonka-dynamodb) weakremover(ghc-amazonka-dynamodb-devel) weakremover(ghc-amazonka-dynamodb-streams) weakremover(ghc-amazonka-dynamodb-streams-devel) weakremover(ghc-amazonka-ecr) weakremover(ghc-amazonka-ecr-devel) weakremover(ghc-amazonka-ecs) weakremover(ghc-amazonka-ecs-devel) weakremover(ghc-amazonka-efs) weakremover(ghc-amazonka-efs-devel) weakremover(ghc-amazonka-elasticache) weakremover(ghc-amazonka-elasticache-devel) weakremover(ghc-amazonka-elasticbeanstalk) weakremover(ghc-amazonka-elasticbeanstalk-devel) weakremover(ghc-amazonka-elasticsearch) weakremover(ghc-amazonka-elasticsearch-devel) weakremover(ghc-amazonka-elastictranscoder) weakremover(ghc-amazonka-elastictranscoder-devel) weakremover(ghc-amazonka-elb) weakremover(ghc-amazonka-elb-devel) weakremover(ghc-amazonka-elbv2) weakremover(ghc-amazonka-elbv2-devel) weakremover(ghc-amazonka-emr) weakremover(ghc-amazonka-emr-devel) weakremover(ghc-amazonka-gamelift) weakremover(ghc-amazonka-gamelift-devel) weakremover(ghc-amazonka-glacier) weakremover(ghc-amazonka-glacier-devel) weakremover(ghc-amazonka-health) weakremover(ghc-amazonka-health-devel) weakremover(ghc-amazonka-iam) weakremover(ghc-amazonka-iam-devel) weakremover(ghc-amazonka-importexport) weakremover(ghc-amazonka-importexport-devel) weakremover(ghc-amazonka-iot) weakremover(ghc-amazonka-iot-dataplane) weakremover(ghc-amazonka-iot-dataplane-devel) weakremover(ghc-amazonka-iot-devel) weakremover(ghc-amazonka-kinesis) weakremover(ghc-amazonka-kinesis-analytics) weakremover(ghc-amazonka-kinesis-analytics-devel) weakremover(ghc-amazonka-kinesis-devel) weakremover(ghc-amazonka-kinesis-firehose) weakremover(ghc-amazonka-kinesis-firehose-devel) weakremover(ghc-amazonka-kms) weakremover(ghc-amazonka-kms-devel) weakremover(ghc-amazonka-lambda) weakremover(ghc-amazonka-lambda-devel) weakremover(ghc-amazonka-lightsail) weakremover(ghc-amazonka-lightsail-devel) weakremover(ghc-amazonka-marketplace-analytics) weakremover(ghc-amazonka-marketplace-analytics-devel) weakremover(ghc-amazonka-marketplace-metering) weakremover(ghc-amazonka-marketplace-metering-devel) weakremover(ghc-amazonka-ml) weakremover(ghc-amazonka-ml-devel) weakremover(ghc-amazonka-opsworks) weakremover(ghc-amazonka-opsworks-cm) weakremover(ghc-amazonka-opsworks-cm-devel) weakremover(ghc-amazonka-opsworks-devel) weakremover(ghc-amazonka-pinpoint) weakremover(ghc-amazonka-pinpoint-devel) weakremover(ghc-amazonka-polly) weakremover(ghc-amazonka-polly-devel) weakremover(ghc-amazonka-redshift) weakremover(ghc-amazonka-redshift-devel) weakremover(ghc-amazonka-rekognition) weakremover(ghc-amazonka-rekognition-devel) weakremover(ghc-amazonka-route53) weakremover(ghc-amazonka-route53-devel) weakremover(ghc-amazonka-route53-domains) weakremover(ghc-amazonka-route53-domains-devel) weakremover(ghc-amazonka-s3) weakremover(ghc-amazonka-s3-devel) weakremover(ghc-amazonka-sdb) weakremover(ghc-amazonka-sdb-devel) weakremover(ghc-amazonka-servicecatalog) weakremover(ghc-amazonka-servicecatalog-devel) weakremover(ghc-amazonka-ses) weakremover(ghc-amazonka-ses-devel) weakremover(ghc-amazonka-shield) weakremover(ghc-amazonka-shield-devel) weakremover(ghc-amazonka-sms) weakremover(ghc-amazonka-sms-devel) weakremover(ghc-amazonka-snowball) weakremover(ghc-amazonka-snowball-devel) weakremover(ghc-amazonka-sns) weakremover(ghc-amazonka-sns-devel) weakremover(ghc-amazonka-sqs) weakremover(ghc-amazonka-sqs-devel) weakremover(ghc-amazonka-stepfunctions) weakremover(ghc-amazonka-stepfunctions-devel) weakremover(ghc-amazonka-storagegateway) weakremover(ghc-amazonka-storagegateway-devel) weakremover(ghc-amazonka-sts) weakremover(ghc-amazonka-sts-devel) weakremover(ghc-amazonka-support) weakremover(ghc-amazonka-support-devel) weakremover(ghc-amazonka-swf) weakremover(ghc-amazonka-swf-devel) weakremover(ghc-amazonka-test) weakremover(ghc-amazonka-test-devel) weakremover(ghc-amazonka-waf) weakremover(ghc-amazonka-waf-devel) weakremover(ghc-amazonka-workspaces) weakremover(ghc-amazonka-workspaces-devel) weakremover(ghc-amazonka-xray) weakremover(ghc-amazonka-xray-devel) weakremover(ghc-amqp) weakremover(ghc-amqp-devel) weakremover(ghc-annotated-wl-pprint) weakremover(ghc-annotated-wl-pprint-devel) weakremover(ghc-anonymous-sums) weakremover(ghc-anonymous-sums-devel) weakremover(ghc-ansi-terminal) weakremover(ghc-ansi-terminal-devel) weakremover(ghc-ansi-terminal-prof) weakremover(ghc-ansi-terminal-types) weakremover(ghc-ansi-terminal-types-devel) weakremover(ghc-ansi-terminal-types-prof) weakremover(ghc-ansi-wl-pprint) weakremover(ghc-ansi-wl-pprint-devel) weakremover(ghc-ansi-wl-pprint-prof) weakremover(ghc-ansigraph) weakremover(ghc-ansigraph-devel) weakremover(ghc-ap-normalize) weakremover(ghc-ap-normalize-devel) weakremover(ghc-api-field-json-th) weakremover(ghc-api-field-json-th-devel) weakremover(ghc-app-settings) weakremover(ghc-app-settings-devel) weakremover(ghc-appar) weakremover(ghc-appar-devel) weakremover(ghc-appar-prof) weakremover(ghc-applicative-quoters) weakremover(ghc-applicative-quoters-devel) weakremover(ghc-arithmoi) weakremover(ghc-arithmoi-devel) weakremover(ghc-array) weakremover(ghc-array-devel) weakremover(ghc-array-memoize) weakremover(ghc-array-memoize-devel) weakremover(ghc-array-prof) weakremover(ghc-arrow-list) weakremover(ghc-arrow-list-devel) weakremover(ghc-arrows) weakremover(ghc-arrows-devel) weakremover(ghc-ascii-progress) weakremover(ghc-ascii-progress-devel) weakremover(ghc-asciidiagram) weakremover(ghc-asciidiagram-devel) weakremover(ghc-asn1-encoding) weakremover(ghc-asn1-encoding-devel) weakremover(ghc-asn1-encoding-prof) weakremover(ghc-asn1-parse) weakremover(ghc-asn1-parse-devel) weakremover(ghc-asn1-parse-prof) weakremover(ghc-asn1-types) weakremover(ghc-asn1-types-devel) weakremover(ghc-asn1-types-prof) weakremover(ghc-assoc) weakremover(ghc-assoc-devel) weakremover(ghc-assoc-prof) weakremover(ghc-async) weakremover(ghc-async-dejafu) weakremover(ghc-async-dejafu-devel) weakremover(ghc-async-devel) weakremover(ghc-async-extra) weakremover(ghc-async-extra-devel) weakremover(ghc-async-prof) weakremover(ghc-async-timer) weakremover(ghc-async-timer-devel) weakremover(ghc-atom-basic) weakremover(ghc-atom-basic-devel) weakremover(ghc-atom-conduit) weakremover(ghc-atom-conduit-devel) weakremover(ghc-atomic-primops) weakremover(ghc-atomic-primops-devel) weakremover(ghc-atomic-write) weakremover(ghc-atomic-write-devel) weakremover(ghc-attoparsec) weakremover(ghc-attoparsec-binary) weakremover(ghc-attoparsec-binary-devel) weakremover(ghc-attoparsec-devel) weakremover(ghc-attoparsec-expr) weakremover(ghc-attoparsec-expr-devel) weakremover(ghc-attoparsec-iso8601) weakremover(ghc-attoparsec-iso8601-devel) weakremover(ghc-attoparsec-iso8601-prof) weakremover(ghc-attoparsec-prof) weakremover(ghc-authenticate) weakremover(ghc-authenticate-devel) weakremover(ghc-authenticate-oauth) weakremover(ghc-authenticate-oauth-devel) weakremover(ghc-auto) weakremover(ghc-auto-devel) weakremover(ghc-auto-update) weakremover(ghc-auto-update-devel) weakremover(ghc-auto-update-prof) weakremover(ghc-autoexporter) weakremover(ghc-autoexporter-devel) weakremover(ghc-avwx) weakremover(ghc-avwx-devel) weakremover(ghc-aws) weakremover(ghc-aws-devel) weakremover(ghc-aws-prof) weakremover(ghc-b9) weakremover(ghc-b9-devel) weakremover(ghc-bake) weakremover(ghc-bake-devel) weakremover(ghc-bank-holidays-england) weakremover(ghc-bank-holidays-england-devel) weakremover(ghc-barbies) weakremover(ghc-barbies-devel) weakremover(ghc-base) weakremover(ghc-base-compat) weakremover(ghc-base-compat-batteries) weakremover(ghc-base-compat-batteries-devel) weakremover(ghc-base-compat-batteries-prof) weakremover(ghc-base-compat-devel) weakremover(ghc-base-compat-prof) weakremover(ghc-base-devel) weakremover(ghc-base-noprelude) weakremover(ghc-base-noprelude-devel) weakremover(ghc-base-orphans) weakremover(ghc-base-orphans-devel) weakremover(ghc-base-orphans-prof) weakremover(ghc-base-prelude) weakremover(ghc-base-prelude-devel) weakremover(ghc-base-prof) weakremover(ghc-base-unicode-symbols) weakremover(ghc-base-unicode-symbols-devel) weakremover(ghc-base-unicode-symbols-prof) weakremover(ghc-base16-bytestring) weakremover(ghc-base16-bytestring-devel) weakremover(ghc-base16-bytestring-prof) weakremover(ghc-base32string) weakremover(ghc-base32string-devel) weakremover(ghc-base58-bytestring) weakremover(ghc-base58-bytestring-devel) weakremover(ghc-base58string) weakremover(ghc-base58string-devel) weakremover(ghc-base64) weakremover(ghc-base64-bytestring) weakremover(ghc-base64-bytestring-devel) weakremover(ghc-base64-bytestring-prof) weakremover(ghc-base64-bytestring-type) weakremover(ghc-base64-bytestring-type-devel) weakremover(ghc-base64-devel) weakremover(ghc-base64-prof) weakremover(ghc-base64-string) weakremover(ghc-base64-string-devel) weakremover(ghc-basement) weakremover(ghc-basement-devel) weakremover(ghc-basement-prof) weakremover(ghc-basic-prelude) weakremover(ghc-basic-prelude-devel) weakremover(ghc-bcrypt) weakremover(ghc-bcrypt-devel) weakremover(ghc-bech32) weakremover(ghc-bech32-devel) weakremover(ghc-bech32-th) weakremover(ghc-bech32-th-devel) weakremover(ghc-benchpress) weakremover(ghc-benchpress-devel) weakremover(ghc-bencode) weakremover(ghc-bencode-devel) weakremover(ghc-bencode-prof) weakremover(ghc-bento) weakremover(ghc-bento-devel) weakremover(ghc-bifunctors) weakremover(ghc-bifunctors-devel) weakremover(ghc-bifunctors-prof) weakremover(ghc-bimap) weakremover(ghc-bimap-devel) weakremover(ghc-bimap-prof) weakremover(ghc-bimap-server) weakremover(ghc-bimap-server-devel) weakremover(ghc-binary) weakremover(ghc-binary-bits) weakremover(ghc-binary-bits-devel) weakremover(ghc-binary-conduit) weakremover(ghc-binary-conduit-devel) weakremover(ghc-binary-devel) weakremover(ghc-binary-ieee754) weakremover(ghc-binary-ieee754-devel) weakremover(ghc-binary-list) weakremover(ghc-binary-list-devel) weakremover(ghc-binary-orphans) weakremover(ghc-binary-orphans-devel) weakremover(ghc-binary-orphans-prof) weakremover(ghc-binary-parser) weakremover(ghc-binary-parser-devel) weakremover(ghc-binary-parsers) weakremover(ghc-binary-parsers-devel) weakremover(ghc-binary-prof) weakremover(ghc-binary-search) weakremover(ghc-binary-search-devel) weakremover(ghc-binary-tagged) weakremover(ghc-binary-tagged-devel) weakremover(ghc-bindings-DSL) weakremover(ghc-bindings-DSL-devel) weakremover(ghc-bindings-GLFW) weakremover(ghc-bindings-GLFW-devel) weakremover(ghc-bindings-libzip) weakremover(ghc-bindings-libzip-devel) weakremover(ghc-bindings-uname) weakremover(ghc-bindings-uname-devel) weakremover(ghc-bioace) weakremover(ghc-bioace-devel) weakremover(ghc-bioalign) weakremover(ghc-bioalign-devel) weakremover(ghc-biocore) weakremover(ghc-biocore-devel) weakremover(ghc-biofasta) weakremover(ghc-biofasta-devel) weakremover(ghc-biofastq) weakremover(ghc-biofastq-devel) weakremover(ghc-biopsl) weakremover(ghc-biopsl-devel) weakremover(ghc-bitarray) weakremover(ghc-bitarray-devel) weakremover(ghc-bitcoin-api) weakremover(ghc-bitcoin-api-devel) weakremover(ghc-bitcoin-api-extra) weakremover(ghc-bitcoin-api-extra-devel) weakremover(ghc-bitcoin-block) weakremover(ghc-bitcoin-block-devel) weakremover(ghc-bitcoin-script) weakremover(ghc-bitcoin-script-devel) weakremover(ghc-bitcoin-tx) weakremover(ghc-bitcoin-tx-devel) weakremover(ghc-bitcoin-types) weakremover(ghc-bitcoin-types-devel) weakremover(ghc-bitmap) weakremover(ghc-bitmap-devel) weakremover(ghc-bits) weakremover(ghc-bits-devel) weakremover(ghc-bitvec) weakremover(ghc-bitvec-devel) weakremover(ghc-bitvec-prof) weakremover(ghc-bitx-bitcoin) weakremover(ghc-bitx-bitcoin-devel) weakremover(ghc-blake2) weakremover(ghc-blake2-devel) weakremover(ghc-blank-canvas) weakremover(ghc-blank-canvas-devel) weakremover(ghc-blastxml) weakremover(ghc-blastxml-devel) weakremover(ghc-blaze-bootstrap) weakremover(ghc-blaze-bootstrap-devel) weakremover(ghc-blaze-builder) weakremover(ghc-blaze-builder-devel) weakremover(ghc-blaze-builder-prof) weakremover(ghc-blaze-html) weakremover(ghc-blaze-html-devel) weakremover(ghc-blaze-html-prof) weakremover(ghc-blaze-markup) weakremover(ghc-blaze-markup-devel) weakremover(ghc-blaze-markup-prof) weakremover(ghc-blaze-svg) weakremover(ghc-blaze-svg-devel) weakremover(ghc-blaze-textual) weakremover(ghc-blaze-textual-devel) weakremover(ghc-bloodhound) weakremover(ghc-bloodhound-devel) weakremover(ghc-bloomfilter) weakremover(ghc-bloomfilter-devel) weakremover(ghc-bloomfilter-prof) weakremover(ghc-blosum) weakremover(ghc-blosum-devel) weakremover(ghc-bmp) weakremover(ghc-bmp-devel) weakremover(ghc-boltzmann-samplers) weakremover(ghc-boltzmann-samplers-devel) weakremover(ghc-bool-extras) weakremover(ghc-bool-extras-devel) weakremover(ghc-boolean-like) weakremover(ghc-boolean-like-devel) weakremover(ghc-boolsimplifier) weakremover(ghc-boolsimplifier-devel) weakremover(ghc-boomerang) weakremover(ghc-boomerang-devel) weakremover(ghc-bootstrap) weakremover(ghc-bootstrap-helpers) weakremover(ghc-boring) weakremover(ghc-boring-devel) weakremover(ghc-boring-prof) weakremover(ghc-both) weakremover(ghc-both-devel) weakremover(ghc-boundingboxes) weakremover(ghc-boundingboxes-devel) weakremover(ghc-bower-json) weakremover(ghc-bower-json-devel) weakremover(ghc-boxes) weakremover(ghc-boxes-devel) weakremover(ghc-breakpoint) weakremover(ghc-breakpoint-devel) weakremover(ghc-brick) weakremover(ghc-brick-devel) weakremover(ghc-brick-prof) weakremover(ghc-broadcast-chan) weakremover(ghc-broadcast-chan-devel) weakremover(ghc-bsb-http-chunked) weakremover(ghc-bsb-http-chunked-devel) weakremover(ghc-bsb-http-chunked-prof) weakremover(ghc-bson) weakremover(ghc-bson-devel) weakremover(ghc-bson-lens) weakremover(ghc-bson-lens-devel) weakremover(ghc-btrfs) weakremover(ghc-btrfs-devel) weakremover(ghc-buffer-builder) weakremover(ghc-buffer-builder-devel) weakremover(ghc-bv) weakremover(ghc-bv-devel) weakremover(ghc-byteable) weakremover(ghc-byteable-devel) weakremover(ghc-byteable-prof) weakremover(ghc-bytedump) weakremover(ghc-bytedump-devel) weakremover(ghc-byteorder) weakremover(ghc-byteorder-devel) weakremover(ghc-byteorder-prof) weakremover(ghc-bytes) weakremover(ghc-bytes-devel) weakremover(ghc-byteset) weakremover(ghc-byteset-devel) weakremover(ghc-bytestring) weakremover(ghc-bytestring-builder) weakremover(ghc-bytestring-builder-devel) weakremover(ghc-bytestring-conversion) weakremover(ghc-bytestring-conversion-devel) weakremover(ghc-bytestring-devel) weakremover(ghc-bytestring-handle) weakremover(ghc-bytestring-handle-devel) weakremover(ghc-bytestring-lexing) weakremover(ghc-bytestring-lexing-devel) weakremover(ghc-bytestring-prof) weakremover(ghc-bytestring-strict-builder) weakremover(ghc-bytestring-strict-builder-devel) weakremover(ghc-bytestring-tree-builder) weakremover(ghc-bytestring-tree-builder-devel) weakremover(ghc-bytestring-trie) weakremover(ghc-bytestring-trie-devel) weakremover(ghc-bzlib) weakremover(ghc-bzlib-conduit) weakremover(ghc-bzlib-conduit-devel) weakremover(ghc-bzlib-devel) weakremover(ghc-cab) weakremover(ghc-cab-devel) weakremover(ghc-cabal-doctest) weakremover(ghc-cabal-doctest-devel) weakremover(ghc-cabal-doctest-prof) weakremover(ghc-cabal-file-th) weakremover(ghc-cabal-file-th-devel) weakremover(ghc-cabal-helper) weakremover(ghc-cabal-helper-devel) weakremover(ghc-cabal-install) weakremover(ghc-cabal-install-devel) weakremover(ghc-cabal-install-prof) weakremover(ghc-cabal-install-solver) weakremover(ghc-cabal-install-solver-devel) weakremover(ghc-cabal-install-solver-prof) weakremover(ghc-cabal-plan) weakremover(ghc-cabal-plan-devel) weakremover(ghc-cabal-plan-prof) weakremover(ghc-cabal2spec) weakremover(ghc-cabal2spec-devel) weakremover(ghc-cabal2spec-prof) weakremover(ghc-cache) weakremover(ghc-cache-devel) weakremover(ghc-cacophony) weakremover(ghc-cacophony-devel) weakremover(ghc-cairo) weakremover(ghc-cairo-devel) weakremover(ghc-cairo-prof) weakremover(ghc-call-stack) weakremover(ghc-call-stack-devel) weakremover(ghc-call-stack-prof) weakremover(ghc-canonical-json) weakremover(ghc-canonical-json-devel) weakremover(ghc-carray) weakremover(ghc-carray-devel) weakremover(ghc-cartel) weakremover(ghc-cartel-devel) weakremover(ghc-case-insensitive) weakremover(ghc-case-insensitive-devel) weakremover(ghc-case-insensitive-prof) weakremover(ghc-cased) weakremover(ghc-cased-devel) weakremover(ghc-cases) weakremover(ghc-cases-devel) weakremover(ghc-casing) weakremover(ghc-casing-devel) weakremover(ghc-cassava) weakremover(ghc-cassava-conduit) weakremover(ghc-cassava-conduit-devel) weakremover(ghc-cassava-devel) weakremover(ghc-cassava-megaparsec) weakremover(ghc-cassava-megaparsec-devel) weakremover(ghc-cassava-megaparsec-prof) weakremover(ghc-cassava-prof) weakremover(ghc-cassette) weakremover(ghc-cassette-devel) weakremover(ghc-cayley-client) weakremover(ghc-cayley-client-devel) weakremover(ghc-cborg) weakremover(ghc-cborg-devel) weakremover(ghc-cborg-json) weakremover(ghc-cborg-json-devel) weakremover(ghc-cereal) weakremover(ghc-cereal-conduit) weakremover(ghc-cereal-conduit-devel) weakremover(ghc-cereal-devel) weakremover(ghc-cereal-prof) weakremover(ghc-cereal-text) weakremover(ghc-cereal-text-devel) weakremover(ghc-cereal-vector) weakremover(ghc-cereal-vector-devel) weakremover(ghc-cgi) weakremover(ghc-cgi-devel) weakremover(ghc-charset) weakremover(ghc-charset-devel) weakremover(ghc-cheapskate) weakremover(ghc-cheapskate-devel) weakremover(ghc-cheapskate-highlight) weakremover(ghc-cheapskate-highlight-devel) weakremover(ghc-cheapskate-lucid) weakremover(ghc-cheapskate-lucid-devel) weakremover(ghc-check-email) weakremover(ghc-check-email-devel) weakremover(ghc-checkers) weakremover(ghc-checkers-devel) weakremover(ghc-chell) weakremover(ghc-chell-devel) weakremover(ghc-choice) weakremover(ghc-choice-devel) weakremover(ghc-chunked-data) weakremover(ghc-chunked-data-devel) weakremover(ghc-cipher-aes) weakremover(ghc-cipher-aes-devel) weakremover(ghc-cipher-aes-prof) weakremover(ghc-cipher-aes128) weakremover(ghc-cipher-aes128-devel) weakremover(ghc-cipher-blowfish) weakremover(ghc-cipher-blowfish-devel) weakremover(ghc-cipher-camellia) weakremover(ghc-cipher-camellia-devel) weakremover(ghc-cipher-des) weakremover(ghc-cipher-des-devel) weakremover(ghc-cipher-rc4) weakremover(ghc-cipher-rc4-devel) weakremover(ghc-circle-packing) weakremover(ghc-circle-packing-devel) weakremover(ghc-citeproc) weakremover(ghc-citeproc-devel) weakremover(ghc-citeproc-prof) weakremover(ghc-classy-prelude) weakremover(ghc-classy-prelude-conduit) weakremover(ghc-classy-prelude-conduit-devel) weakremover(ghc-classy-prelude-devel) weakremover(ghc-classy-prelude-yesod) weakremover(ghc-classy-prelude-yesod-devel) weakremover(ghc-clay) weakremover(ghc-clay-devel) weakremover(ghc-cli) weakremover(ghc-cli-devel) weakremover(ghc-clientsession) weakremover(ghc-clientsession-devel) weakremover(ghc-clientsession-prof) weakremover(ghc-clock) weakremover(ghc-clock-devel) weakremover(ghc-clock-extras) weakremover(ghc-clock-extras-devel) weakremover(ghc-clock-prof) weakremover(ghc-clumpiness) weakremover(ghc-clumpiness-devel) weakremover(ghc-clustering) weakremover(ghc-clustering-devel) weakremover(ghc-cmark) weakremover(ghc-cmark-devel) weakremover(ghc-cmark-gfm) weakremover(ghc-cmark-gfm-devel) weakremover(ghc-cmark-highlight) weakremover(ghc-cmark-highlight-devel) weakremover(ghc-cmark-lucid) weakremover(ghc-cmark-lucid-devel) weakremover(ghc-cmdargs) weakremover(ghc-cmdargs-devel) weakremover(ghc-cmdargs-prof) weakremover(ghc-code-builder) weakremover(ghc-code-builder-devel) weakremover(ghc-code-page) weakremover(ghc-code-page-devel) weakremover(ghc-code-page-prof) weakremover(ghc-codo-notation) weakremover(ghc-codo-notation-devel) weakremover(ghc-colorful-monoids) weakremover(ghc-colorful-monoids-devel) weakremover(ghc-colour) weakremover(ghc-colour-devel) weakremover(ghc-colour-prof) weakremover(ghc-colourista) weakremover(ghc-colourista-devel) weakremover(ghc-colourista-prof) weakremover(ghc-commonmark) weakremover(ghc-commonmark-devel) weakremover(ghc-commonmark-extensions) weakremover(ghc-commonmark-extensions-devel) weakremover(ghc-commonmark-extensions-prof) weakremover(ghc-commonmark-pandoc) weakremover(ghc-commonmark-pandoc-devel) weakremover(ghc-commonmark-pandoc-prof) weakremover(ghc-commonmark-prof) weakremover(ghc-commutative) weakremover(ghc-commutative-devel) weakremover(ghc-commutative-semigroups) weakremover(ghc-commutative-semigroups-devel) weakremover(ghc-commutative-semigroups-prof) weakremover(ghc-comonad) weakremover(ghc-comonad-devel) weakremover(ghc-comonad-prof) weakremover(ghc-comonad-transformers) weakremover(ghc-comonad-transformers-devel) weakremover(ghc-comonads-fd) weakremover(ghc-comonads-fd-devel) weakremover(ghc-compactmap) weakremover(ghc-compactmap-devel) weakremover(ghc-compiler) weakremover(ghc-composition) weakremover(ghc-composition-devel) weakremover(ghc-composition-extra) weakremover(ghc-composition-extra-devel) weakremover(ghc-concatenative) weakremover(ghc-concatenative-devel) weakremover(ghc-concise) weakremover(ghc-concise-devel) weakremover(ghc-concurrency) weakremover(ghc-concurrency-devel) weakremover(ghc-concurrent-extra) weakremover(ghc-concurrent-extra-devel) weakremover(ghc-concurrent-output) weakremover(ghc-concurrent-output-devel) weakremover(ghc-concurrent-output-prof) weakremover(ghc-concurrent-supply) weakremover(ghc-concurrent-supply-devel) weakremover(ghc-conduit) weakremover(ghc-conduit-combinators) weakremover(ghc-conduit-combinators-devel) weakremover(ghc-conduit-connection) weakremover(ghc-conduit-connection-devel) weakremover(ghc-conduit-devel) weakremover(ghc-conduit-extra) weakremover(ghc-conduit-extra-devel) weakremover(ghc-conduit-extra-prof) weakremover(ghc-conduit-iconv) weakremover(ghc-conduit-iconv-devel) weakremover(ghc-conduit-parse) weakremover(ghc-conduit-parse-devel) weakremover(ghc-conduit-prof) weakremover(ghc-conduit-zstd) weakremover(ghc-conduit-zstd-devel) weakremover(ghc-config-ini) weakremover(ghc-config-ini-devel) weakremover(ghc-config-ini-prof) weakremover(ghc-configuration-tools) weakremover(ghc-configuration-tools-devel) weakremover(ghc-configurator) weakremover(ghc-configurator-devel) weakremover(ghc-configurator-export) weakremover(ghc-configurator-export-devel) weakremover(ghc-connection) weakremover(ghc-connection-devel) weakremover(ghc-connection-prof) weakremover(ghc-console-style) weakremover(ghc-console-style-devel) weakremover(ghc-constraints) weakremover(ghc-constraints-devel) weakremover(ghc-constraints-prof) weakremover(ghc-consul-haskell) weakremover(ghc-consul-haskell-devel) weakremover(ghc-containers) weakremover(ghc-containers-devel) weakremover(ghc-containers-prof) weakremover(ghc-containers-unicode-symbols) weakremover(ghc-containers-unicode-symbols-devel) weakremover(ghc-continued-fractions) weakremover(ghc-continued-fractions-devel) weakremover(ghc-contravariant) weakremover(ghc-contravariant-devel) weakremover(ghc-contravariant-prof) weakremover(ghc-control-bool) weakremover(ghc-control-bool-devel) weakremover(ghc-control-monad-free) weakremover(ghc-control-monad-free-devel) weakremover(ghc-control-monad-free-prof) weakremover(ghc-control-monad-loop) weakremover(ghc-control-monad-loop-devel) weakremover(ghc-control-monad-omega) weakremover(ghc-control-monad-omega-devel) weakremover(ghc-converge) weakremover(ghc-converge-devel) weakremover(ghc-convertible) weakremover(ghc-convertible-devel) weakremover(ghc-cookie) weakremover(ghc-cookie-devel) weakremover(ghc-cookie-prof) weakremover(ghc-countable) weakremover(ghc-countable-devel) weakremover(ghc-courier) weakremover(ghc-courier-devel) weakremover(ghc-cpphs) weakremover(ghc-cpphs-devel) weakremover(ghc-cpphs-prof) weakremover(ghc-cprng-aes) weakremover(ghc-cprng-aes-devel) weakremover(ghc-cprng-aes-prof) weakremover(ghc-cpu) weakremover(ghc-cpu-devel) weakremover(ghc-cpuinfo) weakremover(ghc-cpuinfo-devel) weakremover(ghc-crackNum) weakremover(ghc-crackNum-devel) weakremover(ghc-criterion) weakremover(ghc-criterion-devel) weakremover(ghc-criterion-measurement) weakremover(ghc-criterion-measurement-devel) weakremover(ghc-criterion-measurement-prof) weakremover(ghc-criterion-prof) weakremover(ghc-cron) weakremover(ghc-cron-devel) weakremover(ghc-crypto-api) weakremover(ghc-crypto-api-devel) weakremover(ghc-crypto-api-prof) weakremover(ghc-crypto-api-tests) weakremover(ghc-crypto-api-tests-devel) weakremover(ghc-crypto-cipher-tests) weakremover(ghc-crypto-cipher-tests-devel) weakremover(ghc-crypto-cipher-types) weakremover(ghc-crypto-cipher-types-devel) weakremover(ghc-crypto-cipher-types-prof) weakremover(ghc-crypto-enigma) weakremover(ghc-crypto-enigma-devel) weakremover(ghc-crypto-numbers) weakremover(ghc-crypto-numbers-devel) weakremover(ghc-crypto-pubkey) weakremover(ghc-crypto-pubkey-devel) weakremover(ghc-crypto-pubkey-types) weakremover(ghc-crypto-pubkey-types-devel) weakremover(ghc-crypto-random) weakremover(ghc-crypto-random-api) weakremover(ghc-crypto-random-api-devel) weakremover(ghc-crypto-random-devel) weakremover(ghc-crypto-random-prof) weakremover(ghc-cryptocipher) weakremover(ghc-cryptocipher-devel) weakremover(ghc-cryptohash) weakremover(ghc-cryptohash-conduit) weakremover(ghc-cryptohash-conduit-devel) weakremover(ghc-cryptohash-cryptoapi) weakremover(ghc-cryptohash-cryptoapi-devel) weakremover(ghc-cryptohash-devel) weakremover(ghc-cryptohash-md5) weakremover(ghc-cryptohash-md5-devel) weakremover(ghc-cryptohash-md5-prof) weakremover(ghc-cryptohash-sha1) weakremover(ghc-cryptohash-sha1-devel) weakremover(ghc-cryptohash-sha1-prof) weakremover(ghc-cryptohash-sha256) weakremover(ghc-cryptohash-sha256-devel) weakremover(ghc-cryptohash-sha256-prof) weakremover(ghc-cryptonite) weakremover(ghc-cryptonite-conduit) weakremover(ghc-cryptonite-conduit-devel) weakremover(ghc-cryptonite-conduit-prof) weakremover(ghc-cryptonite-devel) weakremover(ghc-cryptonite-openssl) weakremover(ghc-cryptonite-openssl-devel) weakremover(ghc-cryptonite-prof) weakremover(ghc-css-syntax) weakremover(ghc-css-syntax-devel) weakremover(ghc-css-text) weakremover(ghc-css-text-devel) weakremover(ghc-css-text-prof) weakremover(ghc-csv) weakremover(ghc-csv-conduit) weakremover(ghc-csv-conduit-devel) weakremover(ghc-csv-devel) weakremover(ghc-csv-prof) weakremover(ghc-ctrie) weakremover(ghc-ctrie-devel) weakremover(ghc-cubicbezier) weakremover(ghc-cubicbezier-devel) weakremover(ghc-cubicspline) weakremover(ghc-cubicspline-devel) weakremover(ghc-cue-sheet) weakremover(ghc-cue-sheet-devel) weakremover(ghc-curl) weakremover(ghc-curl-devel) weakremover(ghc-darcs) weakremover(ghc-darcs-devel) weakremover(ghc-data-accessor) weakremover(ghc-data-accessor-devel) weakremover(ghc-data-accessor-mtl) weakremover(ghc-data-accessor-mtl-devel) weakremover(ghc-data-array-byte) weakremover(ghc-data-array-byte-devel) weakremover(ghc-data-binary-ieee754) weakremover(ghc-data-binary-ieee754-devel) weakremover(ghc-data-bword) weakremover(ghc-data-bword-devel) weakremover(ghc-data-check) weakremover(ghc-data-check-devel) weakremover(ghc-data-checked) weakremover(ghc-data-checked-devel) weakremover(ghc-data-clist) weakremover(ghc-data-clist-devel) weakremover(ghc-data-clist-prof) weakremover(ghc-data-default) weakremover(ghc-data-default-class) weakremover(ghc-data-default-class-devel) weakremover(ghc-data-default-class-prof) weakremover(ghc-data-default-devel) weakremover(ghc-data-default-instances-base) weakremover(ghc-data-default-instances-base-devel) weakremover(ghc-data-default-instances-containers) weakremover(ghc-data-default-instances-containers-devel) weakremover(ghc-data-default-instances-containers-prof) weakremover(ghc-data-default-instances-dlist) weakremover(ghc-data-default-instances-dlist-devel) weakremover(ghc-data-default-instances-dlist-prof) weakremover(ghc-data-default-instances-old-locale) weakremover(ghc-data-default-instances-old-locale-devel) weakremover(ghc-data-default-instances-old-locale-prof) weakremover(ghc-data-default-prof) weakremover(ghc-data-dword) weakremover(ghc-data-dword-devel) weakremover(ghc-data-endian) weakremover(ghc-data-endian-devel) weakremover(ghc-data-fix) weakremover(ghc-data-fix-devel) weakremover(ghc-data-fix-prof) weakremover(ghc-data-hash) weakremover(ghc-data-hash-devel) weakremover(ghc-data-inttrie) weakremover(ghc-data-inttrie-devel) weakremover(ghc-data-lens-light) weakremover(ghc-data-lens-light-devel) weakremover(ghc-data-memocombinators) weakremover(ghc-data-memocombinators-devel) weakremover(ghc-data-msgpack) weakremover(ghc-data-msgpack-devel) weakremover(ghc-data-or) weakremover(ghc-data-or-devel) weakremover(ghc-data-ordlist) weakremover(ghc-data-ordlist-devel) weakremover(ghc-data-reify) weakremover(ghc-data-reify-devel) weakremover(ghc-data-serializer) weakremover(ghc-data-serializer-devel) weakremover(ghc-data-textual) weakremover(ghc-data-textual-devel) weakremover(ghc-datasets) weakremover(ghc-datasets-devel) weakremover(ghc-dataurl) weakremover(ghc-dataurl-devel) weakremover(ghc-dawg-ord) weakremover(ghc-dawg-ord-devel) weakremover(ghc-dbus) weakremover(ghc-dbus-devel) weakremover(ghc-dbus-prof) weakremover(ghc-debian-build) weakremover(ghc-debian-build-devel) weakremover(ghc-dec) weakremover(ghc-dec-devel) weakremover(ghc-dec-prof) weakremover(ghc-declarative) weakremover(ghc-declarative-devel) weakremover(ghc-deepseq) weakremover(ghc-deepseq-devel) weakremover(ghc-deepseq-generics) weakremover(ghc-deepseq-generics-devel) weakremover(ghc-deepseq-prof) weakremover(ghc-dejafu) weakremover(ghc-dejafu-devel) weakremover(ghc-dense-linear-algebra) weakremover(ghc-dense-linear-algebra-devel) weakremover(ghc-dense-linear-algebra-prof) weakremover(ghc-dependent-map) weakremover(ghc-dependent-map-devel) weakremover(ghc-dependent-sum) weakremover(ghc-dependent-sum-devel) weakremover(ghc-derive) weakremover(ghc-derive-devel) weakremover(ghc-deriving-aeson) weakremover(ghc-deriving-aeson-devel) weakremover(ghc-deriving-aeson-prof) weakremover(ghc-deriving-compat) weakremover(ghc-deriving-compat-devel) weakremover(ghc-descriptive) weakremover(ghc-descriptive-devel) weakremover(ghc-devel) weakremover(ghc-dhall) weakremover(ghc-dhall-devel) weakremover(ghc-dhall-json) weakremover(ghc-dhall-json-devel) weakremover(ghc-dhall-yaml) weakremover(ghc-dhall-yaml-devel) weakremover(ghc-diagrams) weakremover(ghc-diagrams-builder) weakremover(ghc-diagrams-builder-devel) weakremover(ghc-diagrams-cairo) weakremover(ghc-diagrams-cairo-devel) weakremover(ghc-diagrams-canvas) weakremover(ghc-diagrams-canvas-devel) weakremover(ghc-diagrams-contrib) weakremover(ghc-diagrams-contrib-devel) weakremover(ghc-diagrams-core) weakremover(ghc-diagrams-core-devel) weakremover(ghc-diagrams-devel) weakremover(ghc-diagrams-lib) weakremover(ghc-diagrams-lib-devel) weakremover(ghc-diagrams-postscript) weakremover(ghc-diagrams-postscript-devel) weakremover(ghc-diagrams-solve) weakremover(ghc-diagrams-solve-devel) weakremover(ghc-diagrams-svg) weakremover(ghc-diagrams-svg-devel) weakremover(ghc-diff3) weakremover(ghc-diff3-devel) weakremover(ghc-digest) weakremover(ghc-digest-devel) weakremover(ghc-digest-prof) weakremover(ghc-digits) weakremover(ghc-digits-devel) weakremover(ghc-dimensional) weakremover(ghc-dimensional-devel) weakremover(ghc-direct-sqlite) weakremover(ghc-direct-sqlite-devel) weakremover(ghc-directory) weakremover(ghc-directory-devel) weakremover(ghc-directory-prof) weakremover(ghc-directory-tree) weakremover(ghc-directory-tree-devel) weakremover(ghc-discount) weakremover(ghc-discount-devel) weakremover(ghc-disk-free-space) weakremover(ghc-disk-free-space-devel) weakremover(ghc-disk-free-space-prof) weakremover(ghc-distance) weakremover(ghc-distance-devel) weakremover(ghc-distributed-closure) weakremover(ghc-distributed-closure-devel) weakremover(ghc-distributed-process) weakremover(ghc-distributed-process-devel) weakremover(ghc-distributed-static) weakremover(ghc-distributed-static-devel) weakremover(ghc-distribution-nixpkgs) weakremover(ghc-distribution-nixpkgs-devel) weakremover(ghc-distribution-opensuse) weakremover(ghc-distribution-opensuse-devel) weakremover(ghc-distributive) weakremover(ghc-distributive-devel) weakremover(ghc-distributive-prof) weakremover(ghc-diversity) weakremover(ghc-diversity-devel) weakremover(ghc-djinn-ghc) weakremover(ghc-djinn-ghc-devel) weakremover(ghc-djinn-lib) weakremover(ghc-djinn-lib-devel) weakremover(ghc-dlist) weakremover(ghc-dlist-devel) weakremover(ghc-dlist-instances) weakremover(ghc-dlist-instances-devel) weakremover(ghc-dlist-prof) weakremover(ghc-dns) weakremover(ghc-dns-devel) weakremover(ghc-do-list) weakremover(ghc-do-list-devel) weakremover(ghc-doc) weakremover(ghc-dockerfile) weakremover(ghc-dockerfile-devel) weakremover(ghc-doclayout) weakremover(ghc-doclayout-devel) weakremover(ghc-doclayout-prof) weakremover(ghc-docopt) weakremover(ghc-docopt-devel) weakremover(ghc-doctemplates) weakremover(ghc-doctemplates-devel) weakremover(ghc-doctemplates-prof) weakremover(ghc-doctest) weakremover(ghc-doctest-devel) weakremover(ghc-doctest-discover) weakremover(ghc-doctest-discover-devel) weakremover(ghc-doctest-prop) weakremover(ghc-doctest-prop-devel) weakremover(ghc-dotenv) weakremover(ghc-dotenv-devel) weakremover(ghc-dotgen) weakremover(ghc-dotgen-devel) weakremover(ghc-dotnet-timespan) weakremover(ghc-dotnet-timespan-devel) weakremover(ghc-double-conversion) weakremover(ghc-double-conversion-devel) weakremover(ghc-dpor) weakremover(ghc-dpor-devel) weakremover(ghc-drawille) weakremover(ghc-drawille-devel) weakremover(ghc-drifter) weakremover(ghc-drifter-devel) weakremover(ghc-drifter-postgresql) weakremover(ghc-drifter-postgresql-devel) weakremover(ghc-dual-tree) weakremover(ghc-dual-tree-devel) weakremover(ghc-dynamic-state) weakremover(ghc-dynamic-state-devel) weakremover(ghc-dyre) weakremover(ghc-dyre-devel) weakremover(ghc-easy-file) weakremover(ghc-easy-file-devel) weakremover(ghc-easy-file-prof) weakremover(ghc-echo) weakremover(ghc-echo-devel) weakremover(ghc-echo-prof) weakremover(ghc-ed25519) weakremover(ghc-ed25519-devel) weakremover(ghc-ed25519-prof) weakremover(ghc-ede) weakremover(ghc-ede-devel) weakremover(ghc-edit-distance) weakremover(ghc-edit-distance-devel) weakremover(ghc-edit-distance-prof) weakremover(ghc-editor-open) weakremover(ghc-editor-open-devel) weakremover(ghc-effect-handlers) weakremover(ghc-effect-handlers-devel) weakremover(ghc-either) weakremover(ghc-either-devel) weakremover(ghc-either-unwrap) weakremover(ghc-either-unwrap-devel) weakremover(ghc-ekg) weakremover(ghc-ekg-core) weakremover(ghc-ekg-core-devel) weakremover(ghc-ekg-devel) weakremover(ghc-ekg-json) weakremover(ghc-ekg-json-devel) weakremover(ghc-ekg-statsd) weakremover(ghc-ekg-statsd-devel) weakremover(ghc-elerea) weakremover(ghc-elerea-devel) weakremover(ghc-elm-bridge) weakremover(ghc-elm-bridge-devel) weakremover(ghc-elm-core-sources) weakremover(ghc-elm-core-sources-devel) weakremover(ghc-elm-export) weakremover(ghc-elm-export-devel) weakremover(ghc-elm-export-persistent) weakremover(ghc-elm-export-persistent-devel) weakremover(ghc-email-validate) weakremover(ghc-email-validate-devel) weakremover(ghc-email-validate-prof) weakremover(ghc-emailaddress) weakremover(ghc-emailaddress-devel) weakremover(ghc-emojis) weakremover(ghc-emojis-devel) weakremover(ghc-emojis-prof) weakremover(ghc-enclosed-exceptions) weakremover(ghc-enclosed-exceptions-devel) weakremover(ghc-entropy) weakremover(ghc-entropy-devel) weakremover(ghc-entropy-prof) weakremover(ghc-enummapset-th) weakremover(ghc-enummapset-th-devel) weakremover(ghc-envelope) weakremover(ghc-envelope-devel) weakremover(ghc-envparse) weakremover(ghc-envparse-devel) weakremover(ghc-envy) weakremover(ghc-envy-devel) weakremover(ghc-epub-metadata) weakremover(ghc-epub-metadata-devel) weakremover(ghc-eq) weakremover(ghc-eq-devel) weakremover(ghc-equivalence) weakremover(ghc-equivalence-devel) weakremover(ghc-erf) weakremover(ghc-erf-devel) weakremover(ghc-errors) weakremover(ghc-errors-devel) weakremover(ghc-ersatz) weakremover(ghc-ersatz-devel) weakremover(ghc-esqueleto) weakremover(ghc-esqueleto-devel) weakremover(ghc-etcd) weakremover(ghc-etcd-devel) weakremover(ghc-ether) weakremover(ghc-ether-devel) weakremover(ghc-event) weakremover(ghc-event-devel) weakremover(ghc-exact-combinatorics) weakremover(ghc-exact-combinatorics-devel) weakremover(ghc-exact-pi) weakremover(ghc-exact-pi-devel) weakremover(ghc-exception-mtl) weakremover(ghc-exception-mtl-devel) weakremover(ghc-exception-transformers) weakremover(ghc-exception-transformers-devel) weakremover(ghc-exceptional) weakremover(ghc-exceptional-devel) weakremover(ghc-exceptions) weakremover(ghc-exceptions-devel) weakremover(ghc-exceptions-prof) weakremover(ghc-executable-hash) weakremover(ghc-executable-hash-devel) weakremover(ghc-executable-path) weakremover(ghc-executable-path-devel) weakremover(ghc-exhaustive) weakremover(ghc-exhaustive-devel) weakremover(ghc-exp-pairs) weakremover(ghc-exp-pairs-devel) weakremover(ghc-expiring-cache-map) weakremover(ghc-expiring-cache-map-devel) weakremover(ghc-explicit-exception) weakremover(ghc-explicit-exception-devel) weakremover(ghc-extensible) weakremover(ghc-extensible-devel) weakremover(ghc-extensible-effects) weakremover(ghc-extensible-effects-devel) weakremover(ghc-extensible-exceptions) weakremover(ghc-extensible-exceptions-devel) weakremover(ghc-extensible-exceptions-prof) weakremover(ghc-extra) weakremover(ghc-extra-devel) weakremover(ghc-extra-prof) weakremover(ghc-fail) weakremover(ghc-fail-devel) weakremover(ghc-farmhash) weakremover(ghc-farmhash-devel) weakremover(ghc-fast-builder) weakremover(ghc-fast-builder-devel) weakremover(ghc-fast-digits) weakremover(ghc-fast-digits-devel) weakremover(ghc-fast-logger) weakremover(ghc-fast-logger-devel) weakremover(ghc-fast-logger-prof) weakremover(ghc-fast-math) weakremover(ghc-fast-math-devel) weakremover(ghc-fasta) weakremover(ghc-fasta-devel) weakremover(ghc-fclabels) weakremover(ghc-fclabels-devel) weakremover(ghc-fdo-notify) weakremover(ghc-fdo-notify-devel) weakremover(ghc-fdo-notify-prof) weakremover(ghc-feature-flags) weakremover(ghc-feature-flags-devel) weakremover(ghc-feed) weakremover(ghc-feed-devel) weakremover(ghc-feed-prof) weakremover(ghc-fft) weakremover(ghc-fft-devel) weakremover(ghc-fgl) weakremover(ghc-fgl-arbitrary) weakremover(ghc-fgl-arbitrary-devel) weakremover(ghc-fgl-devel) weakremover(ghc-fgl-prof) weakremover(ghc-file-embed) weakremover(ghc-file-embed-devel) weakremover(ghc-file-embed-prof) weakremover(ghc-file-modules) weakremover(ghc-file-modules-devel) weakremover(ghc-filecache) weakremover(ghc-filecache-devel) weakremover(ghc-filelock) weakremover(ghc-filelock-devel) weakremover(ghc-filemanip) weakremover(ghc-filemanip-devel) weakremover(ghc-filepath) weakremover(ghc-filepath-bytestring) weakremover(ghc-filepath-bytestring-devel) weakremover(ghc-filepath-bytestring-prof) weakremover(ghc-filepath-devel) weakremover(ghc-filepath-prof) weakremover(ghc-filepattern) weakremover(ghc-filepattern-devel) weakremover(ghc-filepattern-prof) weakremover(ghc-filtrable) weakremover(ghc-filtrable-devel) weakremover(ghc-fingertree) weakremover(ghc-fingertree-devel) weakremover(ghc-fingertree-psqueue) weakremover(ghc-fingertree-psqueue-devel) weakremover(ghc-finite-typelits) weakremover(ghc-finite-typelits-devel) weakremover(ghc-fixed) weakremover(ghc-fixed-devel) weakremover(ghc-fixed-vector) weakremover(ghc-fixed-vector-devel) weakremover(ghc-fixed-vector-hetero) weakremover(ghc-fixed-vector-hetero-devel) weakremover(ghc-flac) weakremover(ghc-flac-devel) weakremover(ghc-flac-picture) weakremover(ghc-flac-picture-devel) weakremover(ghc-flat-mcmc) weakremover(ghc-flat-mcmc-devel) weakremover(ghc-flexible-defaults) weakremover(ghc-flexible-defaults-devel) weakremover(ghc-flow) weakremover(ghc-flow-devel) weakremover(ghc-fmlist) weakremover(ghc-fmlist-devel) weakremover(ghc-fmt) weakremover(ghc-fmt-devel) weakremover(ghc-fn) weakremover(ghc-fn-devel) weakremover(ghc-focus) weakremover(ghc-focus-devel) weakremover(ghc-fold-debounce) weakremover(ghc-fold-debounce-conduit) weakremover(ghc-fold-debounce-conduit-devel) weakremover(ghc-fold-debounce-devel) weakremover(ghc-foldl) weakremover(ghc-foldl-devel) weakremover(ghc-foldl-prof) weakremover(ghc-foldl-statistics) weakremover(ghc-foldl-statistics-devel) weakremover(ghc-folds) weakremover(ghc-folds-devel) weakremover(ghc-force-layout) weakremover(ghc-force-layout-devel) weakremover(ghc-foreign-store) weakremover(ghc-foreign-store-devel) weakremover(ghc-format-numbers) weakremover(ghc-format-numbers-devel) weakremover(ghc-formatting) weakremover(ghc-formatting-devel) weakremover(ghc-foundation) weakremover(ghc-foundation-devel) weakremover(ghc-free) weakremover(ghc-free-devel) weakremover(ghc-free-prof) weakremover(ghc-free-vl) weakremover(ghc-free-vl-devel) weakremover(ghc-freer) weakremover(ghc-freer-devel) weakremover(ghc-friendly-time) weakremover(ghc-friendly-time-devel) weakremover(ghc-frisby) weakremover(ghc-frisby-devel) weakremover(ghc-from-sum) weakremover(ghc-from-sum-devel) weakremover(ghc-frontmatter) weakremover(ghc-frontmatter-devel) weakremover(ghc-fsnotify) weakremover(ghc-fsnotify-conduit) weakremover(ghc-fsnotify-conduit-devel) weakremover(ghc-fsnotify-devel) weakremover(ghc-fsnotify-prof) weakremover(ghc-funcmp) weakremover(ghc-funcmp-devel) weakremover(ghc-fuzzcheck) weakremover(ghc-fuzzcheck-devel) weakremover(ghc-gamma) weakremover(ghc-gamma-devel) weakremover(ghc-gd) weakremover(ghc-gd-devel) weakremover(ghc-generic-aeson) weakremover(ghc-generic-aeson-devel) weakremover(ghc-generic-data) weakremover(ghc-generic-data-devel) weakremover(ghc-generic-deriving) weakremover(ghc-generic-deriving-devel) weakremover(ghc-generic-lens) weakremover(ghc-generic-lens-core) weakremover(ghc-generic-lens-core-devel) weakremover(ghc-generic-lens-devel) weakremover(ghc-generic-monoid) weakremover(ghc-generic-monoid-devel) weakremover(ghc-generic-random) weakremover(ghc-generic-random-devel) weakremover(ghc-generic-xmlpickler) weakremover(ghc-generic-xmlpickler-devel) weakremover(ghc-generically) weakremover(ghc-generically-devel) weakremover(ghc-generically-prof) weakremover(ghc-generics-eot) weakremover(ghc-generics-eot-devel) weakremover(ghc-generics-sop) weakremover(ghc-generics-sop-devel) weakremover(ghc-generics-sop-lens) weakremover(ghc-generics-sop-lens-devel) weakremover(ghc-geniplate-mirror) weakremover(ghc-geniplate-mirror-devel) weakremover(ghc-genvalidity) weakremover(ghc-genvalidity-devel) weakremover(ghc-genvalidity-hspec) weakremover(ghc-genvalidity-hspec-devel) weakremover(ghc-genvalidity-property) weakremover(ghc-genvalidity-property-devel) weakremover(ghc-getopt-generics) weakremover(ghc-getopt-generics-devel) weakremover(ghc-ghc) weakremover(ghc-ghc-boot) weakremover(ghc-ghc-boot-devel) weakremover(ghc-ghc-boot-prof) weakremover(ghc-ghc-boot-th) weakremover(ghc-ghc-boot-th-devel) weakremover(ghc-ghc-boot-th-prof) weakremover(ghc-ghc-byteorder) weakremover(ghc-ghc-byteorder-devel) weakremover(ghc-ghc-compact) weakremover(ghc-ghc-compact-devel) weakremover(ghc-ghc-compact-prof) weakremover(ghc-ghc-devel) weakremover(ghc-ghc-events) weakremover(ghc-ghc-events-devel) weakremover(ghc-ghc-exactprint) weakremover(ghc-ghc-exactprint-devel) weakremover(ghc-ghc-heap) weakremover(ghc-ghc-heap-devel) weakremover(ghc-ghc-heap-prof) weakremover(ghc-ghc-heap-view) weakremover(ghc-ghc-heap-view-devel) weakremover(ghc-ghc-lib-parser) weakremover(ghc-ghc-lib-parser-devel) weakremover(ghc-ghc-lib-parser-ex) weakremover(ghc-ghc-lib-parser-ex-devel) weakremover(ghc-ghc-lib-parser-ex-prof) weakremover(ghc-ghc-lib-parser-prof) weakremover(ghc-ghc-mod) weakremover(ghc-ghc-mod-devel) weakremover(ghc-ghc-paths) weakremover(ghc-ghc-paths-devel) weakremover(ghc-ghc-prof) weakremover(ghc-ghc-prof-devel) weakremover(ghc-ghc-syb-utils) weakremover(ghc-ghc-syb-utils-devel) weakremover(ghc-ghc-tcplugins-extra) weakremover(ghc-ghc-tcplugins-extra-devel) weakremover(ghc-ghc-typelits-extra) weakremover(ghc-ghc-typelits-extra-devel) weakremover(ghc-ghc-typelits-knownnat) weakremover(ghc-ghc-typelits-knownnat-devel) weakremover(ghc-ghc-typelits-natnormalise) weakremover(ghc-ghc-typelits-natnormalise-devel) weakremover(ghc-ghci) weakremover(ghc-ghci-devel) weakremover(ghc-ghci-prof) weakremover(ghc-ghcid) weakremover(ghc-ghcid-devel) weakremover(ghc-ghcjs-codemirror) weakremover(ghc-ghcjs-codemirror-devel) weakremover(ghc-ghcjs-perch) weakremover(ghc-ghcjs-perch-devel) weakremover(ghc-gi-atk) weakremover(ghc-gi-atk-devel) weakremover(ghc-gi-cairo) weakremover(ghc-gi-cairo-devel) weakremover(ghc-gi-glib) weakremover(ghc-gi-glib-devel) weakremover(ghc-gi-gobject) weakremover(ghc-gi-gobject-devel) weakremover(ghc-ginger) weakremover(ghc-ginger-devel) weakremover(ghc-gio) weakremover(ghc-gio-devel) weakremover(ghc-giphy-api) weakremover(ghc-giphy-api-devel) weakremover(ghc-git-lfs) weakremover(ghc-git-lfs-devel) weakremover(ghc-githash) weakremover(ghc-githash-devel) weakremover(ghc-githash-prof) weakremover(ghc-github) weakremover(ghc-github-devel) weakremover(ghc-github-release) weakremover(ghc-github-release-devel) weakremover(ghc-gitlib) weakremover(ghc-gitlib-devel) weakremover(ghc-gitlib-libgit2) weakremover(ghc-gitlib-libgit2-devel) weakremover(ghc-gitlib-test) weakremover(ghc-gitlib-test-devel) weakremover(ghc-gitrev) weakremover(ghc-gitrev-devel) weakremover(ghc-gitrev-prof) weakremover(ghc-glabrous) weakremover(ghc-glabrous-devel) weakremover(ghc-glaze) weakremover(ghc-glaze-devel) weakremover(ghc-glazier) weakremover(ghc-glazier-devel) weakremover(ghc-glazier-pipes) weakremover(ghc-glazier-pipes-devel) weakremover(ghc-glib) weakremover(ghc-glib-devel) weakremover(ghc-glib-prof) weakremover(ghc-glob-posix) weakremover(ghc-glob-posix-devel) weakremover(ghc-gloss) weakremover(ghc-gloss-devel) weakremover(ghc-gloss-rendering) weakremover(ghc-gloss-rendering-devel) weakremover(ghc-gnuidn) weakremover(ghc-gnuidn-devel) weakremover(ghc-gnutls) weakremover(ghc-gnutls-devel) weakremover(ghc-gogol) weakremover(ghc-gogol-adexchange-buyer) weakremover(ghc-gogol-adexchange-buyer-devel) weakremover(ghc-gogol-adexchange-seller) weakremover(ghc-gogol-adexchange-seller-devel) weakremover(ghc-gogol-admin-datatransfer) weakremover(ghc-gogol-admin-datatransfer-devel) weakremover(ghc-gogol-admin-emailmigration) weakremover(ghc-gogol-admin-emailmigration-devel) weakremover(ghc-gogol-admin-reports) weakremover(ghc-gogol-admin-reports-devel) weakremover(ghc-gogol-adsense) weakremover(ghc-gogol-adsense-devel) weakremover(ghc-gogol-adsense-host) weakremover(ghc-gogol-adsense-host-devel) weakremover(ghc-gogol-affiliates) weakremover(ghc-gogol-affiliates-devel) weakremover(ghc-gogol-analytics) weakremover(ghc-gogol-analytics-devel) weakremover(ghc-gogol-android-enterprise) weakremover(ghc-gogol-android-enterprise-devel) weakremover(ghc-gogol-android-publisher) weakremover(ghc-gogol-android-publisher-devel) weakremover(ghc-gogol-appengine) weakremover(ghc-gogol-appengine-devel) weakremover(ghc-gogol-apps-activity) weakremover(ghc-gogol-apps-activity-devel) weakremover(ghc-gogol-apps-calendar) weakremover(ghc-gogol-apps-calendar-devel) weakremover(ghc-gogol-apps-licensing) weakremover(ghc-gogol-apps-licensing-devel) weakremover(ghc-gogol-apps-reseller) weakremover(ghc-gogol-apps-reseller-devel) weakremover(ghc-gogol-apps-tasks) weakremover(ghc-gogol-apps-tasks-devel) weakremover(ghc-gogol-appstate) weakremover(ghc-gogol-appstate-devel) weakremover(ghc-gogol-autoscaler) weakremover(ghc-gogol-autoscaler-devel) weakremover(ghc-gogol-bigquery) weakremover(ghc-gogol-bigquery-devel) weakremover(ghc-gogol-billing) weakremover(ghc-gogol-billing-devel) weakremover(ghc-gogol-civicinfo) weakremover(ghc-gogol-civicinfo-devel) weakremover(ghc-gogol-classroom) weakremover(ghc-gogol-classroom-devel) weakremover(ghc-gogol-cloudmonitoring) weakremover(ghc-gogol-cloudmonitoring-devel) weakremover(ghc-gogol-cloudtrace) weakremover(ghc-gogol-cloudtrace-devel) weakremover(ghc-gogol-container) weakremover(ghc-gogol-container-devel) weakremover(ghc-gogol-core) weakremover(ghc-gogol-core-devel) weakremover(ghc-gogol-customsearch) weakremover(ghc-gogol-customsearch-devel) weakremover(ghc-gogol-dataflow) weakremover(ghc-gogol-dataflow-devel) weakremover(ghc-gogol-dataproc) weakremover(ghc-gogol-dataproc-devel) weakremover(ghc-gogol-datastore) weakremover(ghc-gogol-datastore-devel) weakremover(ghc-gogol-debugger) weakremover(ghc-gogol-debugger-devel) weakremover(ghc-gogol-deploymentmanager) weakremover(ghc-gogol-deploymentmanager-devel) weakremover(ghc-gogol-devel) weakremover(ghc-gogol-discovery) weakremover(ghc-gogol-discovery-devel) weakremover(ghc-gogol-dns) weakremover(ghc-gogol-dns-devel) weakremover(ghc-gogol-doubleclick-bids) weakremover(ghc-gogol-doubleclick-bids-devel) weakremover(ghc-gogol-doubleclick-search) weakremover(ghc-gogol-doubleclick-search-devel) weakremover(ghc-gogol-drive) weakremover(ghc-gogol-drive-devel) weakremover(ghc-gogol-firebase-rules) weakremover(ghc-gogol-firebase-rules-devel) weakremover(ghc-gogol-fitness) weakremover(ghc-gogol-fitness-devel) weakremover(ghc-gogol-fonts) weakremover(ghc-gogol-fonts-devel) weakremover(ghc-gogol-freebasesearch) weakremover(ghc-gogol-freebasesearch-devel) weakremover(ghc-gogol-fusiontables) weakremover(ghc-gogol-fusiontables-devel) weakremover(ghc-gogol-games) weakremover(ghc-gogol-games-configuration) weakremover(ghc-gogol-games-configuration-devel) weakremover(ghc-gogol-games-devel) weakremover(ghc-gogol-games-management) weakremover(ghc-gogol-games-management-devel) weakremover(ghc-gogol-gmail) weakremover(ghc-gogol-gmail-devel) weakremover(ghc-gogol-groups-migration) weakremover(ghc-gogol-groups-migration-devel) weakremover(ghc-gogol-groups-settings) weakremover(ghc-gogol-groups-settings-devel) weakremover(ghc-gogol-identity-toolkit) weakremover(ghc-gogol-identity-toolkit-devel) weakremover(ghc-gogol-kgsearch) weakremover(ghc-gogol-kgsearch-devel) weakremover(ghc-gogol-latencytest) weakremover(ghc-gogol-latencytest-devel) weakremover(ghc-gogol-logging) weakremover(ghc-gogol-logging-devel) weakremover(ghc-gogol-maps-coordinate) weakremover(ghc-gogol-maps-coordinate-devel) weakremover(ghc-gogol-maps-engine) weakremover(ghc-gogol-maps-engine-devel) weakremover(ghc-gogol-mirror) weakremover(ghc-gogol-mirror-devel) weakremover(ghc-gogol-monitoring) weakremover(ghc-gogol-monitoring-devel) weakremover(ghc-gogol-oauth2) weakremover(ghc-gogol-oauth2-devel) weakremover(ghc-gogol-pagespeed) weakremover(ghc-gogol-pagespeed-devel) weakremover(ghc-gogol-partners) weakremover(ghc-gogol-partners-devel) weakremover(ghc-gogol-people) weakremover(ghc-gogol-people-devel) weakremover(ghc-gogol-play-moviespartner) weakremover(ghc-gogol-play-moviespartner-devel) weakremover(ghc-gogol-plus) weakremover(ghc-gogol-plus-devel) weakremover(ghc-gogol-plus-domains) weakremover(ghc-gogol-plus-domains-devel) weakremover(ghc-gogol-prediction) weakremover(ghc-gogol-prediction-devel) weakremover(ghc-gogol-proximitybeacon) weakremover(ghc-gogol-proximitybeacon-devel) weakremover(ghc-gogol-pubsub) weakremover(ghc-gogol-pubsub-devel) weakremover(ghc-gogol-qpxexpress) weakremover(ghc-gogol-qpxexpress-devel) weakremover(ghc-gogol-replicapool) weakremover(ghc-gogol-replicapool-devel) weakremover(ghc-gogol-replicapool-updater) weakremover(ghc-gogol-replicapool-updater-devel) weakremover(ghc-gogol-resourcemanager) weakremover(ghc-gogol-resourcemanager-devel) weakremover(ghc-gogol-resourceviews) weakremover(ghc-gogol-resourceviews-devel) weakremover(ghc-gogol-script) weakremover(ghc-gogol-script-devel) weakremover(ghc-gogol-siteverification) weakremover(ghc-gogol-siteverification-devel) weakremover(ghc-gogol-spectrum) weakremover(ghc-gogol-spectrum-devel) weakremover(ghc-gogol-sqladmin) weakremover(ghc-gogol-sqladmin-devel) weakremover(ghc-gogol-storage) weakremover(ghc-gogol-storage-devel) weakremover(ghc-gogol-storage-transfer) weakremover(ghc-gogol-storage-transfer-devel) weakremover(ghc-gogol-tagmanager) weakremover(ghc-gogol-tagmanager-devel) weakremover(ghc-gogol-taskqueue) weakremover(ghc-gogol-taskqueue-devel) weakremover(ghc-gogol-translate) weakremover(ghc-gogol-translate-devel) weakremover(ghc-gogol-urlshortener) weakremover(ghc-gogol-urlshortener-devel) weakremover(ghc-gogol-useraccounts) weakremover(ghc-gogol-useraccounts-devel) weakremover(ghc-gogol-vision) weakremover(ghc-gogol-vision-devel) weakremover(ghc-gogol-webmaster-tools) weakremover(ghc-gogol-webmaster-tools-devel) weakremover(ghc-gogol-youtube-analytics) weakremover(ghc-gogol-youtube-analytics-devel) weakremover(ghc-gogol-youtube-reporting) weakremover(ghc-gogol-youtube-reporting-devel) weakremover(ghc-google-cloud) weakremover(ghc-google-cloud-devel) weakremover(ghc-google-oauth2-jwt) weakremover(ghc-google-oauth2-jwt-devel) weakremover(ghc-google-translate) weakremover(ghc-google-translate-devel) weakremover(ghc-gpolyline) weakremover(ghc-gpolyline-devel) weakremover(ghc-graph-core) weakremover(ghc-graph-core-devel) weakremover(ghc-graph-wrapper) weakremover(ghc-graph-wrapper-devel) weakremover(ghc-graphs) weakremover(ghc-graphs-devel) weakremover(ghc-graphviz) weakremover(ghc-graphviz-devel) weakremover(ghc-gravatar) weakremover(ghc-gravatar-devel) weakremover(ghc-gray-code) weakremover(ghc-gray-code-devel) weakremover(ghc-graylog) weakremover(ghc-graylog-devel) weakremover(ghc-gridtables) weakremover(ghc-gridtables-devel) weakremover(ghc-gridtables-prof) weakremover(ghc-groom) weakremover(ghc-groom-devel) weakremover(ghc-grouped-list) weakremover(ghc-grouped-list-devel) weakremover(ghc-groups) weakremover(ghc-groups-devel) weakremover(ghc-gsasl) weakremover(ghc-gsasl-devel) weakremover(ghc-gtk) weakremover(ghc-gtk-devel) weakremover(ghc-gtk2hs-buildtools) weakremover(ghc-gtk2hs-buildtools-devel) weakremover(ghc-gtk2hs-buildtools-prof) weakremover(ghc-gtk3) weakremover(ghc-gtk3-devel) weakremover(ghc-hOpenPGP) weakremover(ghc-hOpenPGP-devel) weakremover(ghc-hPDB) weakremover(ghc-hPDB-devel) weakremover(ghc-hackage-db) weakremover(ghc-hackage-db-devel) weakremover(ghc-hackage-security) weakremover(ghc-hackage-security-devel) weakremover(ghc-hackage-security-prof) weakremover(ghc-hackernews) weakremover(ghc-hackernews-devel) weakremover(ghc-haddock-library) weakremover(ghc-haddock-library-devel) weakremover(ghc-haddock-library-prof) weakremover(ghc-hadolint) weakremover(ghc-hadolint-devel) weakremover(ghc-hadolint-prof) weakremover(ghc-hailgun) weakremover(ghc-hailgun-devel) weakremover(ghc-hailgun-simple) weakremover(ghc-hailgun-simple-devel) weakremover(ghc-hakyll) weakremover(ghc-hakyll-devel) weakremover(ghc-half) weakremover(ghc-half-devel) weakremover(ghc-hamilton) weakremover(ghc-hamilton-devel) weakremover(ghc-hamlet) weakremover(ghc-hamlet-devel) weakremover(ghc-handwriting) weakremover(ghc-handwriting-devel) weakremover(ghc-hapistrano) weakremover(ghc-hapistrano-devel) weakremover(ghc-happstack-hsp) weakremover(ghc-happstack-hsp-devel) weakremover(ghc-happstack-jmacro) weakremover(ghc-happstack-jmacro-devel) weakremover(ghc-happstack-server) weakremover(ghc-happstack-server-devel) weakremover(ghc-happstack-server-tls) weakremover(ghc-happstack-server-tls-devel) weakremover(ghc-harp) weakremover(ghc-harp-devel) weakremover(ghc-hashable) weakremover(ghc-hashable-devel) weakremover(ghc-hashable-prof) weakremover(ghc-hashable-time) weakremover(ghc-hashable-time-devel) weakremover(ghc-hashmap) weakremover(ghc-hashmap-devel) weakremover(ghc-hashtables) weakremover(ghc-hashtables-devel) weakremover(ghc-hashtables-prof) weakremover(ghc-haskeline) weakremover(ghc-haskeline-devel) weakremover(ghc-haskeline-prof) weakremover(ghc-haskell-gi) weakremover(ghc-haskell-gi-base) weakremover(ghc-haskell-gi-base-devel) weakremover(ghc-haskell-gi-devel) weakremover(ghc-haskell-lexer) weakremover(ghc-haskell-lexer-devel) weakremover(ghc-haskell-lexer-prof) weakremover(ghc-haskell-names) weakremover(ghc-haskell-names-devel) weakremover(ghc-haskell-neo4j-client) weakremover(ghc-haskell-neo4j-client-devel) weakremover(ghc-haskell-spacegoo) weakremover(ghc-haskell-spacegoo-devel) weakremover(ghc-haskell-src) weakremover(ghc-haskell-src-devel) weakremover(ghc-haskell-src-exts) weakremover(ghc-haskell-src-exts-devel) weakremover(ghc-haskell-src-exts-simple) weakremover(ghc-haskell-src-exts-simple-devel) weakremover(ghc-haskell-src-meta) weakremover(ghc-haskell-src-meta-devel) weakremover(ghc-haskell-tools-ast) weakremover(ghc-haskell-tools-ast-devel) weakremover(ghc-haskell-tools-backend-ghc) weakremover(ghc-haskell-tools-backend-ghc-devel) weakremover(ghc-haskell-tools-cli) weakremover(ghc-haskell-tools-cli-devel) weakremover(ghc-haskell-tools-daemon) weakremover(ghc-haskell-tools-daemon-devel) weakremover(ghc-haskell-tools-debug) weakremover(ghc-haskell-tools-debug-devel) weakremover(ghc-haskell-tools-demo) weakremover(ghc-haskell-tools-demo-devel) weakremover(ghc-haskell-tools-prettyprint) weakremover(ghc-haskell-tools-prettyprint-devel) weakremover(ghc-haskell-tools-refactor) weakremover(ghc-haskell-tools-refactor-devel) weakremover(ghc-haskell-tools-rewrite) weakremover(ghc-haskell-tools-rewrite-devel) weakremover(ghc-haskintex) weakremover(ghc-haskintex-devel) weakremover(ghc-hasql) weakremover(ghc-hasql-devel) weakremover(ghc-hasql-migration) weakremover(ghc-hasql-migration-devel) weakremover(ghc-hasql-transaction) weakremover(ghc-hasql-transaction-devel) weakremover(ghc-hastache) weakremover(ghc-hastache-devel) weakremover(ghc-hasty-hamiltonian) weakremover(ghc-hasty-hamiltonian-devel) weakremover(ghc-haxr) weakremover(ghc-haxr-devel) weakremover(ghc-hbeanstalk) weakremover(ghc-hbeanstalk-devel) weakremover(ghc-hdaemonize) weakremover(ghc-hdaemonize-devel) weakremover(ghc-heap) weakremover(ghc-heap-devel) weakremover(ghc-heaps) weakremover(ghc-heaps-devel) weakremover(ghc-hebrew-time) weakremover(ghc-hebrew-time-devel) weakremover(ghc-hedgehog) weakremover(ghc-hedgehog-corpus) weakremover(ghc-hedgehog-corpus-devel) weakremover(ghc-hedgehog-devel) weakremover(ghc-hedgehog-quickcheck) weakremover(ghc-hedgehog-quickcheck-devel) weakremover(ghc-hedis) weakremover(ghc-hedis-devel) weakremover(ghc-here) weakremover(ghc-here-devel) weakremover(ghc-heredoc) weakremover(ghc-heredoc-devel) weakremover(ghc-heterocephalus) weakremover(ghc-heterocephalus-devel) weakremover(ghc-hex) weakremover(ghc-hex-devel) weakremover(ghc-hexml) weakremover(ghc-hexml-devel) weakremover(ghc-hexstring) weakremover(ghc-hexstring-devel) weakremover(ghc-hflags) weakremover(ghc-hflags-devel) weakremover(ghc-hformat) weakremover(ghc-hformat-devel) weakremover(ghc-hgettext) weakremover(ghc-hgettext-devel) weakremover(ghc-hi-file-parser) weakremover(ghc-hi-file-parser-devel) weakremover(ghc-hid) weakremover(ghc-hid-devel) weakremover(ghc-hidapi) weakremover(ghc-hidapi-devel) weakremover(ghc-hierarchical-clustering) weakremover(ghc-hierarchical-clustering-devel) weakremover(ghc-highjson) weakremover(ghc-highjson-devel) weakremover(ghc-highjson-swagger) weakremover(ghc-highjson-swagger-devel) weakremover(ghc-highjson-th) weakremover(ghc-highjson-th-devel) weakremover(ghc-highlighting-kate) weakremover(ghc-highlighting-kate-devel) weakremover(ghc-hindent) weakremover(ghc-hindent-devel) weakremover(ghc-hinotify) weakremover(ghc-hinotify-devel) weakremover(ghc-hinotify-prof) weakremover(ghc-hint) weakremover(ghc-hint-devel) weakremover(ghc-hip) weakremover(ghc-hip-devel) weakremover(ghc-histogram-fill) weakremover(ghc-histogram-fill-devel) weakremover(ghc-hit) weakremover(ghc-hit-devel) weakremover(ghc-hjpath) weakremover(ghc-hjpath-devel) weakremover(ghc-hjsmin) weakremover(ghc-hjsmin-devel) weakremover(ghc-hjsmin-prof) weakremover(ghc-hjson) weakremover(ghc-hjson-devel) weakremover(ghc-hjsonpointer) weakremover(ghc-hjsonpointer-devel) weakremover(ghc-hjsonschema) weakremover(ghc-hjsonschema-devel) weakremover(ghc-hledger) weakremover(ghc-hledger-devel) weakremover(ghc-hledger-iadd) weakremover(ghc-hledger-iadd-devel) weakremover(ghc-hledger-lib) weakremover(ghc-hledger-lib-devel) weakremover(ghc-hledger-lib-prof) weakremover(ghc-hledger-prof) weakremover(ghc-hledger-web) weakremover(ghc-hledger-web-devel) weakremover(ghc-hlibgit2) weakremover(ghc-hlibgit2-devel) weakremover(ghc-hlibsass) weakremover(ghc-hlibsass-devel) weakremover(ghc-hlint) weakremover(ghc-hlint-devel) weakremover(ghc-hlint-prof) weakremover(ghc-hmatrix) weakremover(ghc-hmatrix-devel) weakremover(ghc-hmatrix-gsl) weakremover(ghc-hmatrix-gsl-devel) weakremover(ghc-hmatrix-repa) weakremover(ghc-hmatrix-repa-devel) weakremover(ghc-hmatrix-special) weakremover(ghc-hmatrix-special-devel) weakremover(ghc-hmpfr) weakremover(ghc-hmpfr-devel) weakremover(ghc-hmt) weakremover(ghc-hmt-devel) weakremover(ghc-hoauth2) weakremover(ghc-hoauth2-devel) weakremover(ghc-holy-project) weakremover(ghc-holy-project-devel) weakremover(ghc-hoogle) weakremover(ghc-hoogle-devel) weakremover(ghc-hoopl) weakremover(ghc-hoopl-devel) weakremover(ghc-hopenssl) weakremover(ghc-hopenssl-devel) weakremover(ghc-hosc) weakremover(ghc-hosc-devel) weakremover(ghc-hostname) weakremover(ghc-hostname-devel) weakremover(ghc-hostname-validate) weakremover(ghc-hostname-validate-devel) weakremover(ghc-hourglass) weakremover(ghc-hourglass-devel) weakremover(ghc-hourglass-prof) weakremover(ghc-hpack) weakremover(ghc-hpack-devel) weakremover(ghc-hpc) weakremover(ghc-hpc-coveralls) weakremover(ghc-hpc-coveralls-devel) weakremover(ghc-hpc-devel) weakremover(ghc-hpc-prof) weakremover(ghc-hpio) weakremover(ghc-hpio-devel) weakremover(ghc-hpp) weakremover(ghc-hpp-devel) weakremover(ghc-hpqtypes) weakremover(ghc-hpqtypes-devel) weakremover(ghc-hquantlib) weakremover(ghc-hquantlib-devel) weakremover(ghc-hreader) weakremover(ghc-hreader-devel) weakremover(ghc-hruby) weakremover(ghc-hruby-devel) weakremover(ghc-hs-GeoIP) weakremover(ghc-hs-GeoIP-devel) weakremover(ghc-hs-bibutils) weakremover(ghc-hs-bibutils-devel) weakremover(ghc-hsass) weakremover(ghc-hsass-devel) weakremover(ghc-hscolour) weakremover(ghc-hscolour-devel) weakremover(ghc-hscolour-prof) weakremover(ghc-hsdns) weakremover(ghc-hsdns-devel) weakremover(ghc-hse-cpp) weakremover(ghc-hse-cpp-devel) weakremover(ghc-hsebaysdk) weakremover(ghc-hsebaysdk-devel) weakremover(ghc-hsemail) weakremover(ghc-hsemail-devel) weakremover(ghc-hset) weakremover(ghc-hset-devel) weakremover(ghc-hsexif) weakremover(ghc-hsexif-devel) weakremover(ghc-hsinstall) weakremover(ghc-hsinstall-devel) weakremover(ghc-hslogger) weakremover(ghc-hslogger-devel) weakremover(ghc-hslua) weakremover(ghc-hslua-aeson) weakremover(ghc-hslua-aeson-devel) weakremover(ghc-hslua-aeson-prof) weakremover(ghc-hslua-classes) weakremover(ghc-hslua-classes-devel) weakremover(ghc-hslua-classes-prof) weakremover(ghc-hslua-cli) weakremover(ghc-hslua-cli-devel) weakremover(ghc-hslua-cli-prof) weakremover(ghc-hslua-core) weakremover(ghc-hslua-core-devel) weakremover(ghc-hslua-core-prof) weakremover(ghc-hslua-devel) weakremover(ghc-hslua-list) weakremover(ghc-hslua-list-devel) weakremover(ghc-hslua-list-prof) weakremover(ghc-hslua-marshalling) weakremover(ghc-hslua-marshalling-devel) weakremover(ghc-hslua-marshalling-prof) weakremover(ghc-hslua-module-doclayout) weakremover(ghc-hslua-module-doclayout-devel) weakremover(ghc-hslua-module-doclayout-prof) weakremover(ghc-hslua-module-path) weakremover(ghc-hslua-module-path-devel) weakremover(ghc-hslua-module-path-prof) weakremover(ghc-hslua-module-system) weakremover(ghc-hslua-module-system-devel) weakremover(ghc-hslua-module-system-prof) weakremover(ghc-hslua-module-text) weakremover(ghc-hslua-module-text-devel) weakremover(ghc-hslua-module-text-prof) weakremover(ghc-hslua-module-version) weakremover(ghc-hslua-module-version-devel) weakremover(ghc-hslua-module-version-prof) weakremover(ghc-hslua-module-zip) weakremover(ghc-hslua-module-zip-devel) weakremover(ghc-hslua-module-zip-prof) weakremover(ghc-hslua-objectorientation) weakremover(ghc-hslua-objectorientation-devel) weakremover(ghc-hslua-objectorientation-prof) weakremover(ghc-hslua-packaging) weakremover(ghc-hslua-packaging-devel) weakremover(ghc-hslua-packaging-prof) weakremover(ghc-hslua-prof) weakremover(ghc-hslua-repl) weakremover(ghc-hslua-repl-devel) weakremover(ghc-hslua-repl-prof) weakremover(ghc-hslua-typing) weakremover(ghc-hslua-typing-devel) weakremover(ghc-hslua-typing-prof) weakremover(ghc-hsndfile) weakremover(ghc-hsndfile-devel) weakremover(ghc-hsndfile-vector) weakremover(ghc-hsndfile-vector-devel) weakremover(ghc-hsp) weakremover(ghc-hsp-devel) weakremover(ghc-hspec) weakremover(ghc-hspec-attoparsec) weakremover(ghc-hspec-attoparsec-devel) weakremover(ghc-hspec-contrib) weakremover(ghc-hspec-contrib-devel) weakremover(ghc-hspec-core) weakremover(ghc-hspec-core-devel) weakremover(ghc-hspec-devel) weakremover(ghc-hspec-discover) weakremover(ghc-hspec-discover-devel) weakremover(ghc-hspec-expectations) weakremover(ghc-hspec-expectations-devel) weakremover(ghc-hspec-expectations-pretty-diff) weakremover(ghc-hspec-expectations-pretty-diff-devel) weakremover(ghc-hspec-golden-aeson) weakremover(ghc-hspec-golden-aeson-devel) weakremover(ghc-hspec-megaparsec) weakremover(ghc-hspec-megaparsec-devel) weakremover(ghc-hspec-meta) weakremover(ghc-hspec-meta-devel) weakremover(ghc-hspec-smallcheck) weakremover(ghc-hspec-smallcheck-devel) weakremover(ghc-hspec-wai) weakremover(ghc-hspec-wai-devel) weakremover(ghc-hspec-wai-json) weakremover(ghc-hspec-wai-json-devel) weakremover(ghc-hspec-webdriver) weakremover(ghc-hspec-webdriver-devel) weakremover(ghc-hstatsd) weakremover(ghc-hstatsd-devel) weakremover(ghc-hsx-jmacro) weakremover(ghc-hsx-jmacro-devel) weakremover(ghc-hsx2hs) weakremover(ghc-hsx2hs-devel) weakremover(ghc-hsyslog) weakremover(ghc-hsyslog-devel) weakremover(ghc-htaglib) weakremover(ghc-htaglib-devel) weakremover(ghc-html) weakremover(ghc-html-conduit) weakremover(ghc-html-conduit-devel) weakremover(ghc-html-devel) weakremover(ghc-html-email-validate) weakremover(ghc-html-email-validate-devel) weakremover(ghc-html-prof) weakremover(ghc-htoml) weakremover(ghc-htoml-devel) weakremover(ghc-http-api-data) weakremover(ghc-http-api-data-devel) weakremover(ghc-http-api-data-prof) weakremover(ghc-http-client) weakremover(ghc-http-client-devel) weakremover(ghc-http-client-openssl) weakremover(ghc-http-client-openssl-devel) weakremover(ghc-http-client-prof) weakremover(ghc-http-client-restricted) weakremover(ghc-http-client-restricted-devel) weakremover(ghc-http-client-restricted-prof) weakremover(ghc-http-client-tls) weakremover(ghc-http-client-tls-devel) weakremover(ghc-http-client-tls-prof) weakremover(ghc-http-common) weakremover(ghc-http-common-devel) weakremover(ghc-http-conduit) weakremover(ghc-http-conduit-devel) weakremover(ghc-http-conduit-prof) weakremover(ghc-http-date) weakremover(ghc-http-date-devel) weakremover(ghc-http-date-prof) weakremover(ghc-http-download) weakremover(ghc-http-download-devel) weakremover(ghc-http-link-header) weakremover(ghc-http-link-header-devel) weakremover(ghc-http-media) weakremover(ghc-http-media-devel) weakremover(ghc-http-media-prof) weakremover(ghc-http-reverse-proxy) weakremover(ghc-http-reverse-proxy-devel) weakremover(ghc-http-streams) weakremover(ghc-http-streams-devel) weakremover(ghc-http-types) weakremover(ghc-http-types-devel) weakremover(ghc-http-types-prof) weakremover(ghc-http2) weakremover(ghc-http2-devel) weakremover(ghc-http2-prof) weakremover(ghc-httpd-shed) weakremover(ghc-httpd-shed-devel) weakremover(ghc-human-readable-duration) weakremover(ghc-human-readable-duration-devel) weakremover(ghc-hunit-dejafu) weakremover(ghc-hunit-dejafu-devel) weakremover(ghc-hvect) weakremover(ghc-hvect-devel) weakremover(ghc-hweblib) weakremover(ghc-hweblib-devel) weakremover(ghc-hworker) weakremover(ghc-hworker-devel) weakremover(ghc-hxt) weakremover(ghc-hxt-charproperties) weakremover(ghc-hxt-charproperties-devel) weakremover(ghc-hxt-css) weakremover(ghc-hxt-css-devel) weakremover(ghc-hxt-devel) weakremover(ghc-hxt-http) weakremover(ghc-hxt-http-devel) weakremover(ghc-hxt-pickle-utils) weakremover(ghc-hxt-pickle-utils-devel) weakremover(ghc-hxt-regex-xmlschema) weakremover(ghc-hxt-regex-xmlschema-devel) weakremover(ghc-hxt-unicode) weakremover(ghc-hxt-unicode-devel) weakremover(ghc-hybrid-vectors) weakremover(ghc-hybrid-vectors-devel) weakremover(ghc-hyphenation) weakremover(ghc-hyphenation-devel) weakremover(ghc-ical) weakremover(ghc-ical-devel) weakremover(ghc-iconv) weakremover(ghc-iconv-devel) weakremover(ghc-identicon) weakremover(ghc-identicon-devel) weakremover(ghc-idna) weakremover(ghc-idna-devel) weakremover(ghc-ieee754) weakremover(ghc-ieee754-devel) weakremover(ghc-if) weakremover(ghc-if-devel) weakremover(ghc-ignore) weakremover(ghc-ignore-devel) weakremover(ghc-ilist) weakremover(ghc-ilist-devel) weakremover(ghc-ilist-prof) weakremover(ghc-imagesize-conduit) weakremover(ghc-imagesize-conduit-devel) weakremover(ghc-imm) weakremover(ghc-imm-devel) weakremover(ghc-immortal) weakremover(ghc-immortal-devel) weakremover(ghc-include-file) weakremover(ghc-include-file-devel) weakremover(ghc-incremental-parser) weakremover(ghc-incremental-parser-devel) weakremover(ghc-indentation-core) weakremover(ghc-indentation-core-devel) weakremover(ghc-indentation-parsec) weakremover(ghc-indentation-parsec-devel) weakremover(ghc-indents) weakremover(ghc-indents-devel) weakremover(ghc-indexed-profunctors) weakremover(ghc-indexed-profunctors-devel) weakremover(ghc-indexed-profunctors-prof) weakremover(ghc-indexed-traversable) weakremover(ghc-indexed-traversable-devel) weakremover(ghc-indexed-traversable-instances) weakremover(ghc-indexed-traversable-instances-devel) weakremover(ghc-indexed-traversable-instances-prof) weakremover(ghc-indexed-traversable-prof) weakremover(ghc-infer-license) weakremover(ghc-infer-license-devel) weakremover(ghc-inflections) weakremover(ghc-inflections-devel) weakremover(ghc-ini) weakremover(ghc-ini-devel) weakremover(ghc-inline-c) weakremover(ghc-inline-c-cpp) weakremover(ghc-inline-c-cpp-devel) weakremover(ghc-inline-c-devel) weakremover(ghc-insert-ordered-containers) weakremover(ghc-insert-ordered-containers-devel) weakremover(ghc-instance-control) weakremover(ghc-instance-control-devel) weakremover(ghc-integer-logarithms) weakremover(ghc-integer-logarithms-devel) weakremover(ghc-integer-logarithms-prof) weakremover(ghc-integration) weakremover(ghc-integration-devel) weakremover(ghc-intern) weakremover(ghc-intern-devel) weakremover(ghc-interpolate) weakremover(ghc-interpolate-devel) weakremover(ghc-interpolatedstring-perl6) weakremover(ghc-interpolatedstring-perl6-devel) weakremover(ghc-intervals) weakremover(ghc-intervals-devel) weakremover(ghc-intro) weakremover(ghc-intro-devel) weakremover(ghc-invariant) weakremover(ghc-invariant-devel) weakremover(ghc-invariant-prof) weakremover(ghc-invertible) weakremover(ghc-invertible-devel) weakremover(ghc-io-choice) weakremover(ghc-io-choice-devel) weakremover(ghc-io-machine) weakremover(ghc-io-machine-devel) weakremover(ghc-io-manager) weakremover(ghc-io-manager-devel) weakremover(ghc-io-memoize) weakremover(ghc-io-memoize-devel) weakremover(ghc-io-region) weakremover(ghc-io-region-devel) weakremover(ghc-io-storage) weakremover(ghc-io-storage-devel) weakremover(ghc-io-streams) weakremover(ghc-io-streams-devel) weakremover(ghc-io-streams-haproxy) weakremover(ghc-io-streams-haproxy-devel) weakremover(ghc-iproute) weakremover(ghc-iproute-devel) weakremover(ghc-iproute-prof) weakremover(ghc-ipynb) weakremover(ghc-ipynb-devel) weakremover(ghc-ipynb-prof) weakremover(ghc-irc) weakremover(ghc-irc-client) weakremover(ghc-irc-client-devel) weakremover(ghc-irc-conduit) weakremover(ghc-irc-conduit-devel) weakremover(ghc-irc-ctcp) weakremover(ghc-irc-ctcp-devel) weakremover(ghc-irc-dcc) weakremover(ghc-irc-dcc-devel) weakremover(ghc-irc-devel) weakremover(ghc-islink) weakremover(ghc-islink-devel) weakremover(ghc-iso3166-country-codes) weakremover(ghc-iso3166-country-codes-devel) weakremover(ghc-iso639) weakremover(ghc-iso639-devel) weakremover(ghc-iso8601-time) weakremover(ghc-iso8601-time-devel) weakremover(ghc-isocline) weakremover(ghc-isocline-devel) weakremover(ghc-isocline-prof) weakremover(ghc-iterable) weakremover(ghc-iterable-devel) weakremover(ghc-iwlib) weakremover(ghc-iwlib-devel) weakremover(ghc-iwlib-prof) weakremover(ghc-ix-shapable) weakremover(ghc-ix-shapable-devel) weakremover(ghc-ixset) weakremover(ghc-ixset-devel) weakremover(ghc-ixset-typed) weakremover(ghc-ixset-typed-devel) weakremover(ghc-jira-wiki-markup) weakremover(ghc-jira-wiki-markup-devel) weakremover(ghc-jira-wiki-markup-prof) weakremover(ghc-jmacro-rpc) weakremover(ghc-jmacro-rpc-devel) weakremover(ghc-jmacro-rpc-happstack) weakremover(ghc-jmacro-rpc-happstack-devel) weakremover(ghc-jmacro-rpc-snap) weakremover(ghc-jmacro-rpc-snap-devel) weakremover(ghc-jose) weakremover(ghc-jose-devel) weakremover(ghc-jose-jwt) weakremover(ghc-jose-jwt-devel) weakremover(ghc-js-chart) weakremover(ghc-js-chart-devel) weakremover(ghc-js-chart-prof) weakremover(ghc-js-dgtable) weakremover(ghc-js-dgtable-devel) weakremover(ghc-js-flot) weakremover(ghc-js-flot-devel) weakremover(ghc-js-jquery) weakremover(ghc-js-jquery-devel) weakremover(ghc-json) weakremover(ghc-json-builder) weakremover(ghc-json-builder-devel) weakremover(ghc-json-devel) weakremover(ghc-json-rpc-generic) weakremover(ghc-json-rpc-generic-devel) weakremover(ghc-json-schema) weakremover(ghc-json-schema-devel) weakremover(ghc-json-stream) weakremover(ghc-json-stream-devel) weakremover(ghc-jwt) weakremover(ghc-jwt-devel) weakremover(ghc-kan-extensions) weakremover(ghc-kan-extensions-devel) weakremover(ghc-kan-extensions-prof) weakremover(ghc-kansas-comet) weakremover(ghc-kansas-comet-devel) weakremover(ghc-katip) weakremover(ghc-katip-devel) weakremover(ghc-katip-elasticsearch) weakremover(ghc-katip-elasticsearch-devel) weakremover(ghc-kawhi) weakremover(ghc-kawhi-devel) weakremover(ghc-kdt) weakremover(ghc-kdt-devel) weakremover(ghc-keycode) weakremover(ghc-keycode-devel) weakremover(ghc-keys) weakremover(ghc-keys-devel) weakremover(ghc-kmeans) weakremover(ghc-kmeans-devel) weakremover(ghc-knob) weakremover(ghc-knob-devel) weakremover(ghc-koofr-client) weakremover(ghc-koofr-client-devel) weakremover(ghc-kraken) weakremover(ghc-kraken-devel) weakremover(ghc-l10n) weakremover(ghc-l10n-devel) weakremover(ghc-labels) weakremover(ghc-labels-devel) weakremover(ghc-lackey) weakremover(ghc-lackey-devel) weakremover(ghc-language-c) weakremover(ghc-language-c-devel) weakremover(ghc-language-c-prof) weakremover(ghc-language-c-quote) weakremover(ghc-language-c-quote-devel) weakremover(ghc-language-docker) weakremover(ghc-language-docker-devel) weakremover(ghc-language-docker-prof) weakremover(ghc-language-ecmascript) weakremover(ghc-language-ecmascript-devel) weakremover(ghc-language-fortran) weakremover(ghc-language-fortran-devel) weakremover(ghc-language-glsl) weakremover(ghc-language-glsl-devel) weakremover(ghc-language-haskell-extract) weakremover(ghc-language-haskell-extract-devel) weakremover(ghc-language-java) weakremover(ghc-language-java-devel) weakremover(ghc-language-javascript) weakremover(ghc-language-javascript-devel) weakremover(ghc-language-javascript-prof) weakremover(ghc-language-lua2) weakremover(ghc-language-lua2-devel) weakremover(ghc-language-nix) weakremover(ghc-language-nix-devel) weakremover(ghc-language-puppet) weakremover(ghc-language-puppet-devel) weakremover(ghc-largeword) weakremover(ghc-largeword-devel) weakremover(ghc-lattices) weakremover(ghc-lattices-devel) weakremover(ghc-lazy-csv) weakremover(ghc-lazy-csv-devel) weakremover(ghc-lazysmallcheck) weakremover(ghc-lazysmallcheck-devel) weakremover(ghc-lca) weakremover(ghc-lca-devel) weakremover(ghc-leancheck) weakremover(ghc-leancheck-devel) weakremover(ghc-leapseconds-announced) weakremover(ghc-leapseconds-announced-devel) weakremover(ghc-lens) weakremover(ghc-lens-action) weakremover(ghc-lens-action-devel) weakremover(ghc-lens-aeson) weakremover(ghc-lens-aeson-devel) weakremover(ghc-lens-datetime) weakremover(ghc-lens-datetime-devel) weakremover(ghc-lens-devel) weakremover(ghc-lens-family) weakremover(ghc-lens-family-core) weakremover(ghc-lens-family-core-devel) weakremover(ghc-lens-family-devel) weakremover(ghc-lens-family-th) weakremover(ghc-lens-family-th-devel) weakremover(ghc-lens-prof) weakremover(ghc-lens-regex) weakremover(ghc-lens-regex-devel) weakremover(ghc-lens-simple) weakremover(ghc-lens-simple-devel) weakremover(ghc-leveldb-haskell) weakremover(ghc-leveldb-haskell-devel) weakremover(ghc-lexer-applicative) weakremover(ghc-lexer-applicative-devel) weakremover(ghc-libffi) weakremover(ghc-libffi-devel) weakremover(ghc-libgit) weakremover(ghc-libgit-devel) weakremover(ghc-libinfluxdb) weakremover(ghc-libinfluxdb-devel) weakremover(ghc-libiserv) weakremover(ghc-libiserv-devel) weakremover(ghc-libiserv-prof) weakremover(ghc-libmpd) weakremover(ghc-libmpd-devel) weakremover(ghc-libmpd-prof) weakremover(ghc-libnotify) weakremover(ghc-libnotify-devel) weakremover(ghc-libraries) weakremover(ghc-librato) weakremover(ghc-librato-devel) weakremover(ghc-libsystemd-journal) weakremover(ghc-libsystemd-journal-devel) weakremover(ghc-libxml-sax) weakremover(ghc-libxml-sax-devel) weakremover(ghc-libyaml) weakremover(ghc-libyaml-devel) weakremover(ghc-libyaml-prof) weakremover(ghc-licensor) weakremover(ghc-licensor-devel) weakremover(ghc-lift-generics) weakremover(ghc-lift-generics-devel) weakremover(ghc-lift-type) weakremover(ghc-lift-type-devel) weakremover(ghc-lift-type-prof) weakremover(ghc-lifted-async) weakremover(ghc-lifted-async-devel) weakremover(ghc-lifted-base) weakremover(ghc-lifted-base-devel) weakremover(ghc-lifted-base-prof) weakremover(ghc-line) weakremover(ghc-line-devel) weakremover(ghc-linear) weakremover(ghc-linear-accelerate) weakremover(ghc-linear-accelerate-devel) weakremover(ghc-linear-devel) weakremover(ghc-linked-list-with-iterator) weakremover(ghc-linked-list-with-iterator-devel) weakremover(ghc-linux-file-extents) weakremover(ghc-linux-file-extents-devel) weakremover(ghc-linux-namespaces) weakremover(ghc-linux-namespaces-devel) weakremover(ghc-liquid-fixpoint) weakremover(ghc-liquid-fixpoint-devel) weakremover(ghc-liquidhaskell) weakremover(ghc-liquidhaskell-devel) weakremover(ghc-list-fusion-probe) weakremover(ghc-list-fusion-probe-devel) weakremover(ghc-list-t) weakremover(ghc-list-t-devel) weakremover(ghc-lmdb) weakremover(ghc-lmdb-devel) weakremover(ghc-load-env) weakremover(ghc-load-env-devel) weakremover(ghc-loch-th) weakremover(ghc-loch-th-devel) weakremover(ghc-log) weakremover(ghc-log-base) weakremover(ghc-log-base-devel) weakremover(ghc-log-devel) weakremover(ghc-log-domain) weakremover(ghc-log-domain-devel) weakremover(ghc-log-elasticsearch) weakremover(ghc-log-elasticsearch-devel) weakremover(ghc-log-postgres) weakremover(ghc-log-postgres-devel) weakremover(ghc-logfloat) weakremover(ghc-logfloat-devel) weakremover(ghc-logger-thread) weakremover(ghc-logger-thread-devel) weakremover(ghc-logging-effect) weakremover(ghc-logging-effect-devel) weakremover(ghc-logging-facade) weakremover(ghc-logging-facade-devel) weakremover(ghc-logict) weakremover(ghc-logict-devel) weakremover(ghc-loop) weakremover(ghc-loop-devel) weakremover(ghc-lpeg) weakremover(ghc-lpeg-devel) weakremover(ghc-lpeg-prof) weakremover(ghc-lrucache) weakremover(ghc-lrucache-devel) weakremover(ghc-lrucaching) weakremover(ghc-lrucaching-devel) weakremover(ghc-lua) weakremover(ghc-lua-devel) weakremover(ghc-lua-prof) weakremover(ghc-lucid) weakremover(ghc-lucid-devel) weakremover(ghc-lucid-prof) weakremover(ghc-lukko) weakremover(ghc-lukko-devel) weakremover(ghc-lukko-prof) weakremover(ghc-lzma-conduit) weakremover(ghc-lzma-conduit-devel) weakremover(ghc-machines) weakremover(ghc-machines-binary) weakremover(ghc-machines-binary-devel) weakremover(ghc-machines-devel) weakremover(ghc-machines-directory) weakremover(ghc-machines-directory-devel) weakremover(ghc-machines-io) weakremover(ghc-machines-io-devel) weakremover(ghc-magic) weakremover(ghc-magic-devel) weakremover(ghc-magic-prof) weakremover(ghc-mainland-pretty) weakremover(ghc-mainland-pretty-devel) weakremover(ghc-makefile) weakremover(ghc-makefile-devel) weakremover(ghc-managed) weakremover(ghc-managed-devel) weakremover(ghc-mandrill) weakremover(ghc-mandrill-devel) weakremover(ghc-markdown) weakremover(ghc-markdown-devel) weakremover(ghc-markdown-unlit) weakremover(ghc-markdown-unlit-devel) weakremover(ghc-markup) weakremover(ghc-markup-devel) weakremover(ghc-math-functions) weakremover(ghc-math-functions-devel) weakremover(ghc-math-functions-prof) weakremover(ghc-mathexpr) weakremover(ghc-mathexpr-devel) weakremover(ghc-matrices) weakremover(ghc-matrices-devel) weakremover(ghc-matrix) weakremover(ghc-matrix-devel) weakremover(ghc-matrix-market-attoparsec) weakremover(ghc-matrix-market-attoparsec-devel) weakremover(ghc-maximal-cliques) weakremover(ghc-maximal-cliques-devel) weakremover(ghc-mbox) weakremover(ghc-mbox-devel) weakremover(ghc-mcmc-types) weakremover(ghc-mcmc-types-devel) weakremover(ghc-median-stream) weakremover(ghc-median-stream-devel) weakremover(ghc-megaparsec) weakremover(ghc-megaparsec-devel) weakremover(ghc-megaparsec-prof) weakremover(ghc-memory) weakremover(ghc-memory-devel) weakremover(ghc-memory-prof) weakremover(ghc-mersenne-random) weakremover(ghc-mersenne-random-devel) weakremover(ghc-mersenne-random-pure64) weakremover(ghc-mersenne-random-pure64-devel) weakremover(ghc-messagepack) weakremover(ghc-messagepack-devel) weakremover(ghc-messagepack-rpc) weakremover(ghc-messagepack-rpc-devel) weakremover(ghc-metrics) weakremover(ghc-metrics-devel) weakremover(ghc-mfsolve) weakremover(ghc-mfsolve-devel) weakremover(ghc-microformats2-parser) weakremover(ghc-microformats2-parser-devel) weakremover(ghc-microlens) weakremover(ghc-microlens-aeson) weakremover(ghc-microlens-aeson-devel) weakremover(ghc-microlens-contra) weakremover(ghc-microlens-contra-devel) weakremover(ghc-microlens-devel) weakremover(ghc-microlens-ghc) weakremover(ghc-microlens-ghc-devel) weakremover(ghc-microlens-ghc-prof) weakremover(ghc-microlens-mtl) weakremover(ghc-microlens-mtl-devel) weakremover(ghc-microlens-mtl-prof) weakremover(ghc-microlens-platform) weakremover(ghc-microlens-platform-devel) weakremover(ghc-microlens-platform-prof) weakremover(ghc-microlens-prof) weakremover(ghc-microlens-th) weakremover(ghc-microlens-th-devel) weakremover(ghc-microlens-th-prof) weakremover(ghc-microstache) weakremover(ghc-microstache-devel) weakremover(ghc-microstache-prof) weakremover(ghc-mighty-metropolis) weakremover(ghc-mighty-metropolis-devel) weakremover(ghc-mime-mail) weakremover(ghc-mime-mail-devel) weakremover(ghc-mime-mail-ses) weakremover(ghc-mime-mail-ses-devel) weakremover(ghc-mime-types) weakremover(ghc-mime-types-devel) weakremover(ghc-mime-types-prof) weakremover(ghc-mintty) weakremover(ghc-mintty-devel) weakremover(ghc-misfortune) weakremover(ghc-misfortune-devel) weakremover(ghc-missing-foreign) weakremover(ghc-missing-foreign-devel) weakremover(ghc-mmap) weakremover(ghc-mmap-devel) weakremover(ghc-mmorph) weakremover(ghc-mmorph-devel) weakremover(ghc-mmorph-prof) weakremover(ghc-mockery) weakremover(ghc-mockery-devel) weakremover(ghc-mod) weakremover(ghc-modify-fasta) weakremover(ghc-modify-fasta-devel) weakremover(ghc-monad-control) weakremover(ghc-monad-control-devel) weakremover(ghc-monad-control-prof) weakremover(ghc-monad-coroutine) weakremover(ghc-monad-coroutine-devel) weakremover(ghc-monad-extras) weakremover(ghc-monad-extras-devel) weakremover(ghc-monad-http) weakremover(ghc-monad-http-devel) weakremover(ghc-monad-journal) weakremover(ghc-monad-journal-devel) weakremover(ghc-monad-logger) weakremover(ghc-monad-logger-devel) weakremover(ghc-monad-logger-json) weakremover(ghc-monad-logger-json-devel) weakremover(ghc-monad-logger-prefix) weakremover(ghc-monad-logger-prefix-devel) weakremover(ghc-monad-logger-prof) weakremover(ghc-monad-logger-syslog) weakremover(ghc-monad-logger-syslog-devel) weakremover(ghc-monad-loops) weakremover(ghc-monad-loops-devel) weakremover(ghc-monad-loops-prof) weakremover(ghc-monad-metrics) weakremover(ghc-monad-metrics-devel) weakremover(ghc-monad-par) weakremover(ghc-monad-par-devel) weakremover(ghc-monad-par-extras) weakremover(ghc-monad-par-extras-devel) weakremover(ghc-monad-parallel) weakremover(ghc-monad-parallel-devel) weakremover(ghc-monad-peel) weakremover(ghc-monad-peel-devel) weakremover(ghc-monad-primitive) weakremover(ghc-monad-primitive-devel) weakremover(ghc-monad-products) weakremover(ghc-monad-products-devel) weakremover(ghc-monad-skeleton) weakremover(ghc-monad-skeleton-devel) weakremover(ghc-monad-time) weakremover(ghc-monad-time-devel) weakremover(ghc-monad-unlift) weakremover(ghc-monad-unlift-devel) weakremover(ghc-monad-unlift-ref) weakremover(ghc-monad-unlift-ref-devel) weakremover(ghc-monadLib) weakremover(ghc-monadLib-devel) weakremover(ghc-monadcryptorandom) weakremover(ghc-monadcryptorandom-devel) weakremover(ghc-monadic-arrays) weakremover(ghc-monadic-arrays-devel) weakremover(ghc-monadloc) weakremover(ghc-monadloc-devel) weakremover(ghc-monadplus) weakremover(ghc-monadplus-devel) weakremover(ghc-monads-tf) weakremover(ghc-monads-tf-devel) weakremover(ghc-mongoDB) weakremover(ghc-mongoDB-devel) weakremover(ghc-mono-traversable) weakremover(ghc-mono-traversable-devel) weakremover(ghc-mono-traversable-instances) weakremover(ghc-mono-traversable-instances-devel) weakremover(ghc-mono-traversable-prof) weakremover(ghc-monoid-extras) weakremover(ghc-monoid-extras-devel) weakremover(ghc-monoid-subclasses) weakremover(ghc-monoid-subclasses-devel) weakremover(ghc-monoid-subclasses-prof) weakremover(ghc-monoidal-containers) weakremover(ghc-monoidal-containers-devel) weakremover(ghc-moo) weakremover(ghc-moo-devel) weakremover(ghc-morte) weakremover(ghc-morte-devel) weakremover(ghc-mountpoints) weakremover(ghc-mountpoints-devel) weakremover(ghc-mountpoints-prof) weakremover(ghc-mstate) weakremover(ghc-mstate-devel) weakremover(ghc-mtl) weakremover(ghc-mtl-compat) weakremover(ghc-mtl-compat-devel) weakremover(ghc-mtl-devel) weakremover(ghc-mtl-prelude) weakremover(ghc-mtl-prelude-devel) weakremover(ghc-mtl-prof) weakremover(ghc-multiarg) weakremover(ghc-multiarg-devel) weakremover(ghc-multimap) weakremover(ghc-multimap-devel) weakremover(ghc-multipart) weakremover(ghc-multipart-devel) weakremover(ghc-multiset) weakremover(ghc-multiset-comb) weakremover(ghc-multiset-comb-devel) weakremover(ghc-multiset-devel) weakremover(ghc-multistate) weakremover(ghc-multistate-devel) weakremover(ghc-murmur-hash) weakremover(ghc-murmur-hash-devel) weakremover(ghc-murmur3) weakremover(ghc-murmur3-devel) weakremover(ghc-mustache) weakremover(ghc-mustache-devel) weakremover(ghc-mutable-containers) weakremover(ghc-mutable-containers-devel) weakremover(ghc-mwc-probability) weakremover(ghc-mwc-probability-devel) weakremover(ghc-mwc-random) weakremover(ghc-mwc-random-devel) weakremover(ghc-mwc-random-monad) weakremover(ghc-mwc-random-monad-devel) weakremover(ghc-mwc-random-prof) weakremover(ghc-mysql) weakremover(ghc-mysql-devel) weakremover(ghc-mysql-haskell) weakremover(ghc-mysql-haskell-devel) weakremover(ghc-mysql-haskell-openssl) weakremover(ghc-mysql-haskell-openssl-devel) weakremover(ghc-mysql-simple) weakremover(ghc-mysql-simple-devel) weakremover(ghc-nagios-check) weakremover(ghc-nagios-check-devel) weakremover(ghc-names-th) weakremover(ghc-names-th-devel) weakremover(ghc-nano-erl) weakremover(ghc-nano-erl-devel) weakremover(ghc-nanospec) weakremover(ghc-nanospec-devel) weakremover(ghc-nationstates) weakremover(ghc-nationstates-devel) weakremover(ghc-nats) weakremover(ghc-nats-devel) weakremover(ghc-natural-sort) weakremover(ghc-natural-sort-devel) weakremover(ghc-natural-transformation) weakremover(ghc-natural-transformation-devel) weakremover(ghc-ndjson-conduit) weakremover(ghc-ndjson-conduit-devel) weakremover(ghc-neat-interpolation) weakremover(ghc-neat-interpolation-devel) weakremover(ghc-netlink) weakremover(ghc-netlink-devel) weakremover(ghc-netlink-prof) weakremover(ghc-netpbm) weakremover(ghc-netpbm-devel) weakremover(ghc-nettle) weakremover(ghc-nettle-devel) weakremover(ghc-netwire) weakremover(ghc-netwire-devel) weakremover(ghc-netwire-input) weakremover(ghc-netwire-input-devel) weakremover(ghc-netwire-input-glfw) weakremover(ghc-netwire-input-glfw-devel) weakremover(ghc-network) weakremover(ghc-network-anonymous-i2p) weakremover(ghc-network-anonymous-i2p-devel) weakremover(ghc-network-anonymous-tor) weakremover(ghc-network-anonymous-tor-devel) weakremover(ghc-network-attoparsec) weakremover(ghc-network-attoparsec-devel) weakremover(ghc-network-bsd) weakremover(ghc-network-bsd-devel) weakremover(ghc-network-bsd-prof) weakremover(ghc-network-byte-order) weakremover(ghc-network-byte-order-devel) weakremover(ghc-network-byte-order-prof) weakremover(ghc-network-carbon) weakremover(ghc-network-carbon-devel) weakremover(ghc-network-conduit-tls) weakremover(ghc-network-conduit-tls-devel) weakremover(ghc-network-devel) weakremover(ghc-network-house) weakremover(ghc-network-house-devel) weakremover(ghc-network-info) weakremover(ghc-network-info-devel) weakremover(ghc-network-info-prof) weakremover(ghc-network-ip) weakremover(ghc-network-ip-devel) weakremover(ghc-network-msgpack-rpc) weakremover(ghc-network-msgpack-rpc-devel) weakremover(ghc-network-multicast) weakremover(ghc-network-multicast-devel) weakremover(ghc-network-multicast-prof) weakremover(ghc-network-prof) weakremover(ghc-network-protocol-xmpp) weakremover(ghc-network-protocol-xmpp-devel) weakremover(ghc-network-simple) weakremover(ghc-network-simple-devel) weakremover(ghc-network-transport) weakremover(ghc-network-transport-composed) weakremover(ghc-network-transport-composed-devel) weakremover(ghc-network-transport-devel) weakremover(ghc-network-transport-inmemory) weakremover(ghc-network-transport-inmemory-devel) weakremover(ghc-network-transport-tcp) weakremover(ghc-network-transport-tcp-devel) weakremover(ghc-network-transport-tests) weakremover(ghc-network-transport-tests-devel) weakremover(ghc-network-uri) weakremover(ghc-network-uri-devel) weakremover(ghc-network-uri-flag) weakremover(ghc-network-uri-flag-devel) weakremover(ghc-network-uri-prof) weakremover(ghc-newtype) weakremover(ghc-newtype-devel) weakremover(ghc-newtype-generics) weakremover(ghc-newtype-generics-devel) weakremover(ghc-next-ref) weakremover(ghc-next-ref-devel) weakremover(ghc-nfc) weakremover(ghc-nfc-devel) weakremover(ghc-nicify-lib) weakremover(ghc-nicify-lib-devel) weakremover(ghc-nix-paths) weakremover(ghc-nix-paths-devel) weakremover(ghc-non-empty-sequence) weakremover(ghc-non-empty-sequence-devel) weakremover(ghc-nonce) weakremover(ghc-nonce-devel) weakremover(ghc-nothunks) weakremover(ghc-nothunks-devel) weakremover(ghc-nsis) weakremover(ghc-nsis-devel) weakremover(ghc-numbers) weakremover(ghc-numbers-devel) weakremover(ghc-numeric-extras) weakremover(ghc-numeric-extras-devel) weakremover(ghc-numtype-dk) weakremover(ghc-numtype-dk-devel) weakremover(ghc-oanda-rest-api) weakremover(ghc-oanda-rest-api-devel) weakremover(ghc-objective) weakremover(ghc-objective-devel) weakremover(ghc-oeis) weakremover(ghc-oeis-devel) weakremover(ghc-ofx) weakremover(ghc-ofx-devel) weakremover(ghc-old-locale) weakremover(ghc-old-locale-devel) weakremover(ghc-old-locale-prof) weakremover(ghc-old-time) weakremover(ghc-old-time-devel) weakremover(ghc-old-time-prof) weakremover(ghc-once) weakremover(ghc-once-devel) weakremover(ghc-one-liner) weakremover(ghc-one-liner-devel) weakremover(ghc-oo-prototypes) weakremover(ghc-oo-prototypes-devel) weakremover(ghc-opaleye) weakremover(ghc-opaleye-devel) weakremover(ghc-opaleye-trans) weakremover(ghc-opaleye-trans-devel) weakremover(ghc-open-browser) weakremover(ghc-open-browser-devel) weakremover(ghc-open-witness) weakremover(ghc-open-witness-devel) weakremover(ghc-opensource) weakremover(ghc-opensource-devel) weakremover(ghc-openssl-streams) weakremover(ghc-openssl-streams-devel) weakremover(ghc-operational) weakremover(ghc-operational-class) weakremover(ghc-operational-class-devel) weakremover(ghc-operational-devel) weakremover(ghc-opml-conduit) weakremover(ghc-opml-conduit-devel) weakremover(ghc-optics) weakremover(ghc-optics-core) weakremover(ghc-optics-core-devel) weakremover(ghc-optics-core-prof) weakremover(ghc-optics-devel) weakremover(ghc-optics-extra) weakremover(ghc-optics-extra-devel) weakremover(ghc-optics-th) weakremover(ghc-optics-th-devel) weakremover(ghc-optional-args) weakremover(ghc-optional-args-devel) weakremover(ghc-options) weakremover(ghc-options-devel) weakremover(ghc-optparse-applicative) weakremover(ghc-optparse-applicative-devel) weakremover(ghc-optparse-applicative-prof) weakremover(ghc-optparse-generic) weakremover(ghc-optparse-generic-devel) weakremover(ghc-optparse-helper) weakremover(ghc-optparse-helper-devel) weakremover(ghc-optparse-simple) weakremover(ghc-optparse-simple-devel) weakremover(ghc-optparse-text) weakremover(ghc-optparse-text-devel) weakremover(ghc-osdkeys) weakremover(ghc-osdkeys-devel) weakremover(ghc-package-description-remote) weakremover(ghc-package-description-remote-devel) weakremover(ghc-packdeps) weakremover(ghc-packdeps-devel) weakremover(ghc-pager) weakremover(ghc-pager-devel) weakremover(ghc-pagerduty) weakremover(ghc-pagerduty-devel) weakremover(ghc-pagination) weakremover(ghc-pagination-devel) weakremover(ghc-palette) weakremover(ghc-palette-devel) weakremover(ghc-pandoc) weakremover(ghc-pandoc-citeproc) weakremover(ghc-pandoc-citeproc-devel) weakremover(ghc-pandoc-devel) weakremover(ghc-pandoc-lua-engine) weakremover(ghc-pandoc-lua-engine-devel) weakremover(ghc-pandoc-lua-engine-prof) weakremover(ghc-pandoc-lua-marshal) weakremover(ghc-pandoc-lua-marshal-devel) weakremover(ghc-pandoc-lua-marshal-prof) weakremover(ghc-pandoc-prof) weakremover(ghc-pandoc-server) weakremover(ghc-pandoc-server-devel) weakremover(ghc-pandoc-server-prof) weakremover(ghc-pandoc-types) weakremover(ghc-pandoc-types-devel) weakremover(ghc-pandoc-types-prof) weakremover(ghc-pango) weakremover(ghc-pango-devel) weakremover(ghc-pango-prof) weakremover(ghc-pantry) weakremover(ghc-pantry-devel) weakremover(ghc-pantry-tmp) weakremover(ghc-pantry-tmp-devel) weakremover(ghc-parallel) weakremover(ghc-parallel-devel) weakremover(ghc-parallel-io) weakremover(ghc-parallel-io-devel) weakremover(ghc-parallel-prof) weakremover(ghc-parseargs) weakremover(ghc-parseargs-devel) weakremover(ghc-parsec) weakremover(ghc-parsec-class) weakremover(ghc-parsec-class-devel) weakremover(ghc-parsec-devel) weakremover(ghc-parsec-numbers) weakremover(ghc-parsec-numbers-devel) weakremover(ghc-parsec-numbers-prof) weakremover(ghc-parsec-prof) weakremover(ghc-parser-combinators) weakremover(ghc-parser-combinators-devel) weakremover(ghc-parser-combinators-prof) weakremover(ghc-parsers) weakremover(ghc-parsers-devel) weakremover(ghc-partial-handler) weakremover(ghc-partial-handler-devel) weakremover(ghc-partial-isomorphisms) weakremover(ghc-partial-isomorphisms-devel) weakremover(ghc-partial-order) weakremover(ghc-partial-order-devel) weakremover(ghc-path) weakremover(ghc-path-devel) weakremover(ghc-path-extra) weakremover(ghc-path-extra-devel) weakremover(ghc-path-io) weakremover(ghc-path-io-devel) weakremover(ghc-path-pieces) weakremover(ghc-path-pieces-devel) weakremover(ghc-path-pieces-prof) weakremover(ghc-pathwalk) weakremover(ghc-pathwalk-devel) weakremover(ghc-patience) weakremover(ghc-patience-devel) weakremover(ghc-pattern-arrows) weakremover(ghc-pattern-arrows-devel) weakremover(ghc-pbkdf) weakremover(ghc-pbkdf-devel) weakremover(ghc-pcap) weakremover(ghc-pcap-devel) weakremover(ghc-pcre-heavy) weakremover(ghc-pcre-heavy-devel) weakremover(ghc-pcre-light) weakremover(ghc-pcre-light-devel) weakremover(ghc-pcre-utils) weakremover(ghc-pcre-utils-devel) weakremover(ghc-pdf-toolbox-content) weakremover(ghc-pdf-toolbox-content-devel) weakremover(ghc-pdf-toolbox-core) weakremover(ghc-pdf-toolbox-core-devel) weakremover(ghc-pdf-toolbox-document) weakremover(ghc-pdf-toolbox-document-devel) weakremover(ghc-pdfinfo) weakremover(ghc-pdfinfo-devel) weakremover(ghc-pem) weakremover(ghc-pem-devel) weakremover(ghc-pem-prof) weakremover(ghc-permutation) weakremover(ghc-permutation-devel) weakremover(ghc-persistable-record) weakremover(ghc-persistable-record-devel) weakremover(ghc-persistable-types-HDBC-pg) weakremover(ghc-persistable-types-HDBC-pg-devel) weakremover(ghc-persistent) weakremover(ghc-persistent-devel) weakremover(ghc-persistent-mysql) weakremover(ghc-persistent-mysql-devel) weakremover(ghc-persistent-postgresql) weakremover(ghc-persistent-postgresql-devel) weakremover(ghc-persistent-prof) weakremover(ghc-persistent-refs) weakremover(ghc-persistent-refs-devel) weakremover(ghc-persistent-sqlite) weakremover(ghc-persistent-sqlite-devel) weakremover(ghc-persistent-sqlite-prof) weakremover(ghc-persistent-template) weakremover(ghc-persistent-template-devel) weakremover(ghc-pgp-wordlist) weakremover(ghc-pgp-wordlist-devel) weakremover(ghc-phantom-state) weakremover(ghc-phantom-state-devel) weakremover(ghc-picedit) weakremover(ghc-picedit-devel) weakremover(ghc-picoparsec) weakremover(ghc-picoparsec-devel) weakremover(ghc-pid1) weakremover(ghc-pid1-devel) weakremover(ghc-pinboard) weakremover(ghc-pinboard-devel) weakremover(ghc-pinch) weakremover(ghc-pinch-devel) weakremover(ghc-pipes) weakremover(ghc-pipes-aeson) weakremover(ghc-pipes-aeson-devel) weakremover(ghc-pipes-attoparsec) weakremover(ghc-pipes-attoparsec-devel) weakremover(ghc-pipes-bytestring) weakremover(ghc-pipes-bytestring-devel) weakremover(ghc-pipes-category) weakremover(ghc-pipes-category-devel) weakremover(ghc-pipes-cliff) weakremover(ghc-pipes-cliff-devel) weakremover(ghc-pipes-concurrency) weakremover(ghc-pipes-concurrency-devel) weakremover(ghc-pipes-csv) weakremover(ghc-pipes-csv-devel) weakremover(ghc-pipes-devel) weakremover(ghc-pipes-extras) weakremover(ghc-pipes-extras-devel) weakremover(ghc-pipes-fastx) weakremover(ghc-pipes-fastx-devel) weakremover(ghc-pipes-fluid) weakremover(ghc-pipes-fluid-devel) weakremover(ghc-pipes-group) weakremover(ghc-pipes-group-devel) weakremover(ghc-pipes-http) weakremover(ghc-pipes-http-devel) weakremover(ghc-pipes-misc) weakremover(ghc-pipes-misc-devel) weakremover(ghc-pipes-mongodb) weakremover(ghc-pipes-mongodb-devel) weakremover(ghc-pipes-network) weakremover(ghc-pipes-network-devel) weakremover(ghc-pipes-parse) weakremover(ghc-pipes-parse-devel) weakremover(ghc-pipes-random) weakremover(ghc-pipes-random-devel) weakremover(ghc-pipes-safe) weakremover(ghc-pipes-safe-devel) weakremover(ghc-pipes-text) weakremover(ghc-pipes-text-devel) weakremover(ghc-pipes-wai) weakremover(ghc-pipes-wai-devel) weakremover(ghc-pixelated-avatar-generator) weakremover(ghc-pixelated-avatar-generator-devel) weakremover(ghc-pkcs10) weakremover(ghc-pkcs10-devel) weakremover(ghc-placeholders) weakremover(ghc-placeholders-devel) weakremover(ghc-plan-b) weakremover(ghc-plan-b-devel) weakremover(ghc-plot) weakremover(ghc-plot-devel) weakremover(ghc-plot-gtk) weakremover(ghc-plot-gtk-devel) weakremover(ghc-plot-gtk3) weakremover(ghc-plot-gtk3-devel) weakremover(ghc-pointed) weakremover(ghc-pointed-devel) weakremover(ghc-pointedlist) weakremover(ghc-pointedlist-devel) weakremover(ghc-pointfree) weakremover(ghc-pointfree-devel) weakremover(ghc-pointful) weakremover(ghc-pointful-devel) weakremover(ghc-pointless-fun) weakremover(ghc-pointless-fun-devel) weakremover(ghc-polynomials-bernstein) weakremover(ghc-polynomials-bernstein-devel) weakremover(ghc-polyparse) weakremover(ghc-polyparse-devel) weakremover(ghc-polyparse-prof) weakremover(ghc-posix-paths) weakremover(ghc-posix-paths-devel) weakremover(ghc-posix-realtime) weakremover(ghc-posix-realtime-devel) weakremover(ghc-post-mess-age) weakremover(ghc-post-mess-age-devel) weakremover(ghc-postgresql-binary) weakremover(ghc-postgresql-binary-devel) weakremover(ghc-postgresql-libpq) weakremover(ghc-postgresql-libpq-devel) weakremover(ghc-postgresql-libpq-prof) weakremover(ghc-postgresql-simple) weakremover(ghc-postgresql-simple-devel) weakremover(ghc-postgresql-simple-prof) weakremover(ghc-postgresql-simple-url) weakremover(ghc-postgresql-simple-url-devel) weakremover(ghc-postgresql-transactional) weakremover(ghc-postgresql-transactional-devel) weakremover(ghc-postgresql-typed) weakremover(ghc-postgresql-typed-devel) weakremover(ghc-pqueue) weakremover(ghc-pqueue-devel) weakremover(ghc-pred-set) weakremover(ghc-pred-set-devel) weakremover(ghc-prednote) weakremover(ghc-prednote-devel) weakremover(ghc-prefix-units) weakremover(ghc-prefix-units-devel) weakremover(ghc-prelude-extras) weakremover(ghc-prelude-extras-devel) weakremover(ghc-prelude-safeenum) weakremover(ghc-prelude-safeenum-devel) weakremover(ghc-preprocessor-tools) weakremover(ghc-preprocessor-tools-devel) weakremover(ghc-presburger) weakremover(ghc-presburger-devel) weakremover(ghc-pretty) weakremover(ghc-pretty-class) weakremover(ghc-pretty-class-devel) weakremover(ghc-pretty-devel) weakremover(ghc-pretty-hex) weakremover(ghc-pretty-hex-devel) weakremover(ghc-pretty-hex-prof) weakremover(ghc-pretty-prof) weakremover(ghc-pretty-show) weakremover(ghc-pretty-show-devel) weakremover(ghc-pretty-show-prof) weakremover(ghc-pretty-simple) weakremover(ghc-pretty-simple-devel) weakremover(ghc-pretty-simple-prof) weakremover(ghc-pretty-types) weakremover(ghc-pretty-types-devel) weakremover(ghc-prettyclass) weakremover(ghc-prettyclass-devel) weakremover(ghc-prettyprinter) weakremover(ghc-prettyprinter-ansi-terminal) weakremover(ghc-prettyprinter-ansi-terminal-devel) weakremover(ghc-prettyprinter-ansi-terminal-prof) weakremover(ghc-prettyprinter-devel) weakremover(ghc-prettyprinter-prof) weakremover(ghc-primes) weakremover(ghc-primes-devel) weakremover(ghc-primes-prof) weakremover(ghc-primitive) weakremover(ghc-primitive-devel) weakremover(ghc-primitive-prof) weakremover(ghc-printcess) weakremover(ghc-printcess-devel) weakremover(ghc-process) weakremover(ghc-process-devel) weakremover(ghc-process-extras) weakremover(ghc-process-extras-devel) weakremover(ghc-process-prof) weakremover(ghc-product-profunctors) weakremover(ghc-product-profunctors-devel) weakremover(ghc-prof) weakremover(ghc-profunctor-extras) weakremover(ghc-profunctor-extras-devel) weakremover(ghc-profunctors) weakremover(ghc-profunctors-devel) weakremover(ghc-profunctors-prof) weakremover(ghc-project-template) weakremover(ghc-project-template-devel) weakremover(ghc-projectroot) weakremover(ghc-projectroot-devel) weakremover(ghc-prometheus) weakremover(ghc-prometheus-client) weakremover(ghc-prometheus-client-devel) weakremover(ghc-prometheus-devel) weakremover(ghc-prometheus-metrics-ghc) weakremover(ghc-prometheus-metrics-ghc-devel) weakremover(ghc-prompt) weakremover(ghc-prompt-devel) weakremover(ghc-protobuf) weakremover(ghc-protobuf-devel) weakremover(ghc-protocol-buffers) weakremover(ghc-protocol-buffers-descriptor) weakremover(ghc-protocol-buffers-descriptor-devel) weakremover(ghc-protocol-buffers-devel) weakremover(ghc-protolude) weakremover(ghc-protolude-devel) weakremover(ghc-proxied) weakremover(ghc-proxied-devel) weakremover(ghc-psql-helpers) weakremover(ghc-psql-helpers-devel) weakremover(ghc-psqueues) weakremover(ghc-psqueues-devel) weakremover(ghc-psqueues-prof) weakremover(ghc-publicsuffix) weakremover(ghc-publicsuffix-devel) weakremover(ghc-publicsuffixlist) weakremover(ghc-publicsuffixlist-devel) weakremover(ghc-punycode) weakremover(ghc-punycode-devel) weakremover(ghc-pure-cdb) weakremover(ghc-pure-cdb-devel) weakremover(ghc-pure-io) weakremover(ghc-pure-io-devel) weakremover(ghc-pureMD5) weakremover(ghc-pureMD5-devel) weakremover(ghc-purescript-bridge) weakremover(ghc-purescript-bridge-devel) weakremover(ghc-pusher-http-haskell) weakremover(ghc-pusher-http-haskell-devel) weakremover(ghc-pwstore-fast) weakremover(ghc-pwstore-fast-devel) weakremover(ghc-pwstore-purehaskell) weakremover(ghc-pwstore-purehaskell-devel) weakremover(ghc-quickbench) weakremover(ghc-quickbench-devel) weakremover(ghc-quickcheck-arbitrary-adt) weakremover(ghc-quickcheck-arbitrary-adt-devel) weakremover(ghc-quickcheck-assertions) weakremover(ghc-quickcheck-assertions-devel) weakremover(ghc-quickcheck-instances) weakremover(ghc-quickcheck-instances-devel) weakremover(ghc-quickcheck-io) weakremover(ghc-quickcheck-io-devel) weakremover(ghc-quickcheck-properties) weakremover(ghc-quickcheck-properties-devel) weakremover(ghc-quickcheck-simple) weakremover(ghc-quickcheck-simple-devel) weakremover(ghc-quickcheck-special) weakremover(ghc-quickcheck-special-devel) weakremover(ghc-quickcheck-text) weakremover(ghc-quickcheck-text-devel) weakremover(ghc-quickcheck-unicode) weakremover(ghc-quickcheck-unicode-devel) weakremover(ghc-quiet) weakremover(ghc-quiet-devel) weakremover(ghc-rainbow) weakremover(ghc-rainbow-devel) weakremover(ghc-rainbox) weakremover(ghc-rainbox-devel) weakremover(ghc-ramus) weakremover(ghc-ramus-devel) weakremover(ghc-random) weakremover(ghc-random-devel) weakremover(ghc-random-fu) weakremover(ghc-random-fu-devel) weakremover(ghc-random-prof) weakremover(ghc-random-shuffle) weakremover(ghc-random-shuffle-devel) weakremover(ghc-random-source) weakremover(ghc-random-source-devel) weakremover(ghc-random-tree) weakremover(ghc-random-tree-devel) weakremover(ghc-range) weakremover(ghc-range-devel) weakremover(ghc-range-set-list) weakremover(ghc-range-set-list-devel) weakremover(ghc-rank1dynamic) weakremover(ghc-rank1dynamic-devel) weakremover(ghc-rasterific-svg) weakremover(ghc-rasterific-svg-devel) weakremover(ghc-ratel) weakremover(ghc-ratel-devel) weakremover(ghc-ratel-wai) weakremover(ghc-ratel-wai-devel) weakremover(ghc-rattletrap) weakremover(ghc-rattletrap-devel) weakremover(ghc-raw-strings-qq) weakremover(ghc-raw-strings-qq-devel) weakremover(ghc-rawfilepath) weakremover(ghc-rawfilepath-devel) weakremover(ghc-rawstring-qm) weakremover(ghc-rawstring-qm-devel) weakremover(ghc-rdf) weakremover(ghc-rdf-devel) weakremover(ghc-read-editor) weakremover(ghc-read-editor-devel) weakremover(ghc-read-env-var) weakremover(ghc-read-env-var-devel) weakremover(ghc-readable) weakremover(ghc-readable-devel) weakremover(ghc-readline) weakremover(ghc-readline-devel) weakremover(ghc-rebase) weakremover(ghc-rebase-devel) weakremover(ghc-recursion-schemes) weakremover(ghc-recursion-schemes-devel) weakremover(ghc-recv) weakremover(ghc-recv-devel) weakremover(ghc-recv-prof) weakremover(ghc-redis-io) weakremover(ghc-redis-io-devel) weakremover(ghc-redis-resp) weakremover(ghc-redis-resp-devel) weakremover(ghc-reducers) weakremover(ghc-reducers-devel) weakremover(ghc-ref-fd) weakremover(ghc-ref-fd-devel) weakremover(ghc-refact) weakremover(ghc-refact-devel) weakremover(ghc-refact-prof) weakremover(ghc-references) weakremover(ghc-references-devel) weakremover(ghc-reflection) weakremover(ghc-reflection-devel) weakremover(ghc-reflection-prof) weakremover(ghc-reform) weakremover(ghc-reform-blaze) weakremover(ghc-reform-blaze-devel) weakremover(ghc-reform-devel) weakremover(ghc-reform-hamlet) weakremover(ghc-reform-hamlet-devel) weakremover(ghc-reform-happstack) weakremover(ghc-reform-happstack-devel) weakremover(ghc-reform-hsp) weakremover(ghc-reform-hsp-devel) weakremover(ghc-regex-applicative) weakremover(ghc-regex-applicative-devel) weakremover(ghc-regex-applicative-text) weakremover(ghc-regex-applicative-text-devel) weakremover(ghc-regex-base) weakremover(ghc-regex-base-devel) weakremover(ghc-regex-base-prof) weakremover(ghc-regex-compat) weakremover(ghc-regex-compat-devel) weakremover(ghc-regex-compat-prof) weakremover(ghc-regex-compat-tdfa) weakremover(ghc-regex-compat-tdfa-devel) weakremover(ghc-regex-pcre) weakremover(ghc-regex-pcre-builtin) weakremover(ghc-regex-pcre-builtin-devel) weakremover(ghc-regex-pcre-devel) weakremover(ghc-regex-posix) weakremover(ghc-regex-posix-devel) weakremover(ghc-regex-posix-prof) weakremover(ghc-regex-tdfa) weakremover(ghc-regex-tdfa-devel) weakremover(ghc-regex-tdfa-prof) weakremover(ghc-regex-tdfa-rc) weakremover(ghc-regex-tdfa-rc-devel) weakremover(ghc-regex-tdfa-text) weakremover(ghc-regex-tdfa-text-devel) weakremover(ghc-reinterpret-cast) weakremover(ghc-reinterpret-cast-devel) weakremover(ghc-relational-query) weakremover(ghc-relational-query-HDBC) weakremover(ghc-relational-query-HDBC-devel) weakremover(ghc-relational-query-devel) weakremover(ghc-relational-record) weakremover(ghc-relational-record-devel) weakremover(ghc-relational-schemas) weakremover(ghc-relational-schemas-devel) weakremover(ghc-renderable) weakremover(ghc-renderable-devel) weakremover(ghc-repa) weakremover(ghc-repa-algorithms) weakremover(ghc-repa-algorithms-devel) weakremover(ghc-repa-devel) weakremover(ghc-repa-io) weakremover(ghc-repa-io-devel) weakremover(ghc-repline) weakremover(ghc-repline-devel) weakremover(ghc-req) weakremover(ghc-req-conduit) weakremover(ghc-req-conduit-devel) weakremover(ghc-req-devel) weakremover(ghc-reroute) weakremover(ghc-reroute-devel) weakremover(ghc-resolv) weakremover(ghc-resolv-devel) weakremover(ghc-resolv-prof) weakremover(ghc-resource-pool) weakremover(ghc-resource-pool-devel) weakremover(ghc-resource-pool-prof) weakremover(ghc-resourcet) weakremover(ghc-resourcet-devel) weakremover(ghc-resourcet-prof) weakremover(ghc-rest-client) weakremover(ghc-rest-client-devel) weakremover(ghc-rest-core) weakremover(ghc-rest-core-devel) weakremover(ghc-rest-gen) weakremover(ghc-rest-gen-devel) weakremover(ghc-rest-happstack) weakremover(ghc-rest-happstack-devel) weakremover(ghc-rest-snap) weakremover(ghc-rest-snap-devel) weakremover(ghc-rest-stringmap) weakremover(ghc-rest-stringmap-devel) weakremover(ghc-rest-types) weakremover(ghc-rest-types-devel) weakremover(ghc-rest-wai) weakremover(ghc-rest-wai-devel) weakremover(ghc-result) weakremover(ghc-result-devel) weakremover(ghc-rethinkdb) weakremover(ghc-rethinkdb-client-driver) weakremover(ghc-rethinkdb-client-driver-devel) weakremover(ghc-rethinkdb-devel) weakremover(ghc-retry) weakremover(ghc-retry-devel) weakremover(ghc-rev-state) weakremover(ghc-rev-state-devel) weakremover(ghc-rfc5051) weakremover(ghc-rfc5051-devel) weakremover(ghc-riak) weakremover(ghc-riak-devel) weakremover(ghc-riak-protobuf) weakremover(ghc-riak-protobuf-devel) weakremover(ghc-rio) weakremover(ghc-rio-devel) weakremover(ghc-rio-orphans) weakremover(ghc-rio-orphans-devel) weakremover(ghc-rio-prettyprint) weakremover(ghc-rio-prettyprint-devel) weakremover(ghc-rng-utils) weakremover(ghc-rng-utils-devel) weakremover(ghc-rose-trees) weakremover(ghc-rose-trees-devel) weakremover(ghc-rosezipper) weakremover(ghc-rosezipper-devel) weakremover(ghc-rot13) weakremover(ghc-rot13-devel) weakremover(ghc-rss-conduit) weakremover(ghc-rss-conduit-devel) weakremover(ghc-runmemo) weakremover(ghc-runmemo-devel) weakremover(ghc-rvar) weakremover(ghc-rvar-devel) weakremover(ghc-s3-signer) weakremover(ghc-s3-signer-devel) weakremover(ghc-safe) weakremover(ghc-safe-devel) weakremover(ghc-safe-exceptions) weakremover(ghc-safe-exceptions-checked) weakremover(ghc-safe-exceptions-checked-devel) weakremover(ghc-safe-exceptions-devel) weakremover(ghc-safe-exceptions-prof) weakremover(ghc-safe-prof) weakremover(ghc-safecopy) weakremover(ghc-safecopy-devel) weakremover(ghc-sampling) weakremover(ghc-sampling-devel) weakremover(ghc-sandi) weakremover(ghc-sandi-devel) weakremover(ghc-sandi-prof) weakremover(ghc-sandwich) weakremover(ghc-sandwich-devel) weakremover(ghc-say) weakremover(ghc-say-devel) weakremover(ghc-sbv) weakremover(ghc-sbv-devel) weakremover(ghc-scalpel) weakremover(ghc-scalpel-core) weakremover(ghc-scalpel-core-devel) weakremover(ghc-scalpel-devel) weakremover(ghc-scanner) weakremover(ghc-scanner-devel) weakremover(ghc-scientific) weakremover(ghc-scientific-devel) weakremover(ghc-scientific-prof) weakremover(ghc-scotty) weakremover(ghc-scotty-devel) weakremover(ghc-sdl2) weakremover(ghc-sdl2-devel) weakremover(ghc-sdl2-gfx) weakremover(ghc-sdl2-gfx-devel) weakremover(ghc-sdl2-image) weakremover(ghc-sdl2-image-devel) weakremover(ghc-secp256k1) weakremover(ghc-secp256k1-devel) weakremover(ghc-securemem) weakremover(ghc-securemem-devel) weakremover(ghc-securemem-prof) weakremover(ghc-semialign) weakremover(ghc-semialign-devel) weakremover(ghc-semialign-prof) weakremover(ghc-semigroupoid-extras) weakremover(ghc-semigroupoid-extras-devel) weakremover(ghc-semigroupoids) weakremover(ghc-semigroupoids-devel) weakremover(ghc-semigroupoids-prof) weakremover(ghc-semigroups) weakremover(ghc-semigroups-devel) weakremover(ghc-semigroups-prof) weakremover(ghc-semiring-simple) weakremover(ghc-semiring-simple-devel) weakremover(ghc-semver) weakremover(ghc-semver-devel) weakremover(ghc-semver-prof) weakremover(ghc-sendfile) weakremover(ghc-sendfile-devel) weakremover(ghc-seqloc) weakremover(ghc-seqloc-devel) weakremover(ghc-serf) weakremover(ghc-serf-devel) weakremover(ghc-serialise) weakremover(ghc-serialise-devel) weakremover(ghc-servant) weakremover(ghc-servant-JuicyPixels) weakremover(ghc-servant-JuicyPixels-devel) weakremover(ghc-servant-auth-cookie) weakremover(ghc-servant-auth-cookie-devel) weakremover(ghc-servant-blaze) weakremover(ghc-servant-blaze-devel) weakremover(ghc-servant-cassava) weakremover(ghc-servant-cassava-devel) weakremover(ghc-servant-client) weakremover(ghc-servant-client-core) weakremover(ghc-servant-client-core-devel) weakremover(ghc-servant-client-devel) weakremover(ghc-servant-devel) weakremover(ghc-servant-docs) weakremover(ghc-servant-docs-devel) weakremover(ghc-servant-elm) weakremover(ghc-servant-elm-devel) weakremover(ghc-servant-foreign) weakremover(ghc-servant-foreign-devel) weakremover(ghc-servant-lucid) weakremover(ghc-servant-lucid-devel) weakremover(ghc-servant-mock) weakremover(ghc-servant-mock-devel) weakremover(ghc-servant-prof) weakremover(ghc-servant-purescript) weakremover(ghc-servant-purescript-devel) weakremover(ghc-servant-server) weakremover(ghc-servant-server-devel) weakremover(ghc-servant-server-prof) weakremover(ghc-servant-subscriber) weakremover(ghc-servant-subscriber-devel) weakremover(ghc-servant-swagger) weakremover(ghc-servant-swagger-devel) weakremover(ghc-servant-swagger-ui) weakremover(ghc-servant-swagger-ui-devel) weakremover(ghc-servant-yaml) weakremover(ghc-servant-yaml-devel) weakremover(ghc-serversession) weakremover(ghc-serversession-backend-acid-state) weakremover(ghc-serversession-backend-acid-state-devel) weakremover(ghc-serversession-devel) weakremover(ghc-serversession-frontend-wai) weakremover(ghc-serversession-frontend-wai-devel) weakremover(ghc-serversession-frontend-yesod) weakremover(ghc-serversession-frontend-yesod-devel) weakremover(ghc-set-monad) weakremover(ghc-set-monad-devel) weakremover(ghc-setenv) weakremover(ghc-setenv-devel) weakremover(ghc-setenv-prof) weakremover(ghc-setlocale) weakremover(ghc-setlocale-devel) weakremover(ghc-setlocale-prof) weakremover(ghc-sets) weakremover(ghc-sets-devel) weakremover(ghc-shake) weakremover(ghc-shake-devel) weakremover(ghc-shake-language-c) weakremover(ghc-shake-language-c-devel) weakremover(ghc-shakespeare) weakremover(ghc-shakespeare-devel) weakremover(ghc-shakespeare-prof) weakremover(ghc-shell-conduit) weakremover(ghc-shell-conduit-devel) weakremover(ghc-shelly) weakremover(ghc-shelly-devel) weakremover(ghc-shortcut-links) weakremover(ghc-shortcut-links-devel) weakremover(ghc-should-not-typecheck) weakremover(ghc-should-not-typecheck-devel) weakremover(ghc-show-combinators) weakremover(ghc-show-combinators-devel) weakremover(ghc-show-prettyprint) weakremover(ghc-show-prettyprint-devel) weakremover(ghc-show-type) weakremover(ghc-show-type-devel) weakremover(ghc-signal) weakremover(ghc-signal-devel) weakremover(ghc-silently) weakremover(ghc-silently-devel) weakremover(ghc-silently-prof) weakremover(ghc-simple) weakremover(ghc-simple-devel) weakremover(ghc-simple-log) weakremover(ghc-simple-log-devel) weakremover(ghc-simple-reflect) weakremover(ghc-simple-reflect-devel) weakremover(ghc-simple-sendfile) weakremover(ghc-simple-sendfile-devel) weakremover(ghc-simple-sendfile-prof) weakremover(ghc-simple-session) weakremover(ghc-simple-session-devel) weakremover(ghc-simple-smt) weakremover(ghc-simple-smt-devel) weakremover(ghc-simple-templates) weakremover(ghc-simple-templates-devel) weakremover(ghc-singleton-bool) weakremover(ghc-singleton-bool-devel) weakremover(ghc-singleton-bool-prof) weakremover(ghc-singletons) weakremover(ghc-singletons-devel) weakremover(ghc-siphash) weakremover(ghc-siphash-devel) weakremover(ghc-skein) weakremover(ghc-skein-devel) weakremover(ghc-skein-prof) weakremover(ghc-skylighting) weakremover(ghc-skylighting-core) weakremover(ghc-skylighting-core-devel) weakremover(ghc-skylighting-core-prof) weakremover(ghc-skylighting-devel) weakremover(ghc-skylighting-format-ansi) weakremover(ghc-skylighting-format-ansi-devel) weakremover(ghc-skylighting-format-ansi-prof) weakremover(ghc-skylighting-format-blaze-html) weakremover(ghc-skylighting-format-blaze-html-devel) weakremover(ghc-skylighting-format-blaze-html-prof) weakremover(ghc-skylighting-format-context) weakremover(ghc-skylighting-format-context-devel) weakremover(ghc-skylighting-format-context-prof) weakremover(ghc-skylighting-format-latex) weakremover(ghc-skylighting-format-latex-devel) weakremover(ghc-skylighting-format-latex-prof) weakremover(ghc-skylighting-prof) weakremover(ghc-slave-thread) weakremover(ghc-slave-thread-devel) weakremover(ghc-slug) weakremover(ghc-slug-devel) weakremover(ghc-smallcheck) weakremover(ghc-smallcheck-devel) weakremover(ghc-smoothie) weakremover(ghc-smoothie-devel) weakremover(ghc-smtLib) weakremover(ghc-smtLib-devel) weakremover(ghc-smtp-mail) weakremover(ghc-smtp-mail-devel) weakremover(ghc-snap-core) weakremover(ghc-snap-core-devel) weakremover(ghc-snap-server) weakremover(ghc-snap-server-devel) weakremover(ghc-snowflake) weakremover(ghc-snowflake-devel) weakremover(ghc-soap) weakremover(ghc-soap-devel) weakremover(ghc-soap-openssl) weakremover(ghc-soap-openssl-devel) weakremover(ghc-soap-tls) weakremover(ghc-soap-tls-devel) weakremover(ghc-socket) weakremover(ghc-socket-activation) weakremover(ghc-socket-activation-devel) weakremover(ghc-socket-devel) weakremover(ghc-socks) weakremover(ghc-socks-devel) weakremover(ghc-socks-prof) weakremover(ghc-some) weakremover(ghc-some-devel) weakremover(ghc-some-prof) weakremover(ghc-sop-core) weakremover(ghc-sop-core-devel) weakremover(ghc-sop-core-prof) weakremover(ghc-sorted-list) weakremover(ghc-sorted-list-devel) weakremover(ghc-sourcemap) weakremover(ghc-sourcemap-devel) weakremover(ghc-sparse-linear-algebra) weakremover(ghc-sparse-linear-algebra-devel) weakremover(ghc-spdx) weakremover(ghc-spdx-devel) weakremover(ghc-spdx-prof) weakremover(ghc-speculation) weakremover(ghc-speculation-devel) weakremover(ghc-speedy-slice) weakremover(ghc-speedy-slice-devel) weakremover(ghc-sphinx) weakremover(ghc-sphinx-devel) weakremover(ghc-splice) weakremover(ghc-splice-devel) weakremover(ghc-split) weakremover(ghc-split-devel) weakremover(ghc-split-prof) weakremover(ghc-splitmix) weakremover(ghc-splitmix-devel) weakremover(ghc-splitmix-prof) weakremover(ghc-spool) weakremover(ghc-spool-devel) weakremover(ghc-spoon) weakremover(ghc-spoon-devel) weakremover(ghc-sql-words) weakremover(ghc-sql-words-devel) weakremover(ghc-sqlite-simple) weakremover(ghc-sqlite-simple-devel) weakremover(ghc-sqlite-simple-errors) weakremover(ghc-sqlite-simple-errors-devel) weakremover(ghc-srcloc) weakremover(ghc-srcloc-devel) weakremover(ghc-stache) weakremover(ghc-stache-devel) weakremover(ghc-stack) weakremover(ghc-stack-devel) weakremover(ghc-stack-type) weakremover(ghc-stack-type-devel) weakremover(ghc-state-plus) weakremover(ghc-state-plus-devel) weakremover(ghc-stateWriter) weakremover(ghc-stateWriter-devel) weakremover(ghc-stateref) weakremover(ghc-stateref-devel) weakremover(ghc-statestack) weakremover(ghc-statestack-devel) weakremover(ghc-statistics) weakremover(ghc-statistics-devel) weakremover(ghc-statistics-linreg) weakremover(ghc-statistics-linreg-devel) weakremover(ghc-statistics-prof) weakremover(ghc-stb-image-redux) weakremover(ghc-stb-image-redux-devel) weakremover(ghc-stm) weakremover(ghc-stm-chans) weakremover(ghc-stm-chans-devel) weakremover(ghc-stm-chans-prof) weakremover(ghc-stm-conduit) weakremover(ghc-stm-conduit-devel) weakremover(ghc-stm-containers) weakremover(ghc-stm-containers-devel) weakremover(ghc-stm-delay) weakremover(ghc-stm-delay-devel) weakremover(ghc-stm-devel) weakremover(ghc-stm-extras) weakremover(ghc-stm-extras-devel) weakremover(ghc-stm-prof) weakremover(ghc-stm-stats) weakremover(ghc-stm-stats-devel) weakremover(ghc-stm-supply) weakremover(ghc-stm-supply-devel) weakremover(ghc-stopwatch) weakremover(ghc-stopwatch-devel) weakremover(ghc-storable-complex) weakremover(ghc-storable-complex-devel) weakremover(ghc-storable-endian) weakremover(ghc-storable-endian-devel) weakremover(ghc-storable-record) weakremover(ghc-storable-record-devel) weakremover(ghc-store) weakremover(ghc-store-core) weakremover(ghc-store-core-devel) weakremover(ghc-store-devel) weakremover(ghc-stratosphere) weakremover(ghc-stratosphere-devel) weakremover(ghc-streaming) weakremover(ghc-streaming-binary) weakremover(ghc-streaming-binary-devel) weakremover(ghc-streaming-bytestring) weakremover(ghc-streaming-bytestring-devel) weakremover(ghc-streaming-commons) weakremover(ghc-streaming-commons-devel) weakremover(ghc-streaming-commons-prof) weakremover(ghc-streaming-devel) weakremover(ghc-streaming-wai) weakremover(ghc-streaming-wai-devel) weakremover(ghc-streamproc) weakremover(ghc-streamproc-devel) weakremover(ghc-streams) weakremover(ghc-streams-devel) weakremover(ghc-strict) weakremover(ghc-strict-base-types) weakremover(ghc-strict-base-types-devel) weakremover(ghc-strict-concurrency) weakremover(ghc-strict-concurrency-devel) weakremover(ghc-strict-devel) weakremover(ghc-strict-prof) weakremover(ghc-string-class) weakremover(ghc-string-class-devel) weakremover(ghc-string-combinators) weakremover(ghc-string-combinators-devel) weakremover(ghc-string-conv) weakremover(ghc-string-conv-devel) weakremover(ghc-string-conversions) weakremover(ghc-string-conversions-devel) weakremover(ghc-string-conversions-prof) weakremover(ghc-string-interpolate) weakremover(ghc-string-interpolate-devel) weakremover(ghc-string-qq) weakremover(ghc-string-qq-devel) weakremover(ghc-stringable) weakremover(ghc-stringable-devel) weakremover(ghc-stringbuilder) weakremover(ghc-stringbuilder-devel) weakremover(ghc-stringprep) weakremover(ghc-stringprep-devel) weakremover(ghc-stringsearch) weakremover(ghc-stringsearch-devel) weakremover(ghc-strive) weakremover(ghc-strive-devel) weakremover(ghc-stylish-haskell) weakremover(ghc-stylish-haskell-devel) weakremover(ghc-success) weakremover(ghc-success-devel) weakremover(ghc-sundown) weakremover(ghc-sundown-devel) weakremover(ghc-superbuffer) weakremover(ghc-superbuffer-devel) weakremover(ghc-svg-builder) weakremover(ghc-svg-builder-devel) weakremover(ghc-svg-tree) weakremover(ghc-svg-tree-devel) weakremover(ghc-swagger) weakremover(ghc-swagger-devel) weakremover(ghc-swagger2) weakremover(ghc-swagger2-devel) weakremover(ghc-syb) weakremover(ghc-syb-devel) weakremover(ghc-syb-prof) weakremover(ghc-syb-with-class) weakremover(ghc-syb-with-class-devel) weakremover(ghc-symbol) weakremover(ghc-symbol-devel) weakremover(ghc-system-argv0) weakremover(ghc-system-argv0-devel) weakremover(ghc-system-fileio) weakremover(ghc-system-fileio-devel) weakremover(ghc-system-filepath) weakremover(ghc-system-filepath-devel) weakremover(ghc-system-posix-redirect) weakremover(ghc-system-posix-redirect-devel) weakremover(ghc-systemd) weakremover(ghc-systemd-devel) weakremover(ghc-syz) weakremover(ghc-syz-devel) weakremover(ghc-tabular) weakremover(ghc-tabular-devel) weakremover(ghc-tabular-prof) weakremover(ghc-tagged) weakremover(ghc-tagged-binary) weakremover(ghc-tagged-binary-devel) weakremover(ghc-tagged-devel) weakremover(ghc-tagged-identity) weakremover(ghc-tagged-identity-devel) weakremover(ghc-tagged-prof) weakremover(ghc-taggy) weakremover(ghc-taggy-devel) weakremover(ghc-taggy-lens) weakremover(ghc-taggy-lens-devel) weakremover(ghc-tagshare) weakremover(ghc-tagshare-devel) weakremover(ghc-tagsoup) weakremover(ghc-tagsoup-devel) weakremover(ghc-tagsoup-prof) weakremover(ghc-tagstream-conduit) weakremover(ghc-tagstream-conduit-devel) weakremover(ghc-tar) weakremover(ghc-tar-conduit) weakremover(ghc-tar-conduit-devel) weakremover(ghc-tar-devel) weakremover(ghc-tar-prof) weakremover(ghc-tardis) weakremover(ghc-tardis-devel) weakremover(ghc-tasty) weakremover(ghc-tasty-ant-xml) weakremover(ghc-tasty-ant-xml-devel) weakremover(ghc-tasty-dejafu) weakremover(ghc-tasty-dejafu-devel) weakremover(ghc-tasty-devel) weakremover(ghc-tasty-discover) weakremover(ghc-tasty-discover-devel) weakremover(ghc-tasty-expected-failure) weakremover(ghc-tasty-expected-failure-devel) weakremover(ghc-tasty-fail-fast) weakremover(ghc-tasty-fail-fast-devel) weakremover(ghc-tasty-golden) weakremover(ghc-tasty-golden-devel) weakremover(ghc-tasty-hedgehog) weakremover(ghc-tasty-hedgehog-devel) weakremover(ghc-tasty-hspec) weakremover(ghc-tasty-hspec-devel) weakremover(ghc-tasty-html) weakremover(ghc-tasty-html-devel) weakremover(ghc-tasty-hunit) weakremover(ghc-tasty-hunit-devel) weakremover(ghc-tasty-hunit-prof) weakremover(ghc-tasty-kat) weakremover(ghc-tasty-kat-devel) weakremover(ghc-tasty-prof) weakremover(ghc-tasty-program) weakremover(ghc-tasty-program-devel) weakremover(ghc-tasty-quickcheck) weakremover(ghc-tasty-quickcheck-devel) weakremover(ghc-tasty-quickcheck-prof) weakremover(ghc-tasty-rerun) weakremover(ghc-tasty-rerun-devel) weakremover(ghc-tasty-rerun-prof) weakremover(ghc-tasty-silver) weakremover(ghc-tasty-silver-devel) weakremover(ghc-tasty-smallcheck) weakremover(ghc-tasty-smallcheck-devel) weakremover(ghc-tasty-tap) weakremover(ghc-tasty-tap-devel) weakremover(ghc-tasty-th) weakremover(ghc-tasty-th-devel) weakremover(ghc-tce-conf) weakremover(ghc-tce-conf-devel) weakremover(ghc-tcp-streams) weakremover(ghc-tcp-streams-devel) weakremover(ghc-tcp-streams-openssl) weakremover(ghc-tcp-streams-openssl-devel) weakremover(ghc-tdigest) weakremover(ghc-tdigest-devel) weakremover(ghc-template) weakremover(ghc-template-devel) weakremover(ghc-template-haskell) weakremover(ghc-template-haskell-devel) weakremover(ghc-template-haskell-prof) weakremover(ghc-temporary) weakremover(ghc-temporary-devel) weakremover(ghc-temporary-prof) weakremover(ghc-temporary-rc) weakremover(ghc-temporary-rc-devel) weakremover(ghc-terminal-progress-bar) weakremover(ghc-terminal-progress-bar-devel) weakremover(ghc-terminal-size) weakremover(ghc-terminal-size-devel) weakremover(ghc-terminal-size-prof) weakremover(ghc-terminfo) weakremover(ghc-terminfo-devel) weakremover(ghc-terminfo-prof) weakremover(ghc-test-fixture) weakremover(ghc-test-fixture-devel) weakremover(ghc-test-framework) weakremover(ghc-test-framework-devel) weakremover(ghc-test-framework-hunit) weakremover(ghc-test-framework-hunit-devel) weakremover(ghc-test-framework-quickcheck2) weakremover(ghc-test-framework-quickcheck2-devel) weakremover(ghc-test-framework-smallcheck) weakremover(ghc-test-framework-smallcheck-devel) weakremover(ghc-test-framework-th) weakremover(ghc-test-framework-th-devel) weakremover(ghc-testing-feat) weakremover(ghc-testing-feat-devel) weakremover(ghc-texmath) weakremover(ghc-texmath-devel) weakremover(ghc-texmath-prof) weakremover(ghc-text) weakremover(ghc-text-all) weakremover(ghc-text-all-devel) weakremover(ghc-text-binary) weakremover(ghc-text-binary-devel) weakremover(ghc-text-conversions) weakremover(ghc-text-conversions-devel) weakremover(ghc-text-conversions-prof) weakremover(ghc-text-devel) weakremover(ghc-text-format) weakremover(ghc-text-format-devel) weakremover(ghc-text-generic-pretty) weakremover(ghc-text-generic-pretty-devel) weakremover(ghc-text-icu) weakremover(ghc-text-icu-devel) weakremover(ghc-text-latin1) weakremover(ghc-text-latin1-devel) weakremover(ghc-text-ldap) weakremover(ghc-text-ldap-devel) weakremover(ghc-text-manipulate) weakremover(ghc-text-manipulate-devel) weakremover(ghc-text-metrics) weakremover(ghc-text-metrics-devel) weakremover(ghc-text-postgresql) weakremover(ghc-text-postgresql-devel) weakremover(ghc-text-printer) weakremover(ghc-text-printer-devel) weakremover(ghc-text-prof) weakremover(ghc-text-region) weakremover(ghc-text-region-devel) weakremover(ghc-text-short) weakremover(ghc-text-short-devel) weakremover(ghc-text-short-prof) weakremover(ghc-text-show) weakremover(ghc-text-show-devel) weakremover(ghc-text-show-instances) weakremover(ghc-text-show-instances-devel) weakremover(ghc-text-zipper) weakremover(ghc-text-zipper-devel) weakremover(ghc-text-zipper-prof) weakremover(ghc-textlocal) weakremover(ghc-textlocal-devel) weakremover(ghc-tf-random) weakremover(ghc-tf-random-devel) weakremover(ghc-th-abstraction) weakremover(ghc-th-abstraction-devel) weakremover(ghc-th-abstraction-prof) weakremover(ghc-th-compat) weakremover(ghc-th-compat-devel) weakremover(ghc-th-compat-prof) weakremover(ghc-th-data-compat) weakremover(ghc-th-data-compat-devel) weakremover(ghc-th-desugar) weakremover(ghc-th-desugar-devel) weakremover(ghc-th-expand-syns) weakremover(ghc-th-expand-syns-devel) weakremover(ghc-th-extras) weakremover(ghc-th-extras-devel) weakremover(ghc-th-lift) weakremover(ghc-th-lift-devel) weakremover(ghc-th-lift-instances) weakremover(ghc-th-lift-instances-devel) weakremover(ghc-th-lift-instances-prof) weakremover(ghc-th-lift-prof) weakremover(ghc-th-orphans) weakremover(ghc-th-orphans-devel) weakremover(ghc-th-reify-compat) weakremover(ghc-th-reify-compat-devel) weakremover(ghc-th-reify-many) weakremover(ghc-th-reify-many-devel) weakremover(ghc-th-to-exp) weakremover(ghc-th-to-exp-devel) weakremover(ghc-th-utilities) weakremover(ghc-th-utilities-devel) weakremover(ghc-these) weakremover(ghc-these-devel) weakremover(ghc-these-prof) weakremover(ghc-thread-local-storage) weakremover(ghc-thread-local-storage-devel) weakremover(ghc-threads) weakremover(ghc-threads-devel) weakremover(ghc-threepenny-gui) weakremover(ghc-threepenny-gui-devel) weakremover(ghc-through-text) weakremover(ghc-through-text-devel) weakremover(ghc-thumbnail-plus) weakremover(ghc-thumbnail-plus-devel) weakremover(ghc-thyme) weakremover(ghc-thyme-devel) weakremover(ghc-tidal) weakremover(ghc-tidal-devel) weakremover(ghc-time) weakremover(ghc-time-compat) weakremover(ghc-time-compat-devel) weakremover(ghc-time-compat-prof) weakremover(ghc-time-devel) weakremover(ghc-time-lens) weakremover(ghc-time-lens-devel) weakremover(ghc-time-locale-compat) weakremover(ghc-time-locale-compat-devel) weakremover(ghc-time-locale-compat-prof) weakremover(ghc-time-manager) weakremover(ghc-time-manager-devel) weakremover(ghc-time-manager-prof) weakremover(ghc-time-parsers) weakremover(ghc-time-parsers-devel) weakremover(ghc-time-prof) weakremover(ghc-time-units) weakremover(ghc-time-units-devel) weakremover(ghc-timeit) weakremover(ghc-timeit-devel) weakremover(ghc-timeit-prof) weakremover(ghc-timelens) weakremover(ghc-timelens-devel) weakremover(ghc-timemap) weakremover(ghc-timemap-devel) weakremover(ghc-timerep) weakremover(ghc-timerep-devel) weakremover(ghc-timerep-prof) weakremover(ghc-timespan) weakremover(ghc-timespan-devel) weakremover(ghc-timezone-olson) weakremover(ghc-timezone-olson-devel) weakremover(ghc-timezone-olson-prof) weakremover(ghc-timezone-series) weakremover(ghc-timezone-series-devel) weakremover(ghc-timezone-series-prof) weakremover(ghc-tinylog) weakremover(ghc-tinylog-devel) weakremover(ghc-tinytemplate) weakremover(ghc-tinytemplate-devel) weakremover(ghc-titlecase) weakremover(ghc-titlecase-devel) weakremover(ghc-tls) weakremover(ghc-tls-devel) weakremover(ghc-tls-prof) weakremover(ghc-tls-session-manager) weakremover(ghc-tls-session-manager-devel) weakremover(ghc-tls-session-manager-prof) weakremover(ghc-token-bucket) weakremover(ghc-token-bucket-devel) weakremover(ghc-topograph) weakremover(ghc-topograph-devel) weakremover(ghc-topograph-prof) weakremover(ghc-torrent) weakremover(ghc-torrent-devel) weakremover(ghc-torrent-prof) weakremover(ghc-tostring) weakremover(ghc-tostring-devel) weakremover(ghc-transformers) weakremover(ghc-transformers-base) weakremover(ghc-transformers-base-devel) weakremover(ghc-transformers-base-prof) weakremover(ghc-transformers-compat) weakremover(ghc-transformers-compat-devel) weakremover(ghc-transformers-compat-prof) weakremover(ghc-transformers-devel) weakremover(ghc-transformers-except) weakremover(ghc-transformers-except-devel) weakremover(ghc-transformers-lift) weakremover(ghc-transformers-lift-devel) weakremover(ghc-transformers-prof) weakremover(ghc-transient) weakremover(ghc-transient-devel) weakremover(ghc-traverse-with-class) weakremover(ghc-traverse-with-class-devel) weakremover(ghc-tree-diff) weakremover(ghc-tree-diff-devel) weakremover(ghc-tree-fun) weakremover(ghc-tree-fun-devel) weakremover(ghc-tree-view) weakremover(ghc-tree-view-devel) weakremover(ghc-tries) weakremover(ghc-tries-devel) weakremover(ghc-trifecta) weakremover(ghc-trifecta-devel) weakremover(ghc-true-name) weakremover(ghc-true-name-devel) weakremover(ghc-ttrie) weakremover(ghc-ttrie-devel) weakremover(ghc-tuple) weakremover(ghc-tuple-devel) weakremover(ghc-tuple-th) weakremover(ghc-tuple-th-devel) weakremover(ghc-tuples-homogenous-h98) weakremover(ghc-tuples-homogenous-h98-devel) weakremover(ghc-turtle) weakremover(ghc-turtle-devel) weakremover(ghc-turtle-options) weakremover(ghc-turtle-options-devel) weakremover(ghc-twitter-feed) weakremover(ghc-twitter-feed-devel) weakremover(ghc-twitter-types) weakremover(ghc-twitter-types-devel) weakremover(ghc-twitter-types-lens) weakremover(ghc-twitter-types-lens-devel) weakremover(ghc-type-aligned) weakremover(ghc-type-aligned-devel) weakremover(ghc-type-assertions) weakremover(ghc-type-assertions-devel) weakremover(ghc-type-eq) weakremover(ghc-type-eq-devel) weakremover(ghc-type-equality) weakremover(ghc-type-equality-devel) weakremover(ghc-type-equality-prof) weakremover(ghc-type-fun) weakremover(ghc-type-fun-devel) weakremover(ghc-type-hint) weakremover(ghc-type-hint-devel) weakremover(ghc-type-level-kv-list) weakremover(ghc-type-level-kv-list-devel) weakremover(ghc-type-level-numbers) weakremover(ghc-type-level-numbers-devel) weakremover(ghc-type-operators) weakremover(ghc-type-operators-devel) weakremover(ghc-type-spec) weakremover(ghc-type-spec-devel) weakremover(ghc-typed-process) weakremover(ghc-typed-process-devel) weakremover(ghc-typed-process-prof) weakremover(ghc-typelits-witnesses) weakremover(ghc-typelits-witnesses-devel) weakremover(ghc-typerep-map) weakremover(ghc-typerep-map-devel) weakremover(ghc-typography-geometry) weakremover(ghc-typography-geometry-devel) weakremover(ghc-tz) weakremover(ghc-tz-devel) weakremover(ghc-tzdata) weakremover(ghc-tzdata-devel) weakremover(ghc-ua-parser) weakremover(ghc-ua-parser-devel) weakremover(ghc-uglymemo) weakremover(ghc-uglymemo-devel) weakremover(ghc-uglymemo-prof) weakremover(ghc-unbound-generics) weakremover(ghc-unbound-generics-devel) weakremover(ghc-unbounded-delays) weakremover(ghc-unbounded-delays-devel) weakremover(ghc-uncertain) weakremover(ghc-uncertain-devel) weakremover(ghc-unexceptionalio) weakremover(ghc-unexceptionalio-devel) weakremover(ghc-unfoldable) weakremover(ghc-unfoldable-devel) weakremover(ghc-unfoldable-restricted) weakremover(ghc-unfoldable-restricted-devel) weakremover(ghc-unicode) weakremover(ghc-unicode-collation) weakremover(ghc-unicode-collation-devel) weakremover(ghc-unicode-collation-prof) weakremover(ghc-unicode-data) weakremover(ghc-unicode-data-devel) weakremover(ghc-unicode-data-prof) weakremover(ghc-unicode-devel) weakremover(ghc-unicode-show) weakremover(ghc-unicode-show-devel) weakremover(ghc-unicode-transforms) weakremover(ghc-unicode-transforms-devel) weakremover(ghc-unicode-transforms-prof) weakremover(ghc-unification-fd) weakremover(ghc-unification-fd-devel) weakremover(ghc-union) weakremover(ghc-union-devel) weakremover(ghc-union-find) weakremover(ghc-union-find-devel) weakremover(ghc-uniplate) weakremover(ghc-uniplate-devel) weakremover(ghc-uniplate-prof) weakremover(ghc-unique) weakremover(ghc-unique-devel) weakremover(ghc-unit-constraint) weakremover(ghc-unit-constraint-devel) weakremover(ghc-units-parser) weakremover(ghc-units-parser-devel) weakremover(ghc-universe) weakremover(ghc-universe-base) weakremover(ghc-universe-base-devel) weakremover(ghc-universe-devel) weakremover(ghc-universe-instances-base) weakremover(ghc-universe-instances-base-devel) weakremover(ghc-universe-instances-extended) weakremover(ghc-universe-instances-extended-devel) weakremover(ghc-universe-instances-trans) weakremover(ghc-universe-instances-trans-devel) weakremover(ghc-universe-reverse-instances) weakremover(ghc-universe-reverse-instances-devel) weakremover(ghc-unix) weakremover(ghc-unix-bytestring) weakremover(ghc-unix-bytestring-devel) weakremover(ghc-unix-compat) weakremover(ghc-unix-compat-devel) weakremover(ghc-unix-compat-prof) weakremover(ghc-unix-devel) weakremover(ghc-unix-prof) weakremover(ghc-unix-time) weakremover(ghc-unix-time-devel) weakremover(ghc-unix-time-prof) weakremover(ghc-unliftio) weakremover(ghc-unliftio-core) weakremover(ghc-unliftio-core-devel) weakremover(ghc-unliftio-core-prof) weakremover(ghc-unliftio-devel) weakremover(ghc-unliftio-prof) weakremover(ghc-unlit) weakremover(ghc-unlit-devel) weakremover(ghc-unordered-containers) weakremover(ghc-unordered-containers-devel) weakremover(ghc-unordered-containers-prof) weakremover(ghc-uri-bytestring) weakremover(ghc-uri-bytestring-aeson) weakremover(ghc-uri-bytestring-aeson-devel) weakremover(ghc-uri-bytestring-devel) weakremover(ghc-uri-encode) weakremover(ghc-uri-encode-devel) weakremover(ghc-uri-templater) weakremover(ghc-uri-templater-devel) weakremover(ghc-url) weakremover(ghc-url-devel) weakremover(ghc-urlpath) weakremover(ghc-urlpath-devel) weakremover(ghc-userid) weakremover(ghc-userid-devel) weakremover(ghc-users) weakremover(ghc-users-devel) weakremover(ghc-users-postgresql-simple) weakremover(ghc-users-postgresql-simple-devel) weakremover(ghc-users-test) weakremover(ghc-users-test-devel) weakremover(ghc-utf8-light) weakremover(ghc-utf8-light-devel) weakremover(ghc-utf8-string) weakremover(ghc-utf8-string-devel) weakremover(ghc-utf8-string-prof) weakremover(ghc-utility-ht) weakremover(ghc-utility-ht-devel) weakremover(ghc-utility-ht-prof) weakremover(ghc-uu-interleaved) weakremover(ghc-uu-interleaved-devel) weakremover(ghc-uu-parsinglib) weakremover(ghc-uu-parsinglib-devel) weakremover(ghc-uuid) weakremover(ghc-uuid-devel) weakremover(ghc-uuid-orphans) weakremover(ghc-uuid-orphans-devel) weakremover(ghc-uuid-prof) weakremover(ghc-uuid-types) weakremover(ghc-uuid-types-devel) weakremover(ghc-uuid-types-prof) weakremover(ghc-vado) weakremover(ghc-vado-devel) weakremover(ghc-validate-input) weakremover(ghc-validate-input-devel) weakremover(ghc-validation) weakremover(ghc-validation-devel) weakremover(ghc-validity) weakremover(ghc-validity-devel) weakremover(ghc-varying) weakremover(ghc-varying-devel) weakremover(ghc-vault) weakremover(ghc-vault-devel) weakremover(ghc-vault-prof) weakremover(ghc-vcswrapper) weakremover(ghc-vcswrapper-devel) weakremover(ghc-vector) weakremover(ghc-vector-algorithms) weakremover(ghc-vector-algorithms-devel) weakremover(ghc-vector-algorithms-prof) weakremover(ghc-vector-binary-instances) weakremover(ghc-vector-binary-instances-devel) weakremover(ghc-vector-binary-instances-prof) weakremover(ghc-vector-buffer) weakremover(ghc-vector-buffer-devel) weakremover(ghc-vector-builder) weakremover(ghc-vector-builder-devel) weakremover(ghc-vector-devel) weakremover(ghc-vector-fftw) weakremover(ghc-vector-fftw-devel) weakremover(ghc-vector-instances) weakremover(ghc-vector-instances-devel) weakremover(ghc-vector-prof) weakremover(ghc-vector-sized) weakremover(ghc-vector-sized-devel) weakremover(ghc-vector-space) weakremover(ghc-vector-space-devel) weakremover(ghc-vector-split) weakremover(ghc-vector-split-devel) weakremover(ghc-vector-stream) weakremover(ghc-vector-stream-devel) weakremover(ghc-vector-stream-prof) weakremover(ghc-vector-th-unbox) weakremover(ghc-vector-th-unbox-devel) weakremover(ghc-vector-th-unbox-prof) weakremover(ghc-vectortiles) weakremover(ghc-vectortiles-devel) weakremover(ghc-versions) weakremover(ghc-versions-devel) weakremover(ghc-vhd) weakremover(ghc-vhd-devel) weakremover(ghc-vinyl) weakremover(ghc-vinyl-devel) weakremover(ghc-void) weakremover(ghc-void-devel) weakremover(ghc-void-prof) weakremover(ghc-vty) weakremover(ghc-vty-devel) weakremover(ghc-vty-prof) weakremover(ghc-wai) weakremover(ghc-wai-app-static) weakremover(ghc-wai-app-static-devel) weakremover(ghc-wai-app-static-prof) weakremover(ghc-wai-cli) weakremover(ghc-wai-cli-devel) weakremover(ghc-wai-conduit) weakremover(ghc-wai-conduit-devel) weakremover(ghc-wai-cors) weakremover(ghc-wai-cors-devel) weakremover(ghc-wai-cors-prof) weakremover(ghc-wai-devel) weakremover(ghc-wai-eventsource) weakremover(ghc-wai-eventsource-devel) weakremover(ghc-wai-extra) weakremover(ghc-wai-extra-devel) weakremover(ghc-wai-extra-prof) weakremover(ghc-wai-handler-launch) weakremover(ghc-wai-handler-launch-devel) weakremover(ghc-wai-logger) weakremover(ghc-wai-logger-devel) weakremover(ghc-wai-logger-prof) weakremover(ghc-wai-middleware-auth) weakremover(ghc-wai-middleware-auth-devel) weakremover(ghc-wai-middleware-caching) weakremover(ghc-wai-middleware-caching-devel) weakremover(ghc-wai-middleware-caching-lru) weakremover(ghc-wai-middleware-caching-lru-devel) weakremover(ghc-wai-middleware-caching-redis) weakremover(ghc-wai-middleware-caching-redis-devel) weakremover(ghc-wai-middleware-consul) weakremover(ghc-wai-middleware-consul-devel) weakremover(ghc-wai-middleware-crowd) weakremover(ghc-wai-middleware-crowd-devel) weakremover(ghc-wai-middleware-metrics) weakremover(ghc-wai-middleware-metrics-devel) weakremover(ghc-wai-middleware-prometheus) weakremover(ghc-wai-middleware-prometheus-devel) weakremover(ghc-wai-middleware-static) weakremover(ghc-wai-middleware-static-devel) weakremover(ghc-wai-middleware-throttle) weakremover(ghc-wai-middleware-throttle-devel) weakremover(ghc-wai-middleware-verbs) weakremover(ghc-wai-middleware-verbs-devel) weakremover(ghc-wai-prof) weakremover(ghc-wai-request-spec) weakremover(ghc-wai-request-spec-devel) weakremover(ghc-wai-route) weakremover(ghc-wai-route-devel) weakremover(ghc-wai-session) weakremover(ghc-wai-session-devel) weakremover(ghc-wai-session-postgresql) weakremover(ghc-wai-session-postgresql-devel) weakremover(ghc-wai-transformers) weakremover(ghc-wai-transformers-devel) weakremover(ghc-wai-websockets) weakremover(ghc-wai-websockets-devel) weakremover(ghc-waitra) weakremover(ghc-waitra-devel) weakremover(ghc-warp) weakremover(ghc-warp-devel) weakremover(ghc-warp-prof) weakremover(ghc-warp-tls) weakremover(ghc-warp-tls-devel) weakremover(ghc-warp-tls-prof) weakremover(ghc-wave) weakremover(ghc-wave-devel) weakremover(ghc-wavefront) weakremover(ghc-wavefront-devel) weakremover(ghc-wcwidth) weakremover(ghc-wcwidth-devel) weakremover(ghc-web-plugins) weakremover(ghc-web-plugins-devel) weakremover(ghc-web-routes) weakremover(ghc-web-routes-boomerang) weakremover(ghc-web-routes-boomerang-devel) weakremover(ghc-web-routes-devel) weakremover(ghc-web-routes-happstack) weakremover(ghc-web-routes-happstack-devel) weakremover(ghc-web-routes-hsp) weakremover(ghc-web-routes-hsp-devel) weakremover(ghc-web-routes-th) weakremover(ghc-web-routes-th-devel) weakremover(ghc-web-routes-wai) weakremover(ghc-web-routes-wai-devel) weakremover(ghc-webdriver) weakremover(ghc-webdriver-angular) weakremover(ghc-webdriver-angular-devel) weakremover(ghc-webdriver-devel) weakremover(ghc-webpage) weakremover(ghc-webpage-devel) weakremover(ghc-webrtc-vad) weakremover(ghc-webrtc-vad-devel) weakremover(ghc-websockets) weakremover(ghc-websockets-devel) weakremover(ghc-websockets-snap) weakremover(ghc-websockets-snap-devel) weakremover(ghc-weeder) weakremover(ghc-weeder-devel) weakremover(ghc-weigh) weakremover(ghc-weigh-devel) weakremover(ghc-wikicfp-scraper) weakremover(ghc-wikicfp-scraper-devel) weakremover(ghc-wild-bind) weakremover(ghc-wild-bind-devel) weakremover(ghc-wild-bind-indicator) weakremover(ghc-wild-bind-indicator-devel) weakremover(ghc-wild-bind-task-x11) weakremover(ghc-wild-bind-task-x11-devel) weakremover(ghc-wild-bind-x11) weakremover(ghc-wild-bind-x11-devel) weakremover(ghc-wire-streams) weakremover(ghc-wire-streams-devel) weakremover(ghc-with-location) weakremover(ghc-with-location-devel) weakremover(ghc-withdependencies) weakremover(ghc-withdependencies-devel) weakremover(ghc-witherable) weakremover(ghc-witherable-devel) weakremover(ghc-witherable-prof) weakremover(ghc-witness) weakremover(ghc-witness-devel) weakremover(ghc-wizards) weakremover(ghc-wizards-devel) weakremover(ghc-wizards-prof) weakremover(ghc-wl-pprint) weakremover(ghc-wl-pprint-annotated) weakremover(ghc-wl-pprint-annotated-devel) weakremover(ghc-wl-pprint-console) weakremover(ghc-wl-pprint-console-devel) weakremover(ghc-wl-pprint-devel) weakremover(ghc-wl-pprint-extras) weakremover(ghc-wl-pprint-extras-devel) weakremover(ghc-wl-pprint-text) weakremover(ghc-wl-pprint-text-devel) weakremover(ghc-word-trie) weakremover(ghc-word-trie-devel) weakremover(ghc-word-wrap) weakremover(ghc-word-wrap-devel) weakremover(ghc-word-wrap-prof) weakremover(ghc-word24) weakremover(ghc-word24-devel) weakremover(ghc-word8) weakremover(ghc-word8-devel) weakremover(ghc-word8-prof) weakremover(ghc-wrap) weakremover(ghc-wrap-devel) weakremover(ghc-wreq) weakremover(ghc-wreq-devel) weakremover(ghc-writer-cps-full) weakremover(ghc-writer-cps-full-devel) weakremover(ghc-writer-cps-lens) weakremover(ghc-writer-cps-lens-devel) weakremover(ghc-writer-cps-morph) weakremover(ghc-writer-cps-morph-devel) weakremover(ghc-writer-cps-mtl) weakremover(ghc-writer-cps-mtl-devel) weakremover(ghc-writer-cps-transformers) weakremover(ghc-writer-cps-transformers-devel) weakremover(ghc-wuss) weakremover(ghc-wuss-devel) weakremover(ghc-x509) weakremover(ghc-x509-devel) weakremover(ghc-x509-prof) weakremover(ghc-x509-store) weakremover(ghc-x509-store-devel) weakremover(ghc-x509-store-prof) weakremover(ghc-x509-system) weakremover(ghc-x509-system-devel) weakremover(ghc-x509-system-prof) weakremover(ghc-x509-validation) weakremover(ghc-x509-validation-devel) weakremover(ghc-x509-validation-prof) weakremover(ghc-xdg-basedir) weakremover(ghc-xdg-basedir-devel) weakremover(ghc-xenstore) weakremover(ghc-xenstore-devel) weakremover(ghc-xhtml) weakremover(ghc-xhtml-devel) weakremover(ghc-xhtml-prof) weakremover(ghc-xlsior) weakremover(ghc-xlsior-devel) weakremover(ghc-xlsx) weakremover(ghc-xlsx-devel) weakremover(ghc-xlsx-tabular) weakremover(ghc-xlsx-tabular-devel) weakremover(ghc-xml) weakremover(ghc-xml-conduit) weakremover(ghc-xml-conduit-devel) weakremover(ghc-xml-conduit-parse) weakremover(ghc-xml-conduit-parse-devel) weakremover(ghc-xml-conduit-prof) weakremover(ghc-xml-conduit-writer) weakremover(ghc-xml-conduit-writer-devel) weakremover(ghc-xml-devel) weakremover(ghc-xml-hamlet) weakremover(ghc-xml-hamlet-devel) weakremover(ghc-xml-hamlet-prof) weakremover(ghc-xml-html-qq) weakremover(ghc-xml-html-qq-devel) weakremover(ghc-xml-lens) weakremover(ghc-xml-lens-devel) weakremover(ghc-xml-picklers) weakremover(ghc-xml-picklers-devel) weakremover(ghc-xml-prof) weakremover(ghc-xml-to-json-fast) weakremover(ghc-xml-to-json-fast-devel) weakremover(ghc-xml-types) weakremover(ghc-xml-types-devel) weakremover(ghc-xml-types-prof) weakremover(ghc-xmlgen) weakremover(ghc-xmlgen-devel) weakremover(ghc-xmobar) weakremover(ghc-xmobar-devel) weakremover(ghc-xmobar-prof) weakremover(ghc-xmonad) weakremover(ghc-xmonad-contrib) weakremover(ghc-xmonad-contrib-devel) weakremover(ghc-xmonad-contrib-prof) weakremover(ghc-xmonad-devel) weakremover(ghc-xmonad-prof) weakremover(ghc-xss-sanitize) weakremover(ghc-xss-sanitize-devel) weakremover(ghc-xss-sanitize-prof) weakremover(ghc-yahoo-finance-api) weakremover(ghc-yahoo-finance-api-devel) weakremover(ghc-yaml) weakremover(ghc-yaml-devel) weakremover(ghc-yaml-prof) weakremover(ghc-yes-precure5-command) weakremover(ghc-yes-precure5-command-devel) weakremover(ghc-yesod) weakremover(ghc-yesod-auth) weakremover(ghc-yesod-auth-account) weakremover(ghc-yesod-auth-account-devel) weakremover(ghc-yesod-auth-basic) weakremover(ghc-yesod-auth-basic-devel) weakremover(ghc-yesod-auth-devel) weakremover(ghc-yesod-auth-hashdb) weakremover(ghc-yesod-auth-hashdb-devel) weakremover(ghc-yesod-core) weakremover(ghc-yesod-core-devel) weakremover(ghc-yesod-core-prof) weakremover(ghc-yesod-default) weakremover(ghc-yesod-default-devel) weakremover(ghc-yesod-devel) weakremover(ghc-yesod-eventsource) weakremover(ghc-yesod-eventsource-devel) weakremover(ghc-yesod-form) weakremover(ghc-yesod-form-devel) weakremover(ghc-yesod-form-prof) weakremover(ghc-yesod-form-richtext) weakremover(ghc-yesod-form-richtext-devel) weakremover(ghc-yesod-gitrepo) weakremover(ghc-yesod-gitrepo-devel) weakremover(ghc-yesod-gitrev) weakremover(ghc-yesod-gitrev-devel) weakremover(ghc-yesod-newsfeed) weakremover(ghc-yesod-newsfeed-devel) weakremover(ghc-yesod-persistent) weakremover(ghc-yesod-persistent-devel) weakremover(ghc-yesod-persistent-prof) weakremover(ghc-yesod-prof) weakremover(ghc-yesod-sitemap) weakremover(ghc-yesod-sitemap-devel) weakremover(ghc-yesod-static) weakremover(ghc-yesod-static-angular) weakremover(ghc-yesod-static-angular-devel) weakremover(ghc-yesod-static-devel) weakremover(ghc-yesod-static-prof) weakremover(ghc-yesod-table) weakremover(ghc-yesod-table-devel) weakremover(ghc-yesod-test) weakremover(ghc-yesod-test-devel) weakremover(ghc-yesod-websockets) weakremover(ghc-yesod-websockets-devel) weakremover(ghc-yi-language) weakremover(ghc-yi-language-devel) weakremover(ghc-yjtools) weakremover(ghc-yjtools-devel) weakremover(ghc-zero) weakremover(ghc-zero-devel) weakremover(ghc-zeromq4-haskell) weakremover(ghc-zeromq4-haskell-devel) weakremover(ghc-zip) weakremover(ghc-zip-archive) weakremover(ghc-zip-archive-devel) weakremover(ghc-zip-archive-prof) weakremover(ghc-zip-devel) weakremover(ghc-zippers) weakremover(ghc-zippers-devel) weakremover(ghc-zlib) weakremover(ghc-zlib-bindings) weakremover(ghc-zlib-bindings-devel) weakremover(ghc-zlib-devel) weakremover(ghc-zlib-lens) weakremover(ghc-zlib-lens-devel) weakremover(ghc-zlib-prof) weakremover(ghc-zstd) weakremover(ghc-zstd-devel) weakremover(ghcid) weakremover(ghex) weakremover(ghex-devel) weakremover(ghostscript) weakremover(ghostscript-cjk) weakremover(ghostscript-devel) weakremover(ghostscript-mini) weakremover(ghostscript-mini-devel) weakremover(ghostscript-x11) weakremover(ghostview) weakremover(ghostwriter) weakremover(giac) weakremover(giac-devel) weakremover(giada) weakremover(giblib-devel) weakremover(giflib-devel) weakremover(giflib-progs) weakremover(gifsicle) weakremover(gigaset-frontend) weakremover(gigaset-frontend-qt) weakremover(giggle) weakremover(giggle-devel) weakremover(giggle-lang) weakremover(gigolo) weakremover(gimp) weakremover(gimp-devel) weakremover(gimp-gap) weakremover(gimp-help-browser) weakremover(gimp-plugin-aa) weakremover(gimp-plugin-dds) weakremover(gimp-plugin-dds-doc) weakremover(gimp-plugin-gmic) weakremover(gimp-plugin-lqr) weakremover(gimp-plugin-resynthesizer) weakremover(gimp-plugins-python) weakremover(gimp-save-for-web) weakremover(gimp-ufraw) weakremover(ginac) weakremover(ginac-devel) weakremover(gio-qt-devel) weakremover(gio-sharp) weakremover(gio-sharp-devel) weakremover(gio-sharp3) weakremover(gio-sharp3-devel) weakremover(girara-devel) weakremover(girepository-1_0) weakremover(girl) weakremover(girl-lang) weakremover(git) weakremover(git-annex) weakremover(git-annex-bash-completion) weakremover(git-arch) weakremover(git-bug) weakremover(git-cliff) weakremover(git-core) weakremover(git-credential-gnome-keyring) weakremover(git-credential-libsecret) weakremover(git-crypt) weakremover(git-cvs) weakremover(git-daemon) weakremover(git-delta) weakremover(git-email) weakremover(git-gui) weakremover(git-lfs) weakremover(git-merge-changelog) weakremover(git-p4) weakremover(git-svn) weakremover(git-web) weakremover(gitg) weakremover(gitk) weakremover(gitleaks) weakremover(gitui) weakremover(givaro-devel) weakremover(gjiten) weakremover(gjs) weakremover(gkeyfile-sharp) weakremover(gkeyfile-sharp-devel) weakremover(gkrellm) weakremover(gkrellm-cpufreq) weakremover(gkrellm-cpupower) weakremover(gkrellm-devel) weakremover(gkrellmd) weakremover(gl2ps-devel) weakremover(gl3w-devel) weakremover(glab) weakremover(glabels) weakremover(glabels-devel) weakremover(glade) weakremover(glade-catalog-anjuta) weakremover(glade-catalog-evolution) weakremover(glade-catalog-gitg) weakremover(glade-catalog-gtkdatabox) weakremover(glade-catalog-gtkhtml) weakremover(glade-catalog-gtksourceview) weakremover(glade-catalog-gtksourceview4) weakremover(glade-catalog-libgda) weakremover(glade-catalog-libhandy) weakremover(glade-catalog-libhandy0) weakremover(glade-catalog-v3270) weakremover(glade-catalog-vte) weakremover(glade-sharp2) weakremover(glade3) weakremover(glade3-catalog-gtksourceview) weakremover(glade3-catalog-libxfce4ui) weakremover(glade3-catalog-vte) weakremover(glade3-lang) weakremover(glava) weakremover(gle-graphics) weakremover(gle-graphics-doc) weakremover(glew) weakremover(glew-devel) weakremover(glfw2-devel) weakremover(gli-devel) weakremover(glib-networking) weakremover(glib-sharp2) weakremover(glib-sharp3) weakremover(glib2-devel) weakremover(glib2-devel-static) weakremover(glib2-doc) weakremover(glib2-tests) weakremover(glib2-tests-devel) weakremover(glib2-tools) weakremover(glibc) weakremover(glibc-devel) weakremover(glibc-devel-static) weakremover(glibc-extra) weakremover(glibc-locale) weakremover(glibc-locale-base) weakremover(glibc-profile) weakremover(glibc-usrmerge-bootstrap-helper) weakremover(glibc-utils) weakremover(glibmm2-devel) weakremover(glibmm2_4-devel) weakremover(glipper) weakremover(glipper-lang) weakremover(glm-devel) weakremover(glmark2) weakremover(global) weakremover(glog-devel) weakremover(glom) weakremover(glom-lang) weakremover(gloox-devel) weakremover(glorytun) weakremover(glow) weakremover(glpk) weakremover(glpk-devel) weakremover(glslang-devel) weakremover(gltt) weakremover(gltt-devel) weakremover(glu-devel) weakremover(glucat-devel) weakremover(glucat-doc) weakremover(gluegen2) weakremover(glusterfs) weakremover(glusterfs-devel) weakremover(glyr-devel) weakremover(glyrc) weakremover(gmenudbusmenuproxy) weakremover(gmetrics) weakremover(gmetrics-javadoc) weakremover(gmic) weakremover(gmic-zart) weakremover(gmime-devel) weakremover(gmime2_6-devel) weakremover(gmime2_6-sharp) weakremover(gmixer) weakremover(gmock) weakremover(gmp-devel) weakremover(gmp-ecm) weakremover(gmp-ecm-devel) weakremover(gmsh) weakremover(gmsh-devel) weakremover(gmsh-julia) weakremover(gmusicbrowser) weakremover(gmusicbrowser-lang) weakremover(gn) weakremover(gnac) weakremover(gnac-lang) weakremover(gnet) weakremover(gnet-devel) weakremover(gnet-doc) weakremover(gnokii) weakremover(gnokii-devel) weakremover(gnokii-lang) weakremover(gnokii-smsd) weakremover(gnome-2048) weakremover(gnome-activity-journal) weakremover(gnome-activity-journal-lang) weakremover(gnome-autoar-devel) weakremover(gnome-bluetooth) weakremover(gnome-bluetooth-1) weakremover(gnome-bluetooth-1-devel) weakremover(gnome-bluetooth-devel) weakremover(gnome-bluetooth-plugin-phone-manager) weakremover(gnome-books) weakremover(gnome-books-lang) weakremover(gnome-boxes) weakremover(gnome-break-timer) weakremover(gnome-break-timer-lang) weakremover(gnome-browser-connector) weakremover(gnome-builder) weakremover(gnome-builder-plugin-beautifier) weakremover(gnome-builder-plugin-clang) weakremover(gnome-builder-plugin-cmake) weakremover(gnome-builder-plugin-ctags) weakremover(gnome-builder-plugin-devhelp) weakremover(gnome-builder-plugin-fpaste) weakremover(gnome-builder-plugin-gettext) weakremover(gnome-builder-plugin-gnome-code-assistance) weakremover(gnome-builder-plugin-html-completion) weakremover(gnome-builder-plugin-jedi) weakremover(gnome-builder-plugin-jhbuild) weakremover(gnome-builder-plugin-mingw) weakremover(gnome-builder-plugin-symbol-tree) weakremover(gnome-builder-plugin-sysmon) weakremover(gnome-builder-plugin-todo) weakremover(gnome-builder-plugin-vala-pack) weakremover(gnome-builder-plugin-xml-pack) weakremover(gnome-calculator) weakremover(gnome-calculator-devel) weakremover(gnome-calendar) weakremover(gnome-characters) weakremover(gnome-chess) weakremover(gnome-clocks) weakremover(gnome-code-assistance) weakremover(gnome-color-chooser) weakremover(gnome-color-chooser-lang) weakremover(gnome-color-manager) weakremover(gnome-commander) weakremover(gnome-commander-devel) weakremover(gnome-commander-doc) weakremover(gnome-connections) weakremover(gnome-contacts) weakremover(gnome-control-center) weakremover(gnome-desktop-sharp2) weakremover(gnome-desktop-sharp2-devel) weakremover(gnome-desktop2) weakremover(gnome-desktop2-lang) weakremover(gnome-dictionary) weakremover(gnome-directory-thumbnailer) weakremover(gnome-disk-utility) weakremover(gnome-do) weakremover(gnome-do-lang) weakremover(gnome-do-plugins) weakremover(gnome-do-plugins-lang) weakremover(gnome-documents) weakremover(gnome-documents-lang) weakremover(gnome-documents_books-common) weakremover(gnome-dvb-daemon) weakremover(gnome-epub-thumbnailer) weakremover(gnome-extensions) weakremover(gnome-firmware) weakremover(gnome-firmware-updater) weakremover(gnome-firmware-updater-lang) weakremover(gnome-font-viewer) weakremover(gnome-games) weakremover(gnome-games-extra-data) weakremover(gnome-games-lang) weakremover(gnome-games-recommended) weakremover(gnome-genius) weakremover(gnome-gmail) weakremover(gnome-gmail-lang) weakremover(gnome-gmail-notifier) weakremover(gnome-gmail-notifier-lang) weakremover(gnome-initial-setup) weakremover(gnome-internet-radio-locator) weakremover(gnome-internet-radio-locator-lang) weakremover(gnome-js-common) weakremover(gnome-keyring) weakremover(gnome-keyring-pam) weakremover(gnome-keyring-sharp) weakremover(gnome-keyring-sharp-devel) weakremover(gnome-keysign) weakremover(gnome-kiosk) weakremover(gnome-klotski) weakremover(gnome-latex) weakremover(gnome-logs) weakremover(gnome-mahjongg) weakremover(gnome-maps) weakremover(gnome-menus) weakremover(gnome-menus-devel) weakremover(gnome-mime-data) weakremover(gnome-mines) weakremover(gnome-mpv) weakremover(gnome-mpv-lang) weakremover(gnome-multi-writer) weakremover(gnome-nettool) weakremover(gnome-network-displays) weakremover(gnome-news) weakremover(gnome-news-lang) weakremover(gnome-nibbles) weakremover(gnome-online-accounts) weakremover(gnome-online-accounts-devel) weakremover(gnome-online-miners) weakremover(gnome-packagekit) weakremover(gnome-packagekit-extras) weakremover(gnome-passwordsafe-lang) weakremover(gnome-phone-manager) weakremover(gnome-phone-manager-lang) weakremover(gnome-photos) weakremover(gnome-pie) weakremover(gnome-podcasts) weakremover(gnome-pomodoro) weakremover(gnome-power-manager) weakremover(gnome-print-sharp) weakremover(gnome-python-desktop) weakremover(gnome-python-desktop-devel) weakremover(gnome-radio) weakremover(gnome-recipes) weakremover(gnome-remote-desktop) weakremover(gnome-robots) weakremover(gnome-schedule) weakremover(gnome-schedule-lang) weakremover(gnome-screenshot) weakremover(gnome-search-tool) weakremover(gnome-session) weakremover(gnome-session-core) weakremover(gnome-session-default-session) weakremover(gnome-session-wayland) weakremover(gnome-settings-daemon) weakremover(gnome-settings-daemon-devel) weakremover(gnome-sharp2) weakremover(gnome-sharp2-complete) weakremover(gnome-shell) weakremover(gnome-shell-browser-plugin) weakremover(gnome-shell-calendar) weakremover(gnome-shell-classic-session) weakremover(gnome-shell-devel) weakremover(gnome-shell-search-provider-bijiben) weakremover(gnome-shell-search-provider-boxes) weakremover(gnome-shell-search-provider-contacts) weakremover(gnome-shell-search-provider-documents) weakremover(gnome-shell-search-provider-elementary-appcenter) weakremover(gnome-shell-search-provider-epiphany) weakremover(gnome-shell-search-provider-gnome-calculator) weakremover(gnome-shell-search-provider-gnome-games) weakremover(gnome-shell-search-provider-gnome-photos) weakremover(gnome-shell-search-provider-gnome-recipes) weakremover(gnome-shell-theme-plata) weakremover(gnome-software) weakremover(gnome-software-devel) weakremover(gnome-software-plugin-packagekit) weakremover(gnome-subtitles) weakremover(gnome-sudoku) weakremover(gnome-system-monitor) weakremover(gnome-taquin) weakremover(gnome-terminal) weakremover(gnome-tetravex) weakremover(gnome-text-editor) weakremover(gnome-todo) weakremover(gnome-todo-devel) weakremover(gnome-todo-lang) weakremover(gnome-tour) weakremover(gnome-usage) weakremover(gnome-user-share) weakremover(gnome-version) weakremover(gnome-vfs-monikers) weakremover(gnome-vfs-sharp2) weakremover(gnome-vfs2) weakremover(gnome-vfs2-devel) weakremover(gnome-vfs2-doc) weakremover(gnome-vfs2-lang) weakremover(gnome-web-photo) weakremover(gnome-web-photo-lang) weakremover(gnomekbd-tools) weakremover(gnonograms) weakremover(gnote) weakremover(gns3) weakremover(gns3-converter) weakremover(gns3-net-converter) weakremover(gnu-cobol) weakremover(gnu-efi) weakremover(gnu-inetlib) weakremover(gnu-netcat) weakremover(gnu-recutils) weakremover(gnu-recutils-devel) weakremover(gnu-recutils-lang) weakremover(gnu10-compilers-hpc) weakremover(gnu10-compilers-hpc-devel) weakremover(gnu10-compilers-hpc-macros-devel) weakremover(gnu8-compilers-hpc) weakremover(gnu8-compilers-hpc-devel) weakremover(gnu8-compilers-hpc-macros-devel) weakremover(gnu9-compilers-hpc) weakremover(gnu9-compilers-hpc-devel) weakremover(gnu9-compilers-hpc-macros-devel) weakremover(gnu_ddrescue) weakremover(gnuastro) weakremover(gnuastro-devel) weakremover(gnubg) weakremover(gnucap) weakremover(gnucash) weakremover(gnucash-devel) weakremover(gnuchess) weakremover(gnugk) weakremover(gnugo) weakremover(gnumeric) weakremover(gnumeric-devel) weakremover(gnump3d) weakremover(gnuplot) weakremover(gnuradio) weakremover(gnuradio-devel) weakremover(gnuradio-examples) weakremover(gnuradio-examples-wxgui) weakremover(gnuradio-wxgui) weakremover(gnuserv) weakremover(gnusocialshell) weakremover(gnustep-base) weakremover(gnustep-base-devel) weakremover(gnustep-make) weakremover(gnutls) weakremover(gnutls-guile) weakremover(go) weakremover(go-containerregistry) weakremover(go-doc) weakremover(go-for-it) weakremover(go-mango-doc) weakremover(go-md2man) weakremover(go-race) weakremover(go-sendxmpp) weakremover(go-tools) weakremover(go1.10) weakremover(go1.10-doc) weakremover(go1.11) weakremover(go1.11-doc) weakremover(go1.12) weakremover(go1.12-doc) weakremover(go1.13) weakremover(go1.13-doc) weakremover(go1.14) weakremover(go1.14-doc) weakremover(go1.14-race) weakremover(go1.15) weakremover(go1.15-doc) weakremover(go1.15-race) weakremover(go1.16) weakremover(go1.16-doc) weakremover(go1.16-race) weakremover(go1.17) weakremover(go1.17-doc) weakremover(go1.17-libstd) weakremover(go1.17-race) weakremover(go1.18) weakremover(go1.18-doc) weakremover(go1.18-libstd) weakremover(go1.18-race) weakremover(go1.19) weakremover(go1.19-doc) weakremover(go1.19-libstd) weakremover(go1.19-race) weakremover(go1.20) weakremover(go1.20-doc) weakremover(go1.20-libstd) weakremover(go1.20-race) weakremover(go1.6) weakremover(go1.6-doc) weakremover(go1.7) weakremover(go1.7-doc) weakremover(go1.8) weakremover(go1.8-doc) weakremover(go1.9) weakremover(go1.9-doc) weakremover(goaccess) weakremover(goatattack) weakremover(goatattack-data) weakremover(gob2) weakremover(gobby) weakremover(gobject-introspection) weakremover(gobject-introspection-devel) weakremover(gocode) weakremover(gocr) weakremover(godot) weakremover(godot-headless) weakremover(godot-runner) weakremover(godot-server) weakremover(godot3) weakremover(godot3-headless) weakremover(godot3-runner) weakremover(godot3-server) weakremover(goffice-0_8-devel) weakremover(goffice-0_8-lang) weakremover(goffice-devel) weakremover(gojsontoyaml) weakremover(gokart) weakremover(golang-github-QubitProducts-exporter_exporter) weakremover(golang-github-boynux-squid_exporter) weakremover(golang-github-constabulary-gb) weakremover(golang-github-cpuguy83-go-md2man) weakremover(golang-github-cpuguy83-go-md2man-source) weakremover(golang-github-czerwonk-ping_exporter) weakremover(golang-github-dchest-authcookie) weakremover(golang-github-dchest-authcookie-source) weakremover(golang-github-docker-libnetwork) weakremover(golang-github-docker-libnetwork-kubic) weakremover(golang-github-exercism-cli) weakremover(golang-github-exercism-cli-source) weakremover(golang-github-fitstar-falcore) weakremover(golang-github-fitstar-falcore-source) weakremover(golang-github-golang-geo) weakremover(golang-github-golang-glog) weakremover(golang-github-golang-glog-source) weakremover(golang-github-golang-protobuf) weakremover(golang-github-gorilla-context) weakremover(golang-github-gorilla-context-source) weakremover(golang-github-gorilla-websocket) weakremover(golang-github-hoisie-httplib) weakremover(golang-github-hoisie-httplib-source) weakremover(golang-github-hoisie-mustache) weakremover(golang-github-hoisie-mustache-source) weakremover(golang-github-hoisie-web) weakremover(golang-github-hoisie-web-source) weakremover(golang-github-jteeuwen-go-bindata) weakremover(golang-github-kr-pretty) weakremover(golang-github-kr-pty) weakremover(golang-github-kr-pty-source) weakremover(golang-github-kr-text) weakremover(golang-github-kr-text-source) weakremover(golang-github-linuxdeepin-deepin-desktop-schemas) weakremover(golang-github-lusitaniae-apache_exporter) weakremover(golang-github-naoina-go-stringutil) weakremover(golang-github-nsf-gocode) weakremover(golang-github-petar-gollrb) weakremover(golang-github-petar-gollrb-source) weakremover(golang-github-philio-gomysql) weakremover(golang-github-philio-gomysql-source) weakremover(golang-github-pkg-errors) weakremover(golang-github-prometheus-alertmanager) weakremover(golang-github-prometheus-node_exporter) weakremover(golang-github-prometheus-prometheus) weakremover(golang-github-prometheus-promu) weakremover(golang-github-rogpeppe-godef) weakremover(golang-github-russross-blackfriday) weakremover(golang-github-russross-blackfriday-source) weakremover(golang-github-shurcool-sanitized_anchor_name) weakremover(golang-github-shurcool-sanitized_anchor_name-source) weakremover(golang-github-v2ray-v2ray-core) weakremover(golang-github-vpenso-prometheus_slurm_exporter) weakremover(golang-github-wrouesnel-postgres_exporter) weakremover(golang-google-golangorg-api) weakremover(golang-google-golangorg-api-source) weakremover(golang-google-golangorg-appengine) weakremover(golang-google-golangorg-appengine-source) weakremover(golang-google-golangorg-cloud) weakremover(golang-google-golangorg-cloud-source) weakremover(golang-googlecode-couch-go) weakremover(golang-googlecode-couch-go-source) weakremover(golang-googlecode-freetype-go) weakremover(golang-googlecode-go-gb) weakremover(golang-googlecode-goconf) weakremover(golang-googlecode-goconf-source) weakremover(golang-googlecode-mango-doc) weakremover(golang-gopkgin-check) weakremover(golang-gopkgin-check-source) weakremover(golang-org-x-crypto) weakremover(golang-org-x-image) weakremover(golang-org-x-image-source) weakremover(golang-org-x-net) weakremover(golang-org-x-net-context) weakremover(golang-org-x-net-html) weakremover(golang-org-x-net-source) weakremover(golang-org-x-net-websocket) weakremover(golang-org-x-oauth2) weakremover(golang-org-x-oauth2-source) weakremover(golang-org-x-sync) weakremover(golang-org-x-sys) weakremover(golang-org-x-sys-source) weakremover(golang-org-x-text) weakremover(golang-org-x-text-source) weakremover(golang-org-x-time-rate) weakremover(golang-org-x-tools) weakremover(golang-org-x-tools-source) weakremover(golangci-lint) weakremover(goldendict) weakremover(gom-devel) weakremover(gom-lang) weakremover(gomuks) weakremover(gontributions) weakremover(gonvert) weakremover(goobox) weakremover(goocanvas-devel) weakremover(goocanvas2-devel) weakremover(goodvibes) weakremover(google-authenticator-libpam) weakremover(google-cloud-sdk) weakremover(google-cloud-sdk-doc) weakremover(google-compute-engine-init) weakremover(google-compute-engine-oslogin) weakremover(google-croscore-fonts) weakremover(google-daemon) weakremover(google-guest-agent) weakremover(google-guest-oslogin) weakremover(google-http-java-client) weakremover(google-http-java-client-findbugs) weakremover(google-http-java-client-gson) weakremover(google-http-java-client-jackson) weakremover(google-http-java-client-jackson2) weakremover(google-http-java-client-javadoc) weakremover(google-http-java-client-jdo) weakremover(google-http-java-client-parent) weakremover(google-http-java-client-protobuf) weakremover(google-http-java-client-test) weakremover(google-http-java-client-xml) weakremover(google-noto-fonts-doc) weakremover(google-oauth-java-client) weakremover(google-oauth-java-client-java6) weakremover(google-oauth-java-client-javadoc) weakremover(google-oauth-java-client-parent) weakremover(google-oauth-java-client-servlet) weakremover(google-or-tools) weakremover(google-or-tools-devel) weakremover(google-or-tools-minizinc) weakremover(google-osconfig-agent) weakremover(google-startup-scripts) weakremover(google-symbolneu-fonts) weakremover(googletest-devel) weakremover(gops) weakremover(gosec) weakremover(goss) weakremover(gotext) weakremover(gource) weakremover(gourmet) weakremover(gourmet-lang) weakremover(goverlay) weakremover(govpn) weakremover(govpn-server) weakremover(goxel) weakremover(gp2c) weakremover(gpa) weakremover(gpars) weakremover(gpart) weakremover(gparted) weakremover(gpaste) weakremover(gpaste-devel) weakremover(gperf) weakremover(gperftools) weakremover(gperftools-devel) weakremover(gperftools-devel-static) weakremover(gperiodic) weakremover(gpg-offline) weakremover(gpg-pubkey-3d25d3d9-36e12d04) weakremover(gpg2) weakremover(gpg2-tpm) weakremover(gpgme) weakremover(gpgmepp5) weakremover(gpgmepp5-devel) weakremover(gphoto) weakremover(gphoto2-webcam) weakremover(gphotofs) weakremover(gpick) weakremover(gpicview) weakremover(gpm) weakremover(gpm-devel) weakremover(gpp) weakremover(gpredict) weakremover(gpresagemate) weakremover(gprofng) weakremover(gprompter) weakremover(gpsbabel) weakremover(gpsd) weakremover(gpsd-clients) weakremover(gpsd-devel) weakremover(gptfdisk) weakremover(gptfdisk-fixparts) weakremover(gputils) weakremover(gpuvis) weakremover(gpxsee) weakremover(gq) weakremover(gqrx) weakremover(gr-fcdproplus) weakremover(gr-fcdproplus-devel-doc) weakremover(gr-funcube) weakremover(gr-osmosdr) weakremover(gr-osmosdr-devel) weakremover(gr-osmosdr-devel-doc) weakremover(grabpng) weakremover(gradio) weakremover(gradio-lang) weakremover(gradle) weakremover(gradle-local) weakremover(gradle-open-api) weakremover(grafana) weakremover(grafx2) weakremover(grail) weakremover(grail-devel) weakremover(gramofile) weakremover(granatier) weakremover(grandorgue) weakremover(granite-common) weakremover(granite-demo) weakremover(granite-devel) weakremover(grantlee-devel) weakremover(grantlee-editor) weakremover(grantlee5) weakremover(grantlee5-devel) weakremover(grantleetheme) weakremover(grantleetheme-devel) weakremover(graphite2) weakremover(graphite2-devel) weakremover(graphviz) weakremover(graphviz-devel) weakremover(graphviz-doc) weakremover(graphviz-gd) weakremover(graphviz-gnome) weakremover(graphviz-guile) weakremover(graphviz-gvedit) weakremover(graphviz-java) weakremover(graphviz-lua) weakremover(graphviz-perl) weakremover(graphviz-php) weakremover(graphviz-plugins-core) weakremover(graphviz-python) weakremover(graphviz-ruby) weakremover(graphviz-smyrna) weakremover(graphviz-tcl) weakremover(graphviz-webp) weakremover(graphviz-x11) weakremover(grass) weakremover(grass-devel) weakremover(grass-doc) weakremover(greenbone-security-assistant) weakremover(greetd) weakremover(grep) weakremover(grepcidr) weakremover(grfcodec) weakremover(gri) weakremover(grilo-devel) weakremover(grilo-plugin-dleyna) weakremover(grilo-plugin-tracker) weakremover(grilo-plugin-youtube) weakremover(grilo-plugins) weakremover(grilo-plugins-devel) weakremover(grilo-tools) weakremover(grim) weakremover(grisbi) weakremover(groff) weakremover(groff-full) weakremover(gromacs) weakremover(gromacs-devel) weakremover(gromacs-openmpi) weakremover(gromacs-openmpi2) weakremover(gromit) weakremover(gromit-mpx) weakremover(grommunio-index) weakremover(gromox) weakremover(gron) weakremover(groovy) weakremover(groovy-ant) weakremover(groovy-bsf) weakremover(groovy-console) weakremover(groovy-docgenerator) weakremover(groovy-groovydoc) weakremover(groovy-groovysh) weakremover(groovy-jmx) weakremover(groovy-json) weakremover(groovy-jsr223) weakremover(groovy-lib) weakremover(groovy-nio) weakremover(groovy-servlet) weakremover(groovy-sql) weakremover(groovy-swing) weakremover(groovy-templates) weakremover(groovy-test) weakremover(groovy-testng) weakremover(groovy-xml) weakremover(growlight) weakremover(growpart-rootgrow) weakremover(grpc-devel) weakremover(grpc-httpjson-transcoding-devel) weakremover(grsync) weakremover(grub2) weakremover(grub2-arm-efi) weakremover(grub2-arm-uboot) weakremover(grub2-branding-upstream) weakremover(grub2-powerpc-ieee1275) weakremover(grubby) weakremover(grype) weakremover(gsequencer) weakremover(gsequencer-devel) weakremover(gsettings-backend-dconf) weakremover(gsettings-desktop-schemas) weakremover(gsettings-desktop-schemas-devel) weakremover(gsettings-qt) weakremover(gsettings-qt-devel) weakremover(gsf-office-thumbnailer) weakremover(gsignond) weakremover(gsignond-config-upstream) weakremover(gsignond-devel) weakremover(gsignond-doc) weakremover(gsignond-plugin-oauth) weakremover(gsl) weakremover(gsl-devel) weakremover(gsl_2_4-gnu-hpc) weakremover(gsl_2_4-gnu-hpc-devel) weakremover(gsl_2_4-gnu-hpc-doc) weakremover(gsl_2_4-gnu-hpc-examples) weakremover(gsl_2_4-gnu-hpc-module) weakremover(gsl_2_5-gnu-hpc) weakremover(gsl_2_5-gnu-hpc-devel) weakremover(gsl_2_5-gnu-hpc-doc) weakremover(gsl_2_5-gnu-hpc-examples) weakremover(gsl_2_5-gnu-hpc-module) weakremover(gsl_2_6-gnu-hpc) weakremover(gsl_2_6-gnu-hpc-devel) weakremover(gsl_2_6-gnu-hpc-doc) weakremover(gsl_2_6-gnu-hpc-examples) weakremover(gsl_2_6-gnu-hpc-module) weakremover(gsl_2_7_1-gnu-hpc) weakremover(gsl_2_7_1-gnu-hpc-devel) weakremover(gsl_2_7_1-gnu-hpc-module) weakremover(gsmartcontrol) weakremover(gsoap-devel) weakremover(gsound) weakremover(gsound-devel) weakremover(gspell) weakremover(gspell-devel) weakremover(gssdp-utils) weakremover(gssntlmssp) weakremover(gssntlmssp-devel) weakremover(gssproxy) weakremover(gst-rtsp-server-devel) weakremover(gst123) weakremover(gstreamer) weakremover(gstreamer-0_10) weakremover(gstreamer-0_10-devel) weakremover(gstreamer-0_10-doc) weakremover(gstreamer-0_10-lang) weakremover(gstreamer-0_10-plugin-esd) weakremover(gstreamer-0_10-plugin-gnomevfs) weakremover(gstreamer-0_10-plugins-bad) weakremover(gstreamer-0_10-plugins-bad-devel) weakremover(gstreamer-0_10-plugins-bad-doc) weakremover(gstreamer-0_10-plugins-bad-lang) weakremover(gstreamer-0_10-plugins-base) weakremover(gstreamer-0_10-plugins-base-devel) weakremover(gstreamer-0_10-plugins-base-doc) weakremover(gstreamer-0_10-plugins-base-lang) weakremover(gstreamer-0_10-plugins-good) weakremover(gstreamer-0_10-plugins-good-doc) weakremover(gstreamer-0_10-plugins-good-extra) weakremover(gstreamer-0_10-plugins-good-lang) weakremover(gstreamer-0_10-plugins-ugly) weakremover(gstreamer-0_10-plugins-ugly-doc) weakremover(gstreamer-0_10-plugins-ugly-lang) weakremover(gstreamer-0_10-utils) weakremover(gstreamer-0_10-utils-unversioned) weakremover(gstreamer-1_0-plugins-buzztrax) weakremover(gstreamer-devel) weakremover(gstreamer-devtools) weakremover(gstreamer-devtools-devel) weakremover(gstreamer-editing-services) weakremover(gstreamer-editing-services-devel) weakremover(gstreamer-libnice) weakremover(gstreamer-plugin-aravis) weakremover(gstreamer-plugin-cluttergst3) weakremover(gstreamer-plugin-gnonlin) weakremover(gstreamer-plugin-gnonlin-doc) weakremover(gstreamer-plugin-gstclutter) weakremover(gstreamer-plugin-gstclutter-3_0) weakremover(gstreamer-plugin-pipewire) weakremover(gstreamer-plugin-pocketsphinx) weakremover(gstreamer-plugin-python) weakremover(gstreamer-plugins-bad) weakremover(gstreamer-plugins-bad-chromaprint) weakremover(gstreamer-plugins-bad-devel) weakremover(gstreamer-plugins-bad-fluidsynth) weakremover(gstreamer-plugins-base) weakremover(gstreamer-plugins-base-devel) weakremover(gstreamer-plugins-cogl) weakremover(gstreamer-plugins-farstream) weakremover(gstreamer-plugins-good) weakremover(gstreamer-plugins-good-extra) weakremover(gstreamer-plugins-good-gtk) weakremover(gstreamer-plugins-good-jack) weakremover(gstreamer-plugins-good-qtqml) weakremover(gstreamer-plugins-libav) weakremover(gstreamer-plugins-libcamera) weakremover(gstreamer-plugins-qt) weakremover(gstreamer-plugins-qt-devel) weakremover(gstreamer-plugins-qt5) weakremover(gstreamer-plugins-qt5-devel) weakremover(gstreamer-plugins-rs) weakremover(gstreamer-plugins-rs-devel) weakremover(gstreamer-plugins-ugly) weakremover(gstreamer-plugins-vaapi) weakremover(gstreamer-rtsp-server-devel) weakremover(gstreamer-transcoder) weakremover(gstreamer-transcoder-devel) weakremover(gstreamer-utils) weakremover(gstreamer-validate) weakremover(gstreamer-validate-devel) weakremover(gstreamermm-devel) weakremover(gsynaptics) weakremover(gsynaptics-lang) weakremover(gtef-2-lang) weakremover(gtef-devel) weakremover(gtest) weakremover(gthumb) weakremover(gthumb-devel) weakremover(gti) weakremover(gtick) weakremover(gtk-doc) weakremover(gtk-doc-lang) weakremover(gtk-doc-mkpdf) weakremover(gtk-frdp-devel) weakremover(gtk-layer-shell-devel) weakremover(gtk-recordMyDesktop) weakremover(gtk-recordMyDesktop-lang) weakremover(gtk-sharp-beans) weakremover(gtk-sharp-beans-devel) weakremover(gtk-sharp2) weakremover(gtk-sharp2-complete) weakremover(gtk-sharp2-doc) weakremover(gtk-sharp2-gapi) weakremover(gtk-sharp3) weakremover(gtk-sharp3-complete) weakremover(gtk-sharp3-devel) weakremover(gtk-sharp3-doc) weakremover(gtk-sharp3-gapi) weakremover(gtk-sharp3-gapi-devel) weakremover(gtk-vnc-devel) weakremover(gtk-vnc-tools) weakremover(gtk-vnc2-devel) weakremover(gtk-xfce-engine) weakremover(gtk2-devel) weakremover(gtk2-engine-aurora) weakremover(gtk2-engine-cleanice) weakremover(gtk2-engine-clearlooks) weakremover(gtk2-engine-crux) weakremover(gtk2-engine-equinox) weakremover(gtk2-engine-glide) weakremover(gtk2-engine-hcengine) weakremover(gtk2-engine-industrial) weakremover(gtk2-engine-mist) weakremover(gtk2-engine-murrine) weakremover(gtk2-engine-nimbus) weakremover(gtk2-engine-oxygen) weakremover(gtk2-engine-redmond95) weakremover(gtk2-engine-thinice) weakremover(gtk2-engines) weakremover(gtk2-engines-devel) weakremover(gtk2-immodule-amharic) weakremover(gtk2-immodule-inuktitut) weakremover(gtk2-immodule-multipress) weakremover(gtk2-immodule-thai) weakremover(gtk2-immodule-tigrigna) weakremover(gtk2-immodule-vietnamese) weakremover(gtk2-immodule-xim) weakremover(gtk2-immodules-tigrigna) weakremover(gtk2-metatheme-ambiant-mate) weakremover(gtk2-metatheme-equinox) weakremover(gtk2-metatheme-geeko) weakremover(gtk2-metatheme-nimbus) weakremover(gtk2-metatheme-plata) weakremover(gtk2-metatheme-radiant-mate) weakremover(gtk2-theme-oxygen) weakremover(gtk2-themes) weakremover(gtk2-theming-engine-adwaita) weakremover(gtk2-tools) weakremover(gtk2hs-buildtools) weakremover(gtk3-devel) weakremover(gtk3-engine-unico) weakremover(gtk3-immodule-amharic) weakremover(gtk3-immodule-broadway) weakremover(gtk3-immodule-inuktitut) weakremover(gtk3-immodule-multipress) weakremover(gtk3-immodule-thai) weakremover(gtk3-immodule-tigrigna) weakremover(gtk3-immodule-vietnamese) weakremover(gtk3-immodule-wayland) weakremover(gtk3-immodule-xim) weakremover(gtk3-immodules-tigrigna) weakremover(gtk3-metatheme-ambiant-mate) weakremover(gtk3-metatheme-geeko) weakremover(gtk3-metatheme-plata) weakremover(gtk3-metatheme-radiant-mate) weakremover(gtk3-tools) weakremover(gtk4-devel) weakremover(gtk4-devel-tools) weakremover(gtk4-metatheme-plata) weakremover(gtk4-tools) weakremover(gtkam) weakremover(gtkam-doc) weakremover(gtkd-devel) weakremover(gtkdatabox-devel) weakremover(gtkdatabox-devel-examples) weakremover(gtkdatabox-gtk-doc) weakremover(gtkglext-devel) weakremover(gtkglext-doc) weakremover(gtkgreet) weakremover(gtkhtml-devel) weakremover(gtkimageview-devel) weakremover(gtkiterm) weakremover(gtklock) weakremover(gtkmm2-devel) weakremover(gtkmm3-devel) weakremover(gtkmm4-devel) weakremover(gtkparasite) weakremover(gtkpod) weakremover(gtkpod-devel) weakremover(gtksourceview-devel) weakremover(gtksourceview18) weakremover(gtksourceview18-devel) weakremover(gtksourceview18-doc) weakremover(gtksourceview2-devel) weakremover(gtksourceview2-sharp) weakremover(gtksourceview4-devel) weakremover(gtksourceview5-devel) weakremover(gtksourceviewmm-devel) weakremover(gtksourceviewmm3_0-devel) weakremover(gtkspell-devel) weakremover(gtkspell-doc) weakremover(gtkspell3-devel) weakremover(gtkwave) weakremover(gtp-echo-responder) weakremover(gtranslator) weakremover(gtranslator-devel) weakremover(gtranslator-doc) weakremover(gts) weakremover(gts-devel) weakremover(gtypist) weakremover(gtypist-lang) weakremover(guava20) weakremover(guava20-javadoc) weakremover(guava20-testlib) weakremover(gucharmap) weakremover(gucharmap-devel) weakremover(gudev-sharp) weakremover(gudev-sharp-devel) weakremover(guess-changelog) weakremover(guestfs-data) weakremover(guestfs-tools) weakremover(guestfs-winsupport) weakremover(guestfsd) weakremover(gufw) weakremover(gufw-lang) weakremover(guice-testlib) weakremover(guile) weakremover(guile-bytestructures) weakremover(guile-cairo) weakremover(guile-cairo-devel) weakremover(guile-charting) weakremover(guile-devel) weakremover(guile-gcrypt) weakremover(guile-git) weakremover(guile-gnutls) weakremover(guile-json) weakremover(guile-lzlib) weakremover(guile-modules-2_0) weakremover(guile-modules-2_2) weakremover(guile-modules-3_0) weakremover(guile-newt) weakremover(guile-parted) weakremover(guile-sqlite3) weakremover(guile-ssh-devel) weakremover(guile-zlib) weakremover(guile1) weakremover(guitarix) weakremover(guix) weakremover(gulkan-devel) weakremover(gulkan0_15-0) weakremover(gummi) weakremover(gup) weakremover(gupnp-av) weakremover(gupnp-dlna) weakremover(gupnp-dlna-tools) weakremover(gupnp-tools) weakremover(gurlchecker) weakremover(gurlchecker-doc) weakremover(gurlchecker-lang) weakremover(gutenprint) weakremover(gutenprint-devel) weakremover(gutenprint-gimpplugin) weakremover(guvcview) weakremover(guvcview-devel) weakremover(guvcview-qt5) weakremover(gv) weakremover(gvfs) weakremover(gvfs-backend-afc) weakremover(gvfs-backend-goa) weakremover(gvfs-backend-samba) weakremover(gvfs-backends) weakremover(gvfs-devel) weakremover(gvfs-fuse) weakremover(gvim) weakremover(gweather-data) weakremover(gweather4-data) weakremover(gwenhywfar) weakremover(gwenhywfar-devel) weakremover(gwenhywfar-gwenbuild) weakremover(gwenhywfar-tools) weakremover(gwenview5) weakremover(gwget) weakremover(gwget-lang) weakremover(gxditview) weakremover(gypsy) weakremover(gzdoom) weakremover(gzip) weakremover(gzrt) weakremover(h2i) weakremover(h323plus-devel) weakremover(h5utils) weakremover(ha-cluster-bootstrap) weakremover(habootstrap-formula-suma) weakremover(hackbench) weakremover(hackrf) weakremover(hackrf-devel) weakremover(hackrf-udev) weakremover(hactool) weakremover(hadolint) weakremover(haguichi) weakremover(hamlib) weakremover(hamlib-devel) weakremover(hanadb_exporter) weakremover(handwriting) weakremover(hapistrano) weakremover(happy) weakremover(haproxy) weakremover(hardening-check) weakremover(hardlink) weakremover(harfbuzz-devel) weakremover(harfbuzz-tools) weakremover(harminv) weakremover(harminv-devel) weakremover(haruna) weakremover(haserl) weakremover(hashalot) weakremover(hashdeep) weakremover(hashlink) weakremover(hashlink-devel) weakremover(hashlink-hdlls) weakremover(haskintex) weakremover(haveged) weakremover(haveged-devel) weakremover(hawk-apiserver) weakremover(hawk2) weakremover(hawknl-devel) weakremover(hawknl-libs) weakremover(hawtbuf) weakremover(hawtbuf-javadoc) weakremover(hawtbuf-proto) weakremover(hawtbuf-protoc) weakremover(hawtjni) weakremover(hawtjni-javadoc) weakremover(hawtjni-maven-plugin) weakremover(hawtjni-maven-plugin-javadoc) weakremover(hawtjni-runtime) weakremover(haxe) weakremover(hbci4java) weakremover(hcode) weakremover(hda-verb) weakremover(hdajackretask) weakremover(hdajacksensetest) weakremover(hddtemp) weakremover(hdevtools) weakremover(hdf) weakremover(hdf-devel) weakremover(hdf-devel-data) weakremover(hdf-devel-static) weakremover(hdf-openmpi) weakremover(hdf-openmpi-devel) weakremover(hdf-openmpi-devel-static) weakremover(hdf5) weakremover(hdf5-devel) weakremover(hdf5-devel-data) weakremover(hdf5-devel-static) weakremover(hdf5-examples) weakremover(hdf5-mvapich2) weakremover(hdf5-mvapich2-devel) weakremover(hdf5-mvapich2-devel-static) weakremover(hdf5-openmpi) weakremover(hdf5-openmpi-devel) weakremover(hdf5-openmpi-devel-static) weakremover(hdf5-openmpi1) weakremover(hdf5-openmpi1-devel) weakremover(hdf5-openmpi1-devel-static) weakremover(hdf5-openmpi2) weakremover(hdf5-openmpi2-devel) weakremover(hdf5-openmpi2-devel-static) weakremover(hdf5-openmpi3) weakremover(hdf5-openmpi3-devel) weakremover(hdf5-openmpi3-devel-static) weakremover(hdf5-openmpi4) weakremover(hdf5-openmpi4-devel) weakremover(hdf5-openmpi4-devel-static) weakremover(hdf5_1_10_1-gnu-hpc) weakremover(hdf5_1_10_1-gnu-hpc-devel) weakremover(hdf5_1_10_1-gnu-hpc-devel-static) weakremover(hdf5_1_10_1-gnu-hpc-module) weakremover(hdf5_1_10_1-gnu-mpich-hpc) weakremover(hdf5_1_10_1-gnu-mpich-hpc-devel) weakremover(hdf5_1_10_1-gnu-mpich-hpc-devel-static) weakremover(hdf5_1_10_1-gnu-mpich-hpc-module) weakremover(hdf5_1_10_1-gnu-mvapich2-hpc) weakremover(hdf5_1_10_1-gnu-mvapich2-hpc-devel) weakremover(hdf5_1_10_1-gnu-mvapich2-hpc-devel-static) weakremover(hdf5_1_10_1-gnu-mvapich2-hpc-module) weakremover(hdf5_1_10_1-gnu-openmpi1-hpc) weakremover(hdf5_1_10_1-gnu-openmpi1-hpc-devel) weakremover(hdf5_1_10_1-gnu-openmpi1-hpc-devel-static) weakremover(hdf5_1_10_1-gnu-openmpi1-hpc-module) weakremover(hdf5_1_10_1-gnu-openmpi2-hpc) weakremover(hdf5_1_10_1-gnu-openmpi2-hpc-devel) weakremover(hdf5_1_10_1-gnu-openmpi2-hpc-devel-static) weakremover(hdf5_1_10_1-gnu-openmpi2-hpc-module) weakremover(hdf5_1_10_1-gnu-openmpi3-hpc) weakremover(hdf5_1_10_1-gnu-openmpi3-hpc-devel) weakremover(hdf5_1_10_1-gnu-openmpi3-hpc-devel-static) weakremover(hdf5_1_10_1-gnu-openmpi3-hpc-module) weakremover(hdf5_1_10_4-gnu-hpc) weakremover(hdf5_1_10_4-gnu-hpc-devel) weakremover(hdf5_1_10_4-gnu-hpc-devel-static) weakremover(hdf5_1_10_4-gnu-hpc-module) weakremover(hdf5_1_10_4-gnu-mpich-hpc) weakremover(hdf5_1_10_4-gnu-mpich-hpc-devel) weakremover(hdf5_1_10_4-gnu-mpich-hpc-devel-static) weakremover(hdf5_1_10_4-gnu-mpich-hpc-module) weakremover(hdf5_1_10_4-gnu-mvapich2-hpc) weakremover(hdf5_1_10_4-gnu-mvapich2-hpc-devel) weakremover(hdf5_1_10_4-gnu-mvapich2-hpc-devel-static) weakremover(hdf5_1_10_4-gnu-mvapich2-hpc-module) weakremover(hdf5_1_10_4-gnu-openmpi1-hpc) weakremover(hdf5_1_10_4-gnu-openmpi1-hpc-devel) weakremover(hdf5_1_10_4-gnu-openmpi1-hpc-devel-static) weakremover(hdf5_1_10_4-gnu-openmpi1-hpc-module) weakremover(hdf5_1_10_4-gnu-openmpi2-hpc) weakremover(hdf5_1_10_4-gnu-openmpi2-hpc-devel) weakremover(hdf5_1_10_4-gnu-openmpi2-hpc-devel-static) weakremover(hdf5_1_10_4-gnu-openmpi2-hpc-module) weakremover(hdf5_1_10_4-gnu-openmpi3-hpc) weakremover(hdf5_1_10_4-gnu-openmpi3-hpc-devel) weakremover(hdf5_1_10_4-gnu-openmpi3-hpc-devel-static) weakremover(hdf5_1_10_4-gnu-openmpi3-hpc-module) weakremover(hdf5_1_10_4-hpc-examples) weakremover(hdf5_1_10_5-gnu-hpc) weakremover(hdf5_1_10_5-gnu-hpc-devel) weakremover(hdf5_1_10_5-gnu-hpc-devel-static) weakremover(hdf5_1_10_5-gnu-hpc-module) weakremover(hdf5_1_10_5-gnu-mpich-hpc) weakremover(hdf5_1_10_5-gnu-mpich-hpc-devel) weakremover(hdf5_1_10_5-gnu-mpich-hpc-devel-static) weakremover(hdf5_1_10_5-gnu-mpich-hpc-module) weakremover(hdf5_1_10_5-gnu-mvapich2-hpc) weakremover(hdf5_1_10_5-gnu-mvapich2-hpc-devel) weakremover(hdf5_1_10_5-gnu-mvapich2-hpc-devel-static) weakremover(hdf5_1_10_5-gnu-mvapich2-hpc-module) weakremover(hdf5_1_10_5-gnu-openmpi1-hpc) weakremover(hdf5_1_10_5-gnu-openmpi1-hpc-devel) weakremover(hdf5_1_10_5-gnu-openmpi1-hpc-devel-static) weakremover(hdf5_1_10_5-gnu-openmpi1-hpc-module) weakremover(hdf5_1_10_5-gnu-openmpi2-hpc) weakremover(hdf5_1_10_5-gnu-openmpi2-hpc-devel) weakremover(hdf5_1_10_5-gnu-openmpi2-hpc-devel-static) weakremover(hdf5_1_10_5-gnu-openmpi2-hpc-module) weakremover(hdf5_1_10_5-gnu-openmpi3-hpc) weakremover(hdf5_1_10_5-gnu-openmpi3-hpc-devel) weakremover(hdf5_1_10_5-gnu-openmpi3-hpc-devel-static) weakremover(hdf5_1_10_5-gnu-openmpi3-hpc-module) weakremover(hdf5_1_10_5-gnu-openmpi4-hpc) weakremover(hdf5_1_10_5-gnu-openmpi4-hpc-devel) weakremover(hdf5_1_10_5-gnu-openmpi4-hpc-devel-static) weakremover(hdf5_1_10_5-gnu-openmpi4-hpc-module) weakremover(hdf5_1_10_5-hpc-examples) weakremover(hdf5_1_10_7-gnu-hpc) weakremover(hdf5_1_10_7-gnu-hpc-devel) weakremover(hdf5_1_10_7-gnu-hpc-devel-static) weakremover(hdf5_1_10_7-gnu-hpc-module) weakremover(hdf5_1_10_7-gnu-mpich-hpc) weakremover(hdf5_1_10_7-gnu-mpich-hpc-devel) weakremover(hdf5_1_10_7-gnu-mpich-hpc-devel-static) weakremover(hdf5_1_10_7-gnu-mpich-hpc-module) weakremover(hdf5_1_10_7-gnu-mvapich2-hpc) weakremover(hdf5_1_10_7-gnu-mvapich2-hpc-devel) weakremover(hdf5_1_10_7-gnu-mvapich2-hpc-devel-static) weakremover(hdf5_1_10_7-gnu-mvapich2-hpc-module) weakremover(hdf5_1_10_7-gnu-openmpi1-hpc) weakremover(hdf5_1_10_7-gnu-openmpi1-hpc-devel) weakremover(hdf5_1_10_7-gnu-openmpi1-hpc-devel-static) weakremover(hdf5_1_10_7-gnu-openmpi1-hpc-module) weakremover(hdf5_1_10_7-gnu-openmpi2-hpc) weakremover(hdf5_1_10_7-gnu-openmpi2-hpc-devel) weakremover(hdf5_1_10_7-gnu-openmpi2-hpc-devel-static) weakremover(hdf5_1_10_7-gnu-openmpi2-hpc-module) weakremover(hdf5_1_10_7-gnu-openmpi3-hpc) weakremover(hdf5_1_10_7-gnu-openmpi3-hpc-devel) weakremover(hdf5_1_10_7-gnu-openmpi3-hpc-devel-static) weakremover(hdf5_1_10_7-gnu-openmpi3-hpc-module) weakremover(hdf5_1_10_7-gnu-openmpi4-hpc) weakremover(hdf5_1_10_7-gnu-openmpi4-hpc-devel) weakremover(hdf5_1_10_7-gnu-openmpi4-hpc-devel-static) weakremover(hdf5_1_10_7-gnu-openmpi4-hpc-module) weakremover(hdf5_1_10_7-hpc-examples) weakremover(hdf5_1_10_8-gnu-hpc) weakremover(hdf5_1_10_8-gnu-hpc-devel) weakremover(hdf5_1_10_8-gnu-hpc-devel-static) weakremover(hdf5_1_10_8-gnu-hpc-module) weakremover(hdf5_1_10_8-gnu-mpich-hpc) weakremover(hdf5_1_10_8-gnu-mpich-hpc-devel) weakremover(hdf5_1_10_8-gnu-mpich-hpc-devel-static) weakremover(hdf5_1_10_8-gnu-mpich-hpc-module) weakremover(hdf5_1_10_8-gnu-mvapich2-hpc) weakremover(hdf5_1_10_8-gnu-mvapich2-hpc-devel) weakremover(hdf5_1_10_8-gnu-mvapich2-hpc-devel-static) weakremover(hdf5_1_10_8-gnu-mvapich2-hpc-module) weakremover(hdf5_1_10_8-gnu-openmpi1-hpc) weakremover(hdf5_1_10_8-gnu-openmpi1-hpc-devel) weakremover(hdf5_1_10_8-gnu-openmpi1-hpc-devel-static) weakremover(hdf5_1_10_8-gnu-openmpi1-hpc-module) weakremover(hdf5_1_10_8-gnu-openmpi2-hpc) weakremover(hdf5_1_10_8-gnu-openmpi2-hpc-devel) weakremover(hdf5_1_10_8-gnu-openmpi2-hpc-devel-static) weakremover(hdf5_1_10_8-gnu-openmpi2-hpc-module) weakremover(hdf5_1_10_8-gnu-openmpi3-hpc) weakremover(hdf5_1_10_8-gnu-openmpi3-hpc-devel) weakremover(hdf5_1_10_8-gnu-openmpi3-hpc-devel-static) weakremover(hdf5_1_10_8-gnu-openmpi3-hpc-module) weakremover(hdf5_1_10_8-gnu-openmpi4-hpc) weakremover(hdf5_1_10_8-gnu-openmpi4-hpc-devel) weakremover(hdf5_1_10_8-gnu-openmpi4-hpc-devel-static) weakremover(hdf5_1_10_8-gnu-openmpi4-hpc-module) weakremover(hdf5_1_10_8-hpc-examples) weakremover(hdf5_1_12_2-gnu-hpc) weakremover(hdf5_1_12_2-gnu-hpc-devel) weakremover(hdf5_1_12_2-gnu-hpc-devel-static) weakremover(hdf5_1_12_2-gnu-hpc-module) weakremover(hdf5_1_12_2-gnu-mpich-hpc) weakremover(hdf5_1_12_2-gnu-mpich-hpc-devel) weakremover(hdf5_1_12_2-gnu-mpich-hpc-devel-static) weakremover(hdf5_1_12_2-gnu-mpich-hpc-module) weakremover(hdf5_1_12_2-gnu-mvapich2-hpc) weakremover(hdf5_1_12_2-gnu-mvapich2-hpc-devel) weakremover(hdf5_1_12_2-gnu-mvapich2-hpc-devel-static) weakremover(hdf5_1_12_2-gnu-mvapich2-hpc-module) weakremover(hdf5_1_12_2-gnu-openmpi1-hpc) weakremover(hdf5_1_12_2-gnu-openmpi1-hpc-devel) weakremover(hdf5_1_12_2-gnu-openmpi1-hpc-devel-static) weakremover(hdf5_1_12_2-gnu-openmpi1-hpc-module) weakremover(hdf5_1_12_2-gnu-openmpi2-hpc) weakremover(hdf5_1_12_2-gnu-openmpi2-hpc-devel) weakremover(hdf5_1_12_2-gnu-openmpi2-hpc-devel-static) weakremover(hdf5_1_12_2-gnu-openmpi2-hpc-module) weakremover(hdf5_1_12_2-gnu-openmpi3-hpc) weakremover(hdf5_1_12_2-gnu-openmpi3-hpc-devel) weakremover(hdf5_1_12_2-gnu-openmpi3-hpc-devel-static) weakremover(hdf5_1_12_2-gnu-openmpi3-hpc-module) weakremover(hdf5_1_12_2-gnu-openmpi4-hpc) weakremover(hdf5_1_12_2-gnu-openmpi4-hpc-devel) weakremover(hdf5_1_12_2-gnu-openmpi4-hpc-devel-static) weakremover(hdf5_1_12_2-gnu-openmpi4-hpc-module) weakremover(hdf5_1_12_2-hpc-examples) weakremover(hdhomerun_config) weakremover(hdhomerun_config_gui) weakremover(hdjmod-kmp-64kb) weakremover(hdjmod-kmp-default) weakremover(hdparm) weakremover(hdspconf) weakremover(hdsploader) weakremover(hdspmixer) weakremover(headmore) weakremover(healpix) weakremover(healpix_cxx-devel) weakremover(health-check) weakremover(heapster) weakremover(heaptrack) weakremover(heaptrack-devel) weakremover(heaptrack-gui) weakremover(hedgewars) weakremover(heimdall) weakremover(heimdall-frontend) weakremover(heimer) weakremover(helix) weakremover(helix-runtime) weakremover(hello) weakremover(hello-kubic) weakremover(helm) weakremover(helm-docs) weakremover(helm-mirror) weakremover(helmfile) weakremover(helmfile-bash-completion) weakremover(helmfile-zsh-completion) weakremover(helmify) weakremover(help2man) weakremover(helvum) weakremover(herbstluftwm) weakremover(hercules) weakremover(heroes-tron) weakremover(herqq-devel) weakremover(hevea) weakremover(hex) weakremover(hex2bin) weakremover(hexchat) weakremover(hexchat-devel) weakremover(hexchat-plugins-lua) weakremover(hexchat-plugins-perl) weakremover(hexchat-plugins-python3) weakremover(hexd) weakremover(hexedit) weakremover(hexter) weakremover(hexyl) weakremover(hfst) weakremover(hfst-devel) weakremover(hfst-ospell) weakremover(hfst-ospell-devel) weakremover(hfsutils) weakremover(hg-fast-export) weakremover(hg-git) weakremover(hgview) weakremover(hgview-qt4) weakremover(hhdate) weakremover(hhdate-devel) weakremover(hiawatha) weakremover(hiawatha-letsencrypt) weakremover(hibiscus) weakremover(hidviz) weakremover(highlight) weakremover(highlight-gui) weakremover(highlighting-kate) weakremover(highway-devel) weakremover(himalaya) weakremover(himeno) weakremover(hindent) weakremover(hiredis) weakremover(hiredis-devel) weakremover(hitori) weakremover(hivelytracker) weakremover(hivex) weakremover(hivex-devel) weakremover(hledger) weakremover(hledger-api) weakremover(hledger-interest) weakremover(hledger-ui) weakremover(hledger-web) weakremover(hlint) weakremover(hmaccalc) weakremover(hmcfgusb) weakremover(hmconv) weakremover(hoard) weakremover(holy-project) weakremover(homebank) weakremover(honggfuzz) weakremover(hoogle) weakremover(horst) weakremover(hostap-utils) weakremover(hostapd) weakremover(hostname) weakremover(hotdoc) weakremover(hotspot) weakremover(hourglass) weakremover(hp-drive-guard) weakremover(hp2xx) weakremover(hpack) weakremover(hpc-coveralls) weakremover(hping) weakremover(hping-doc) weakremover(hplip) weakremover(hplip-devel) weakremover(hplip-hpijs) weakremover(hplip-sane) weakremover(hplip-scan-utils) weakremover(hplip-udev-rules) weakremover(hpx) weakremover(hpx-devel) weakremover(hpx-devel-static) weakremover(hsb2hs) weakremover(hscolour) weakremover(hsetroot) weakremover(hspec-discover) weakremover(ht) weakremover(ht2html) weakremover(htcondor) weakremover(htcondor-bosco) weakremover(htcondor-classads) weakremover(htcondor-classads-devel) weakremover(htcondor-credmon-oauth) weakremover(htcondor-credmon-vault) weakremover(htcondor-devel) weakremover(htcondor-doc) weakremover(htcondor-kbdd) weakremover(htcondor-procd) weakremover(htcondor-vm-gahp) weakremover(htdig) weakremover(htdig-devel) weakremover(htdig-doc) weakremover(hte) weakremover(html-xml-utils) weakremover(htmlcxx) weakremover(htmlcxx-devel) weakremover(htmldoc) weakremover(htop) weakremover(htscodecs-devel) weakremover(htsfile) weakremover(http-builder) weakremover(http-builder-javadoc) weakremover(http-parser-devel) weakremover(httperf) weakremover(httrack) weakremover(httrack-devel) weakremover(hub) weakremover(hugin) weakremover(hugo) weakremover(hunspell) weakremover(hunspell-devel) weakremover(hunspell-static) weakremover(hunspell-tools) weakremover(hut) weakremover(hwinfo) weakremover(hwinfo-devel) weakremover(hwloc) weakremover(hwloc-devel) weakremover(hwloc-lstopo) weakremover(hwmixvolume) weakremover(hxtools) weakremover(hydrogen) weakremover(hyena) weakremover(hylafax+) weakremover(hylafax+-client) weakremover(hyper-v) weakremover(hyperfine) weakremover(hyperlink-app-client) weakremover(hyphen) weakremover(hyphen-devel) weakremover(hypre-devel) weakremover(hypre-doc) weakremover(hypre-examples) weakremover(hypre-mpich-devel) weakremover(hypre-mvapich2-devel) weakremover(hypre-openmpi-devel) weakremover(hypre-openmpi1-devel) weakremover(hypre-openmpi2-devel) weakremover(hypre-openmpi3-devel) weakremover(hypre-openmpi4-devel) weakremover(hypre_2_15_1-gnu-mpich-hpc-devel) weakremover(hypre_2_15_1-gnu-mvapich2-hpc-devel) weakremover(hypre_2_15_1-gnu-openmpi1-hpc-devel) weakremover(hypre_2_15_1-gnu-openmpi2-hpc-devel) weakremover(hypre_2_15_1-gnu-openmpi3-hpc-devel) weakremover(hypre_2_17_0-gnu-mpich-hpc-devel) weakremover(hypre_2_17_0-gnu-mvapich2-hpc-devel) weakremover(hypre_2_17_0-gnu-openmpi1-hpc-devel) weakremover(hypre_2_17_0-gnu-openmpi2-hpc-devel) weakremover(hypre_2_17_0-gnu-openmpi3-hpc-devel) weakremover(hypre_2_18_2-gnu-mpich-hpc-devel) weakremover(hypre_2_18_2-gnu-mvapich2-hpc-devel) weakremover(hypre_2_18_2-gnu-openmpi1-hpc-devel) weakremover(hypre_2_18_2-gnu-openmpi2-hpc-devel) weakremover(hypre_2_18_2-gnu-openmpi3-hpc-devel) weakremover(hypre_2_18_2-gnu-openmpi4-hpc-devel) weakremover(hypre_2_20_0-gnu-mpich-hpc-devel) weakremover(hypre_2_20_0-gnu-mvapich2-hpc-devel) weakremover(hypre_2_20_0-gnu-openmpi1-hpc-devel) weakremover(hypre_2_20_0-gnu-openmpi2-hpc-devel) weakremover(hypre_2_20_0-gnu-openmpi3-hpc-devel) weakremover(hypre_2_20_0-gnu-openmpi4-hpc-devel) weakremover(hyprland) weakremover(i2c-tools) weakremover(i2pd) weakremover(i3) weakremover(i3-devel) weakremover(i3-gaps) weakremover(i3-gaps-devel) weakremover(i3blocks) weakremover(i3lock) weakremover(i3lock-xlock-compat) weakremover(i3status) weakremover(i3status-rust) weakremover(i4l-base) weakremover(i4l-isdnlog) weakremover(i4l-vbox) weakremover(i4lfirm) weakremover(iagno) weakremover(ibacm) weakremover(ibacm-devel) weakremover(ibm-data-db2) weakremover(ibmrtpkgs) weakremover(ibmswtpm2) weakremover(ibmtss) weakremover(ibmtss-devel) weakremover(ibsim) weakremover(ibus) weakremover(ibus-anthy) weakremover(ibus-anthy-devel) weakremover(ibus-branding-openSUSE-KDE) weakremover(ibus-chewing) weakremover(ibus-devel) weakremover(ibus-googlepinyin) weakremover(ibus-gtk) weakremover(ibus-gtk3) weakremover(ibus-gtk4) weakremover(ibus-hangul) weakremover(ibus-input-pad) weakremover(ibus-kkc) weakremover(ibus-libpinyin) weakremover(ibus-libzhuyin) weakremover(ibus-m17n) weakremover(ibus-mozc) weakremover(ibus-mozc-candidate-window) weakremover(ibus-pinyin) weakremover(ibus-qt) weakremover(ibus-qt-devel) weakremover(ibus-rime) weakremover(ibus-skk) weakremover(ibus-sunpinyin) weakremover(ibus-table) weakremover(ibus-table-devel) weakremover(ibus-table-zhengma) weakremover(ibus-table-zhuyin) weakremover(ibus-table-ziranma) weakremover(ibus-typing-booster) weakremover(ibus-unikey) weakremover(ibutils) weakremover(ibutils-devel) weakremover(ibutils-devel-static) weakremover(ibutils-ui) weakremover(ibvexdmtools) weakremover(icc-examin) weakremover(icc-examin-lang) weakremover(icc-profiles-scp-argyll) weakremover(icc-profiles-scp-fogra) weakremover(icc-profiles-scp-oysonar) weakremover(icc-profiles-scp-yamma) weakremover(iceWMCP) weakremover(iceWMCP-addons) weakremover(iceauth) weakremover(icebreaker) weakremover(icecast) weakremover(icecream) weakremover(icecream-clang-wrappers) weakremover(icecream-monitor) weakremover(icedax) weakremover(icedtea-web) weakremover(ices) weakremover(icewm) weakremover(icewm-default) weakremover(icewm-lite) weakremover(icinga) weakremover(icinga-devel) weakremover(icinga-doc) weakremover(icinga-idoutils) weakremover(icinga-idoutils-mysql) weakremover(icinga-idoutils-oracle) weakremover(icinga-idoutils-pgsql) weakremover(icinga-plugins-downtimes) weakremover(icinga-plugins-eventhandlers) weakremover(icinga-www) weakremover(icinga-www-config) weakremover(icinga2) weakremover(icinga2-bin) weakremover(icinga2-common) weakremover(icinga2-doc) weakremover(icinga2-ido-mysql) weakremover(icinga2-ido-pgsql) weakremover(icinga2-libs) weakremover(icmake) weakremover(icmpinfo) weakremover(icmptunnel) weakremover(icns-utils) weakremover(ico) weakremover(icoutils) weakremover(icu) weakremover(icu-data) weakremover(id3lib) weakremover(id3lib-devel) weakremover(id3lib-examples) weakremover(id3v2) weakremover(idep) weakremover(ido-devel) weakremover(idutils) weakremover(idzebra) weakremover(idzebra-devel) weakremover(idzebra-doc) weakremover(iec16022) weakremover(ifplugd) weakremover(iftop) weakremover(ifuse) weakremover(ignition) weakremover(ignition-config-transpiler) weakremover(ignition-dracut) weakremover(ignition-dracut-grub2) weakremover(ignuit) weakremover(iio-sensor-proxy) weakremover(ikona) weakremover(iksemel) weakremover(iksemel-devel) weakremover(ilbc-devel) weakremover(ilmbase-devel) weakremover(ima-evm-utils-devel) weakremover(ima-inspect) weakremover(imageburner) weakremover(imagewriter) weakremover(imake) weakremover(imap) weakremover(imap-devel) weakremover(imapfilter) weakremover(imb) weakremover(imb-mpich) weakremover(imb-mvapich2) weakremover(imb-openmpi) weakremover(imb-openmpi1) weakremover(imb-openmpi2) weakremover(imb-openmpi3) weakremover(imb-openmpi4) weakremover(imb_2019_1-gnu-mpich-hpc) weakremover(imb_2019_1-gnu-mvapich2-hpc) weakremover(imb_2019_1-gnu-openmpi1-hpc) weakremover(imb_2019_1-gnu-openmpi2-hpc) weakremover(imb_2019_1-gnu-openmpi3-hpc) weakremover(imb_2019_3-gnu-mpich-hpc) weakremover(imb_2019_3-gnu-mvapich2-hpc) weakremover(imb_2019_3-gnu-openmpi1-hpc) weakremover(imb_2019_3-gnu-openmpi2-hpc) weakremover(imb_2019_3-gnu-openmpi3-hpc) weakremover(imb_2019_6-gnu-mpich-hpc) weakremover(imb_2019_6-gnu-mvapich2-hpc) weakremover(imb_2019_6-gnu-openmpi1-hpc) weakremover(imb_2019_6-gnu-openmpi2-hpc) weakremover(imb_2019_6-gnu-openmpi3-hpc) weakremover(imb_2019_6-gnu-openmpi4-hpc) weakremover(imb_2021_2-gnu-mpich-hpc) weakremover(imb_2021_2-gnu-mvapich2-hpc) weakremover(imb_2021_2-gnu-openmpi1-hpc) weakremover(imb_2021_2-gnu-openmpi2-hpc) weakremover(imb_2021_2-gnu-openmpi3-hpc) weakremover(imb_2021_2-gnu-openmpi4-hpc) weakremover(imb_2021_3-gnu-mpich-hpc) weakremover(imb_2021_3-gnu-mvapich2-hpc) weakremover(imb_2021_3-gnu-openmpi1-hpc) weakremover(imb_2021_3-gnu-openmpi2-hpc) weakremover(imb_2021_3-gnu-openmpi3-hpc) weakremover(imb_2021_3-gnu-openmpi4-hpc) weakremover(imgen) weakremover(imgui-devel) weakremover(imgvtopgm) weakremover(imhangul) weakremover(iml-devel) weakremover(imlib2) weakremover(imlib2-devel) weakremover(imlib2-filters) weakremover(imlib2-loaders) weakremover(imobiledevice-tools) weakremover(imv) weakremover(imwheel) weakremover(imx-usb-loader) weakremover(inarpd) weakremover(inchi) weakremover(inchi-devel) weakremover(incidenceeditor) weakremover(incidenceeditor-devel) weakremover(incidenceeditor-lang) weakremover(include-what-you-use) weakremover(indent) weakremover(indi) weakremover(indi-devel) weakremover(indi-plugins) weakremover(indicator-common) weakremover(ineffassign) weakremover(infiniband-diags) weakremover(infiniband-diags-devel) weakremover(infiniband-diags-devel-static) weakremover(infinoted) weakremover(influxdb) weakremover(influxdb-devel) weakremover(info) weakremover(info4) weakremover(initviocons) weakremover(injeqt-devel) weakremover(inkscape) weakremover(inkscape-extensions-dia) weakremover(inkscape-extensions-extra) weakremover(inkscape-extensions-fig) weakremover(inkscape-extensions-gimp) weakremover(inkscape-extensions-scribus) weakremover(inkscape-extensions-skencil) weakremover(inn) weakremover(inn-devel) weakremover(innoextract) weakremover(inotify-tools) weakremover(inotify-tools-devel) weakremover(input-pad) weakremover(input-pad-devel) weakremover(input-pad-eek) weakremover(input-pad-xtest) weakremover(insighttoolkit-devel) weakremover(inspectrum) weakremover(insserv-compat) weakremover(install-initrd-Kubic) weakremover(install-initrd-MicroOS) weakremover(install-initrd-openSUSE) weakremover(installation-images-Kubic) weakremover(installation-images-MicroOS) weakremover(installation-images-debuginfodeps-MicroOS) weakremover(installation-images-debuginfodeps-openSUSE) weakremover(installation-images-openSUSE) weakremover(interbench) weakremover(interceptty) weakremover(intero) weakremover(iodbc) weakremover(iodbc-admin) weakremover(iodine) weakremover(ioping) weakremover(ioquake3) weakremover(ioquake3-devel) weakremover(ior) weakremover(iotop) weakremover(iotop-c) weakremover(iouyap) weakremover(ip2unix) weakremover(ip6addr) weakremover(ipcalc) weakremover(iperf) weakremover(iperf-devel) weakremover(ipmitool) weakremover(ipmiutil) weakremover(ipmiutil-devel) weakremover(ipmiutil-static) weakremover(iprange) weakremover(iproute2) weakremover(iproute2-arpd) weakremover(iproute2-bash-completion) weakremover(iproute2-doc) weakremover(iproxy) weakremover(ipsec-tools) weakremover(ipset) weakremover(ipset-devel) weakremover(ipset-kmp-default) weakremover(iptables) weakremover(iptables-backend-nft) weakremover(iptables-nft) weakremover(iptraf-ng) weakremover(iputils) weakremover(ipv6toolkit) weakremover(ipvsadm) weakremover(ipxe-bootimgs) weakremover(ipxrip) weakremover(irda) weakremover(irman-common) weakremover(irman-utils) weakremover(irqbalance) weakremover(irqbalance-ui) weakremover(irqd) weakremover(irrlicht-data) weakremover(irrlicht-devel) weakremover(irssi) weakremover(irssi-devel) weakremover(irssi-extra) weakremover(irssi-otr) weakremover(isatapd) weakremover(iscsiuio) weakremover(isight-firmware-tools) weakremover(isl-devel) weakremover(ispc) weakremover(ispc-devel) weakremover(ispell) weakremover(ispell-american) weakremover(ispell-brazilian) weakremover(ispell-british) weakremover(ispell-catalan) weakremover(ispell-czech) weakremover(ispell-danish) weakremover(ispell-dutch) weakremover(ispell-esperanto) weakremover(ispell-estonian) weakremover(ispell-finnish) weakremover(ispell-french) weakremover(ispell-german) weakremover(ispell-greek) weakremover(ispell-italian) weakremover(ispell-naustrian) weakremover(ispell-ngerman) weakremover(ispell-norsk) weakremover(ispell-nswiss) weakremover(ispell-polish) weakremover(ispell-portuguese) weakremover(ispell-russian) weakremover(ispell-slovene) weakremover(ispell-spanish) weakremover(ispell-swedish) weakremover(istgt) weakremover(istioctl) weakremover(isync) weakremover(it2play) weakremover(itinerary) weakremover(itk) weakremover(itpp-devel) weakremover(itpp-doc) weakremover(iverilog) weakremover(iverilog-devel) weakremover(ivykis-devel) weakremover(iw) weakremover(iwd) weakremover(iwpmd) weakremover(iwscanner) weakremover(jack) weakremover(jack-example-tools) weakremover(jack-rack) weakremover(jackEQ) weakremover(jack_capture) weakremover(jackson) weakremover(jackson-javadoc) weakremover(jacktrip) weakremover(jaero) weakremover(jaf-javadoc) weakremover(jag) weakremover(jag-editor) weakremover(jag-level-editor) weakremover(jailbreak-cabal) weakremover(jakarta-commons-compress-javadoc) weakremover(jakarta-commons-dbcp-javadoc) weakremover(jakarta-commons-dbcp-src) weakremover(jakarta-commons-digester-javadoc) weakremover(jakarta-commons-fileupload-javadoc) weakremover(jakarta-commons-net-javadoc) weakremover(jakarta-commons-pool-javadoc) weakremover(jakarta-commons-pool-tomcat5) weakremover(jakarta-commons-transaction-javadoc) weakremover(jamin) weakremover(jansi) weakremover(jansi-native) weakremover(jansi-native-javadoc) weakremover(janus-gateway) weakremover(janus-gateway-devel) weakremover(jasper) weakremover(java-10-openjdk) weakremover(java-10-openjdk-accessibility) weakremover(java-10-openjdk-demo) weakremover(java-10-openjdk-devel) weakremover(java-10-openjdk-headless) weakremover(java-10-openjdk-jmods) weakremover(java-10-openjdk-src) weakremover(java-11-openj9) weakremover(java-11-openj9-accessibility) weakremover(java-11-openj9-demo) weakremover(java-11-openj9-devel) weakremover(java-11-openj9-headless) weakremover(java-11-openj9-jmods) weakremover(java-11-openj9-src) weakremover(java-11-openjdk) weakremover(java-11-openjdk-accessibility) weakremover(java-11-openjdk-demo) weakremover(java-11-openjdk-devel) weakremover(java-11-openjdk-headless) weakremover(java-11-openjdk-jmods) weakremover(java-11-openjdk-src) weakremover(java-12-openjdk) weakremover(java-12-openjdk-accessibility) weakremover(java-12-openjdk-demo) weakremover(java-12-openjdk-devel) weakremover(java-12-openjdk-headless) weakremover(java-12-openjdk-javadoc) weakremover(java-12-openjdk-jmods) weakremover(java-12-openjdk-src) weakremover(java-13-openjdk) weakremover(java-13-openjdk-accessibility) weakremover(java-13-openjdk-demo) weakremover(java-13-openjdk-devel) weakremover(java-13-openjdk-headless) weakremover(java-13-openjdk-jmods) weakremover(java-13-openjdk-src) weakremover(java-14-openjdk) weakremover(java-14-openjdk-accessibility) weakremover(java-14-openjdk-demo) weakremover(java-14-openjdk-devel) weakremover(java-14-openjdk-headless) weakremover(java-14-openjdk-javadoc) weakremover(java-14-openjdk-jmods) weakremover(java-14-openjdk-src) weakremover(java-15-openjdk) weakremover(java-15-openjdk-accessibility) weakremover(java-15-openjdk-demo) weakremover(java-15-openjdk-devel) weakremover(java-15-openjdk-headless) weakremover(java-15-openjdk-jmods) weakremover(java-15-openjdk-src) weakremover(java-16-openjdk) weakremover(java-16-openjdk-accessibility) weakremover(java-16-openjdk-demo) weakremover(java-16-openjdk-devel) weakremover(java-16-openjdk-headless) weakremover(java-16-openjdk-javadoc) weakremover(java-16-openjdk-jmods) weakremover(java-16-openjdk-src) weakremover(java-17-openj9) weakremover(java-17-openj9-accessibility) weakremover(java-17-openj9-demo) weakremover(java-17-openj9-devel) weakremover(java-17-openj9-headless) weakremover(java-17-openj9-jmods) weakremover(java-17-openj9-src) weakremover(java-17-openjdk) weakremover(java-17-openjdk-accessibility) weakremover(java-17-openjdk-demo) weakremover(java-17-openjdk-devel) weakremover(java-17-openjdk-headless) weakremover(java-17-openjdk-jmods) weakremover(java-17-openjdk-src) weakremover(java-18-openjdk) weakremover(java-18-openjdk-accessibility) weakremover(java-18-openjdk-demo) weakremover(java-18-openjdk-devel) weakremover(java-18-openjdk-headless) weakremover(java-18-openjdk-jmods) weakremover(java-18-openjdk-src) weakremover(java-19-openjdk) weakremover(java-19-openjdk-accessibility) weakremover(java-19-openjdk-demo) weakremover(java-19-openjdk-devel) weakremover(java-19-openjdk-headless) weakremover(java-19-openjdk-jmods) weakremover(java-19-openjdk-src) weakremover(java-1_5_0-gcj-compat) weakremover(java-1_5_0-gcj-compat-devel) weakremover(java-1_7_0-openjdk) weakremover(java-1_7_0-openjdk-accessibility) weakremover(java-1_7_0-openjdk-bootstrap) weakremover(java-1_7_0-openjdk-bootstrap-devel) weakremover(java-1_7_0-openjdk-bootstrap-headless) weakremover(java-1_7_0-openjdk-demo) weakremover(java-1_7_0-openjdk-devel) weakremover(java-1_7_0-openjdk-headless) weakremover(java-1_7_0-openjdk-javadoc) weakremover(java-1_7_0-openjdk-plugin) weakremover(java-1_7_0-openjdk-src) weakremover(java-1_8_0-openj9) weakremover(java-1_8_0-openj9-accessibility) weakremover(java-1_8_0-openj9-demo) weakremover(java-1_8_0-openj9-devel) weakremover(java-1_8_0-openj9-headless) weakremover(java-1_8_0-openj9-src) weakremover(java-1_8_0-openjdk) weakremover(java-1_8_0-openjdk-accessibility) weakremover(java-1_8_0-openjdk-demo) weakremover(java-1_8_0-openjdk-devel) weakremover(java-1_8_0-openjdk-headless) weakremover(java-1_8_0-openjdk-plugin) weakremover(java-1_8_0-openjdk-src) weakremover(java-1_8_0-openjfx) weakremover(java-1_8_0-openjfx-devel) weakremover(java-1_8_0-openjfx-src) weakremover(java-atk-wrapper) weakremover(java-binfmt-misc) weakremover(java-libkolabxml1) weakremover(java-mraa) weakremover(javacc3) weakremover(javacc3-demo) weakremover(javacc3-manual) weakremover(javacc3-repolib) weakremover(javapackages-filesystem) weakremover(javapackages-gradle) weakremover(javapackages-tools) weakremover(jbig2dec) weakremover(jbig2dec-devel) weakremover(jbigkit) weakremover(jcat-tool) weakremover(jconvolver) weakremover(jctools-parent) weakremover(jdo2-api) weakremover(jdo2-api-javadoc) weakremover(jdupes) weakremover(jemalloc) weakremover(jemalloc-devel) weakremover(jemalloc-devel-static) weakremover(jetty-alpn) weakremover(jetty-alpn-api) weakremover(jetty-alpn-api-javadoc) weakremover(jetty-alpn-javadoc) weakremover(jfbterm) weakremover(jffi) weakremover(jffi-native) weakremover(jfsutils) weakremover(jgmenu) weakremover(jgoodies-forms) weakremover(jgoodies-forms-demo) weakremover(jgoodies-forms-javadoc) weakremover(jgoodies-forms-manual) weakremover(jgoodies-looks) weakremover(jgoodies-looks-demo) weakremover(jgoodies-looks-javadoc) weakremover(jgoodies-looks-manual) weakremover(jhbuild) weakremover(jhbuild-lang) weakremover(jhbuild-recommended-deps) weakremover(jhead) weakremover(jigdo) weakremover(jigit) weakremover(jikes) weakremover(jimtcl) weakremover(jimtcl-devel) weakremover(jira-cli) weakremover(jitterentropy-devel) weakremover(jitterentropy-devel-static) weakremover(jless) weakremover(jline1) weakremover(jna) weakremover(jo) weakremover(joe) weakremover(jogl2) weakremover(john) weakremover(jose) weakremover(jovie) weakremover(joycond) weakremover(jp) weakremover(jp2a) weakremover(jpcre2-devel) weakremover(jpegoptim) weakremover(jpnevulator) weakremover(jq) weakremover(jrtplib-devel) weakremover(jshon) weakremover(jsmn-devel) weakremover(json-glib-devel) weakremover(json-table) weakremover(jsoncpp-devel) weakremover(jsonnet) weakremover(jsonrpc-glib-devel) weakremover(jtc) weakremover(jthread-devel) weakremover(judy-devel) weakremover(juk) weakremover(julia) weakremover(julia-debug) weakremover(julia-devel) weakremover(julia-doc) weakremover(juliaup) weakremover(julius) weakremover(jumpnbump) weakremover(jupyter-cadabra2-kernel) weakremover(jupyter-hide-code) weakremover(jupyter-hide_code) weakremover(jupyter-ipykernel-doc) weakremover(jupyter-ipykernel-python2) weakremover(jupyter-ipyparallel-doc) weakremover(jupyter-jupyter-contrib-nbextensions) weakremover(jupyter-jupyter-core-doc) weakremover(jupyter-jupyter-full-width) weakremover(jupyter-jupyter-require) weakremover(jupyter-jupyter-themer) weakremover(jupyter-jupyter_client-doc) weakremover(jupyter-jupyter_cms) weakremover(jupyter-jupyter_core-doc) weakremover(jupyter-jupyter_dashboards) weakremover(jupyter-jupyterbgnotify) weakremover(jupyter-jupyterlab_github) weakremover(jupyter-jupytext) weakremover(jupyter-jupytext-jupyterlab) weakremover(jupyter-nbconvert-doc) weakremover(jupyter-nbformat) weakremover(jupyter-nbformat-doc) weakremover(jupyter-nbinteract) weakremover(jupyter-nbpresent) weakremover(jupyter-qtconsole-doc) weakremover(jupyter-rise) weakremover(jupyter-vispy) weakremover(jupyter-voila) weakremover(just) weakremover(jwt_verify_lib-devel) weakremover(jxrlib) weakremover(jxrlib-devel) weakremover(k0sctl) weakremover(k3b) weakremover(k3b-devel) weakremover(k3d) weakremover(k3d-bash-completion) weakremover(k3d-fish-completion) weakremover(k3d-zsh-completion) weakremover(k3s) weakremover(k3s-hyperkube) weakremover(k3s-install) weakremover(k3sup) weakremover(k4dirstat) weakremover(k9s) weakremover(kColorPicker-devel) weakremover(kImageAnnotator) weakremover(kImageAnnotator-devel) weakremover(kaccessible) weakremover(kaccounts-integration) weakremover(kaccounts-integration-devel) weakremover(kaccounts-providers) weakremover(kactivities-stats-devel) weakremover(kactivities5-devel) weakremover(kactivities5-imports) weakremover(kactivities5-tools) weakremover(kactivitymanagerd) weakremover(kactivitymanagerd-lang) weakremover(kaddressbook) weakremover(kaddressbook5) weakremover(kadu) weakremover(kadu-anonymous_check) weakremover(kadu-completion) weakremover(kadu-devel) weakremover(kadu-import_history) weakremover(kadu-mimetex) weakremover(kadu-sound-bns) weakremover(kadu-sound-drums) weakremover(kadu-sound-florkus) weakremover(kadu-sound-michalsrodek) weakremover(kadu-sound-percussion) weakremover(kadu-sound-ultr) weakremover(kaffeine) weakremover(kafka-source) weakremover(kaidan) weakremover(kail) weakremover(kajaani-kombat) weakremover(kajaani-kombat-server) weakremover(kak-lsp) weakremover(kakasi) weakremover(kakasi-devel) weakremover(kakasi-dict) weakremover(kakoune) weakremover(kalarm) weakremover(kalarm5) weakremover(kalarmcal) weakremover(kalarmcal-devel) weakremover(kalarmcal-lang) weakremover(kalendar) weakremover(kalendar-plasmoid) weakremover(kalendarac) weakremover(kalgebra) weakremover(kalgebra-mobile) weakremover(kalk) weakremover(kalzium) weakremover(kalzium-devel) weakremover(kamerka) weakremover(kamoso) weakremover(kanagram) weakremover(kanidm) weakremover(kanidm-clients) weakremover(kanidm-docs) weakremover(kanidm-server) weakremover(kanidm-unixd-clients) weakremover(kanjipad) weakremover(kanshi) weakremover(kapman) weakremover(kapptemplate) weakremover(karchive-devel) weakremover(karim) weakremover(kasts) weakremover(kasumi) weakremover(katacontainers) weakremover(katacontainers-image-initrd) weakremover(kate) weakremover(kate-plugins) weakremover(kate4-parts) weakremover(katomic) weakremover(kauth-devel) weakremover(kbackup) weakremover(kbd) weakremover(kbdsniffd) weakremover(kbfs) weakremover(kbfs-git) weakremover(kbfs-tool) weakremover(kbibtex) weakremover(kbibtex-devel) weakremover(kblackbox) weakremover(kblocks) weakremover(kblog-devel) weakremover(kblog-lang) weakremover(kbookmarks-devel) weakremover(kbounce) weakremover(kbreakout) weakremover(kbruch) weakremover(kbuild) weakremover(kcachegrind) weakremover(kcalc) weakremover(kcalcore-devel) weakremover(kcalendarcore-devel) weakremover(kcalutils) weakremover(kcalutils-devel) weakremover(kcharselect) weakremover(kchmviewer) weakremover(kclock) weakremover(kcm-touchpad) weakremover(kcm_fcitx5) weakremover(kcm_flatpak) weakremover(kcm_sddm) weakremover(kcm_tablet) weakremover(kcmutils-devel) weakremover(kcmutils-imports) weakremover(kcodecs-devel) weakremover(kcolorchooser) weakremover(kcompletion-devel) weakremover(kconf_update5) weakremover(kconfig-devel) weakremover(kconfigwidgets-devel) weakremover(kcontacts-devel) weakremover(kcoreaddons) weakremover(kcoreaddons-devel) weakremover(kcov) weakremover(kcrash-devel) weakremover(kcron) weakremover(kdav) weakremover(kdav-devel) weakremover(kdb-devel) weakremover(kdb-mysql-driver) weakremover(kdb-postgresql-driver) weakremover(kdb-sqlite3-driver) weakremover(kdbg) weakremover(kdbg-doc) weakremover(kdbusaddons-devel) weakremover(kdbusaddons-tools) weakremover(kddockwidgets-devel) weakremover(kddockwidgets-qt6-devel) weakremover(kde-cli-tools5) weakremover(kde-gtk-config5) weakremover(kde-gtk-config5-gtk2) weakremover(kde-gtk-config5-gtk3) weakremover(kde-gtk-config5-lang) weakremover(kde-inotify-survey) weakremover(kde-l10n-ar) weakremover(kde-l10n-ast) weakremover(kde-l10n-bg) weakremover(kde-l10n-bs) weakremover(kde-l10n-ca) weakremover(kde-l10n-caValencia) weakremover(kde-l10n-cs) weakremover(kde-l10n-da) weakremover(kde-l10n-da-data) weakremover(kde-l10n-da-doc) weakremover(kde-l10n-de) weakremover(kde-l10n-de-data) weakremover(kde-l10n-de-doc) weakremover(kde-l10n-devel) weakremover(kde-l10n-el) weakremover(kde-l10n-en_GB) weakremover(kde-l10n-en_GB-data) weakremover(kde-l10n-en_GB-doc) weakremover(kde-l10n-eo) weakremover(kde-l10n-es) weakremover(kde-l10n-es-data) weakremover(kde-l10n-es-doc) weakremover(kde-l10n-et) weakremover(kde-l10n-et-data) weakremover(kde-l10n-et-doc) weakremover(kde-l10n-eu) weakremover(kde-l10n-fa) weakremover(kde-l10n-fi) weakremover(kde-l10n-fr) weakremover(kde-l10n-fr-data) weakremover(kde-l10n-fr-doc) weakremover(kde-l10n-ga) weakremover(kde-l10n-gl) weakremover(kde-l10n-he) weakremover(kde-l10n-hi) weakremover(kde-l10n-hr) weakremover(kde-l10n-hu) weakremover(kde-l10n-ia) weakremover(kde-l10n-id) weakremover(kde-l10n-is) weakremover(kde-l10n-it) weakremover(kde-l10n-it-data) weakremover(kde-l10n-it-doc) weakremover(kde-l10n-ja) weakremover(kde-l10n-kk) weakremover(kde-l10n-km) weakremover(kde-l10n-ko) weakremover(kde-l10n-lt) weakremover(kde-l10n-lv) weakremover(kde-l10n-mr) weakremover(kde-l10n-nb) weakremover(kde-l10n-nds) weakremover(kde-l10n-nl) weakremover(kde-l10n-nl-data) weakremover(kde-l10n-nl-doc) weakremover(kde-l10n-nn) weakremover(kde-l10n-pa) weakremover(kde-l10n-pl) weakremover(kde-l10n-pl-data) weakremover(kde-l10n-pl-doc) weakremover(kde-l10n-pt) weakremover(kde-l10n-pt_BR) weakremover(kde-l10n-pt_BR-data) weakremover(kde-l10n-pt_BR-doc) weakremover(kde-l10n-ro) weakremover(kde-l10n-ru) weakremover(kde-l10n-ru-data) weakremover(kde-l10n-ru-doc) weakremover(kde-l10n-sk) weakremover(kde-l10n-sl) weakremover(kde-l10n-sr) weakremover(kde-l10n-sv) weakremover(kde-l10n-sv-data) weakremover(kde-l10n-sv-doc) weakremover(kde-l10n-tr) weakremover(kde-l10n-ug) weakremover(kde-l10n-uk) weakremover(kde-l10n-uk-data) weakremover(kde-l10n-uk-doc) weakremover(kde-l10n-wa) weakremover(kde-l10n-zh_CN) weakremover(kde-l10n-zh_TW) weakremover(kde-odf-thumbnail) weakremover(kde-print-manager) weakremover(kde-user-manager) weakremover(kde-user-manager-lang) weakremover(kde4-filesystem) weakremover(kde4-kgreeter-plugins) weakremover(kde4-mediainfo) weakremover(kdebase4-libkonq) weakremover(kdebase4-nsplugin) weakremover(kdebase4-runtime) weakremover(kdebase4-runtime-devel) weakremover(kdebase4-workspace) weakremover(kdebase4-workspace-addons) weakremover(kdebase4-workspace-ksysguardd) weakremover(kdebase4-workspace-liboxygenstyle) weakremover(kdebase4-workspace-libs) weakremover(kdebindings-smokegen) weakremover(kdebugsettings) weakremover(kdeclarative-components) weakremover(kdeclarative-devel) weakremover(kdeclarative-tools) weakremover(kdeconnect-kde) weakremover(kded) weakremover(kded-devel) weakremover(kdedesktopcheck) weakremover(kdegames4-carddecks-default) weakremover(kdegames4-carddecks-other) weakremover(kdegraphics-thumbnailers) weakremover(kdelibs4) weakremover(kdelibs4-apidocs) weakremover(kdelibs4-branding-openSUSE) weakremover(kdelibs4-branding-upstream) weakremover(kdelibs4-core) weakremover(kdelibs4-doc) weakremover(kdelibs4support) weakremover(kdelibs4support-devel) weakremover(kdenetwork-filesharing) weakremover(kdenetwork4-filesharing) weakremover(kdenetwork4-filesharing-lang) weakremover(kdenlive) weakremover(kdepasswd) weakremover(kdepim) weakremover(kdepim-addons) weakremover(kdepim-apps-libs) weakremover(kdepim-apps-libs-devel) weakremover(kdepim-apps-libs-lang) weakremover(kdepim-runtime) weakremover(kdepim4) weakremover(kdepim4-runtime) weakremover(kdepimlibs4) weakremover(kdesdk-scripts) weakremover(kdesdk-scripts-kf5-porting) weakremover(kdesdk-thumbnailers) weakremover(kdesdk4-scripts) weakremover(kdesdk4-scripts-kf5-porting) weakremover(kdesignerplugin) weakremover(kdesignerplugin-devel) weakremover(kdesu-devel) weakremover(kdesvn) weakremover(kdevelop4) weakremover(kdevelop4-devel) weakremover(kdevelop4-doc) weakremover(kdevelop4-lang) weakremover(kdevelop4-pg-qt) weakremover(kdevelop4-plugin-cppsupport) weakremover(kdevelop4-plugin-python) weakremover(kdevelop4-plugin-python-lang) weakremover(kdevelop4-plugins-php) weakremover(kdevelop4-plugins-php-doc) weakremover(kdevelop5) weakremover(kdevelop5-pg-qt) weakremover(kdevelop5-plugin-clang-tidy) weakremover(kdevelop5-plugin-php) weakremover(kdevelop5-plugin-php-devel) weakremover(kdevelop5-plugin-python3) weakremover(kdevplatform) weakremover(kdevplatform-devel) weakremover(kdevplatform4) weakremover(kdevplatform4-lang) weakremover(kdewebkit-devel) weakremover(kdf) weakremover(kdgantt2) weakremover(kdgantt2-devel) weakremover(kdiagram-devel) weakremover(kdialog) weakremover(kdiamond) weakremover(kdiff3) weakremover(kdiskmark) weakremover(kdm) weakremover(kdm-branding-openSUSE) weakremover(kdm-branding-upstream) weakremover(kdnssd) weakremover(kdnssd-framework-devel) weakremover(kdoctools) weakremover(kdoctools-devel) weakremover(kdsoap-devel) weakremover(kdsoap-qt6-devel) weakremover(kdstatemachineeditor) weakremover(kdstatemachineeditor-devel) weakremover(kdump) weakremover(kdumpid) weakremover(kea) weakremover(kea-devel) weakremover(kea-hooks) weakremover(keditbookmarks) weakremover(keepalived) weakremover(keepassx) weakremover(keepassxc) weakremover(kelbt) weakremover(kemoticons-devel) weakremover(kepas) weakremover(kernel-64kb) weakremover(kernel-64kb-base) weakremover(kernel-64kb-devel) weakremover(kernel-coverage) weakremover(kernel-debug) weakremover(kernel-debug-devel) weakremover(kernel-default) weakremover(kernel-default-base) weakremover(kernel-default-base-rebuild) weakremover(kernel-default-devel) weakremover(kernel-desktop) weakremover(kernel-docs-pdf) weakremover(kernel-ec2) weakremover(kernel-firmware-nvidia-gsp-G06) weakremover(kernel-install-tools) weakremover(kernel-kvmsmall) weakremover(kernel-kvmsmall-devel) weakremover(kernel-obs-build) weakremover(kernel-obs-qa) weakremover(kernel-pae) weakremover(kernel-syms) weakremover(kernel-vanilla) weakremover(kernel-vanilla-base) weakremover(kernel-vanilla-devel) weakremover(kernel-xen) weakremover(kernelshark) weakremover(kernelshark-devel) weakremover(kexec-tools) weakremover(kexi) weakremover(keybase-client) weakremover(keybinder-3.0-devel) weakremover(keybinder-devel) weakremover(keybinder-lua) weakremover(keybinder3-devel) weakremover(keyd) weakremover(keylightctl) weakremover(keylime-agent) weakremover(keylime-ima-policy) weakremover(keyutils) weakremover(keyutils-devel) weakremover(kf5-filesystem) weakremover(kf5-kcm-fcitx) weakremover(kf5-mediainfo) weakremover(kfilemetadata) weakremover(kfilemetadata-devel) weakremover(kfilemetadata5) weakremover(kfilemetadata5-devel) weakremover(kfilereplace) weakremover(kfind) weakremover(kfloppy) weakremover(kfourinline) weakremover(kgamma5) weakremover(kgeography) weakremover(kgeotag) weakremover(kget) weakremover(kglobalaccel-devel) weakremover(kglobalaccel5) weakremover(kgoldrunner) weakremover(kgpg) weakremover(kguiaddons) weakremover(kguiaddons-devel) weakremover(khangman) weakremover(khelpcenter5) weakremover(kholidays) weakremover(kholidays-devel) weakremover(kholidays-lang) weakremover(khotkeys5) weakremover(khotkeys5-devel) weakremover(khtml-devel) weakremover(khunphan) weakremover(ki18n-devel) weakremover(ki18n-imports) weakremover(kicad) weakremover(kicad-doc-nl) weakremover(kicad-doc-pdf-ca) weakremover(kicad-doc-pdf-de) weakremover(kicad-doc-pdf-en) weakremover(kicad-doc-pdf-es) weakremover(kicad-doc-pdf-fr) weakremover(kicad-doc-pdf-id) weakremover(kicad-doc-pdf-it) weakremover(kicad-doc-pdf-ja) weakremover(kicad-doc-pdf-ru) weakremover(kicad-doc-pdf-zh) weakremover(kicad-lang-bg) weakremover(kicad-lang-ca) weakremover(kicad-lang-cs) weakremover(kicad-lang-de) weakremover(kicad-lang-el) weakremover(kicad-lang-en) weakremover(kicad-lang-es) weakremover(kicad-lang-fi) weakremover(kicad-lang-fr) weakremover(kicad-lang-hu) weakremover(kicad-lang-id) weakremover(kicad-lang-it) weakremover(kicad-lang-ja) weakremover(kicad-lang-ko) weakremover(kicad-lang-lt) weakremover(kicad-lang-nl) weakremover(kicad-lang-pl) weakremover(kicad-lang-pt) weakremover(kicad-lang-ro) weakremover(kicad-lang-ru) weakremover(kicad-lang-sk) weakremover(kicad-lang-sl) weakremover(kicad-lang-sv) weakremover(kicad-lang-zh_CN) weakremover(kicad-lang-zh_TW) weakremover(kicad-library-install) weakremover(kiconthemes-devel) weakremover(kid3) weakremover(kid3-cli) weakremover(kid3-core) weakremover(kid3-doc) weakremover(kid3-qt) weakremover(kid3-qt-doc) weakremover(kidentitymanagement) weakremover(kidentitymanagement-devel) weakremover(kidletime-devel) weakremover(kig) weakremover(kigo) weakremover(kile) weakremover(kile5) weakremover(kile5-lang) weakremover(killbots) weakremover(killerd) weakremover(killswitch-applet) weakremover(kim-api) weakremover(kim-api-devel) weakremover(kim-api-examples) weakremover(kimageformats) weakremover(kimageformats-eps) weakremover(kimagemapeditor) weakremover(kimap) weakremover(kimap-devel) weakremover(kimap-lang) weakremover(kinfocenter5) weakremover(kinit) weakremover(kinit-devel) weakremover(kinput2) weakremover(kio) weakremover(kio-core) weakremover(kio-devel) weakremover(kio-extras5) weakremover(kio-fuse) weakremover(kio-gdrive) weakremover(kio-stash) weakremover(kio_audiocd) weakremover(kio_audiocd-devel) weakremover(kio_audiocd4) weakremover(kio_audiocd4-devel) weakremover(kio_iso) weakremover(kio_kamera) weakremover(kio_mtp) weakremover(kio_perldoc) weakremover(kipi-plugins) weakremover(kipi-plugins-acquireimage) weakremover(kipi-plugins-geolocation) weakremover(kirigami) weakremover(kirigami-addons) weakremover(kirigami-addons-devel) weakremover(kirigami-devel) weakremover(kirigami-gallery) weakremover(kirigami2) weakremover(kirigami2-devel) weakremover(kiriki) weakremover(kismet) weakremover(kismet-capture-bt-geiger) weakremover(kismet-capture-freaklabs-zigbee) weakremover(kismet-capture-linux-bluetooth) weakremover(kismet-capture-linux-wifi) weakremover(kismet-capture-nrf-51822) weakremover(kismet-capture-nrf-52840) weakremover(kismet-capture-nrf-mousejack) weakremover(kismet-capture-nrf-nxp-kw41z) weakremover(kismet-capture-rz-killerbee) weakremover(kismet-capture-sdr-rtl433) weakremover(kismet-capture-sdr-rtladsb) weakremover(kismet-capture-sdr-rtlamr) weakremover(kismet-capture-ti-cc-2531) weakremover(kismet-capture-ti-cc2540) weakremover(kismet-devel) weakremover(kismet-logtools) weakremover(kissfft) weakremover(kissfft-devel) weakremover(kitemmodels-devel) weakremover(kitemmodels-imports) weakremover(kitemviews-devel) weakremover(kiten) weakremover(kiten-devel) weakremover(kitinerary) weakremover(kitinerary-devel) weakremover(kitty) weakremover(kiwi) weakremover(kiwi-boot-descriptions) weakremover(kiwi-boot-requires) weakremover(kiwi-desc-oemboot) weakremover(kiwi-desc-oemboot-requires) weakremover(kiwi-desc-vmxboot) weakremover(kiwi-desc-vmxboot-requires) weakremover(kiwi-doc) weakremover(kiwi-filesystem-requires) weakremover(kiwi-image-docker-requires) weakremover(kiwi-image-iso-requires) weakremover(kiwi-image-oem-requires) weakremover(kiwi-image-pxe-requires) weakremover(kiwi-image-tbz-requires) weakremover(kiwi-image-vmx-requires) weakremover(kiwi-image-wsl-requires) weakremover(kiwi-instsource) weakremover(kiwi-instsource-plugins-openSUSE-13-2) weakremover(kiwi-man-pages) weakremover(kiwi-media-requires) weakremover(kiwi-requires) weakremover(kiwi-systemdeps) weakremover(kiwi-systemdeps-bootloaders) weakremover(kiwi-systemdeps-containers) weakremover(kiwi-systemdeps-core) weakremover(kiwi-systemdeps-disk-images) weakremover(kiwi-systemdeps-filesystems) weakremover(kiwi-systemdeps-image-validation) weakremover(kiwi-systemdeps-iso-media) weakremover(kiwi-templates) weakremover(kiwi-test) weakremover(kiwi-tools) weakremover(kjobwidgets-devel) weakremover(kjots) weakremover(kjournald) weakremover(kjs-devel) weakremover(kjsembed-devel) weakremover(kjumpingcube) weakremover(kkc-data) weakremover(klatexformula) weakremover(klatexformula-devel) weakremover(klatexformula-ktexteditor-plugin) weakremover(klavaro) weakremover(klavaro-devel) weakremover(kldap) weakremover(kldap-devel) weakremover(klee) weakremover(kleopatra) weakremover(kleopatra5) weakremover(klettres) weakremover(klfbackend-devel) weakremover(klftools-devel) weakremover(klickety) weakremover(klines) weakremover(klinkstatus) weakremover(klogd) weakremover(kmag) weakremover(kmahjongg) weakremover(kmail) weakremover(kmail-account-wizard) weakremover(kmail-application-icons) weakremover(kmail5) weakremover(kmailtransport) weakremover(kmailtransport-devel) weakremover(kmarkdownwebview) weakremover(kmbox) weakremover(kmbox-devel) weakremover(kmediaplayer-devel) weakremover(kmenuedit5) weakremover(kmime) weakremover(kmime-devel) weakremover(kmime-lang) weakremover(kmines) weakremover(kmix) weakremover(kmod) weakremover(kmod-compat) weakremover(kmousetool) weakremover(kmouth) weakremover(kmozillahelper) weakremover(kmplot) weakremover(kmscon) weakremover(kmscube) weakremover(kmtrace) weakremover(kmymoney) weakremover(kmymoney-devel) weakremover(kmymoney-doc) weakremover(knavalbattle) weakremover(knemo) weakremover(knemo-lang) weakremover(knetwalk) weakremover(knewstuff) weakremover(knewstuff-core-devel) weakremover(knewstuff-devel) weakremover(knewstuff-imports) weakremover(knewstuff-quick-devel) weakremover(knights) weakremover(knock) weakremover(knockd) weakremover(knode) weakremover(knot) weakremover(knot-devel) weakremover(knotes) weakremover(knotes5) weakremover(knotifications-devel) weakremover(knotifications-imports) weakremover(knotifyconfig-devel) weakremover(kochmorse) weakremover(kohana2) weakremover(kokkos-devel) weakremover(koko) weakremover(kolf) weakremover(kollision) weakremover(kolor-manager) weakremover(kolourpaint) weakremover(kommander-runtime) weakremover(kommander-runtime-devel) weakremover(kompare) weakremover(kompare-devel) weakremover(kompose) weakremover(kongress) weakremover(konkretcmpi-devel) weakremover(konkretcmpi-python) weakremover(konkretcmpi-python3) weakremover(konqueror) weakremover(konqueror-devel) weakremover(konqueror-plugins) weakremover(konquest) weakremover(konsole) weakremover(konsole-part) weakremover(konsole4-part) weakremover(konstraint) weakremover(kontact) weakremover(kontact5) weakremover(kontactinterface-devel) weakremover(kontactinterface-lang) weakremover(kontrast) weakremover(konversation) weakremover(kopano-archiver) weakremover(kopano-backup) weakremover(kopano-bash-completion) weakremover(kopano-client) weakremover(kopano-common) weakremover(kopano-compat) weakremover(kopano-contacts) weakremover(kopano-dagent) weakremover(kopano-dagent-pytils) weakremover(kopano-devel) weakremover(kopano-gateway) weakremover(kopano-ical) weakremover(kopano-indexer) weakremover(kopano-lang) weakremover(kopano-migration-imap) weakremover(kopano-migration-pst) weakremover(kopano-monitor) weakremover(kopano-presence) weakremover(kopano-python-utils) weakremover(kopano-search) weakremover(kopano-server) weakremover(kopano-server-packages) weakremover(kopano-spamd) weakremover(kopano-spooler) weakremover(kopano-statsd) weakremover(kopano-utils) weakremover(kopano-webapp) weakremover(kopano-webapp-contactfax) weakremover(kopano-webapp-folderwidgets) weakremover(kopano-webapp-gmaps) weakremover(kopano-webapp-lang) weakremover(kopano-webapp-pimfolder) weakremover(kopano-webapp-quickitems) weakremover(kopano-webapp-titlecounter) weakremover(kopano-webapp-webappmanual) weakremover(kopano-webapp-zdeveloper) weakremover(kopeninghours) weakremover(kopeninghours-devel) weakremover(kopete) weakremover(kopete-devel) weakremover(korganizer) weakremover(korganizer5) weakremover(kosmindoormap) weakremover(kosmindoormap-devel) weakremover(kpackage) weakremover(kpackage-devel) weakremover(kpartloader) weakremover(kparts-devel) weakremover(kpartx) weakremover(kpassgen) weakremover(kpat) weakremover(kpeople5) weakremover(kpeople5-devel) weakremover(kpeoplevcard) weakremover(kpeoplevcard-devel) weakremover(kphotoalbum) weakremover(kpimtextedit) weakremover(kpimtextedit-devel) weakremover(kpimtextedit-lang) weakremover(kpipewire-devel) weakremover(kpipewire-imports) weakremover(kpkpass) weakremover(kpkpass-devel) weakremover(kplotting-devel) weakremover(kpmcore) weakremover(kpmcore-devel) weakremover(kppp) weakremover(kprofilemethod) weakremover(kproperty) weakremover(kproperty-devel) weakremover(kpty-devel) weakremover(kpublictransport) weakremover(kpublictransport-devel) weakremover(kqtquickcharts) weakremover(kquickcharts) weakremover(kquickcharts-devel) weakremover(kquickimageeditor-devel) weakremover(kquickimageeditor-imports) weakremover(kradio) weakremover(kraft) weakremover(krandr) weakremover(krb5) weakremover(krb5-appl-clients) weakremover(krb5-appl-servers) weakremover(krb5-auth-dialog) weakremover(krb5-client) weakremover(krb5-devel) weakremover(krb5-doc) weakremover(krb5-mini) weakremover(krb5-mini-devel) weakremover(krb5-plugin-kdb-ldap) weakremover(krb5-plugin-preauth-otp) weakremover(krb5-plugin-preauth-pkinit) weakremover(krb5-plugin-preauth-spake) weakremover(krb5-server) weakremover(krb5-ticket-watcher) weakremover(krdc) weakremover(krdc-devel) weakremover(krecorder) weakremover(kremotecontrol) weakremover(kremotecontrol-devel) weakremover(krename) weakremover(kreport) weakremover(kreport-devel) weakremover(kreversi) weakremover(krfb) weakremover(kristall) weakremover(krita) weakremover(krita-devel) weakremover(krita-plugin-gmic) weakremover(krius) weakremover(kronometer) weakremover(kross) weakremover(kross-devel) weakremover(kross-python) weakremover(kross-ruby) weakremover(kruler) weakremover(krunner-devel) weakremover(krunvm) weakremover(krusader) weakremover(krusader-doc) weakremover(ksanecore-devel) weakremover(kscd) weakremover(kscreen5) weakremover(kscreen5-plasmoid) weakremover(kscreenlocker) weakremover(kscreenlocker-devel) weakremover(kseexpr-devel) weakremover(kseg) weakremover(kselftests-kmp-default) weakremover(kselftests-kmp-vanilla) weakremover(kservice) weakremover(kservice-devel) weakremover(ksh) weakremover(ksh-devel) weakremover(kshisen) weakremover(kshutdown) weakremover(ksirk) weakremover(ksmbd-tools) weakremover(ksmtp) weakremover(ksmtp-devel) weakremover(ksmtp-lang) weakremover(ksnakeduel) weakremover(ksnip) weakremover(kspaceduel) weakremover(ksplash-qml-branding-openSUSE) weakremover(ksplashx-branding-openSUSE) weakremover(ksquares) weakremover(ksshaskpass5) weakremover(kssl) weakremover(kst) weakremover(kst-devel) weakremover(kstars) weakremover(kstartperf) weakremover(ksudoku) weakremover(ksysguard5) weakremover(ksysguardsystemstats-data) weakremover(ksystemlog) weakremover(ksystemstats5) weakremover(kteatime) weakremover(kterm) weakremover(ktextaddons) weakremover(ktextaddons-devel) weakremover(ktexteditor) weakremover(ktexteditor-devel) weakremover(ktextwidgets-devel) weakremover(ktikz) weakremover(ktimer) weakremover(ktimetracker) weakremover(ktnef) weakremover(ktnef-common) weakremover(ktnef-devel) weakremover(ktnef-lang) weakremover(ktnef5) weakremover(ktoblzcheck) weakremover(ktoblzcheck-devel) weakremover(ktop) weakremover(ktorrent) weakremover(ktouch) weakremover(ktp-accounts-kcm) weakremover(ktp-approver) weakremover(ktp-auth-handler) weakremover(ktp-call-ui) weakremover(ktp-call-ui-lang) weakremover(ktp-common-internals) weakremover(ktp-common-internals-devel) weakremover(ktp-contact-list) weakremover(ktp-contact-runner) weakremover(ktp-desktop-applets) weakremover(ktp-filetransfer-handler) weakremover(ktp-icons) weakremover(ktp-kded-module) weakremover(ktp-send-file) weakremover(ktp-text-ui) weakremover(ktrip) weakremover(ktuberling) weakremover(kturtle) weakremover(kube-no-trouble) weakremover(kube-prometheus-k8s-yaml) weakremover(kube-prometheus-sources) weakremover(kubeaudit) weakremover(kubeconform) weakremover(kubectl) weakremover(kubectl-explore) weakremover(kubectl-foreach) weakremover(kubectl-neat) weakremover(kubectl-oomd) weakremover(kubectl-who-can) weakremover(kubelogin) weakremover(kuberlr) weakremover(kubernetes-404-server) weakremover(kubernetes-apiserver) weakremover(kubernetes-apiserver-minus1) weakremover(kubernetes-client) weakremover(kubernetes-common) weakremover(kubernetes-controller-manager) weakremover(kubernetes-controller-manager-minus1) weakremover(kubernetes-coredns) weakremover(kubernetes-coredns-minus1) weakremover(kubernetes-dns) weakremover(kubernetes-etcd) weakremover(kubernetes-etcd-minus1) weakremover(kubernetes-extra) weakremover(kubernetes-kubeadm) weakremover(kubernetes-kubelet) weakremover(kubernetes-kubelet-common) weakremover(kubernetes-kubelet1.17) weakremover(kubernetes-kubelet1.18) weakremover(kubernetes-master) weakremover(kubernetes-node) weakremover(kubernetes-node-image-pause) weakremover(kubernetes-pause) weakremover(kubernetes-proxy) weakremover(kubernetes-proxy-minus1) weakremover(kubernetes-salt) weakremover(kubernetes-scheduler) weakremover(kubernetes-scheduler-minus1) weakremover(kubernetes1.17-apiserver) weakremover(kubernetes1.17-client) weakremover(kubernetes1.17-controller-manager) weakremover(kubernetes1.17-kubeadm) weakremover(kubernetes1.17-kubelet) weakremover(kubernetes1.17-kubelet-common) weakremover(kubernetes1.17-proxy) weakremover(kubernetes1.17-scheduler) weakremover(kubernetes1.18-apiserver) weakremover(kubernetes1.18-client) weakremover(kubernetes1.18-client-common) weakremover(kubernetes1.18-controller-manager) weakremover(kubernetes1.18-kubeadm) weakremover(kubernetes1.18-kubelet) weakremover(kubernetes1.18-kubelet-common) weakremover(kubernetes1.18-proxy) weakremover(kubernetes1.18-scheduler) weakremover(kubernetes1.19-apiserver) weakremover(kubernetes1.19-client) weakremover(kubernetes1.19-client-common) weakremover(kubernetes1.19-controller-manager) weakremover(kubernetes1.19-kubeadm) weakremover(kubernetes1.19-kubelet) weakremover(kubernetes1.19-kubelet-common) weakremover(kubernetes1.19-proxy) weakremover(kubernetes1.19-scheduler) weakremover(kubernetes1.20-apiserver) weakremover(kubernetes1.20-client) weakremover(kubernetes1.20-client-common) weakremover(kubernetes1.20-controller-manager) weakremover(kubernetes1.20-kubeadm) weakremover(kubernetes1.20-kubelet) weakremover(kubernetes1.20-kubelet-common) weakremover(kubernetes1.20-proxy) weakremover(kubernetes1.20-scheduler) weakremover(kubernetes1.21-apiserver) weakremover(kubernetes1.21-client) weakremover(kubernetes1.21-client-common) weakremover(kubernetes1.21-controller-manager) weakremover(kubernetes1.21-kubeadm) weakremover(kubernetes1.21-kubelet) weakremover(kubernetes1.21-kubelet-common) weakremover(kubernetes1.21-proxy) weakremover(kubernetes1.21-scheduler) weakremover(kubernetes1.22-apiserver) weakremover(kubernetes1.22-client) weakremover(kubernetes1.22-client-common) weakremover(kubernetes1.22-controller-manager) weakremover(kubernetes1.22-kubeadm) weakremover(kubernetes1.22-kubelet) weakremover(kubernetes1.22-kubelet-common) weakremover(kubernetes1.22-proxy) weakremover(kubernetes1.22-scheduler) weakremover(kubernetes1.23-apiserver) weakremover(kubernetes1.23-client) weakremover(kubernetes1.23-client-common) weakremover(kubernetes1.23-controller-manager) weakremover(kubernetes1.23-kubeadm) weakremover(kubernetes1.23-kubelet) weakremover(kubernetes1.23-kubelet-common) weakremover(kubernetes1.23-proxy) weakremover(kubernetes1.23-scheduler) weakremover(kubernetes1.24-apiserver) weakremover(kubernetes1.24-client) weakremover(kubernetes1.24-client-common) weakremover(kubernetes1.24-controller-manager) weakremover(kubernetes1.24-kubeadm) weakremover(kubernetes1.24-kubelet) weakremover(kubernetes1.24-kubelet-common) weakremover(kubernetes1.24-proxy) weakremover(kubernetes1.24-scheduler) weakremover(kubernetes1.25-apiserver) weakremover(kubernetes1.25-client) weakremover(kubernetes1.25-client-common) weakremover(kubernetes1.25-controller-manager) weakremover(kubernetes1.25-kubeadm) weakremover(kubernetes1.25-kubelet) weakremover(kubernetes1.25-kubelet-common) weakremover(kubernetes1.25-proxy) weakremover(kubernetes1.25-scheduler) weakremover(kubernetes1.26-apiserver) weakremover(kubernetes1.26-client) weakremover(kubernetes1.26-client-common) weakremover(kubernetes1.26-controller-manager) weakremover(kubernetes1.26-kubeadm) weakremover(kubernetes1.26-kubelet) weakremover(kubernetes1.26-kubelet-common) weakremover(kubernetes1.26-proxy) weakremover(kubernetes1.26-scheduler) weakremover(kubernetes1.27-apiserver) weakremover(kubernetes1.27-client) weakremover(kubernetes1.27-client-common) weakremover(kubernetes1.27-controller-manager) weakremover(kubernetes1.27-kubeadm) weakremover(kubernetes1.27-kubelet) weakremover(kubernetes1.27-kubelet-common) weakremover(kubernetes1.27-proxy) weakremover(kubernetes1.27-scheduler) weakremover(kubescape) weakremover(kubeseal) weakremover(kubespy) weakremover(kubetap) weakremover(kubeval) weakremover(kubevirt-container-disk) weakremover(kubevirt-manifests) weakremover(kubevirt-tests) weakremover(kubevirt-virt-api) weakremover(kubevirt-virt-controller) weakremover(kubevirt-virt-exportproxy) weakremover(kubevirt-virt-exportserver) weakremover(kubevirt-virt-handler) weakremover(kubevirt-virt-launcher) weakremover(kubevirt-virt-operator) weakremover(kubevirt-virtctl) weakremover(kubic-dex-branding) weakremover(kubic-haproxycfg) weakremover(kubic-pause) weakremover(kubicctl) weakremover(kubicd) weakremover(kubie) weakremover(kubrick) weakremover(kucero) weakremover(kuiviewer) weakremover(kunitconversion-devel) weakremover(kup-backup) weakremover(kup-client) weakremover(kup-server) weakremover(kured) weakremover(kured-yaml) weakremover(kurso-de-esperanto) weakremover(kuser) weakremover(kuserfeedback-devel) weakremover(kuserfeedback-imports) weakremover(kuserfeedback-server) weakremover(kuserfeedback-tools) weakremover(kustomize) weakremover(kvantum-manager) weakremover(kvantum-openbox-themes) weakremover(kvantum-qt5) weakremover(kvantum-qt6) weakremover(kvirc) weakremover(kvirc-devel) weakremover(kvirustotal) weakremover(kvirustotal-lang) weakremover(kvkbd) weakremover(kvpnc) weakremover(kwallet-devel) weakremover(kwallet-tools) weakremover(kwallet-tools-lang) weakremover(kwalletd5) weakremover(kwalletmanager) weakremover(kwalletmanager5) weakremover(kwave) weakremover(kwayland) weakremover(kwayland-devel) weakremover(kwayland-integration) weakremover(kwayland-server-devel) weakremover(kweather) weakremover(kweathercore-devel) weakremover(kwebkitpart) weakremover(kwebkitpart-lang) weakremover(kwidgetsaddons-devel) weakremover(kwikdisk) weakremover(kwin) weakremover(kwin5) weakremover(kwin5-devel) weakremover(kwindowsystem-devel) weakremover(kwordquiz) weakremover(kwrite) weakremover(kwrited5) weakremover(kxmlgui-devel) weakremover(kxmlrpcclient5-devel) weakremover(kye) weakremover(kye-data) weakremover(kyotocabinet) weakremover(kyverno) weakremover(labplot-kf5) weakremover(ladish) weakremover(ladspa) weakremover(ladspa-AMB) weakremover(ladspa-FIL) weakremover(ladspa-MCP) weakremover(ladspa-REV) weakremover(ladspa-VCO) weakremover(ladspa-alienwah) weakremover(ladspa-blepvco) weakremover(ladspa-blop) weakremover(ladspa-caps) weakremover(ladspa-cmt) weakremover(ladspa-guitarix) weakremover(ladspa-lsp-plugins) weakremover(ladspa-matched) weakremover(ladspa-preamp) weakremover(ladspa-pvoc) weakremover(ladspa-rnnoise) weakremover(ladspa-sooperlooper) weakremover(ladspa-super-60) weakremover(ladspa-swh-plugins) weakremover(ladspa-tap-plugins) weakremover(ladspa-vcf) weakremover(ladspa-vlevel) weakremover(ladspa-vocoder) weakremover(laeqed) weakremover(lagrange) weakremover(lal-devel) weakremover(lalapps) weakremover(lalburst-devel) weakremover(lalframe-devel) weakremover(lalinference-devel) weakremover(lalinspiral-devel) weakremover(lalmetaio-devel) weakremover(lalpulsar-devel) weakremover(lalsimulation-devel) weakremover(lam) weakremover(lam-devel) weakremover(lame) weakremover(lame-doc) weakremover(lame-mp3rtp) weakremover(lammps) weakremover(lammps-devel) weakremover(languagetool) weakremover(lapack-devel) weakremover(lapack-devel-static) weakremover(lapacke-devel) weakremover(lapacke-devel-static) weakremover(lapce) weakremover(lapdog) weakremover(lasem) weakremover(lasem-devel) weakremover(lash) weakremover(lash-devel) weakremover(lastlog2) weakremover(lastlog2-devel) weakremover(lastpass-cli) weakremover(laszip-devel) weakremover(laszip-test) weakremover(latencytop) weakremover(latex2rtf) weakremover(latexila) weakremover(latrace) weakremover(latte-dock) weakremover(layer-shell-qt5) weakremover(layer-shell-qt5-devel) weakremover(lazarus) weakremover(lbdb) weakremover(lbreakouthd) weakremover(lbxproxy) weakremover(lbzip2) weakremover(lcab) weakremover(lcdf-typetools) weakremover(lcms) weakremover(lcms2) weakremover(ld10k1) weakremover(ld10k1-devel) weakremover(ldacBT-devel) weakremover(ldap-yp-tools) weakremover(ldapfuse) weakremover(ldapjdk) weakremover(ldapjdk-javadoc) weakremover(ldapvi) weakremover(ldas-tools-al-devel) weakremover(ldas-tools-al-swig) weakremover(ldas-tools-framecpp-c-devel) weakremover(ldas-tools-framecpp-devel) weakremover(ldas-tools-framecpp-utils) weakremover(ldb-tools) weakremover(ldc) weakremover(ldc-bash-completion) weakremover(ldc-jit-devel) weakremover(ldc-phobos-devel) weakremover(ldc-runtime-devel) weakremover(ldirectord) weakremover(ldmtool) weakremover(ldns) weakremover(ldns-devel) weakremover(ldtp) weakremover(leafnode) weakremover(leafpad) weakremover(ledger) weakremover(ledmon) weakremover(leechcraft) weakremover(leechcraft-advancednotifications) weakremover(leechcraft-aggregator) weakremover(leechcraft-aggregator-bodyfetch) weakremover(leechcraft-aggregator-webaccess) weakremover(leechcraft-anhero) weakremover(leechcraft-auscrie) weakremover(leechcraft-azoth) weakremover(leechcraft-azoth-abbrev) weakremover(leechcraft-azoth-acetamide) weakremover(leechcraft-azoth-adiumstyles) weakremover(leechcraft-azoth-astrality) weakremover(leechcraft-azoth-autoidler) weakremover(leechcraft-azoth-autopaste) weakremover(leechcraft-azoth-birthdaynotifier) weakremover(leechcraft-azoth-chathistory) weakremover(leechcraft-azoth-depester) weakremover(leechcraft-azoth-embedmedia) weakremover(leechcraft-azoth-herbicide) weakremover(leechcraft-azoth-hili) weakremover(leechcraft-azoth-isterique) weakremover(leechcraft-azoth-juick) weakremover(leechcraft-azoth-keeso) weakremover(leechcraft-azoth-lastseen) weakremover(leechcraft-azoth-metacontacts) weakremover(leechcraft-azoth-modnok) weakremover(leechcraft-azoth-mucommands) weakremover(leechcraft-azoth-murm) weakremover(leechcraft-azoth-nativeemoticons) weakremover(leechcraft-azoth-otroid) weakremover(leechcraft-azoth-rosenthal) weakremover(leechcraft-azoth-shx) weakremover(leechcraft-azoth-standardstyles) weakremover(leechcraft-azoth-vader) weakremover(leechcraft-azoth-velvetbird) weakremover(leechcraft-azoth-woodpecker) weakremover(leechcraft-azoth-xoox) weakremover(leechcraft-azoth-xtazy) weakremover(leechcraft-bittorrent) weakremover(leechcraft-blasq) weakremover(leechcraft-blasq-deathnote) weakremover(leechcraft-blasq-rappor) weakremover(leechcraft-blasq-spegnersi) weakremover(leechcraft-blasq-vangog) weakremover(leechcraft-blogique) weakremover(leechcraft-blogique-hestia) weakremover(leechcraft-blogique-metida) weakremover(leechcraft-certmgr) weakremover(leechcraft-cpuload) weakremover(leechcraft-cstp) weakremover(leechcraft-dbusmanager) weakremover(leechcraft-deadlyrics) weakremover(leechcraft-devel) weakremover(leechcraft-devmon) weakremover(leechcraft-dolozhee) weakremover(leechcraft-dumbeep) weakremover(leechcraft-eleeminator) weakremover(leechcraft-fenet) weakremover(leechcraft-gacts) weakremover(leechcraft-glance) weakremover(leechcraft-gmailnotifier) weakremover(leechcraft-harbinger) weakremover(leechcraft-historyholder) weakremover(leechcraft-hotstreams) weakremover(leechcraft-htthare) weakremover(leechcraft-imgaste) weakremover(leechcraft-intermutko) weakremover(leechcraft-kbswitch) weakremover(leechcraft-kinotify) weakremover(leechcraft-knowhow) weakremover(leechcraft-krigstask) weakremover(leechcraft-lackman) weakremover(leechcraft-lastfmscrobble) weakremover(leechcraft-laughty) weakremover(leechcraft-launchy) weakremover(leechcraft-lemon) weakremover(leechcraft-lhtr) weakremover(leechcraft-liznoo) weakremover(leechcraft-lmp) weakremover(leechcraft-lmp-brainslugz) weakremover(leechcraft-lmp-dumbsync) weakremover(leechcraft-lmp-fradj) weakremover(leechcraft-lmp-graffiti) weakremover(leechcraft-lmp-httstream) weakremover(leechcraft-lmp-mp3tunes) weakremover(leechcraft-lmp-mtpsync) weakremover(leechcraft-lmp-potorchu) weakremover(leechcraft-lmp-ppl) weakremover(leechcraft-mellonetray) weakremover(leechcraft-monocle) weakremover(leechcraft-monocle-dik) weakremover(leechcraft-monocle-fxb) weakremover(leechcraft-monocle-pdf) weakremover(leechcraft-monocle-postrus) weakremover(leechcraft-monocle-seen) weakremover(leechcraft-musiczombie) weakremover(leechcraft-namauth) weakremover(leechcraft-netstoremanager) weakremover(leechcraft-netstoremanager-googledrive) weakremover(leechcraft-networkmonitor) weakremover(leechcraft-newlife) weakremover(leechcraft-ooronee) weakremover(leechcraft-otlozhu) weakremover(leechcraft-pintab) weakremover(leechcraft-pogooglue) weakremover(leechcraft-popishu) weakremover(leechcraft-poshuku) weakremover(leechcraft-poshuku-autosearch) weakremover(leechcraft-poshuku-cleanweb) weakremover(leechcraft-poshuku-dcac) weakremover(leechcraft-poshuku-fatape) weakremover(leechcraft-poshuku-filescheme) weakremover(leechcraft-poshuku-foc) weakremover(leechcraft-poshuku-fua) weakremover(leechcraft-poshuku-keywords) weakremover(leechcraft-poshuku-onlinebookmarks) weakremover(leechcraft-poshuku-onlinebookmarks-delicious) weakremover(leechcraft-poshuku-onlinebookmarks-readitlater) weakremover(leechcraft-poshuku-qrd) weakremover(leechcraft-poshuku-speeddial) weakremover(leechcraft-poshuku-webengineview) weakremover(leechcraft-poshuku-webkitview) weakremover(leechcraft-qrosp) weakremover(leechcraft-rosenthal) weakremover(leechcraft-sb2) weakremover(leechcraft-scroblibre) weakremover(leechcraft-secman) weakremover(leechcraft-secman-simplestorage) weakremover(leechcraft-seekthru) weakremover(leechcraft-summary) weakremover(leechcraft-sysnotify) weakremover(leechcraft-tabsessionmanager) weakremover(leechcraft-tabslist) weakremover(leechcraft-textogroose) weakremover(leechcraft-touchstreams) weakremover(leechcraft-tpi) weakremover(leechcraft-vgrabber) weakremover(leechcraft-vrooby) weakremover(leechcraft-vtyulc) weakremover(leechcraft-xproxy) weakremover(leechcraft-xtazy) weakremover(leechcraft-zalil) weakremover(leftwm) weakremover(legion-devel) weakremover(lekha) weakremover(lemon) weakremover(lemon-devel) weakremover(lemon-doc) weakremover(lemonbar) weakremover(lensfun-devel) weakremover(lensfun-doc) weakremover(lensfun-tools) weakremover(lentil) weakremover(leocad) weakremover(leptonica-devel) weakremover(leptonica-tools) weakremover(less) weakremover(lessons4lizards_en) weakremover(letshelp-certbot) weakremover(leveldb) weakremover(leveldb-devel) weakremover(leveldb-devel-static) weakremover(levmar-devel) weakremover(lftp) weakremover(lha) weakremover(lhasa) weakremover(lhasa-devel) weakremover(lib++dfb-1_7-1) weakremover(lib++dfb-1_7-6) weakremover(lib++dfb-devel) weakremover(lib2geom-devel) weakremover(lib2geom1_1_0) weakremover(lib2geom1_2_0) weakremover(lib3270-5_0) weakremover(lib3270-5_1) weakremover(lib3270-5_2) weakremover(lib3270-5_3) weakremover(lib3270-5_4) weakremover(lib3270-devel) weakremover(lib389) weakremover(lib3ds-1-3) weakremover(lib3ds-devel) weakremover(lib4store-devel) weakremover(lib4store0) weakremover(lib4ti2-0) weakremover(lib5250-0) weakremover(lib96BoardsGPIO0) weakremover(libADLMIDI1) weakremover(libAPFEL0) weakremover(libAlembic1_7) weakremover(libAlembic1_8) weakremover(libAnalitza5) weakremover(libAnalitza8) weakremover(libAppStreamQt-devel) weakremover(libAppStreamQt2) weakremover(libAppstreamQt-devel) weakremover(libAppstreamQt1) weakremover(libArcus-devel) weakremover(libArcus-lulzbot-devel) weakremover(libArcus3) weakremover(libArcus3-lulzbot) weakremover(libAvogadro1) weakremover(libBasicUsageEnvironment1) weakremover(libBasicUsageEnvironment2) weakremover(libBox2D-devel) weakremover(libBox2D2_3_1) weakremover(libBulletFileLoader2_83) weakremover(libBulletFileLoader2_86) weakremover(libBulletFileLoader2_88) weakremover(libBulletFileLoader2_89) weakremover(libBulletFileLoader3_17) weakremover(libBulletInverseDynamicsUtils2_83) weakremover(libBulletInverseDynamicsUtils2_86) weakremover(libBulletInverseDynamicsUtils2_88) weakremover(libBulletInverseDynamicsUtils2_89) weakremover(libBulletInverseDynamicsUtils3_17) weakremover(libBulletWorldImporter2_83) weakremover(libBulletWorldImporter2_86) weakremover(libBulletWorldImporter2_88) weakremover(libBulletWorldImporter2_89) weakremover(libBulletWorldImporter3_17) weakremover(libBulletXmlWorldImporter2_83) weakremover(libBulletXmlWorldImporter2_86) weakremover(libBulletXmlWorldImporter2_88) weakremover(libBulletXmlWorldImporter2_89) weakremover(libBulletXmlWorldImporter3_17) weakremover(libCEGUI-0) weakremover(libCEGUIIrrlichtRenderer-0-2) weakremover(libCEGUINullRenderer-0-2) weakremover(libCEGUIOgreRenderer-0-2) weakremover(libCEGUIOpenGLESRenderer-0-2) weakremover(libCEGUIOpenGLRenderer-0-2) weakremover(libCGAL10) weakremover(libCGAL13) weakremover(libCGAL_Core13) weakremover(libCGAL_ImageIO14) weakremover(libCSXCAD0) weakremover(libCbc3) weakremover(libCgl1) weakremover(libCharLS1) weakremover(libCharLS2) weakremover(libClp1) weakremover(libCoin60) weakremover(libCoin80) weakremover(libCoinUtils3) weakremover(libColPack0) weakremover(libColorFull0) weakremover(libConvexDecomposition2_83) weakremover(libConvexDecomposition2_86) weakremover(libConvexDecomposition2_88) weakremover(libConvexDecomposition2_89) weakremover(libConvexDecomposition3_17) weakremover(libDWaylandClient5) weakremover(libDWaylandServer5) weakremover(libDebugUtils1) weakremover(libDetour1) weakremover(libDetourCrowd1) weakremover(libDetourTileCache1) weakremover(libEMF-devel) weakremover(libEMF-utils) weakremover(libEMF1) weakremover(libEspresso4) weakremover(libFAudio0) weakremover(libFLAC++10) weakremover(libFLAC++6) weakremover(libFLAC12) weakremover(libFLAC8) weakremover(libFOX-1_6-0) weakremover(libFS-devel) weakremover(libFS6) weakremover(libFcitx5Config6) weakremover(libFcitx5Core7) weakremover(libFcitx5GClient-devel) weakremover(libFcitx5GClient2) weakremover(libFcitx5Qt5DBusAddons1) weakremover(libFcitx5Qt5WidgetsAddons2) weakremover(libFcitx5Qt6DBusAddons1) weakremover(libFcitx5Utils2) weakremover(libFuzzer) weakremover(libGIMPACTUtils2_83) weakremover(libGIMPACTUtils2_86) weakremover(libGIMPACTUtils2_88) weakremover(libGIMPACTUtils2_89) weakremover(libGIMPACTUtils3_17) weakremover(libGLC-devel) weakremover(libGLC0) weakremover(libGLEW1_13) weakremover(libGLEW2_1) weakremover(libGLEW2_2) weakremover(libGLU1) weakremover(libGLw-devel) weakremover(libGLw1) weakremover(libGLwM1) weakremover(libGammu7) weakremover(libGammu8) weakremover(libGeneratedSaxParser0_3) weakremover(libGeoIP-devel) weakremover(libGeoIP1) weakremover(libGetDP2_11) weakremover(libGetDP2_4) weakremover(libGraphicsMagick++-Q16-12) weakremover(libGraphicsMagick++-devel) weakremover(libGraphicsMagick-Q16-3) weakremover(libGraphicsMagick3-config) weakremover(libGraphicsMagickWand-Q16-2) weakremover(libHACD2_83) weakremover(libHACD2_86) weakremover(libHACD2_88) weakremover(libHACD2_89) weakremover(libHACD3_17) weakremover(libHBAAPI2) weakremover(libHBAAPI2-devel) weakremover(libHUpnp1) weakremover(libHX-devel) weakremover(libHX28) weakremover(libHX32) weakremover(libHYPRE-gnu-mpich-hpc) weakremover(libHYPRE-gnu-mvapich2-hpc) weakremover(libHYPRE-gnu-openmpi1-hpc) weakremover(libHYPRE-gnu-openmpi2-hpc) weakremover(libHYPRE-gnu-openmpi3-hpc) weakremover(libHYPRE-gnu-openmpi4-hpc) weakremover(libHYPRE0) weakremover(libHYPRE0-mpich) weakremover(libHYPRE0-mvapich2) weakremover(libHYPRE0-openmpi) weakremover(libHYPRE0-openmpi2) weakremover(libHYPRE2_18_2) weakremover(libHYPRE2_18_2-mpich) weakremover(libHYPRE2_18_2-mvapich2) weakremover(libHYPRE2_18_2-openmpi1) weakremover(libHYPRE2_18_2-openmpi2) weakremover(libHYPRE2_18_2-openmpi3) weakremover(libHYPRE2_18_2-openmpi4) weakremover(libHYPRE2_20_0) weakremover(libHYPRE2_20_0-mpich) weakremover(libHYPRE2_20_0-mvapich2) weakremover(libHYPRE2_20_0-openmpi1) weakremover(libHYPRE2_20_0-openmpi2) weakremover(libHYPRE2_20_0-openmpi3) weakremover(libHYPRE2_20_0-openmpi4) weakremover(libHYPRE_2_15_1-gnu-mpich-hpc) weakremover(libHYPRE_2_15_1-gnu-mvapich2-hpc) weakremover(libHYPRE_2_15_1-gnu-openmpi1-hpc) weakremover(libHYPRE_2_15_1-gnu-openmpi2-hpc) weakremover(libHYPRE_2_15_1-gnu-openmpi3-hpc) weakremover(libHYPRE_2_17_0-gnu-mpich-hpc) weakremover(libHYPRE_2_17_0-gnu-mvapich2-hpc) weakremover(libHYPRE_2_17_0-gnu-openmpi1-hpc) weakremover(libHYPRE_2_17_0-gnu-openmpi2-hpc) weakremover(libHYPRE_2_17_0-gnu-openmpi3-hpc) weakremover(libHYPRE_2_18_2-gnu-mpich-hpc) weakremover(libHYPRE_2_18_2-gnu-mvapich2-hpc) weakremover(libHYPRE_2_18_2-gnu-openmpi1-hpc) weakremover(libHYPRE_2_18_2-gnu-openmpi2-hpc) weakremover(libHYPRE_2_18_2-gnu-openmpi3-hpc) weakremover(libHYPRE_2_18_2-gnu-openmpi4-hpc) weakremover(libHYPRE_2_20_0-gnu-mpich-hpc) weakremover(libHYPRE_2_20_0-gnu-mvapich2-hpc) weakremover(libHYPRE_2_20_0-gnu-openmpi1-hpc) weakremover(libHYPRE_2_20_0-gnu-openmpi2-hpc) weakremover(libHYPRE_2_20_0-gnu-openmpi3-hpc) weakremover(libHYPRE_2_20_0-gnu-openmpi4-hpc) weakremover(libHalf-2_4-24) weakremover(libHalf-2_5-25) weakremover(libHalf11) weakremover(libHalf23) weakremover(libHalf24) weakremover(libHepMC-3_0_0) weakremover(libHepMC3-1) weakremover(libHepMC3-3) weakremover(libHepMC3search4) weakremover(libHepMC4) weakremover(libICE-devel) weakremover(libICE6) weakremover(libIDL-2-0) weakremover(libIL1) weakremover(libIMECore0) weakremover(libIMEPinyin0) weakremover(libIMETable0) weakremover(libIccXML-devel) weakremover(libIccXML2) weakremover(libIex-2_1-11) weakremover(libIex-2_2-23) weakremover(libIex-2_3-24) weakremover(libIex-2_4-24) weakremover(libIex-2_5-25) weakremover(libIex-3_1-30) weakremover(libIexMath-2_1-11) weakremover(libIexMath-2_2-23) weakremover(libIexMath-2_3-24) weakremover(libIexMath-2_4-24) weakremover(libIexMath-2_5-25) weakremover(libIlmImf-2_2-23) weakremover(libIlmImf-2_3-24) weakremover(libIlmImf-2_4-24) weakremover(libIlmImf-2_5-25) weakremover(libIlmImf-Imf_2_1-21) weakremover(libIlmImfUtil-2_2-23) weakremover(libIlmImfUtil-2_3-24) weakremover(libIlmImfUtil-2_4-24) weakremover(libIlmImfUtil-2_5-25) weakremover(libIlmThread-2_1-11) weakremover(libIlmThread-2_2-23) weakremover(libIlmThread-2_3-24) weakremover(libIlmThread-2_4-24) weakremover(libIlmThread-2_5-25) weakremover(libIlmThread-3_1-30) weakremover(libImath-2_1-11) weakremover(libImath-2_2-23) weakremover(libImath-2_3-24) weakremover(libImath-2_4-24) weakremover(libImath-2_5-25) weakremover(libImath-3_1-29) weakremover(libImlib2-1) weakremover(libIrrlicht1_8) weakremover(libJudy1) weakremover(libKChart2) weakremover(libKDb3-3) weakremover(libKDb3-4) weakremover(libKEduVocDocument5) weakremover(libKF5Activities5) weakremover(libKF5ActivitiesStats1) weakremover(libKF5AkonadiAgentBase5) weakremover(libKF5AkonadiCalendar5) weakremover(libKF5AkonadiContact5) weakremover(libKF5AkonadiCore5) weakremover(libKF5AkonadiMime5) weakremover(libKF5AkonadiNotes5) weakremover(libKF5AkonadiPrivate5) weakremover(libKF5AkonadiSearch) weakremover(libKF5AkonadiSearch5) weakremover(libKF5AkonadiWidgets5) weakremover(libKF5AkonadiXml5) weakremover(libKF5AlarmCalendar5) weakremover(libKF5Archive5) weakremover(libKF5Attica5) weakremover(libKF5Auth5) weakremover(libKF5AuthCore5) weakremover(libKF5Baloo5) weakremover(libKF5BalooEngine5) weakremover(libKF5Blog5) weakremover(libKF5BluezQt6) weakremover(libKF5Bookmarks5) weakremover(libKF5CalendarCore5) weakremover(libKF5CalendarEvents5) weakremover(libKF5CalendarSupport5) weakremover(libKF5CalendarUtils5) weakremover(libKF5Cddb5) weakremover(libKF5CddbWidgets5) weakremover(libKF5Codecs5) weakremover(libKF5CompactDisc5) weakremover(libKF5Completion5) weakremover(libKF5ConfigCore5) weakremover(libKF5ConfigGui5) weakremover(libKF5ConfigQml5) weakremover(libKF5ConfigWidgets5) weakremover(libKF5ContactEditor5) weakremover(libKF5Contacts5) weakremover(libKF5CoreAddons5) weakremover(libKF5Crash5) weakremover(libKF5DAV5) weakremover(libKF5DBusAddons5) weakremover(libKF5DNSSD5) weakremover(libKF5Declarative5) weakremover(libKF5DocTools5) weakremover(libKF5Emoticons5) weakremover(libKF5EventViews5) weakremover(libKF5GAPIBlogger5) weakremover(libKF5GAPICalendar5) weakremover(libKF5GAPIContacts5) weakremover(libKF5GAPICore5) weakremover(libKF5GAPIDrive5) weakremover(libKF5GAPILatitude5) weakremover(libKF5GAPIMaps5) weakremover(libKF5GAPITasks5) weakremover(libKF5GlobalAccel5) weakremover(libKF5GlobalAccelPrivate5) weakremover(libKF5GrantleeTheme5) weakremover(libKF5Gravatar5) weakremover(libKF5GuiAddons5) weakremover(libKF5Holidays5) weakremover(libKF5I18n5) weakremover(libKF5IMAP5) weakremover(libKF5IconThemes5) weakremover(libKF5IdentityManagement5) weakremover(libKF5IdentityManagementWidgets5) weakremover(libKF5IdleTime5) weakremover(libKF5IncidenceEditor5) weakremover(libKF5ItemModels5) weakremover(libKF5ItemViews5) weakremover(libKF5JS5) weakremover(libKF5JSApi5) weakremover(libKF5JobWidgets5) weakremover(libKF5JsEmbed5) weakremover(libKF5KCMUtils5) weakremover(libKF5KCMUtilsCore5) weakremover(libKF5KDEGames7) weakremover(libKF5KDELibs4Support5) weakremover(libKF5KDGantt2-5) weakremover(libKF5KDcraw5) weakremover(libKF5KExiv2-15_0_0) weakremover(libKF5KFace10_0_0) weakremover(libKF5KGeoMap10_0_0) weakremover(libKF5KHtml5) weakremover(libKF5KMahjongglib5) weakremover(libKF5KWeatherCore5) weakremover(libKF5Kipi31_0_0) weakremover(libKF5Kipi32_0_0) weakremover(libKF5Kirigami2-5) weakremover(libKF5KontactInterface5) weakremover(libKF5Ldap5) weakremover(libKF5Libkdepim5) weakremover(libKF5LibkdepimAkonadi5) weakremover(libKF5Libkleo5) weakremover(libKF5MailCommon5) weakremover(libKF5MailImporter5) weakremover(libKF5MailImporterAkonadi5) weakremover(libKF5MailTransport5) weakremover(libKF5MailTransportAkonadi5) weakremover(libKF5Mbox5) weakremover(libKF5MediaPlayer5) weakremover(libKF5MediaWiki5) weakremover(libKF5Mime5) weakremover(libKF5ModemManagerQt-devel) weakremover(libKF5ModemManagerQt6) weakremover(libKF5NetworkManagerQt-devel) weakremover(libKF5NetworkManagerQt6) weakremover(libKF5NewStuff5) weakremover(libKF5NewStuffCore5) weakremover(libKF5NewStuffWidgets5) weakremover(libKF5Notifications5) weakremover(libKF5NotifyConfig5) weakremover(libKF5Parts5) weakremover(libKF5PimCommon5) weakremover(libKF5PimCommonAkonadi5) weakremover(libKF5PimCommonAutoCorrection5) weakremover(libKF5PimTextEdit5) weakremover(libKF5Plasma5) weakremover(libKF5Plotting5) weakremover(libKF5Prison5) weakremover(libKF5Pty5) weakremover(libKF5PulseAudioQt1) weakremover(libKF5PulseAudioQt2) weakremover(libKF5PulseAudioQt3) weakremover(libKF5Purpose5) weakremover(libKF5PurposeWidgets5) weakremover(libKF5QGpgme5) weakremover(libKF5QuickAddons5) weakremover(libKF5Runner5) weakremover(libKF5Sane5) weakremover(libKF5Screen7) weakremover(libKF5Screen7-lang) weakremover(libKF5Screen8) weakremover(libKF5ScreenDpms8) weakremover(libKF5Solid5) weakremover(libKF5SonnetCore5) weakremover(libKF5SonnetUi5) weakremover(libKF5Style5) weakremover(libKF5Su5) weakremover(libKF5Syndication5) weakremover(libKF5SyntaxHighlighting5) weakremover(libKF5TextAutoCorrection1) weakremover(libKF5TextEditTextToSpeech1) weakremover(libKF5TextGrammarCheck1) weakremover(libKF5TextTranslator1) weakremover(libKF5TextWidgets5) weakremover(libKF5ThreadWeaver5) weakremover(libKF5Tnef5) weakremover(libKF5Torrent6) weakremover(libKF5UnitConversion5) weakremover(libKF5Vkontakte2) weakremover(libKF5Wallet5) weakremover(libKF5WebKit5) weakremover(libKF5WidgetsAddons5) weakremover(libKF5WindowSystem5) weakremover(libKF5XmlGui5) weakremover(libKF5XmlRpcClient5) weakremover(libKGantt2) weakremover(libKOSM1) weakremover(libKOSMIndoorMap1) weakremover(libKOpeningHours1) weakremover(libKPim5AddressbookImportExport5) weakremover(libKPim5AddressbookImportExport5-devel) weakremover(libKPim5AkonadiAgentBase5) weakremover(libKPim5AkonadiCalendar5) weakremover(libKPim5AkonadiContact5) weakremover(libKPim5AkonadiCore5) weakremover(libKPim5AkonadiMime5) weakremover(libKPim5AkonadiNotes5) weakremover(libKPim5AkonadiPrivate5) weakremover(libKPim5AkonadiSearch5) weakremover(libKPim5AkonadiWidgets5) weakremover(libKPim5AkonadiXml5) weakremover(libKPim5CalendarSupport5) weakremover(libKPim5CalendarUtils5) weakremover(libKPim5ContactEditor5) weakremover(libKPim5EventViews5) weakremover(libKPim5GAPIBlogger5) weakremover(libKPim5GAPICalendar5) weakremover(libKPim5GAPICore5) weakremover(libKPim5GAPIDrive5) weakremover(libKPim5GAPILatitude5) weakremover(libKPim5GAPIMaps5) weakremover(libKPim5GAPIPeople5) weakremover(libKPim5GAPITasks5) weakremover(libKPim5GrantleeTheme5) weakremover(libKPim5Gravatar5) weakremover(libKPim5IMAP5) weakremover(libKPim5IdentityManagement5) weakremover(libKPim5IdentityManagementWidgets5) weakremover(libKPim5ImportWizard5) weakremover(libKPim5IncidenceEditor5) weakremover(libKPim5Itinerary5) weakremover(libKPim5KontactInterface5) weakremover(libKPim5Ldap5) weakremover(libKPim5Libkdepim5) weakremover(libKPim5MailCommon5) weakremover(libKPim5MailImporter5) weakremover(libKPim5MailImporterAkonadi5) weakremover(libKPim5MailTransport5) weakremover(libKPim5MailTransportAkonadi5) weakremover(libKPim5Mbox5) weakremover(libKPim5Mime5) weakremover(libKPim5PkPass5) weakremover(libKPim5SMTP5) weakremover(libKPim5TextEdit5) weakremover(libKPim5Tnef5) weakremover(libKPim5libkleo5) weakremover(libKPimAddressbookImportExport5) weakremover(libKPimAddressbookImportExport5-devel) weakremover(libKPimGAPIBlogger5) weakremover(libKPimGAPICalendar5) weakremover(libKPimGAPIContacts5) weakremover(libKPimGAPICore5) weakremover(libKPimGAPIDrive5) weakremover(libKPimGAPILatitude5) weakremover(libKPimGAPIMaps5) weakremover(libKPimGAPITasks5) weakremover(libKPimImportWizard5) weakremover(libKPimItinerary5) weakremover(libKPimItinerary5-lang) weakremover(libKPimKDAV5) weakremover(libKPimPkPass5) weakremover(libKPimSMTP5) weakremover(libKPipeWire5) weakremover(libKPipeWireDmaBuf5) weakremover(libKPipeWireRecord5) weakremover(libKPropertyCore3-3) weakremover(libKPropertyCore3-4) weakremover(libKPropertyWidgets3-3) weakremover(libKPropertyWidgets3-4) weakremover(libKPublicTransport1) weakremover(libKPublicTransportOnboard1) weakremover(libKReport3-3) weakremover(libKReport3-4) weakremover(libKSaneCore1) weakremover(libKScreenLocker5) weakremover(libKSeExpr4) weakremover(libKSeExpr4_0_1_0) weakremover(libKSeExpr4_0_2_0) weakremover(libKSysGuardSystemStats1) weakremover(libKUserFeedbackCore1) weakremover(libKUserFeedbackWidgets1) weakremover(libKWaylandServer5) weakremover(libKasten4) weakremover(libLASi-devel) weakremover(libLASi1) weakremover(libLASi2) weakremover(libLHAPDF) weakremover(libLHAPDF-6_2_1) weakremover(libLHAPDF-6_2_3) weakremover(libLHAPDF-6_3_0) weakremover(libLHAPDF-6_4_0) weakremover(libLHAPDF-6_5_1) weakremover(libLHAPDF-6_5_3) weakremover(libLHAPDF-6_5_4) weakremover(libLLVM) weakremover(libLLVM10) weakremover(libLLVM11) weakremover(libLLVM12) weakremover(libLLVM13) weakremover(libLLVM14) weakremover(libLLVM15) weakremover(libLLVM16) weakremover(libLLVM4) weakremover(libLLVM5) weakremover(libLLVM6) weakremover(libLLVM7) weakremover(libLLVM8) weakremover(libLLVM9) weakremover(libLLVMSPIRVLib-devel) weakremover(libLLVMSPIRVLib15) weakremover(libLLVMSPIRVLib16) weakremover(libLTO10) weakremover(libLTO11) weakremover(libLTO12) weakremover(libLTO13) weakremover(libLTO14) weakremover(libLTO15) weakremover(libLTO16) weakremover(libLTO4) weakremover(libLTO5) weakremover(libLTO6) weakremover(libLTO7) weakremover(libLTO8) weakremover(libLTO9) weakremover(libLibreGraphAPI1) weakremover(libLimeSuite18_04-1) weakremover(libLimeSuite18_10-1) weakremover(libLimeSuite19_01-1) weakremover(libLimeSuite19_04-1) weakremover(libLimeSuite20_01-1) weakremover(libLimeSuite20_07-1) weakremover(libLimeSuite20_10-1) weakremover(libLimeSuite22_09-1) weakremover(libMagick++-6_Q16-3) weakremover(libMagick++-7_Q16HDRI4) weakremover(libMagick++-7_Q16HDRI5) weakremover(libMagick++-devel) weakremover(libMagickCore-6_Q16-1) weakremover(libMagickCore-7_Q16HDRI10) weakremover(libMagickCore-7_Q16HDRI6) weakremover(libMagickCore-7_Q16HDRI7) weakremover(libMagickCore-7_Q16HDRI8) weakremover(libMagickCore-7_Q16HDRI9) weakremover(libMagickWand-6_Q16-1) weakremover(libMagickWand-7_Q16HDRI10) weakremover(libMagickWand-7_Q16HDRI6) weakremover(libMagickWand-7_Q16HDRI7) weakremover(libMagickWand-7_Q16HDRI8) weakremover(libMagickWand-7_Q16HDRI9) weakremover(libMathMLSolver0_3) weakremover(libMrm4) weakremover(libMyGUICommon3_4_1) weakremover(libMyGUIEngine3) weakremover(libMyGUIEngine3_4_0) weakremover(libMyGUIEngine3_4_1) weakremover(libNE10-10) weakremover(libNE10_test10) weakremover(libOIS-1_3_0) weakremover(libOIS-devel) weakremover(libOIS1_5_0) weakremover(libOSMesa-devel) weakremover(libOSMesa8) weakremover(libOSMesa9) weakremover(libOgreBites-devel) weakremover(libOgreBites13_2) weakremover(libOgreBites13_3) weakremover(libOgreBites13_5) weakremover(libOgreBites1_12_12) weakremover(libOgreBitesQt13_2) weakremover(libOgreBitesQt13_3) weakremover(libOgreBitesQt13_5) weakremover(libOgreBitesQt1_12_12) weakremover(libOgreMain-devel) weakremover(libOgreMain13_2) weakremover(libOgreMain13_2-codecs) weakremover(libOgreMain13_2-plugins) weakremover(libOgreMain13_3) weakremover(libOgreMain13_3-codecs) weakremover(libOgreMain13_3-plugins) weakremover(libOgreMain13_5) weakremover(libOgreMain13_5-codecs) weakremover(libOgreMain13_5-plugins) weakremover(libOgreMain1_12_12) weakremover(libOgreMain1_12_12-codecs) weakremover(libOgreMain1_12_12-plugins) weakremover(libOgreMain1_9_0) weakremover(libOgreMain1_9_0-plugins) weakremover(libOgreMeshLodGenerator-devel) weakremover(libOgreMeshLodGenerator13_2) weakremover(libOgreMeshLodGenerator13_3) weakremover(libOgreMeshLodGenerator13_5) weakremover(libOgreMeshLodGenerator1_12_12) weakremover(libOgreOverlay-devel) weakremover(libOgreOverlay13_2) weakremover(libOgreOverlay13_3) weakremover(libOgreOverlay13_5) weakremover(libOgreOverlay1_12_12) weakremover(libOgreOverlay1_9_0) weakremover(libOgrePaging-devel) weakremover(libOgrePaging13_2) weakremover(libOgrePaging13_3) weakremover(libOgrePaging13_5) weakremover(libOgrePaging1_12_12) weakremover(libOgrePaging1_9_0) weakremover(libOgreProperty-devel) weakremover(libOgreProperty13_2) weakremover(libOgreProperty13_3) weakremover(libOgreProperty13_5) weakremover(libOgreProperty1_12_12) weakremover(libOgreProperty1_9_0) weakremover(libOgreRTShaderSystem-devel) weakremover(libOgreRTShaderSystem13_2) weakremover(libOgreRTShaderSystem13_3) weakremover(libOgreRTShaderSystem13_5) weakremover(libOgreRTShaderSystem1_12_12) weakremover(libOgreRTShaderSystem1_9_0) weakremover(libOgreTerrain-devel) weakremover(libOgreTerrain13_2) weakremover(libOgreTerrain13_3) weakremover(libOgreTerrain13_5) weakremover(libOgreTerrain1_12_12) weakremover(libOgreTerrain1_9_0) weakremover(libOgreVolume-devel) weakremover(libOgreVolume13_2) weakremover(libOgreVolume13_3) weakremover(libOgreVolume13_5) weakremover(libOgreVolume1_12_12) weakremover(libOgreVolume1_9_0) weakremover(libOkteta3) weakremover(libOpenCL1) weakremover(libOpenCOLLADA0) weakremover(libOpenCOLLADABaseUtils0_3) weakremover(libOpenCOLLADAFramework0_3) weakremover(libOpenCOLLADASaxFrameworkLoader0_3) weakremover(libOpenCOLLADAStreamWriter0_3) weakremover(libOpenColorIO1) weakremover(libOpenColorIO2_0) weakremover(libOpenColorIO2_1) weakremover(libOpenEXR-3_1-30) weakremover(libOpenEXRCore-3_1-30) weakremover(libOpenEXRUtil-3_1-30) weakremover(libOpenIPMI0) weakremover(libOpenIPMIui1) weakremover(libOpenImageIO1_7) weakremover(libOpenImageIO1_8) weakremover(libOpenImageIO2_1) weakremover(libOpenImageIO2_2) weakremover(libOpenImageIO2_3) weakremover(libOpenImageIO2_4) weakremover(libOpenImageIO_Util1_7) weakremover(libOpenImageIO_Util1_8) weakremover(libOpenImageIO_Util2_1) weakremover(libOpenImageIO_Util2_2) weakremover(libOpenImageIO_Util2_3) weakremover(libOpenImageIO_Util2_4) weakremover(libOpenSceneGraph-devel) weakremover(libOpenSceneGraph130) weakremover(libOpenSceneGraph131) weakremover(libOpenSceneGraph131-devel) weakremover(libOpenSceneGraph158) weakremover(libOpenSceneGraph161) weakremover(libOpenThreads-devel) weakremover(libOpenThreads20) weakremover(libOpenThreads20-devel) weakremover(libOpenThreads21) weakremover(libOsi1) weakremover(libOsiCbc3) weakremover(libOsiClp1) weakremover(libOyranosSynnefo-devel) weakremover(libOyranosSynnefo-devel-static) weakremover(libOyranosSynnefo1) weakremover(libPDAL13) weakremover(libPocoActiveRecord82) weakremover(libPocoActiveRecord83) weakremover(libPocoActiveRecord92) weakremover(libPocoCppParser63) weakremover(libPocoCppParser71) weakremover(libPocoCppParser82) weakremover(libPocoCppParser83) weakremover(libPocoCppParser92) weakremover(libPocoCrypto63) weakremover(libPocoCrypto71) weakremover(libPocoCrypto82) weakremover(libPocoCrypto83) weakremover(libPocoCrypto92) weakremover(libPocoData63) weakremover(libPocoData71) weakremover(libPocoData82) weakremover(libPocoData83) weakremover(libPocoData92) weakremover(libPocoDataMySQL63) weakremover(libPocoDataMySQL71) weakremover(libPocoDataMySQL82) weakremover(libPocoDataMySQL83) weakremover(libPocoDataMySQL92) weakremover(libPocoDataODBC63) weakremover(libPocoDataODBC71) weakremover(libPocoDataODBC82) weakremover(libPocoDataODBC83) weakremover(libPocoDataODBC92) weakremover(libPocoDataSQLite63) weakremover(libPocoDataSQLite71) weakremover(libPocoDataSQLite82) weakremover(libPocoDataSQLite83) weakremover(libPocoDataSQLite92) weakremover(libPocoEncodings63) weakremover(libPocoEncodings71) weakremover(libPocoEncodings82) weakremover(libPocoEncodings83) weakremover(libPocoEncodings92) weakremover(libPocoFoundation63) weakremover(libPocoFoundation71) weakremover(libPocoFoundation82) weakremover(libPocoFoundation83) weakremover(libPocoFoundation92) weakremover(libPocoJSON63) weakremover(libPocoJSON71) weakremover(libPocoJSON82) weakremover(libPocoJSON83) weakremover(libPocoJSON92) weakremover(libPocoJWT71) weakremover(libPocoJWT82) weakremover(libPocoJWT83) weakremover(libPocoJWT92) weakremover(libPocoMongoDB63) weakremover(libPocoMongoDB71) weakremover(libPocoMongoDB82) weakremover(libPocoMongoDB83) weakremover(libPocoMongoDB92) weakremover(libPocoNet63) weakremover(libPocoNet71) weakremover(libPocoNet82) weakremover(libPocoNet83) weakremover(libPocoNet92) weakremover(libPocoNetSSL63) weakremover(libPocoNetSSL71) weakremover(libPocoNetSSL82) weakremover(libPocoNetSSL83) weakremover(libPocoNetSSL92) weakremover(libPocoPDF63) weakremover(libPocoPDF71) weakremover(libPocoPDF82) weakremover(libPocoPDF83) weakremover(libPocoPDF92) weakremover(libPocoPrometheus92) weakremover(libPocoRedis63) weakremover(libPocoRedis71) weakremover(libPocoRedis82) weakremover(libPocoRedis83) weakremover(libPocoRedis92) weakremover(libPocoUtil63) weakremover(libPocoUtil71) weakremover(libPocoUtil82) weakremover(libPocoUtil83) weakremover(libPocoUtil92) weakremover(libPocoXML63) weakremover(libPocoXML71) weakremover(libPocoXML82) weakremover(libPocoXML83) weakremover(libPocoXML92) weakremover(libPocoZip63) weakremover(libPocoZip71) weakremover(libPocoZip82) weakremover(libPocoZip83) weakremover(libPocoZip92) weakremover(libQCSXCAD0) weakremover(libQCoro5Core0) weakremover(libQCoro5DBus0) weakremover(libQCoro5Network0) weakremover(libQCoro5Qml0) weakremover(libQCoro5Quick0) weakremover(libQCoro5WebSockets0) weakremover(libQCoro6Core0) weakremover(libQCoro6DBus0) weakremover(libQCoro6Network0) weakremover(libQCoro6Qml0) weakremover(libQCoro6Quick0) weakremover(libQCoro6WebSockets0) weakremover(libQCoroCore0) weakremover(libQCoroDBus0) weakremover(libQCoroNetwork0) weakremover(libQMatrixClient0_4) weakremover(libQMatrixClient0_5_1) weakremover(libQMatrixClient0_5_3) weakremover(libQgpsmm22) weakremover(libQgpsmm23) weakremover(libQgpsmm24) weakremover(libQgpsmm25) weakremover(libQgpsmm27) weakremover(libQgpsmm28) weakremover(libQgpsmm29) weakremover(libQgpsmm30) weakremover(libQt53DAnimation-devel) weakremover(libQt53DAnimation5) weakremover(libQt53DCore-devel) weakremover(libQt53DCore5) weakremover(libQt53DExtras-devel) weakremover(libQt53DExtras5) weakremover(libQt53DInput-devel) weakremover(libQt53DInput5) weakremover(libQt53DLogic-devel) weakremover(libQt53DLogic5) weakremover(libQt53DQuick-devel) weakremover(libQt53DQuick5) weakremover(libQt53DQuickAnimation-devel) weakremover(libQt53DQuickAnimation5) weakremover(libQt53DQuickExtras-devel) weakremover(libQt53DQuickExtras5) weakremover(libQt53DQuickInput-devel) weakremover(libQt53DQuickInput5) weakremover(libQt53DQuickRender-devel) weakremover(libQt53DQuickRender5) weakremover(libQt53DQuickScene2D-devel) weakremover(libQt53DQuickScene2D5) weakremover(libQt53DRender-devel) weakremover(libQt53DRender5) weakremover(libQt5Bluetooth5) weakremover(libQt5Bluetooth5-imports) weakremover(libQt5Bodymovin-devel) weakremover(libQt5Bodymovin-private-headers-devel) weakremover(libQt5Bodymovin5) weakremover(libQt5Bootstrap-devel-static) weakremover(libQt5CLucene5) weakremover(libQt5Charts5) weakremover(libQt5Charts5-designer) weakremover(libQt5Charts5-devel) weakremover(libQt5Compositor5) weakremover(libQt5Concurrent-devel) weakremover(libQt5Concurrent5) weakremover(libQt5Core-devel) weakremover(libQt5Core5) weakremover(libQt5DBus-devel) weakremover(libQt5DBus5) weakremover(libQt5DataVisualization5) weakremover(libQt5DataVisualization5-devel) weakremover(libQt5Designer5) weakremover(libQt5DesignerComponents5) weakremover(libQt5Gamepad5) weakremover(libQt5Gui-devel) weakremover(libQt5Gui5) weakremover(libQt5Help5) weakremover(libQt5HunspellInputMethod-private-headers-devel) weakremover(libQt5HunspellInputMethod5) weakremover(libQt5KmsSupport-devel-static) weakremover(libQt5Location5) weakremover(libQt5Multimedia5) weakremover(libQt5Network-devel) weakremover(libQt5Network5) weakremover(libQt5NetworkAuth5) weakremover(libQt5Nfc5) weakremover(libQt5Nfc5-imports) weakremover(libQt5OpenGL-devel) weakremover(libQt5OpenGL5) weakremover(libQt5OpenGLExtensions-devel-static) weakremover(libQt5Pas-devel) weakremover(libQt5Pas1) weakremover(libQt5Pdf5) weakremover(libQt5PdfWidgets5) weakremover(libQt5PlatformHeaders-devel) weakremover(libQt5PlatformSupport-devel-static) weakremover(libQt5Positioning5) weakremover(libQt5PositioningQuick5) weakremover(libQt5PrintSupport-devel) weakremover(libQt5PrintSupport5) weakremover(libQt5Quick3D5) weakremover(libQt5Quick3DAssetImport5) weakremover(libQt5QuickControls2-5) weakremover(libQt5QuickControls2-devel) weakremover(libQt5QuickTemplates2-5) weakremover(libQt5QuickTemplates2-devel) weakremover(libQt5RemoteObjects5) weakremover(libQt5Script5) weakremover(libQt5Scxml5) weakremover(libQt5Scxml5-imports) weakremover(libQt5Sensors5) weakremover(libQt5Sensors5-imports) weakremover(libQt5SerialBus5) weakremover(libQt5SerialPort5) weakremover(libQt5Sql-devel) weakremover(libQt5Sql5) weakremover(libQt5Sql5-mysql) weakremover(libQt5Sql5-postgresql) weakremover(libQt5Sql5-sqlite) weakremover(libQt5Sql5-unixODBC) weakremover(libQt5Svg5) weakremover(libQt5Test-devel) weakremover(libQt5Test5) weakremover(libQt5TextToSpeech5) weakremover(libQt5VirtualKeyboard5) weakremover(libQt5WaylandClient5) weakremover(libQt5WaylandCompositor5) weakremover(libQt5WebChannel5) weakremover(libQt5WebChannel5-imports) weakremover(libQt5WebKit-private-headers-devel) weakremover(libQt5WebKit5) weakremover(libQt5WebKit5-devel) weakremover(libQt5WebKit5-imports) weakremover(libQt5WebKitWidgets-devel) weakremover(libQt5WebKitWidgets-private-headers-devel) weakremover(libQt5WebKitWidgets5) weakremover(libQt5WebSockets5) weakremover(libQt5WebSockets5-imports) weakremover(libQt5WebView5) weakremover(libQt5WebView5-imports) weakremover(libQt5Widgets-devel) weakremover(libQt5Widgets5) weakremover(libQt5X11Extras5) weakremover(libQt5Xdg2) weakremover(libQt5Xdg3) weakremover(libQt5XdgIconLoader-devel) weakremover(libQt5XdgIconLoader2) weakremover(libQt5XdgIconLoader3) weakremover(libQt5Xml-devel) weakremover(libQt5Xml5) weakremover(libQt5XmlPatterns5) weakremover(libQt63DAnimation6) weakremover(libQt63DCore6) weakremover(libQt63DExtras6) weakremover(libQt63DInput6) weakremover(libQt63DLogic6) weakremover(libQt63DQuick6) weakremover(libQt63DQuickAnimation6) weakremover(libQt63DQuickExtras6) weakremover(libQt63DQuickInput6) weakremover(libQt63DQuickRender6) weakremover(libQt63DQuickScene2D6) weakremover(libQt63DRender6) weakremover(libQt6Bluetooth6) weakremover(libQt6Bodymovin6) weakremover(libQt6Charts6) weakremover(libQt6ChartsQml6) weakremover(libQt6Coap6) weakremover(libQt6Concurrent6) weakremover(libQt6Core5Compat6) weakremover(libQt6Core6) weakremover(libQt6DBus6) weakremover(libQt6DataVisualization6) weakremover(libQt6DataVisualizationQml6) weakremover(libQt6DeclarativeOpcua6) weakremover(libQt6Designer6) weakremover(libQt6DesignerComponents6) weakremover(libQt6Grpc6) weakremover(libQt6Gui6) weakremover(libQt6Help6) weakremover(libQt6HttpServer6) weakremover(libQt6HunspellInputMethod6) weakremover(libQt6JsonRpc6) weakremover(libQt6LabsAnimation6) weakremover(libQt6LabsFolderListModel6) weakremover(libQt6LabsQmlModels6) weakremover(libQt6LabsSettings6) weakremover(libQt6LabsSharedImage6) weakremover(libQt6LabsWavefrontMesh6) weakremover(libQt6LanguageServer6) weakremover(libQt6Location6) weakremover(libQt6Mqtt6) weakremover(libQt6Multimedia6) weakremover(libQt6MultimediaQuick6) weakremover(libQt6MultimediaWidgets6) weakremover(libQt6Network6) weakremover(libQt6NetworkAuth6) weakremover(libQt6Nfc6) weakremover(libQt6OpcUa6) weakremover(libQt6OpenGL6) weakremover(libQt6OpenGLWidgets6) weakremover(libQt6Pdf6) weakremover(libQt6PdfQuick6) weakremover(libQt6PdfWidgets6) weakremover(libQt6Positioning6) weakremover(libQt6PositioningQuick6) weakremover(libQt6PrintSupport6) weakremover(libQt6Protobuf6) weakremover(libQt6Qml6) weakremover(libQt6QmlCompiler6) weakremover(libQt6QmlCore6) weakremover(libQt6QmlLocalStorage6) weakremover(libQt6QmlModels6) weakremover(libQt6QmlWorkerScript6) weakremover(libQt6QmlXmlListModel6) weakremover(libQt6Quick3D6) weakremover(libQt6Quick3DAssetImport6) weakremover(libQt6Quick3DAssetUtils6) weakremover(libQt6Quick3DEffects6) weakremover(libQt6Quick3DGlslParser6) weakremover(libQt6Quick3DHelpers6) weakremover(libQt6Quick3DHelpersImpl6) weakremover(libQt6Quick3DIblBaker6) weakremover(libQt6Quick3DParticleEffects6) weakremover(libQt6Quick3DParticles6) weakremover(libQt6Quick3DPhysics6) weakremover(libQt6Quick3DPhysicsHelpers6) weakremover(libQt6Quick3DRuntimeRender6) weakremover(libQt6Quick3DSpatialAudio6) weakremover(libQt6Quick3DUtils6) weakremover(libQt6Quick6) weakremover(libQt6QuickControls2-6) weakremover(libQt6QuickControls2Impl6) weakremover(libQt6QuickDialogs2-6) weakremover(libQt6QuickDialogs2QuickImpl6) weakremover(libQt6QuickDialogs2Utils6) weakremover(libQt6QuickEffects6) weakremover(libQt6QuickLayouts6) weakremover(libQt6QuickParticles6) weakremover(libQt6QuickShapes6) weakremover(libQt6QuickTemplates2-6) weakremover(libQt6QuickTest6) weakremover(libQt6QuickTimeline6) weakremover(libQt6QuickWidgets6) weakremover(libQt6RemoteObjects6) weakremover(libQt6RemoteObjectsQml6) weakremover(libQt6Scxml6) weakremover(libQt6ScxmlQml6) weakremover(libQt6Sensors6) weakremover(libQt6SensorsQuick6) weakremover(libQt6SerialBus6) weakremover(libQt6SerialPort6) weakremover(libQt6ShaderTools6) weakremover(libQt6SpatialAudio6) weakremover(libQt6Sql6) weakremover(libQt6StateMachine6) weakremover(libQt6StateMachineQml6) weakremover(libQt6Svg6) weakremover(libQt6SvgWidgets6) weakremover(libQt6Test6) weakremover(libQt6TextToSpeech6) weakremover(libQt6UiTools6) weakremover(libQt6VirtualKeyboard6) weakremover(libQt6WaylandClient6) weakremover(libQt6WaylandCompositor6) weakremover(libQt6WaylandEglClientHwIntegration6) weakremover(libQt6WaylandEglCompositorHwIntegration6) weakremover(libQt6WebChannel6) weakremover(libQt6WebEngineCore6) weakremover(libQt6WebEngineQuick6) weakremover(libQt6WebEngineWidgets6) weakremover(libQt6WebSockets6) weakremover(libQt6WebView6) weakremover(libQt6WebViewQuick6) weakremover(libQt6Widgets6) weakremover(libQt6WlShellIntegration6) weakremover(libQt6Xml6) weakremover(libQtAV1) weakremover(libQtAVWidgets1) weakremover(libQtAssistantClient4) weakremover(libQtOlm3_0) weakremover(libQtQuick5) weakremover(libQtSolutions_SOAP-2_7-1) weakremover(libQtWebKit-devel) weakremover(libQtWebKit4) weakremover(libQuotient-devel) weakremover(libQuotient0_6) weakremover(libRaTools0) weakremover(libRecast1) weakremover(libRivet-2_5_2) weakremover(libRivet-2_5_4) weakremover(libRivet-2_6_0) weakremover(libRivet-2_7_2) weakremover(libRivet-3_1_0) weakremover(libRivet-3_1_1) weakremover(libRivet-3_1_2) weakremover(libRivet-3_1_3) weakremover(libRivet-3_1_5) weakremover(libRivet-3_1_6) weakremover(libRivet-3_1_7) weakremover(libSDL-1_2-0) weakremover(libSDL-devel) weakremover(libSDL2-2_0-0) weakremover(libSDL2-devel) weakremover(libSDL2_Pango4) weakremover(libSDL2_gfx-1_0-0) weakremover(libSDL2_gfx-devel) weakremover(libSDL2_image-2_0-0) weakremover(libSDL2_image-devel) weakremover(libSDL2_mixer-2_0-0) weakremover(libSDL2_mixer-devel) weakremover(libSDL2_net-2_0-0) weakremover(libSDL2_net-devel) weakremover(libSDL2_sound2) weakremover(libSDL2_ttf-2_0-0) weakremover(libSDL2_ttf-devel) weakremover(libSDL_Pango-devel) weakremover(libSDL_Pango1) weakremover(libSDL_bgi-devel) weakremover(libSDL_bgi-suse3) weakremover(libSDL_bgi-suse4) weakremover(libSDL_bgi-suse5) weakremover(libSDL_bgi-suse6) weakremover(libSDL_bgi-suse7) weakremover(libSDL_bgi-suse8) weakremover(libSDL_bgi-suse9) weakremover(libSDL_bgi0) weakremover(libSDL_bgi1) weakremover(libSDL_bgi2) weakremover(libSDL_gfx-devel) weakremover(libSDL_gfx15) weakremover(libSDL_image-1_2-0) weakremover(libSDL_image-devel) weakremover(libSDL_mixer-1_2-0) weakremover(libSDL_mixer-devel) weakremover(libSDL_net-1_2-0) weakremover(libSDL_net-devel) weakremover(libSDL_sound-1_0-1) weakremover(libSDL_sound-devel) weakremover(libSDL_ttf-2_0-0) weakremover(libSDL_ttf-devel) weakremover(libSDLmm-0_1-8) weakremover(libSDLmm-devel) weakremover(libSFCGAL1) weakremover(libSHERPA-MC0) weakremover(libSILLY-devel) weakremover(libSILLY1) weakremover(libSM-devel) weakremover(libSM6) weakremover(libSOIL-devel) weakremover(libSOIL1) weakremover(libSPIRV-Tools-1_1) weakremover(libSPIRV-Tools-2022_3) weakremover(libSPIRV-Tools-2022_3_sdk216) weakremover(libSPIRV-Tools-2022_4) weakremover(libSPIRV-Tools-2022_4_sdk236) weakremover(libSPIRV-Tools-2023_1) weakremover(libSPIRV-Tools-2023_2) weakremover(libSPIRV-Tools-suse11) weakremover(libSPIRV-Tools-suse12) weakremover(libSPIRV-Tools-suse13) weakremover(libSPIRV-Tools-suse15) weakremover(libSPIRV-Tools-suse16) weakremover(libSPIRV-Tools-suse17) weakremover(libSPIRV-Tools-suse18) weakremover(libSPIRV-Tools-suse19) weakremover(libSPIRV-Tools-suse20) weakremover(libSPIRV-Tools-suse21) weakremover(libSPIRV-Tools-suse22) weakremover(libSPIRV-Tools-suse23) weakremover(libSPIRV-Tools-suse24) weakremover(libSPIRV-Tools-suse25) weakremover(libSPIRV-Tools-suse4) weakremover(libSPIRV-Tools-suse9) weakremover(libSampleICC-devel) weakremover(libSampleICC1) weakremover(libSampleICC2) weakremover(libSavitar-devel) weakremover(libSavitar0) weakremover(libSciTokens0) weakremover(libSimGearCore-2017_1_2) weakremover(libSimGearCore-2017_3_1) weakremover(libSimGearCore-2018_3_1) weakremover(libSimGearCore-2018_3_2) weakremover(libSimGearCore-2018_3_4) weakremover(libSimGearCore-2020_1_1) weakremover(libSimGearCore-2020_1_2) weakremover(libSimGearCore-2020_1_3) weakremover(libSimGearCore-2020_3_1) weakremover(libSimGearCore-2020_3_11) weakremover(libSimGearCore-2020_3_12) weakremover(libSimGearCore-2020_3_13) weakremover(libSimGearCore-2020_3_17) weakremover(libSimGearCore-2020_3_18) weakremover(libSimGearCore-2020_3_2) weakremover(libSimGearCore-2020_3_4) weakremover(libSimGearCore-2020_3_5) weakremover(libSimGearCore-2020_3_6) weakremover(libSimGearCore-2020_3_8) weakremover(libSimGearCore-2020_3_9) weakremover(libSingular-4_3_1) weakremover(libSingular-devel) weakremover(libSoQt20) weakremover(libSoapyOsmoSDR0) weakremover(libSoapySDR0_6) weakremover(libSoapySDR0_7) weakremover(libSoapySDR0_8) weakremover(libSoundTouch0) weakremover(libSoundTouch1) weakremover(libSoundTouchDll1) weakremover(libStatTimer2) weakremover(libSvtAv1Dec0) weakremover(libSvtAv1Enc1) weakremover(libSwiften4) weakremover(libTMCG-devel) weakremover(libTMCG12) weakremover(libTMCG16) weakremover(libTMCG18) weakremover(libTutf-devel) weakremover(libTutf1) weakremover(libTw-devel) weakremover(libTw5) weakremover(libUTF0_3) weakremover(libUil4) weakremover(libUnitTest++-2_0_0) weakremover(libUsageEnvironment3) weakremover(libVFlib3-10) weakremover(libVFlib3-5) weakremover(libVSyntaxHighlighting1) weakremover(libVTextEdit1) weakremover(libVkLayer_utils-1_2_151) weakremover(libVkLayer_utils-1_2_153) weakremover(libVkLayer_utils-1_2_154) weakremover(libVkLayer_utils-1_2_162_0) weakremover(libVkLayer_utils-1_2_162_1) weakremover(libVkLayer_utils-1_2_165) weakremover(libVkLayer_utils-1_2_166) weakremover(libVkLayer_utils-1_2_170_0) weakremover(libVkLayer_utils-1_2_176_0) weakremover(libVkLayer_utils-1_2_182_0) weakremover(libVkLayer_utils-1_2_189_0) weakremover(libVkLayer_utils-1_2_198_0) weakremover(libVkLayer_utils-1_3_204_0) weakremover(libVkLayer_utils-1_3_211_0) weakremover(libVkLayer_utils-1_3_216_0) weakremover(libVkLayer_utils-1_3_224_0) weakremover(libVkLayer_utils-1_3_224_1) weakremover(libVkLayer_utils-1_3_231_0) weakremover(libVkLayer_utils-1_3_236_0) weakremover(libWN3) weakremover(libWPEBackend-fdo-1_0-1) weakremover(libWildMidi2) weakremover(libX11-6) weakremover(libX11-devel) weakremover(libX11-xcb1) weakremover(libXISF) weakremover(libXISF-devel) weakremover(libXISF0) weakremover(libXNVCtrl-devel) weakremover(libXNVCtrl0) weakremover(libXRes1) weakremover(libXScrnSaver-devel) weakremover(libXTrap-devel) weakremover(libXTrap6) weakremover(libXau-devel) weakremover(libXau6) weakremover(libXaw-devel) weakremover(libXaw3d-devel) weakremover(libXaw3d6) weakremover(libXaw3d7) weakremover(libXaw3d8) weakremover(libXaw6) weakremover(libXaw7) weakremover(libXaw8) weakremover(libXbgi-devel) weakremover(libXbgi1) weakremover(libXcm-devel) weakremover(libXcm0) weakremover(libXcmDDC0) weakremover(libXcmEDID0) weakremover(libXcmX11-0) weakremover(libXcomposite-devel) weakremover(libXcomposite1) weakremover(libXcursor-devel) weakremover(libXcursor1) weakremover(libXdamage-devel) weakremover(libXdamage1) weakremover(libXdgUtilsBaseDir1_0_1) weakremover(libXdgUtilsDesktopEntry1_0_1) weakremover(libXdmcp-devel) weakremover(libXdmcp6) weakremover(libXevie-devel) weakremover(libXevie1) weakremover(libXext-devel) weakremover(libXext6) weakremover(libXfixes-devel) weakremover(libXfixes3) weakremover(libXfont-devel) weakremover(libXfont1) weakremover(libXfont2-2) weakremover(libXfont2-devel) weakremover(libXfontcache-devel) weakremover(libXfontcache1) weakremover(libXft-devel) weakremover(libXft2) weakremover(libXi-devel) weakremover(libXi6) weakremover(libXinerama-devel) weakremover(libXinerama1) weakremover(libXiterm-devel) weakremover(libXiterm1) weakremover(libXm4) weakremover(libXmu-devel) weakremover(libXmu6) weakremover(libXmuu1) weakremover(libXp-devel) weakremover(libXp6) weakremover(libXpm-devel) weakremover(libXpm-tools) weakremover(libXpm4) weakremover(libXpresent-devel) weakremover(libXpresent1) weakremover(libXprintAppUtil-devel) weakremover(libXprintAppUtil1) weakremover(libXprintUtil-devel) weakremover(libXprintUtil1) weakremover(libXrandr-devel) weakremover(libXrandr2) weakremover(libXrender-devel) weakremover(libXrender1) weakremover(libXres-devel) weakremover(libXss-devel) weakremover(libXss1) weakremover(libXt-devel) weakremover(libXt6) weakremover(libXtst-devel) weakremover(libXtst6) weakremover(libXv-devel) weakremover(libXv1) weakremover(libXvMC-devel) weakremover(libXvMC1) weakremover(libXvMC_nouveau) weakremover(libXvMC_r600) weakremover(libXvnc-devel) weakremover(libXvnc1) weakremover(libXxf86dga-devel) weakremover(libXxf86dga1) weakremover(libXxf86misc-devel) weakremover(libXxf86misc1) weakremover(libXxf86vm-devel) weakremover(libXxf86vm1) weakremover(libYODA-1_6_5) weakremover(libYODA-1_6_7) weakremover(libYODA-1_7_0) weakremover(libYODA-1_7_4) weakremover(libYODA-1_7_7) weakremover(libYODA-1_8_0) weakremover(libYODA-1_8_3) weakremover(libYODA-1_8_4) weakremover(libYODA-1_8_5) weakremover(libYODA-1_9_0) weakremover(libYODA-1_9_4) weakremover(libYODA-1_9_5) weakremover(libYODA-1_9_6) weakremover(libYODA-1_9_7) weakremover(libZXing1) weakremover(libZXing3) weakremover(libZXingCore1) weakremover(liba2ps1) weakremover(liba52-0) weakremover(liba52-devel) weakremover(libaa1) weakremover(libaal-1_0-6) weakremover(libaal-1_0-7) weakremover(libaal-devel) weakremover(libaal-devel-static) weakremover(libaal-minimal0) weakremover(libabigail-devel) weakremover(libabigail-tools) weakremover(libabigail0) weakremover(libabiword-3_0) weakremover(libabiword-3_0-devel) weakremover(libabseil0) weakremover(libabsl2111_0_0) weakremover(libabsl2206_0_0) weakremover(libabsl2301_0_0) weakremover(libabw-0_1-1) weakremover(libabw-devel) weakremover(libabw-tools) weakremover(libacars-2-2) weakremover(libacars-devel) weakremover(libacars1) weakremover(libacars2-devel) weakremover(libaccel-config1) weakremover(libaccounts-glib-devel) weakremover(libaccounts-glib-tools) weakremover(libaccounts-glib0) weakremover(libaccounts-glib1) weakremover(libaccounts-qt5-1) weakremover(libaccounts-qt5-devel) weakremover(libaccounts-qt5-tools) weakremover(libaccountsservice0) weakremover(libacl-devel) weakremover(libacl1) weakremover(libacr38ucontrol0) weakremover(libada10) weakremover(libada11) weakremover(libada12) weakremover(libada13) weakremover(libada7) weakremover(libada8) weakremover(libada9) weakremover(libaddrxlat-devel) weakremover(libaddrxlat0) weakremover(libaddrxlat1) weakremover(libaddrxlat2) weakremover(libaddrxlat3) weakremover(libadlmidi-devel) weakremover(libadms0) weakremover(libadns-devel) weakremover(libadns1) weakremover(libadolc2) weakremover(libadplug-devel) weakremover(libadplug2_3_3-0) weakremover(libadwaita-1-0) weakremover(libadwaita-devel) weakremover(libadwaita-qt5-devel) weakremover(libadwaita-qt6-devel) weakremover(libadwaitaqt-devel) weakremover(libadwaitaqt1) weakremover(libadwaitaqt1_2_0) weakremover(libadwaitaqt5-1) weakremover(libadwaitaqt6-1) weakremover(libaec-devel) weakremover(libaec0) weakremover(libagdb-devel) weakremover(libagdb-tools) weakremover(libagdb1) weakremover(libagg2) weakremover(libags1) weakremover(libags2) weakremover(libags3) weakremover(libags4) weakremover(libaio-devel) weakremover(libaio1) weakremover(libairspy0) weakremover(libairspyhf0) weakremover(libakai0) weakremover(libakonadi4) weakremover(libakonadiprotocolinternals-devel) weakremover(libakonadiprotocolinternals1) weakremover(libalac-devel) weakremover(libalac0) weakremover(libaldmb-0_9_3) weakremover(libaldmb-devel) weakremover(libalkimia-devel) weakremover(libalkimia4) weakremover(libalkimia5-7) weakremover(libalkimia5-8) weakremover(libalkimia5-devel) weakremover(libalkimia7) weakremover(liballeg-devel) weakremover(liballeg44-devel) weakremover(liballeg4_4) weakremover(liballeggl-devel) weakremover(liballeggl44-devel) weakremover(liballeggl4_4) weakremover(liballegro5_2) weakremover(liballegro5_2-devel) weakremover(liballegro_acodec5_2) weakremover(liballegro_acodec5_2-devel) weakremover(liballegro_audio5_2) weakremover(liballegro_audio5_2-devel) weakremover(liballegro_color5_2) weakremover(liballegro_color5_2-devel) weakremover(liballegro_dialog5_2) weakremover(liballegro_dialog5_2-devel) weakremover(liballegro_font5_2) weakremover(liballegro_font5_2-devel) weakremover(liballegro_image5_2) weakremover(liballegro_image5_2-devel) weakremover(liballegro_main5_2) weakremover(liballegro_main5_2-devel) weakremover(liballegro_memfile5_2) weakremover(liballegro_memfile5_2-devel) weakremover(liballegro_physfs5_2) weakremover(liballegro_physfs5_2-devel) weakremover(liballegro_primitives5_2) weakremover(liballegro_primitives5_2-devel) weakremover(liballegro_ttf5_2) weakremover(liballegro_ttf5_2-devel) weakremover(liballegro_video5_2) weakremover(liballegro_video5_2-devel) weakremover(libalternatives-devel) weakremover(libalternatives1) weakremover(libalure1) weakremover(libalut0) weakremover(libamd-2_4_1) weakremover(libamd-2_4_6) weakremover(libamd-doc) weakremover(libamd2) weakremover(libaml0) weakremover(libamtk-3-0) weakremover(libamtk-5-0) weakremover(libamtk-5-1) weakremover(libancient2) weakremover(libangelscript2_31_2) weakremover(libangelscript2_33_0) weakremover(libangelscript2_34_0) weakremover(libangelscript2_35_0) weakremover(libangelscript2_35_1) weakremover(libangelscript_addons2_35_0) weakremover(libangelscript_addons2_35_1) weakremover(libanjuta-3-0) weakremover(libansilove-devel) weakremover(libansilove1) weakremover(libanthy0) weakremover(libantic0) weakremover(libantlr3c-3_4) weakremover(libantlr3c3) weakremover(libantlr4-runtime-devel) weakremover(libantlr4-runtime4_7_2) weakremover(libantlr4-runtime4_8) weakremover(libantlr4-runtime4_9_1) weakremover(libantlr4-runtime4_9_2) weakremover(libantlr4-runtime4_9_3) weakremover(libao-devel) weakremover(libao-plugins4) weakremover(libao4) weakremover(libaom-devel) weakremover(libaom0) weakremover(libaom2) weakremover(libaom3) weakremover(libapparmor-devel) weakremover(libapparmor1) weakremover(libappindicator-devel) weakremover(libappindicator-doc) weakremover(libappindicator1) weakremover(libappindicator3-1) weakremover(libappindicator3-devel) weakremover(libappmenu-gtk2-parser-devel) weakremover(libappmenu-gtk2-parser0) weakremover(libappmenu-gtk3-parser-devel) weakremover(libappmenu-gtk3-parser0) weakremover(libappstream-builder8) weakremover(libappstream-compose0) weakremover(libappstream-glib8) weakremover(libappstream4) weakremover(libapr-util1) weakremover(libapr-util1-0) weakremover(libapr-util1-0-dbd-mysql) weakremover(libapr-util1-0-dbd-pgsql) weakremover(libapr-util1-0-dbd-sqlite3) weakremover(libapr-util1-dbd-mysql) weakremover(libapr-util1-dbd-pgsql) weakremover(libapr-util1-dbd-sqlite3) weakremover(libapr-util1-devel) weakremover(libapr1) weakremover(libapr1-0) weakremover(libapr1-devel) weakremover(libaqebics0) weakremover(libaqofxconnect7) weakremover(libaravis-0_8-0) weakremover(libaravis-0_8-devel) weakremover(libarb2) weakremover(libarchive-devel) weakremover(libarchive13) weakremover(libargon2-1) weakremover(libargtable2-0) weakremover(libargtable2-devel) weakremover(libaria2-0) weakremover(libarm_compute16) weakremover(libarm_compute17) weakremover(libarm_compute18) weakremover(libarm_compute19) weakremover(libarm_compute20) weakremover(libarm_compute21) weakremover(libarm_compute22) weakremover(libarm_compute23) weakremover(libarm_compute24) weakremover(libarm_compute25) weakremover(libarm_compute26) weakremover(libarm_compute28) weakremover(libarm_compute29) weakremover(libarm_compute30) weakremover(libarm_compute_core22) weakremover(libarm_compute_core23) weakremover(libarm_compute_core24) weakremover(libarm_compute_core25) weakremover(libarm_compute_core26) weakremover(libarm_compute_core28) weakremover(libarm_compute_core29) weakremover(libarm_compute_core30) weakremover(libarm_compute_graph22) weakremover(libarm_compute_graph23) weakremover(libarm_compute_graph24) weakremover(libarm_compute_graph25) weakremover(libarm_compute_graph26) weakremover(libarm_compute_graph28) weakremover(libarm_compute_graph29) weakremover(libarm_compute_graph30) weakremover(libarmadillo10) weakremover(libarmadillo11) weakremover(libarmadillo12) weakremover(libarmadillo7) weakremover(libarmadillo8) weakremover(libarmadillo9) weakremover(libarmnn19) weakremover(libarmnn19-opencl) weakremover(libarmnn20) weakremover(libarmnn20-opencl) weakremover(libarmnn21) weakremover(libarmnn21-opencl) weakremover(libarmnn22) weakremover(libarmnn22-opencl) weakremover(libarmnn23) weakremover(libarmnn23-opencl) weakremover(libarmnn24) weakremover(libarmnn24-opencl) weakremover(libarmnn25) weakremover(libarmnn25-opencl) weakremover(libarmnn27) weakremover(libarmnn27-opencl) weakremover(libarmnn28) weakremover(libarmnn28-opencl) weakremover(libarmnn31) weakremover(libarmnn31-opencl) weakremover(libarmnn32) weakremover(libarmnn32-opencl) weakremover(libarmnnBasePipeServer21) weakremover(libarmnnBasePipeServer21-opencl) weakremover(libarmnnBasePipeServer22) weakremover(libarmnnBasePipeServer22-opencl) weakremover(libarmnnBasePipeServer23) weakremover(libarmnnBasePipeServer23-opencl) weakremover(libarmnnBasePipeServer24) weakremover(libarmnnBasePipeServer24-opencl) weakremover(libarmnnBasePipeServer25) weakremover(libarmnnBasePipeServer25-opencl) weakremover(libarmnnBasePipeServer27) weakremover(libarmnnBasePipeServer27-opencl) weakremover(libarmnnBasePipeServer28) weakremover(libarmnnBasePipeServer28-opencl) weakremover(libarmnnBasePipeServer31) weakremover(libarmnnBasePipeServer31-opencl) weakremover(libarmnnBasePipeServer32) weakremover(libarmnnBasePipeServer32-opencl) weakremover(libarmnnCaffeParser19) weakremover(libarmnnCaffeParser19-opencl) weakremover(libarmnnCaffeParser20) weakremover(libarmnnCaffeParser20-opencl) weakremover(libarmnnCaffeParser21) weakremover(libarmnnCaffeParser21-opencl) weakremover(libarmnnCaffeParser22) weakremover(libarmnnCaffeParser22-opencl) weakremover(libarmnnCaffeParser23) weakremover(libarmnnCaffeParser23-opencl) weakremover(libarmnnCaffeParser24) weakremover(libarmnnCaffeParser24-opencl) weakremover(libarmnnOnnxParser19) weakremover(libarmnnOnnxParser19-opencl) weakremover(libarmnnOnnxParser20) weakremover(libarmnnOnnxParser20-opencl) weakremover(libarmnnOnnxParser21) weakremover(libarmnnOnnxParser21-opencl) weakremover(libarmnnSerializer19) weakremover(libarmnnSerializer19-opencl) weakremover(libarmnnSerializer20) weakremover(libarmnnSerializer20-opencl) weakremover(libarmnnSerializer21) weakremover(libarmnnSerializer21-opencl) weakremover(libarmnnSerializer22) weakremover(libarmnnSerializer22-opencl) weakremover(libarmnnSerializer23) weakremover(libarmnnSerializer23-opencl) weakremover(libarmnnSerializer24) weakremover(libarmnnSerializer24-opencl) weakremover(libarmnnSerializer25) weakremover(libarmnnSerializer25-opencl) weakremover(libarmnnSerializer27) weakremover(libarmnnSerializer27-opencl) weakremover(libarmnnSerializer28) weakremover(libarmnnSerializer28-opencl) weakremover(libarmnnSerializer31) weakremover(libarmnnSerializer31-opencl) weakremover(libarmnnSerializer32) weakremover(libarmnnSerializer32-opencl) weakremover(libarmnnTestUtils2) weakremover(libarmnnTestUtils2-opencl) weakremover(libarmnnTfLiteParser19) weakremover(libarmnnTfLiteParser19-opencl) weakremover(libarmnnTfLiteParser20) weakremover(libarmnnTfLiteParser20-opencl) weakremover(libarmnnTfLiteParser21) weakremover(libarmnnTfLiteParser21-opencl) weakremover(libarmnnTfLiteParser22) weakremover(libarmnnTfLiteParser22-opencl) weakremover(libarmnnTfLiteParser23) weakremover(libarmnnTfLiteParser23-opencl) weakremover(libarmnnTfLiteParser24) weakremover(libarmnnTfLiteParser24-opencl) weakremover(libarmnnTfParser19) weakremover(libarmnnTfParser19-opencl) weakremover(libarmnnTfParser20) weakremover(libarmnnTfParser20-opencl) weakremover(libarmnnTfParser21) weakremover(libarmnnTfParser21-opencl) weakremover(libarmnnTfParser22) weakremover(libarmnnTfParser22-opencl) weakremover(libarmnnTfParser23) weakremover(libarmnnTfParser23-opencl) weakremover(libarmnnTfParser24) weakremover(libarmnnTfParser24-opencl) weakremover(libarpack2) weakremover(libarpec0) weakremover(libarprec0) weakremover(libarrow1100) weakremover(libarrow_dataset1100) weakremover(libart_lgpl-devel) weakremover(libart_lgpl_2-2) weakremover(libasan2) weakremover(libasan3) weakremover(libasan3-gcc6) weakremover(libasan4) weakremover(libasan5) weakremover(libasan5-gcc8) weakremover(libasan6) weakremover(libasan6-gcc10) weakremover(libasan8) weakremover(libasan8-gcc12) weakremover(libaslcommon0) weakremover(libasm-devel) weakremover(libasm1) weakremover(libasn1-8) weakremover(libasn1c-devel) weakremover(libasn1c0) weakremover(libasn1c1) weakremover(libasound2) weakremover(libaspell15) weakremover(libass-devel) weakremover(libass5) weakremover(libass9) weakremover(libassimp3) weakremover(libassimp5) weakremover(libassuan-devel) weakremover(libassuan0) weakremover(libastro-qt5-1) weakremover(libastro1) weakremover(libastylej3) weakremover(libasync) weakremover(libasync-devel) weakremover(libasync1_6) weakremover(libasyncns-devel) weakremover(libasyncns0) weakremover(libatalk16) weakremover(libatasmart-devel) weakremover(libatasmart-utils) weakremover(libatasmart4) weakremover(libathemecore1) weakremover(libatk-1_0-0) weakremover(libatk-bridge-2_0-0) weakremover(libatkmm-1_6-1) weakremover(libatkmm-2_28-1) weakremover(libatkmm-2_30-1) weakremover(libatkmm-2_36-1) weakremover(libatlascpp-0_6-1) weakremover(libatlascpp-0_6-3) weakremover(libatm1) weakremover(libatomic1) weakremover(libatomic1-gcc10) weakremover(libatomic1-gcc11) weakremover(libatomic1-gcc12) weakremover(libatomic1-gcc5) weakremover(libatomic1-gcc6) weakremover(libatomic1-gcc7) weakremover(libatomic1-gcc8) weakremover(libatomic1-gcc9) weakremover(libatomic_ops-devel) weakremover(libatomicparsley0) weakremover(libatopology2) weakremover(libatrildocument3) weakremover(libatrilview3) weakremover(libatspi0) weakremover(libattica-devel) weakremover(libattica0_4) weakremover(libattr-devel) weakremover(libattr-devel-static) weakremover(libattr1) weakremover(libaubio-devel) weakremover(libaubio4) weakremover(libaubio5) weakremover(libaudaspace-c1_3) weakremover(libaudaspace-c1_4) weakremover(libaudaspace-py1_3) weakremover(libaudaspace-py1_4) weakremover(libaudaspace1_3) weakremover(libaudaspace1_4) weakremover(libaudcore4) weakremover(libaudcore5) weakremover(libaudgui4) weakremover(libaudgui5) weakremover(libaudiofile1) weakremover(libaudit1) weakremover(libaudqt1) weakremover(libaudqt2) weakremover(libaudtag3) weakremover(libaugeas0) weakremover(libauparse0) weakremover(libauthselect-devel) weakremover(libauthselect3) weakremover(libautotrace3) weakremover(libav-tools) weakremover(libavahi-client3) weakremover(libavahi-common3) weakremover(libavahi-core7) weakremover(libavahi-devel) weakremover(libavahi-glib-devel) weakremover(libavahi-glib1) weakremover(libavahi-gobject-devel) weakremover(libavahi-gobject0) weakremover(libavahi-libevent1) weakremover(libavahi-qt4-1) weakremover(libavahi-qt4-devel) weakremover(libavahi-qt5-1) weakremover(libavahi-qt5-devel) weakremover(libavahi-ui-gtk3-0) weakremover(libavahi-ui0) weakremover(libavc1394) weakremover(libavc1394-0) weakremover(libavc1394-devel) weakremover(libavc1394-tools) weakremover(libavcall1) weakremover(libavcodec-devel) weakremover(libavcodec56) weakremover(libavcodec57) weakremover(libavcodec58) weakremover(libavcodec58_134) weakremover(libavcodec58_91) weakremover(libavcodec59) weakremover(libavcodec60) weakremover(libavdevice-devel) weakremover(libavdevice56) weakremover(libavdevice57) weakremover(libavdevice58) weakremover(libavdevice58_10) weakremover(libavdevice58_13) weakremover(libavdevice59) weakremover(libavdevice60) weakremover(libavfilter-devel) weakremover(libavfilter5) weakremover(libavfilter6) weakremover(libavfilter7) weakremover(libavfilter7_110) weakremover(libavfilter7_85) weakremover(libavfilter8) weakremover(libavfilter9) weakremover(libavformat-devel) weakremover(libavformat56) weakremover(libavformat57) weakremover(libavformat58) weakremover(libavformat58_45) weakremover(libavformat58_76) weakremover(libavformat59) weakremover(libavformat60) weakremover(libavfs0) weakremover(libavif-devel) weakremover(libavif10) weakremover(libavif12) weakremover(libavif13) weakremover(libavif14) weakremover(libavif15) weakremover(libavif4) weakremover(libavif5) weakremover(libavif6) weakremover(libavif7) weakremover(libavif9) weakremover(libavogadro1) weakremover(libavogadrolibs-suse0) weakremover(libavrdude1) weakremover(libavresample-devel) weakremover(libavresample2) weakremover(libavresample3) weakremover(libavresample4) weakremover(libavresample4_0) weakremover(libavtp-devel) weakremover(libavtp0) weakremover(libavutil-devel) weakremover(libavutil54) weakremover(libavutil55) weakremover(libavutil56) weakremover(libavutil56_51) weakremover(libavutil56_70) weakremover(libavutil57) weakremover(libavutil58) weakremover(libax25-0) weakremover(libax25-devel) weakremover(libax25io0) weakremover(libayatana-appindicator-devel) weakremover(libayatana-appindicator1) weakremover(libayatana-appindicator3-1) weakremover(libayatana-appindicator3-devel) weakremover(libayatana-ido3-0_4-0) weakremover(libayatana-indicator-devel) weakremover(libayatana-indicator3-7) weakremover(libayatana-indicator3-devel) weakremover(libayatana-indicator7) weakremover(libazurestorage7) weakremover(libb2-1) weakremover(libb2-devel) weakremover(libb64) weakremover(libb64-0) weakremover(libb64-devel) weakremover(libbabl-0_1-0) weakremover(libbaloofiles4) weakremover(libbaloopim4) weakremover(libbalooqueryparser4) weakremover(libbaloowidgets-devel) weakremover(libbaloowidgets4) weakremover(libbamf3-2) weakremover(libbaresip2) weakremover(libbarvinok23) weakremover(libbaseencode-devel) weakremover(libbaseencode1) weakremover(libbasicobjects-devel) weakremover(libbasicobjects0) weakremover(libbcc0) weakremover(libbcg729-0) weakremover(libbcmatroska2-0) weakremover(libbctoolbox-tester0) weakremover(libbctoolbox-tester1) weakremover(libbctoolbox0) weakremover(libbctoolbox1) weakremover(libbcunit1) weakremover(libbd_btrfs-devel) weakremover(libbd_btrfs2) weakremover(libbd_crypto-devel) weakremover(libbd_crypto2) weakremover(libbd_dm-devel) weakremover(libbd_dm2) weakremover(libbd_fs-devel) weakremover(libbd_fs2) weakremover(libbd_kbd-devel) weakremover(libbd_kbd2) weakremover(libbd_loop-devel) weakremover(libbd_loop2) weakremover(libbd_lvm-dbus-devel) weakremover(libbd_lvm-dbus2) weakremover(libbd_lvm-devel) weakremover(libbd_lvm2) weakremover(libbd_mdraid-devel) weakremover(libbd_mdraid2) weakremover(libbd_mpath-devel) weakremover(libbd_mpath2) weakremover(libbd_part-devel) weakremover(libbd_part2) weakremover(libbd_swap-devel) weakremover(libbd_swap2) weakremover(libbd_utils-devel) weakremover(libbd_utils2) weakremover(libbd_vdo-devel) weakremover(libbd_vdo2) weakremover(libbde-devel) weakremover(libbde-tools) weakremover(libbde1) weakremover(libbeecrypt-devel) weakremover(libbeecrypt6) weakremover(libbelcard1) weakremover(libbellesip0) weakremover(libbellesip1) weakremover(libbelr1) weakremover(libbemenu0) weakremover(libbenchmark0) weakremover(libbenchmark1) weakremover(libbfio-devel) weakremover(libbfio1) weakremover(libbfoverlay-devel) weakremover(libbfoverlay-tools) weakremover(libbfoverlay1) weakremover(libbiblesync1_1) weakremover(libbiblesync2_0) weakremover(libbind9-1302) weakremover(libbind9-160) weakremover(libbind9-1600) weakremover(libbinio-devel) weakremover(libbinio1) weakremover(libbitcoinconsensus-devel) weakremover(libbitcoinconsensus0) weakremover(libbitmask-devel) weakremover(libbitmask1) weakremover(libblack_hole_solver1) weakremover(libblacs2-gnu-mpich-hpc) weakremover(libblacs2-gnu-mpich-hpc-devel) weakremover(libblacs2-gnu-mvapich2-hpc) weakremover(libblacs2-gnu-mvapich2-hpc-devel) weakremover(libblacs2-gnu-openmpi1-hpc) weakremover(libblacs2-gnu-openmpi1-hpc-devel) weakremover(libblacs2-gnu-openmpi2-hpc) weakremover(libblacs2-gnu-openmpi2-hpc-devel) weakremover(libblacs2-gnu-openmpi3-hpc) weakremover(libblacs2-gnu-openmpi3-hpc-devel) weakremover(libblacs2-mvapich2) weakremover(libblacs2-mvapich2-devel) weakremover(libblacs2-mvapich2-devel-static) weakremover(libblacs2-openmpi) weakremover(libblacs2-openmpi-devel) weakremover(libblacs2-openmpi-devel-static) weakremover(libblacs2-openmpi1) weakremover(libblacs2-openmpi1-devel) weakremover(libblacs2-openmpi1-devel-static) weakremover(libblacs2-openmpi2) weakremover(libblacs2-openmpi2-devel) weakremover(libblacs2-openmpi2-devel-static) weakremover(libblacs2-openmpi3) weakremover(libblacs2-openmpi3-devel) weakremover(libblacs2-openmpi3-devel-static) weakremover(libblacs2-openmpi4) weakremover(libblacs2-openmpi4-devel) weakremover(libblacs2-openmpi4-devel-static) weakremover(libblacs2_2_0_2-gnu-mpich-hpc) weakremover(libblacs2_2_0_2-gnu-mpich-hpc-devel) weakremover(libblacs2_2_0_2-gnu-mpich-hpc-devel-static) weakremover(libblacs2_2_0_2-gnu-mvapich2-hpc) weakremover(libblacs2_2_0_2-gnu-mvapich2-hpc-devel) weakremover(libblacs2_2_0_2-gnu-mvapich2-hpc-devel-static) weakremover(libblacs2_2_0_2-gnu-openmpi1-hpc) weakremover(libblacs2_2_0_2-gnu-openmpi1-hpc-devel) weakremover(libblacs2_2_0_2-gnu-openmpi1-hpc-devel-static) weakremover(libblacs2_2_0_2-gnu-openmpi2-hpc) weakremover(libblacs2_2_0_2-gnu-openmpi2-hpc-devel) weakremover(libblacs2_2_0_2-gnu-openmpi2-hpc-devel-static) weakremover(libblacs2_2_0_2-gnu-openmpi3-hpc) weakremover(libblacs2_2_0_2-gnu-openmpi3-hpc-devel) weakremover(libblacs2_2_0_2-gnu-openmpi3-hpc-devel-static) weakremover(libbladeRF1) weakremover(libbladeRF2) weakremover(libbladeRF2-doc) weakremover(libblas3) weakremover(libblastrampoline-devel) weakremover(libblastrampoline5) weakremover(libbliss-0_73) weakremover(libbliss0_77) weakremover(libblitz0) weakremover(libblkid-devel) weakremover(libblkid-devel-static) weakremover(libblkid1) weakremover(libblockdev) weakremover(libblockdev-devel) weakremover(libblockdev2) weakremover(libblogger2) weakremover(libblosc1) weakremover(libblosc2-2) weakremover(libbluetooth3) weakremover(libbluray-devel) weakremover(libbluray-tools) weakremover(libbluray1) weakremover(libbluray2) weakremover(libbml-devel) weakremover(libbml1) weakremover(libbobcat-devel) weakremover(libbobcat-devel-static) weakremover(libbobcat-light-devel-static) weakremover(libbobcat6) weakremover(libboinc-devel) weakremover(libboinc7) weakremover(libbonobo) weakremover(libbonobo-devel) weakremover(libbonobo-doc) weakremover(libbonobo-lang) weakremover(libbonoboui) weakremover(libbonoboui-devel) weakremover(libbonoboui-doc) weakremover(libbonoboui-lang) weakremover(libbonoboui-tools) weakremover(libboost_atomic1_54_0) weakremover(libboost_atomic1_58_0) weakremover(libboost_atomic1_59_0) weakremover(libboost_atomic1_60_0) weakremover(libboost_atomic1_61_0) weakremover(libboost_atomic1_62_0) weakremover(libboost_atomic1_63_0) weakremover(libboost_atomic1_66_0) weakremover(libboost_atomic1_66_0-devel) weakremover(libboost_atomic1_68_0) weakremover(libboost_atomic1_68_0-devel) weakremover(libboost_atomic1_69_0) weakremover(libboost_atomic1_69_0-devel) weakremover(libboost_atomic1_71_0) weakremover(libboost_atomic1_71_0-devel) weakremover(libboost_atomic1_74_0) weakremover(libboost_atomic1_74_0-devel) weakremover(libboost_atomic1_75_0) weakremover(libboost_atomic1_75_0-devel) weakremover(libboost_atomic1_76_0) weakremover(libboost_atomic1_76_0-devel) weakremover(libboost_atomic1_77_0) weakremover(libboost_atomic1_77_0-devel) weakremover(libboost_atomic1_78_0) weakremover(libboost_atomic1_78_0-devel) weakremover(libboost_atomic1_79_0) weakremover(libboost_atomic1_79_0-devel) weakremover(libboost_atomic1_80_0) weakremover(libboost_atomic1_80_0-devel) weakremover(libboost_atomic1_81_0) weakremover(libboost_atomic1_81_0-devel) weakremover(libboost_atomic1_82_0) weakremover(libboost_atomic1_82_0-devel) weakremover(libboost_chrono1_54_0) weakremover(libboost_chrono1_58_0) weakremover(libboost_chrono1_59_0) weakremover(libboost_chrono1_60_0) weakremover(libboost_chrono1_61_0) weakremover(libboost_chrono1_62_0) weakremover(libboost_chrono1_63_0) weakremover(libboost_chrono1_66_0) weakremover(libboost_chrono1_66_0-devel) weakremover(libboost_chrono1_68_0) weakremover(libboost_chrono1_68_0-devel) weakremover(libboost_chrono1_69_0) weakremover(libboost_chrono1_69_0-devel) weakremover(libboost_chrono1_71_0) weakremover(libboost_chrono1_71_0-devel) weakremover(libboost_chrono1_74_0) weakremover(libboost_chrono1_74_0-devel) weakremover(libboost_chrono1_75_0) weakremover(libboost_chrono1_75_0-devel) weakremover(libboost_chrono1_76_0) weakremover(libboost_chrono1_76_0-devel) weakremover(libboost_chrono1_77_0) weakremover(libboost_chrono1_77_0-devel) weakremover(libboost_chrono1_78_0) weakremover(libboost_chrono1_78_0-devel) weakremover(libboost_chrono1_79_0) weakremover(libboost_chrono1_79_0-devel) weakremover(libboost_chrono1_80_0) weakremover(libboost_chrono1_80_0-devel) weakremover(libboost_chrono1_81_0) weakremover(libboost_chrono1_81_0-devel) weakremover(libboost_chrono1_82_0) weakremover(libboost_chrono1_82_0-devel) weakremover(libboost_container1_58_0) weakremover(libboost_container1_59_0) weakremover(libboost_container1_60_0) weakremover(libboost_container1_61_0) weakremover(libboost_container1_62_0) weakremover(libboost_container1_63_0) weakremover(libboost_container1_66_0) weakremover(libboost_container1_66_0-devel) weakremover(libboost_container1_68_0) weakremover(libboost_container1_68_0-devel) weakremover(libboost_container1_69_0) weakremover(libboost_container1_69_0-devel) weakremover(libboost_container1_71_0) weakremover(libboost_container1_71_0-devel) weakremover(libboost_container1_74_0) weakremover(libboost_container1_74_0-devel) weakremover(libboost_container1_75_0) weakremover(libboost_container1_75_0-devel) weakremover(libboost_container1_76_0) weakremover(libboost_container1_76_0-devel) weakremover(libboost_container1_77_0) weakremover(libboost_container1_77_0-devel) weakremover(libboost_container1_78_0) weakremover(libboost_container1_78_0-devel) weakremover(libboost_container1_79_0) weakremover(libboost_container1_79_0-devel) weakremover(libboost_container1_80_0) weakremover(libboost_container1_80_0-devel) weakremover(libboost_container1_81_0) weakremover(libboost_container1_81_0-devel) weakremover(libboost_container1_82_0) weakremover(libboost_container1_82_0-devel) weakremover(libboost_context1_59_0) weakremover(libboost_context1_60_0) weakremover(libboost_context1_61_0) weakremover(libboost_context1_62_0) weakremover(libboost_context1_63_0) weakremover(libboost_context1_66_0) weakremover(libboost_context1_66_0-devel) weakremover(libboost_context1_68_0) weakremover(libboost_context1_68_0-devel) weakremover(libboost_context1_69_0) weakremover(libboost_context1_69_0-devel) weakremover(libboost_context1_71_0) weakremover(libboost_context1_71_0-devel) weakremover(libboost_context1_74_0) weakremover(libboost_context1_74_0-devel) weakremover(libboost_context1_75_0) weakremover(libboost_context1_75_0-devel) weakremover(libboost_context1_76_0) weakremover(libboost_context1_76_0-devel) weakremover(libboost_context1_77_0) weakremover(libboost_context1_77_0-devel) weakremover(libboost_context1_78_0) weakremover(libboost_context1_78_0-devel) weakremover(libboost_context1_79_0) weakremover(libboost_context1_79_0-devel) weakremover(libboost_context1_80_0) weakremover(libboost_context1_80_0-devel) weakremover(libboost_context1_81_0) weakremover(libboost_context1_81_0-devel) weakremover(libboost_context1_82_0) weakremover(libboost_context1_82_0-devel) weakremover(libboost_contract1_68_0) weakremover(libboost_contract1_68_0-devel) weakremover(libboost_contract1_69_0) weakremover(libboost_contract1_69_0-devel) weakremover(libboost_contract1_71_0) weakremover(libboost_contract1_71_0-devel) weakremover(libboost_contract1_74_0) weakremover(libboost_contract1_74_0-devel) weakremover(libboost_contract1_75_0) weakremover(libboost_contract1_75_0-devel) weakremover(libboost_contract1_76_0) weakremover(libboost_contract1_76_0-devel) weakremover(libboost_contract1_77_0) weakremover(libboost_contract1_77_0-devel) weakremover(libboost_contract1_78_0) weakremover(libboost_contract1_78_0-devel) weakremover(libboost_contract1_79_0) weakremover(libboost_contract1_79_0-devel) weakremover(libboost_contract1_80_0) weakremover(libboost_contract1_80_0-devel) weakremover(libboost_contract1_81_0) weakremover(libboost_contract1_81_0-devel) weakremover(libboost_contract1_82_0) weakremover(libboost_contract1_82_0-devel) weakremover(libboost_coroutine1_59_0) weakremover(libboost_coroutine1_60_0) weakremover(libboost_coroutine1_61_0) weakremover(libboost_coroutine1_62_0) weakremover(libboost_coroutine1_63_0) weakremover(libboost_coroutine1_66_0) weakremover(libboost_coroutine1_66_0-devel) weakremover(libboost_coroutine1_68_0) weakremover(libboost_coroutine1_68_0-devel) weakremover(libboost_coroutine1_69_0) weakremover(libboost_coroutine1_69_0-devel) weakremover(libboost_coroutine1_71_0) weakremover(libboost_coroutine1_71_0-devel) weakremover(libboost_coroutine1_74_0) weakremover(libboost_coroutine1_74_0-devel) weakremover(libboost_coroutine1_75_0) weakremover(libboost_coroutine1_75_0-devel) weakremover(libboost_coroutine1_76_0) weakremover(libboost_coroutine1_76_0-devel) weakremover(libboost_coroutine1_77_0) weakremover(libboost_coroutine1_77_0-devel) weakremover(libboost_coroutine1_78_0) weakremover(libboost_coroutine1_78_0-devel) weakremover(libboost_coroutine1_79_0) weakremover(libboost_coroutine1_79_0-devel) weakremover(libboost_coroutine1_80_0) weakremover(libboost_coroutine1_80_0-devel) weakremover(libboost_coroutine1_81_0) weakremover(libboost_coroutine1_81_0-devel) weakremover(libboost_coroutine1_82_0) weakremover(libboost_coroutine1_82_0-devel) weakremover(libboost_date_time1_54_0) weakremover(libboost_date_time1_58_0) weakremover(libboost_date_time1_59_0) weakremover(libboost_date_time1_60_0) weakremover(libboost_date_time1_61_0) weakremover(libboost_date_time1_62_0) weakremover(libboost_date_time1_63_0) weakremover(libboost_date_time1_66_0) weakremover(libboost_date_time1_66_0-devel) weakremover(libboost_date_time1_68_0) weakremover(libboost_date_time1_68_0-devel) weakremover(libboost_date_time1_69_0) weakremover(libboost_date_time1_69_0-devel) weakremover(libboost_date_time1_71_0) weakremover(libboost_date_time1_71_0-devel) weakremover(libboost_date_time1_74_0) weakremover(libboost_date_time1_74_0-devel) weakremover(libboost_date_time1_75_0) weakremover(libboost_date_time1_75_0-devel) weakremover(libboost_date_time1_76_0) weakremover(libboost_date_time1_76_0-devel) weakremover(libboost_date_time1_77_0) weakremover(libboost_date_time1_77_0-devel) weakremover(libboost_date_time1_78_0) weakremover(libboost_date_time1_78_0-devel) weakremover(libboost_date_time1_79_0) weakremover(libboost_date_time1_79_0-devel) weakremover(libboost_date_time1_80_0) weakremover(libboost_date_time1_80_0-devel) weakremover(libboost_date_time1_81_0) weakremover(libboost_date_time1_81_0-devel) weakremover(libboost_date_time1_82_0) weakremover(libboost_date_time1_82_0-devel) weakremover(libboost_fiber1_66_0) weakremover(libboost_fiber1_66_0-devel) weakremover(libboost_fiber1_68_0) weakremover(libboost_fiber1_68_0-devel) weakremover(libboost_fiber1_69_0) weakremover(libboost_fiber1_69_0-devel) weakremover(libboost_fiber1_71_0) weakremover(libboost_fiber1_71_0-devel) weakremover(libboost_fiber1_74_0) weakremover(libboost_fiber1_74_0-devel) weakremover(libboost_fiber1_75_0) weakremover(libboost_fiber1_75_0-devel) weakremover(libboost_fiber1_76_0) weakremover(libboost_fiber1_76_0-devel) weakremover(libboost_fiber1_77_0) weakremover(libboost_fiber1_77_0-devel) weakremover(libboost_fiber1_78_0) weakremover(libboost_fiber1_78_0-devel) weakremover(libboost_fiber1_79_0) weakremover(libboost_fiber1_79_0-devel) weakremover(libboost_fiber1_80_0) weakremover(libboost_fiber1_80_0-devel) weakremover(libboost_fiber1_81_0) weakremover(libboost_fiber1_81_0-devel) weakremover(libboost_fiber1_82_0) weakremover(libboost_fiber1_82_0-devel) weakremover(libboost_filesystem1_54_0) weakremover(libboost_filesystem1_58_0) weakremover(libboost_filesystem1_59_0) weakremover(libboost_filesystem1_60_0) weakremover(libboost_filesystem1_61_0) weakremover(libboost_filesystem1_62_0) weakremover(libboost_filesystem1_63_0) weakremover(libboost_filesystem1_66_0) weakremover(libboost_filesystem1_66_0-devel) weakremover(libboost_filesystem1_68_0) weakremover(libboost_filesystem1_68_0-devel) weakremover(libboost_filesystem1_69_0) weakremover(libboost_filesystem1_69_0-devel) weakremover(libboost_filesystem1_71_0) weakremover(libboost_filesystem1_71_0-devel) weakremover(libboost_filesystem1_74_0) weakremover(libboost_filesystem1_74_0-devel) weakremover(libboost_filesystem1_75_0) weakremover(libboost_filesystem1_75_0-devel) weakremover(libboost_filesystem1_76_0) weakremover(libboost_filesystem1_76_0-devel) weakremover(libboost_filesystem1_77_0) weakremover(libboost_filesystem1_77_0-devel) weakremover(libboost_filesystem1_78_0) weakremover(libboost_filesystem1_78_0-devel) weakremover(libboost_filesystem1_79_0) weakremover(libboost_filesystem1_79_0-devel) weakremover(libboost_filesystem1_80_0) weakremover(libboost_filesystem1_80_0-devel) weakremover(libboost_filesystem1_81_0) weakremover(libboost_filesystem1_81_0-devel) weakremover(libboost_filesystem1_82_0) weakremover(libboost_filesystem1_82_0-devel) weakremover(libboost_graph1_54_0) weakremover(libboost_graph1_58_0) weakremover(libboost_graph1_59_0) weakremover(libboost_graph1_60_0) weakremover(libboost_graph1_61_0) weakremover(libboost_graph1_62_0) weakremover(libboost_graph1_63_0) weakremover(libboost_graph1_66_0) weakremover(libboost_graph1_66_0-devel) weakremover(libboost_graph1_68_0) weakremover(libboost_graph1_68_0-devel) weakremover(libboost_graph1_69_0) weakremover(libboost_graph1_69_0-devel) weakremover(libboost_graph1_71_0) weakremover(libboost_graph1_71_0-devel) weakremover(libboost_graph1_74_0) weakremover(libboost_graph1_74_0-devel) weakremover(libboost_graph1_75_0) weakremover(libboost_graph1_75_0-devel) weakremover(libboost_graph1_76_0) weakremover(libboost_graph1_76_0-devel) weakremover(libboost_graph1_77_0) weakremover(libboost_graph1_77_0-devel) weakremover(libboost_graph1_78_0) weakremover(libboost_graph1_78_0-devel) weakremover(libboost_graph1_79_0) weakremover(libboost_graph1_79_0-devel) weakremover(libboost_graph1_80_0) weakremover(libboost_graph1_80_0-devel) weakremover(libboost_graph1_81_0) weakremover(libboost_graph1_81_0-devel) weakremover(libboost_graph1_82_0) weakremover(libboost_graph1_82_0-devel) weakremover(libboost_graph_parallel1_54_0) weakremover(libboost_graph_parallel1_58_0) weakremover(libboost_graph_parallel1_61_0) weakremover(libboost_graph_parallel1_66_0) weakremover(libboost_graph_parallel1_66_0-devel) weakremover(libboost_graph_parallel1_68_0) weakremover(libboost_graph_parallel1_68_0-devel) weakremover(libboost_graph_parallel1_69_0) weakremover(libboost_graph_parallel1_69_0-devel) weakremover(libboost_graph_parallel1_71_0) weakremover(libboost_graph_parallel1_71_0-devel) weakremover(libboost_graph_parallel1_74_0) weakremover(libboost_graph_parallel1_74_0-devel) weakremover(libboost_graph_parallel1_75_0) weakremover(libboost_graph_parallel1_75_0-devel) weakremover(libboost_graph_parallel1_76_0) weakremover(libboost_graph_parallel1_76_0-devel) weakremover(libboost_graph_parallel1_77_0) weakremover(libboost_graph_parallel1_77_0-devel) weakremover(libboost_graph_parallel1_78_0) weakremover(libboost_graph_parallel1_78_0-devel) weakremover(libboost_graph_parallel1_79_0) weakremover(libboost_graph_parallel1_79_0-devel) weakremover(libboost_graph_parallel1_80_0) weakremover(libboost_graph_parallel1_80_0-devel) weakremover(libboost_graph_parallel1_81_0) weakremover(libboost_graph_parallel1_81_0-devel) weakremover(libboost_graph_parallel1_82_0) weakremover(libboost_graph_parallel1_82_0-devel) weakremover(libboost_headers1_66_0-devel) weakremover(libboost_headers1_68_0-devel) weakremover(libboost_headers1_69_0-devel) weakremover(libboost_headers1_71_0-devel) weakremover(libboost_headers1_74_0-devel) weakremover(libboost_headers1_75_0-devel) weakremover(libboost_headers1_76_0-devel) weakremover(libboost_headers1_77_0-devel) weakremover(libboost_headers1_78_0-devel) weakremover(libboost_headers1_79_0-devel) weakremover(libboost_headers1_80_0-devel) weakremover(libboost_headers1_81_0-devel) weakremover(libboost_headers1_82_0-devel) weakremover(libboost_iostreams1_54_0) weakremover(libboost_iostreams1_58_0) weakremover(libboost_iostreams1_59_0) weakremover(libboost_iostreams1_61_0) weakremover(libboost_iostreams1_66_0) weakremover(libboost_iostreams1_66_0-devel) weakremover(libboost_iostreams1_68_0) weakremover(libboost_iostreams1_68_0-devel) weakremover(libboost_iostreams1_69_0) weakremover(libboost_iostreams1_69_0-devel) weakremover(libboost_iostreams1_71_0) weakremover(libboost_iostreams1_71_0-devel) weakremover(libboost_iostreams1_74_0) weakremover(libboost_iostreams1_74_0-devel) weakremover(libboost_iostreams1_75_0) weakremover(libboost_iostreams1_75_0-devel) weakremover(libboost_iostreams1_76_0) weakremover(libboost_iostreams1_76_0-devel) weakremover(libboost_iostreams1_77_0) weakremover(libboost_iostreams1_77_0-devel) weakremover(libboost_iostreams1_78_0) weakremover(libboost_iostreams1_78_0-devel) weakremover(libboost_iostreams1_79_0) weakremover(libboost_iostreams1_79_0-devel) weakremover(libboost_iostreams1_80_0) weakremover(libboost_iostreams1_80_0-devel) weakremover(libboost_iostreams1_81_0) weakremover(libboost_iostreams1_81_0-devel) weakremover(libboost_iostreams1_82_0) weakremover(libboost_iostreams1_82_0-devel) weakremover(libboost_json1_75_0) weakremover(libboost_json1_75_0-devel) weakremover(libboost_json1_76_0) weakremover(libboost_json1_76_0-devel) weakremover(libboost_json1_77_0) weakremover(libboost_json1_77_0-devel) weakremover(libboost_json1_78_0) weakremover(libboost_json1_78_0-devel) weakremover(libboost_json1_79_0) weakremover(libboost_json1_79_0-devel) weakremover(libboost_json1_80_0) weakremover(libboost_json1_80_0-devel) weakremover(libboost_json1_81_0) weakremover(libboost_json1_81_0-devel) weakremover(libboost_json1_82_0) weakremover(libboost_json1_82_0-devel) weakremover(libboost_locale1_54_0) weakremover(libboost_locale1_58_0) weakremover(libboost_locale1_59_0) weakremover(libboost_locale1_61_0) weakremover(libboost_locale1_66_0) weakremover(libboost_locale1_66_0-devel) weakremover(libboost_locale1_68_0) weakremover(libboost_locale1_68_0-devel) weakremover(libboost_locale1_69_0) weakremover(libboost_locale1_69_0-devel) weakremover(libboost_locale1_71_0) weakremover(libboost_locale1_71_0-devel) weakremover(libboost_locale1_74_0) weakremover(libboost_locale1_74_0-devel) weakremover(libboost_locale1_75_0) weakremover(libboost_locale1_75_0-devel) weakremover(libboost_locale1_76_0) weakremover(libboost_locale1_76_0-devel) weakremover(libboost_locale1_77_0) weakremover(libboost_locale1_77_0-devel) weakremover(libboost_locale1_78_0) weakremover(libboost_locale1_78_0-devel) weakremover(libboost_locale1_79_0) weakremover(libboost_locale1_79_0-devel) weakremover(libboost_locale1_80_0) weakremover(libboost_locale1_80_0-devel) weakremover(libboost_locale1_81_0) weakremover(libboost_locale1_81_0-devel) weakremover(libboost_locale1_82_0) weakremover(libboost_locale1_82_0-devel) weakremover(libboost_log1_54_0) weakremover(libboost_log1_58_0) weakremover(libboost_log1_59_0) weakremover(libboost_log1_60_0) weakremover(libboost_log1_61_0) weakremover(libboost_log1_62_0) weakremover(libboost_log1_63_0) weakremover(libboost_log1_66_0) weakremover(libboost_log1_66_0-devel) weakremover(libboost_log1_68_0) weakremover(libboost_log1_68_0-devel) weakremover(libboost_log1_69_0) weakremover(libboost_log1_69_0-devel) weakremover(libboost_log1_71_0) weakremover(libboost_log1_71_0-devel) weakremover(libboost_log1_74_0) weakremover(libboost_log1_74_0-devel) weakremover(libboost_log1_75_0) weakremover(libboost_log1_75_0-devel) weakremover(libboost_log1_76_0) weakremover(libboost_log1_76_0-devel) weakremover(libboost_log1_77_0) weakremover(libboost_log1_77_0-devel) weakremover(libboost_log1_78_0) weakremover(libboost_log1_78_0-devel) weakremover(libboost_log1_79_0) weakremover(libboost_log1_79_0-devel) weakremover(libboost_log1_80_0) weakremover(libboost_log1_80_0-devel) weakremover(libboost_log1_81_0) weakremover(libboost_log1_81_0-devel) weakremover(libboost_log1_82_0) weakremover(libboost_log1_82_0-devel) weakremover(libboost_math1_54_0) weakremover(libboost_math1_58_0) weakremover(libboost_math1_59_0) weakremover(libboost_math1_61_0) weakremover(libboost_math1_66_0) weakremover(libboost_math1_66_0-devel) weakremover(libboost_math1_68_0) weakremover(libboost_math1_68_0-devel) weakremover(libboost_math1_69_0) weakremover(libboost_math1_69_0-devel) weakremover(libboost_math1_71_0) weakremover(libboost_math1_71_0-devel) weakremover(libboost_math1_74_0) weakremover(libboost_math1_74_0-devel) weakremover(libboost_math1_75_0) weakremover(libboost_math1_75_0-devel) weakremover(libboost_math1_76_0) weakremover(libboost_math1_76_0-devel) weakremover(libboost_math1_77_0) weakremover(libboost_math1_77_0-devel) weakremover(libboost_math1_78_0) weakremover(libboost_math1_78_0-devel) weakremover(libboost_math1_79_0) weakremover(libboost_math1_79_0-devel) weakremover(libboost_math1_80_0) weakremover(libboost_math1_80_0-devel) weakremover(libboost_math1_81_0) weakremover(libboost_math1_81_0-devel) weakremover(libboost_math1_82_0) weakremover(libboost_math1_82_0-devel) weakremover(libboost_mpi1_54_0) weakremover(libboost_mpi1_58_0) weakremover(libboost_mpi1_61_0) weakremover(libboost_mpi1_66_0) weakremover(libboost_mpi1_66_0-devel) weakremover(libboost_mpi1_68_0) weakremover(libboost_mpi1_68_0-devel) weakremover(libboost_mpi1_69_0) weakremover(libboost_mpi1_69_0-devel) weakremover(libboost_mpi1_71_0) weakremover(libboost_mpi1_71_0-devel) weakremover(libboost_mpi1_74_0) weakremover(libboost_mpi1_74_0-devel) weakremover(libboost_mpi1_75_0) weakremover(libboost_mpi1_75_0-devel) weakremover(libboost_mpi1_76_0) weakremover(libboost_mpi1_76_0-devel) weakremover(libboost_mpi1_77_0) weakremover(libboost_mpi1_77_0-devel) weakremover(libboost_mpi1_78_0) weakremover(libboost_mpi1_78_0-devel) weakremover(libboost_mpi1_79_0) weakremover(libboost_mpi1_79_0-devel) weakremover(libboost_mpi1_80_0) weakremover(libboost_mpi1_80_0-devel) weakremover(libboost_mpi1_81_0) weakremover(libboost_mpi1_81_0-devel) weakremover(libboost_mpi1_82_0) weakremover(libboost_mpi1_82_0-devel) weakremover(libboost_mpi_python-devel) weakremover(libboost_mpi_python-py2_7-1_66_0) weakremover(libboost_mpi_python-py2_7-1_66_0-devel) weakremover(libboost_mpi_python-py2_7-1_68_0) weakremover(libboost_mpi_python-py2_7-1_68_0-devel) weakremover(libboost_mpi_python-py2_7-1_69_0) weakremover(libboost_mpi_python-py2_7-1_69_0-devel) weakremover(libboost_mpi_python-py2_7-1_71_0) weakremover(libboost_mpi_python-py2_7-1_71_0-devel) weakremover(libboost_mpi_python-py3-1_66_0) weakremover(libboost_mpi_python-py3-1_66_0-devel) weakremover(libboost_mpi_python-py3-1_68_0) weakremover(libboost_mpi_python-py3-1_68_0-devel) weakremover(libboost_mpi_python-py3-1_69_0) weakremover(libboost_mpi_python-py3-1_69_0-devel) weakremover(libboost_mpi_python-py3-1_71_0) weakremover(libboost_mpi_python-py3-1_71_0-devel) weakremover(libboost_mpi_python-py3-1_75_0) weakremover(libboost_mpi_python-py3-1_75_0-devel) weakremover(libboost_mpi_python-py3-1_76_0) weakremover(libboost_mpi_python-py3-1_76_0-devel) weakremover(libboost_mpi_python-py3-1_77_0) weakremover(libboost_mpi_python-py3-1_77_0-devel) weakremover(libboost_mpi_python-py3-1_78_0) weakremover(libboost_mpi_python-py3-1_78_0-devel) weakremover(libboost_mpi_python-py3-1_79_0) weakremover(libboost_mpi_python-py3-1_79_0-devel) weakremover(libboost_mpi_python-py3-1_80_0) weakremover(libboost_mpi_python-py3-1_80_0-devel) weakremover(libboost_mpi_python-py3-1_81_0) weakremover(libboost_mpi_python-py3-1_81_0-devel) weakremover(libboost_mpi_python-py3-1_82_0) weakremover(libboost_mpi_python-py3-1_82_0-devel) weakremover(libboost_mpi_python38-py3-1_74_0) weakremover(libboost_mpi_python38-py3-1_74_0-devel) weakremover(libboost_nowide1_74_0) weakremover(libboost_nowide1_74_0-devel) weakremover(libboost_nowide1_75_0) weakremover(libboost_nowide1_75_0-devel) weakremover(libboost_nowide1_76_0) weakremover(libboost_nowide1_76_0-devel) weakremover(libboost_nowide1_77_0) weakremover(libboost_nowide1_77_0-devel) weakremover(libboost_nowide1_78_0) weakremover(libboost_nowide1_78_0-devel) weakremover(libboost_nowide1_79_0) weakremover(libboost_nowide1_79_0-devel) weakremover(libboost_nowide1_80_0) weakremover(libboost_nowide1_80_0-devel) weakremover(libboost_nowide1_81_0) weakremover(libboost_nowide1_81_0-devel) weakremover(libboost_nowide1_82_0) weakremover(libboost_nowide1_82_0-devel) weakremover(libboost_numpy-devel) weakremover(libboost_numpy-py2_7-1_66_0) weakremover(libboost_numpy-py2_7-1_66_0-devel) weakremover(libboost_numpy-py2_7-1_68_0) weakremover(libboost_numpy-py2_7-1_68_0-devel) weakremover(libboost_numpy-py2_7-1_69_0) weakremover(libboost_numpy-py2_7-1_69_0-devel) weakremover(libboost_numpy-py2_7-1_71_0) weakremover(libboost_numpy-py2_7-1_71_0-devel) weakremover(libboost_numpy-py3-1_66_0) weakremover(libboost_numpy-py3-1_66_0-devel) weakremover(libboost_numpy-py3-1_68_0) weakremover(libboost_numpy-py3-1_68_0-devel) weakremover(libboost_numpy-py3-1_69_0) weakremover(libboost_numpy-py3-1_69_0-devel) weakremover(libboost_numpy-py3-1_71_0) weakremover(libboost_numpy-py3-1_71_0-devel) weakremover(libboost_numpy-py3-1_74_0) weakremover(libboost_numpy-py3-1_74_0-devel) weakremover(libboost_numpy-py3-1_75_0) weakremover(libboost_numpy-py3-1_75_0-devel) weakremover(libboost_numpy-py3-1_76_0) weakremover(libboost_numpy-py3-1_76_0-devel) weakremover(libboost_numpy-py3-1_77_0) weakremover(libboost_numpy-py3-1_77_0-devel) weakremover(libboost_numpy-py3-1_78_0) weakremover(libboost_numpy-py3-1_78_0-devel) weakremover(libboost_numpy-py3-1_79_0) weakremover(libboost_numpy-py3-1_79_0-devel) weakremover(libboost_numpy-py3-1_80_0) weakremover(libboost_numpy-py3-1_80_0-devel) weakremover(libboost_numpy-py3-1_81_0) weakremover(libboost_numpy-py3-1_81_0-devel) weakremover(libboost_numpy-py3-1_82_0) weakremover(libboost_numpy-py3-1_82_0-devel) weakremover(libboost_program_options1_54_0) weakremover(libboost_program_options1_58_0) weakremover(libboost_program_options1_59_0) weakremover(libboost_program_options1_61_0) weakremover(libboost_program_options1_66_0) weakremover(libboost_program_options1_66_0-devel) weakremover(libboost_program_options1_68_0) weakremover(libboost_program_options1_68_0-devel) weakremover(libboost_program_options1_69_0) weakremover(libboost_program_options1_69_0-devel) weakremover(libboost_program_options1_71_0) weakremover(libboost_program_options1_71_0-devel) weakremover(libboost_program_options1_74_0) weakremover(libboost_program_options1_74_0-devel) weakremover(libboost_program_options1_75_0) weakremover(libboost_program_options1_75_0-devel) weakremover(libboost_program_options1_76_0) weakremover(libboost_program_options1_76_0-devel) weakremover(libboost_program_options1_77_0) weakremover(libboost_program_options1_77_0-devel) weakremover(libboost_program_options1_78_0) weakremover(libboost_program_options1_78_0-devel) weakremover(libboost_program_options1_79_0) weakremover(libboost_program_options1_79_0-devel) weakremover(libboost_program_options1_80_0) weakremover(libboost_program_options1_80_0-devel) weakremover(libboost_program_options1_81_0) weakremover(libboost_program_options1_81_0-devel) weakremover(libboost_program_options1_82_0) weakremover(libboost_program_options1_82_0-devel) weakremover(libboost_python-devel) weakremover(libboost_python-py2_7-1_66_0) weakremover(libboost_python-py2_7-1_66_0-devel) weakremover(libboost_python-py2_7-1_68_0) weakremover(libboost_python-py2_7-1_68_0-devel) weakremover(libboost_python-py2_7-1_69_0) weakremover(libboost_python-py2_7-1_69_0-devel) weakremover(libboost_python-py2_7-1_71_0) weakremover(libboost_python-py2_7-1_71_0-devel) weakremover(libboost_python-py3-1_66_0) weakremover(libboost_python-py3-1_66_0-devel) weakremover(libboost_python-py3-1_68_0) weakremover(libboost_python-py3-1_68_0-devel) weakremover(libboost_python-py3-1_69_0) weakremover(libboost_python-py3-1_69_0-devel) weakremover(libboost_python-py3-1_71_0) weakremover(libboost_python-py3-1_71_0-devel) weakremover(libboost_python-py3-1_74_0) weakremover(libboost_python-py3-1_74_0-devel) weakremover(libboost_python-py3-1_75_0) weakremover(libboost_python-py3-1_75_0-devel) weakremover(libboost_python-py3-1_76_0) weakremover(libboost_python-py3-1_76_0-devel) weakremover(libboost_python-py3-1_77_0) weakremover(libboost_python-py3-1_77_0-devel) weakremover(libboost_python-py3-1_78_0) weakremover(libboost_python-py3-1_78_0-devel) weakremover(libboost_python-py3-1_79_0) weakremover(libboost_python-py3-1_79_0-devel) weakremover(libboost_python-py3-1_80_0) weakremover(libboost_python-py3-1_80_0-devel) weakremover(libboost_python-py3-1_81_0) weakremover(libboost_python-py3-1_81_0-devel) weakremover(libboost_python-py3-1_82_0) weakremover(libboost_python-py3-1_82_0-devel) weakremover(libboost_python1_54_0) weakremover(libboost_python1_58_0) weakremover(libboost_python1_59_0) weakremover(libboost_python1_61_0) weakremover(libboost_python3-1_61_0) weakremover(libboost_random1_54_0) weakremover(libboost_random1_58_0) weakremover(libboost_random1_59_0) weakremover(libboost_random1_61_0) weakremover(libboost_random1_66_0) weakremover(libboost_random1_66_0-devel) weakremover(libboost_random1_68_0) weakremover(libboost_random1_68_0-devel) weakremover(libboost_random1_69_0) weakremover(libboost_random1_69_0-devel) weakremover(libboost_random1_71_0) weakremover(libboost_random1_71_0-devel) weakremover(libboost_random1_74_0) weakremover(libboost_random1_74_0-devel) weakremover(libboost_random1_75_0) weakremover(libboost_random1_75_0-devel) weakremover(libboost_random1_76_0) weakremover(libboost_random1_76_0-devel) weakremover(libboost_random1_77_0) weakremover(libboost_random1_77_0-devel) weakremover(libboost_random1_78_0) weakremover(libboost_random1_78_0-devel) weakremover(libboost_random1_79_0) weakremover(libboost_random1_79_0-devel) weakremover(libboost_random1_80_0) weakremover(libboost_random1_80_0-devel) weakremover(libboost_random1_81_0) weakremover(libboost_random1_81_0-devel) weakremover(libboost_random1_82_0) weakremover(libboost_random1_82_0-devel) weakremover(libboost_regex1_54_0) weakremover(libboost_regex1_58_0) weakremover(libboost_regex1_59_0) weakremover(libboost_regex1_60_0) weakremover(libboost_regex1_61_0) weakremover(libboost_regex1_62_0) weakremover(libboost_regex1_63_0) weakremover(libboost_regex1_66_0) weakremover(libboost_regex1_66_0-devel) weakremover(libboost_regex1_68_0) weakremover(libboost_regex1_68_0-devel) weakremover(libboost_regex1_69_0) weakremover(libboost_regex1_69_0-devel) weakremover(libboost_regex1_71_0) weakremover(libboost_regex1_71_0-devel) weakremover(libboost_regex1_74_0) weakremover(libboost_regex1_74_0-devel) weakremover(libboost_regex1_75_0) weakremover(libboost_regex1_75_0-devel) weakremover(libboost_regex1_76_0) weakremover(libboost_regex1_76_0-devel) weakremover(libboost_regex1_77_0) weakremover(libboost_regex1_77_0-devel) weakremover(libboost_regex1_78_0) weakremover(libboost_regex1_78_0-devel) weakremover(libboost_regex1_79_0) weakremover(libboost_regex1_79_0-devel) weakremover(libboost_regex1_80_0) weakremover(libboost_regex1_80_0-devel) weakremover(libboost_regex1_81_0) weakremover(libboost_regex1_81_0-devel) weakremover(libboost_regex1_82_0) weakremover(libboost_regex1_82_0-devel) weakremover(libboost_serialization1_54_0) weakremover(libboost_serialization1_58_0) weakremover(libboost_serialization1_59_0) weakremover(libboost_serialization1_61_0) weakremover(libboost_serialization1_66_0) weakremover(libboost_serialization1_66_0-devel) weakremover(libboost_serialization1_68_0) weakremover(libboost_serialization1_68_0-devel) weakremover(libboost_serialization1_69_0) weakremover(libboost_serialization1_69_0-devel) weakremover(libboost_serialization1_71_0) weakremover(libboost_serialization1_71_0-devel) weakremover(libboost_serialization1_74_0) weakremover(libboost_serialization1_74_0-devel) weakremover(libboost_serialization1_75_0) weakremover(libboost_serialization1_75_0-devel) weakremover(libboost_serialization1_76_0) weakremover(libboost_serialization1_76_0-devel) weakremover(libboost_serialization1_77_0) weakremover(libboost_serialization1_77_0-devel) weakremover(libboost_serialization1_78_0) weakremover(libboost_serialization1_78_0-devel) weakremover(libboost_serialization1_79_0) weakremover(libboost_serialization1_79_0-devel) weakremover(libboost_serialization1_80_0) weakremover(libboost_serialization1_80_0-devel) weakremover(libboost_serialization1_81_0) weakremover(libboost_serialization1_81_0-devel) weakremover(libboost_serialization1_82_0) weakremover(libboost_serialization1_82_0-devel) weakremover(libboost_signals1_54_0) weakremover(libboost_signals1_58_0) weakremover(libboost_signals1_59_0) weakremover(libboost_signals1_61_0) weakremover(libboost_signals1_66_0) weakremover(libboost_signals1_66_0-devel) weakremover(libboost_signals1_68_0) weakremover(libboost_signals1_68_0-devel) weakremover(libboost_stacktrace1_66_0) weakremover(libboost_stacktrace1_66_0-devel) weakremover(libboost_stacktrace1_68_0) weakremover(libboost_stacktrace1_68_0-devel) weakremover(libboost_stacktrace1_69_0) weakremover(libboost_stacktrace1_69_0-devel) weakremover(libboost_stacktrace1_71_0) weakremover(libboost_stacktrace1_71_0-devel) weakremover(libboost_stacktrace1_74_0) weakremover(libboost_stacktrace1_74_0-devel) weakremover(libboost_stacktrace1_75_0) weakremover(libboost_stacktrace1_75_0-devel) weakremover(libboost_stacktrace1_76_0) weakremover(libboost_stacktrace1_76_0-devel) weakremover(libboost_stacktrace1_77_0) weakremover(libboost_stacktrace1_77_0-devel) weakremover(libboost_stacktrace1_78_0) weakremover(libboost_stacktrace1_78_0-devel) weakremover(libboost_stacktrace1_79_0) weakremover(libboost_stacktrace1_79_0-devel) weakremover(libboost_stacktrace1_80_0) weakremover(libboost_stacktrace1_80_0-devel) weakremover(libboost_stacktrace1_81_0) weakremover(libboost_stacktrace1_81_0-devel) weakremover(libboost_stacktrace1_82_0) weakremover(libboost_stacktrace1_82_0-devel) weakremover(libboost_system1_54_0) weakremover(libboost_system1_56_0) weakremover(libboost_system1_58_0) weakremover(libboost_system1_59_0) weakremover(libboost_system1_61_0) weakremover(libboost_system1_66_0) weakremover(libboost_system1_66_0-devel) weakremover(libboost_system1_68_0) weakremover(libboost_system1_68_0-devel) weakremover(libboost_system1_69_0) weakremover(libboost_system1_69_0-devel) weakremover(libboost_system1_71_0) weakremover(libboost_system1_71_0-devel) weakremover(libboost_system1_74_0) weakremover(libboost_system1_74_0-devel) weakremover(libboost_system1_75_0) weakremover(libboost_system1_75_0-devel) weakremover(libboost_system1_76_0) weakremover(libboost_system1_76_0-devel) weakremover(libboost_system1_77_0) weakremover(libboost_system1_77_0-devel) weakremover(libboost_system1_78_0) weakremover(libboost_system1_78_0-devel) weakremover(libboost_system1_79_0) weakremover(libboost_system1_79_0-devel) weakremover(libboost_system1_80_0) weakremover(libboost_system1_80_0-devel) weakremover(libboost_system1_81_0) weakremover(libboost_system1_81_0-devel) weakremover(libboost_system1_82_0) weakremover(libboost_system1_82_0-devel) weakremover(libboost_test1_54_0) weakremover(libboost_test1_58_0) weakremover(libboost_test1_59_0) weakremover(libboost_test1_61_0) weakremover(libboost_test1_66_0) weakremover(libboost_test1_66_0-devel) weakremover(libboost_test1_68_0) weakremover(libboost_test1_68_0-devel) weakremover(libboost_test1_69_0) weakremover(libboost_test1_69_0-devel) weakremover(libboost_test1_71_0) weakremover(libboost_test1_71_0-devel) weakremover(libboost_test1_74_0) weakremover(libboost_test1_74_0-devel) weakremover(libboost_test1_75_0) weakremover(libboost_test1_75_0-devel) weakremover(libboost_test1_76_0) weakremover(libboost_test1_76_0-devel) weakremover(libboost_test1_77_0) weakremover(libboost_test1_77_0-devel) weakremover(libboost_test1_78_0) weakremover(libboost_test1_78_0-devel) weakremover(libboost_test1_79_0) weakremover(libboost_test1_79_0-devel) weakremover(libboost_test1_80_0) weakremover(libboost_test1_80_0-devel) weakremover(libboost_test1_81_0) weakremover(libboost_test1_81_0-devel) weakremover(libboost_test1_82_0) weakremover(libboost_test1_82_0-devel) weakremover(libboost_thread1_54_0) weakremover(libboost_thread1_56_0) weakremover(libboost_thread1_58_0) weakremover(libboost_thread1_59_0) weakremover(libboost_thread1_61_0) weakremover(libboost_thread1_66_0) weakremover(libboost_thread1_66_0-devel) weakremover(libboost_thread1_68_0) weakremover(libboost_thread1_68_0-devel) weakremover(libboost_thread1_69_0) weakremover(libboost_thread1_69_0-devel) weakremover(libboost_thread1_71_0) weakremover(libboost_thread1_71_0-devel) weakremover(libboost_thread1_74_0) weakremover(libboost_thread1_74_0-devel) weakremover(libboost_thread1_75_0) weakremover(libboost_thread1_75_0-devel) weakremover(libboost_thread1_76_0) weakremover(libboost_thread1_76_0-devel) weakremover(libboost_thread1_77_0) weakremover(libboost_thread1_77_0-devel) weakremover(libboost_thread1_78_0) weakremover(libboost_thread1_78_0-devel) weakremover(libboost_thread1_79_0) weakremover(libboost_thread1_79_0-devel) weakremover(libboost_thread1_80_0) weakremover(libboost_thread1_80_0-devel) weakremover(libboost_thread1_81_0) weakremover(libboost_thread1_81_0-devel) weakremover(libboost_thread1_82_0) weakremover(libboost_thread1_82_0-devel) weakremover(libboost_timer1_54_0) weakremover(libboost_timer1_58_0) weakremover(libboost_timer1_59_0) weakremover(libboost_timer1_61_0) weakremover(libboost_timer1_66_0) weakremover(libboost_timer1_66_0-devel) weakremover(libboost_timer1_68_0) weakremover(libboost_timer1_68_0-devel) weakremover(libboost_timer1_69_0) weakremover(libboost_timer1_69_0-devel) weakremover(libboost_timer1_71_0) weakremover(libboost_timer1_71_0-devel) weakremover(libboost_timer1_74_0) weakremover(libboost_timer1_74_0-devel) weakremover(libboost_timer1_75_0) weakremover(libboost_timer1_75_0-devel) weakremover(libboost_timer1_76_0) weakremover(libboost_timer1_76_0-devel) weakremover(libboost_timer1_77_0) weakremover(libboost_timer1_77_0-devel) weakremover(libboost_timer1_78_0) weakremover(libboost_timer1_78_0-devel) weakremover(libboost_timer1_79_0) weakremover(libboost_timer1_79_0-devel) weakremover(libboost_timer1_80_0) weakremover(libboost_timer1_80_0-devel) weakremover(libboost_timer1_81_0) weakremover(libboost_timer1_81_0-devel) weakremover(libboost_timer1_82_0) weakremover(libboost_timer1_82_0-devel) weakremover(libboost_type_erasure1_61_0) weakremover(libboost_type_erasure1_66_0) weakremover(libboost_type_erasure1_66_0-devel) weakremover(libboost_type_erasure1_68_0) weakremover(libboost_type_erasure1_68_0-devel) weakremover(libboost_type_erasure1_69_0) weakremover(libboost_type_erasure1_69_0-devel) weakremover(libboost_type_erasure1_71_0) weakremover(libboost_type_erasure1_71_0-devel) weakremover(libboost_type_erasure1_74_0) weakremover(libboost_type_erasure1_74_0-devel) weakremover(libboost_type_erasure1_75_0) weakremover(libboost_type_erasure1_75_0-devel) weakremover(libboost_type_erasure1_76_0) weakremover(libboost_type_erasure1_76_0-devel) weakremover(libboost_type_erasure1_77_0) weakremover(libboost_type_erasure1_77_0-devel) weakremover(libboost_type_erasure1_78_0) weakremover(libboost_type_erasure1_78_0-devel) weakremover(libboost_type_erasure1_79_0) weakremover(libboost_type_erasure1_79_0-devel) weakremover(libboost_type_erasure1_80_0) weakremover(libboost_type_erasure1_80_0-devel) weakremover(libboost_type_erasure1_81_0) weakremover(libboost_type_erasure1_81_0-devel) weakremover(libboost_type_erasure1_82_0) weakremover(libboost_type_erasure1_82_0-devel) weakremover(libboost_url1_81_0) weakremover(libboost_url1_81_0-devel) weakremover(libboost_url1_82_0) weakremover(libboost_url1_82_0-devel) weakremover(libboost_wave1_54_0) weakremover(libboost_wave1_58_0) weakremover(libboost_wave1_59_0) weakremover(libboost_wave1_61_0) weakremover(libboost_wave1_66_0) weakremover(libboost_wave1_66_0-devel) weakremover(libboost_wave1_68_0) weakremover(libboost_wave1_68_0-devel) weakremover(libboost_wave1_69_0) weakremover(libboost_wave1_69_0-devel) weakremover(libboost_wave1_71_0) weakremover(libboost_wave1_71_0-devel) weakremover(libboost_wave1_74_0) weakremover(libboost_wave1_74_0-devel) weakremover(libboost_wave1_75_0) weakremover(libboost_wave1_75_0-devel) weakremover(libboost_wave1_76_0) weakremover(libboost_wave1_76_0-devel) weakremover(libboost_wave1_77_0) weakremover(libboost_wave1_77_0-devel) weakremover(libboost_wave1_78_0) weakremover(libboost_wave1_78_0-devel) weakremover(libboost_wave1_79_0) weakremover(libboost_wave1_79_0-devel) weakremover(libboost_wave1_80_0) weakremover(libboost_wave1_80_0-devel) weakremover(libboost_wave1_81_0) weakremover(libboost_wave1_81_0-devel) weakremover(libboost_wave1_82_0) weakremover(libboost_wave1_82_0-devel) weakremover(libboringssl0) weakremover(libboringssl1) weakremover(libbotan-1_10-1) weakremover(libbotan-2-10) weakremover(libbotan-2-13) weakremover(libbotan-2-15) weakremover(libbotan-2-16) weakremover(libbotan-2-17) weakremover(libbotan-2-18) weakremover(libbotan-2-19) weakremover(libbotan-2-5) weakremover(libbotan-2-7) weakremover(libbotan-devel) weakremover(libbox2d-devel) weakremover(libbox2d2) weakremover(libbpf-devel) weakremover(libbpf-devel-static) weakremover(libbpf0) weakremover(libbpf1) weakremover(libbraiding-devel) weakremover(libbraiding0) weakremover(libbraille) weakremover(libbraille-devel) weakremover(libbraille-fake) weakremover(libbraille-fake0-14) weakremover(libbraille0-14) weakremover(libbrasero-burn3-1) weakremover(libbrasero-media3-1) weakremover(libbrasero-utils3-1) weakremover(libbreezecommon4-5) weakremover(libbreezecommon5-5) weakremover(libbrial3) weakremover(libbrlapi0_6) weakremover(libbrlapi0_7) weakremover(libbrlapi0_8) weakremover(libbrotli-devel) weakremover(libbrotlicommon1) weakremover(libbrotlidec0) weakremover(libbrotlidec1) weakremover(libbrotlienc0) weakremover(libbrotlienc1) weakremover(libbs2b-devel) weakremover(libbs2b0) weakremover(libbsd-ctor-static) weakremover(libbsd-devel) weakremover(libbsd0) weakremover(libbssl_wrapper_lib0) weakremover(libbtf-1_2_1) weakremover(libbtf-1_2_6) weakremover(libbtf1) weakremover(libbtrfs-devel) weakremover(libbtrfs0) weakremover(libbtrfsutil-devel) weakremover(libbtrfsutil1) weakremover(libbudgie-appindexer0) weakremover(libbudgie-plugin0) weakremover(libbudgie-private0) weakremover(libbudgie-raven-plugin0) weakremover(libbudgietheme0) weakremover(libbuffer0_3) weakremover(libbullet-devel) weakremover(libbullet2_82) weakremover(libbullet2_83) weakremover(libbullet2_86) weakremover(libbullet2_88) weakremover(libbullet2_89) weakremover(libbullet3_17) weakremover(libburn-devel) weakremover(libburn4) weakremover(libbuzztrax-core-devel) weakremover(libbuzztrax-core1) weakremover(libbuzztrax-gst-devel) weakremover(libbuzztrax-gst1) weakremover(libbuzztrax-ic-devel) weakremover(libbuzztrax-ic1) weakremover(libbytesize-devel) weakremover(libbytesize1) weakremover(libbz2-1) weakremover(libbz2-devel) weakremover(libbzip3-0) weakremover(libbzrtp0) weakremover(libc++-devel) weakremover(libc++1) weakremover(libc++abi-devel) weakremover(libc++abi1) weakremover(libc-client2007e_suse) weakremover(libc-client2007f_suse) weakremover(libc4core0_1_11) weakremover(libc4core0_1_8) weakremover(libcaca-devel) weakremover(libcaca-python) weakremover(libcaca-ruby) weakremover(libcaca0) weakremover(libcaca0-plugins) weakremover(libcacard) weakremover(libcacard-devel) weakremover(libcacard0) weakremover(libcaes-devel) weakremover(libcaes1) weakremover(libcaffe-gnu-hpc) weakremover(libcaffe1_0_0) weakremover(libcaffe_1_0-gnu-hpc) weakremover(libcairo-gobject2) weakremover(libcairo-script-interpreter2) weakremover(libcairo2) weakremover(libcairomm-1_0-1) weakremover(libcairomm-1_16-1) weakremover(libcaja-extension1) weakremover(libcal3d12) weakremover(libcalc1) weakremover(libcalc2) weakremover(libcalc2_14_0_14) weakremover(libcalc2_14_1_0) weakremover(libcalc2_14_1_2) weakremover(libcalc2_14_1_3) weakremover(libcalc2_14_1_5) weakremover(libcalcium0) weakremover(libcallaudio0_1-0) weakremover(libcallback1) weakremover(libcamd-2_4_1) weakremover(libcamd-2_4_6) weakremover(libcamd-doc) weakremover(libcamd2) weakremover(libcamel-1_2-54) weakremover(libcamel-1_2-57) weakremover(libcamel-1_2-59) weakremover(libcamel-1_2-60) weakremover(libcamel-1_2-62) weakremover(libcamel-1_2-63) weakremover(libcamel-1_2-64) weakremover(libcamera-base0_0_1) weakremover(libcamera-base0_0_3) weakremover(libcamera-base0_0_4) weakremover(libcamera-devel) weakremover(libcamera-suse0) weakremover(libcamera-suse1) weakremover(libcamera-suse2) weakremover(libcamera-suse3) weakremover(libcamera-suse4) weakremover(libcamera-suse5) weakremover(libcamera-suse6) weakremover(libcamera-suse7) weakremover(libcamera-tools) weakremover(libcamera0_0_1) weakremover(libcamera0_0_3) weakremover(libcamera0_0_4) weakremover(libcamgm-devel) weakremover(libcamgm100) weakremover(libcanberra-devel) weakremover(libcanberra-gtk-devel) weakremover(libcanberra-gtk-module-common) weakremover(libcanberra-gtk0) weakremover(libcanberra-gtk2-module) weakremover(libcanberra-gtk3-0) weakremover(libcanberra-gtk3-devel) weakremover(libcanberra-gtk3-module) weakremover(libcanberra0) weakremover(libcangjie-devel) weakremover(libcangjie-tools) weakremover(libcangjie2) weakremover(libcanlock-devel) weakremover(libcanlock3) weakremover(libcantorlibs16) weakremover(libcantorlibs17) weakremover(libcantorlibs20) weakremover(libcantorlibs23) weakremover(libcantorlibs24) weakremover(libcantorlibs27) weakremover(libcantorlibs28) weakremover(libcap-devel) weakremover(libcap-ng-devel) weakremover(libcap-ng-utils) weakremover(libcap-ng0) weakremover(libcap-progs) weakremover(libcap1) weakremover(libcap2) weakremover(libcapi20) weakremover(libcapi20-2) weakremover(libcapi20-3) weakremover(libcapi20-devel) weakremover(libcapi20-mod_misdn) weakremover(libcapnp-0_10_0) weakremover(libcapnp-0_10_2) weakremover(libcapnp-0_10_3) weakremover(libcapnp-0_10_4) weakremover(libcapnp-0_6) weakremover(libcapnp-0_7) weakremover(libcapnp-0_8) weakremover(libcapnp-0_9) weakremover(libcapnp-0_9_1) weakremover(libcapnp-devel) weakremover(libcapstone-devel) weakremover(libcapstone-devel-static) weakremover(libcapstone4) weakremover(libcares-devel) weakremover(libcares2) weakremover(libcaribou0) weakremover(libcasacore5) weakremover(libcasacore5-openmpi1) weakremover(libcasacore5-openmpi2) weakremover(libcasacore5-openmpi3) weakremover(libcasacore5-openmpi4) weakremover(libcasacore6) weakremover(libcasacore6-openmpi1) weakremover(libcasacore6-openmpi2) weakremover(libcasacore6-openmpi3) weakremover(libcasacore6-openmpi4) weakremover(libcasacore7) weakremover(libcasacore7-openmpi1) weakremover(libcasacore7-openmpi2) weakremover(libcasacore7-openmpi3) weakremover(libcasacore7-openmpi4) weakremover(libcblas3) weakremover(libcbor-devel) weakremover(libcbor-doc) weakremover(libcbor0) weakremover(libcbor0_10) weakremover(libcbor0_7) weakremover(libcbor0_8) weakremover(libcbor0_9) weakremover(libccaudio2-1_0-0) weakremover(libccolamd-2_9_1) weakremover(libccolamd-2_9_6) weakremover(libccolamd2) weakremover(libccrtp3) weakremover(libccscript3-1_1-0) weakremover(libcdada-devel) weakremover(libcdada0) weakremover(libcdata-devel) weakremover(libcdata1) weakremover(libcdatetime-devel) weakremover(libcdatetime1) weakremover(libcdaudio-devel) weakremover(libcdaudio1) weakremover(libcdd0) weakremover(libcdda_interface0) weakremover(libcdda_paranoia0) weakremover(libcddb-devel) weakremover(libcddb-utils) weakremover(libcddb2) weakremover(libcdio++0) weakremover(libcdio++1) weakremover(libcdio-devel) weakremover(libcdio-paranoia-devel) weakremover(libcdio16) weakremover(libcdio18) weakremover(libcdio19) weakremover(libcdio_cdda2) weakremover(libcdio_paranoia2) weakremover(libcdirectory-devel) weakremover(libcdirectory1) weakremover(libcdk5) weakremover(libcdk6_2_4) weakremover(libcdr-0_1-1) weakremover(libcdr-devel) weakremover(libcdr-tools) weakremover(libcdrdeflt1_0) weakremover(libcdt5) weakremover(libcdvar0) weakremover(libcec-devel) weakremover(libcec3) weakremover(libcec4) weakremover(libcec6) weakremover(libcegui-0) weakremover(libcegui-devel) weakremover(libcelt-devel) weakremover(libcelt0-2) weakremover(libcelt051-0) weakremover(libcephfs-devel) weakremover(libcephfs1) weakremover(libcephfs2) weakremover(libcephsqlite) weakremover(libcephsqlite-devel) weakremover(libceres-devel) weakremover(libceres1) weakremover(libceres2) weakremover(libceres3) weakremover(libcerf-devel) weakremover(libcerf1) weakremover(libcerf2) weakremover(libcerror-devel) weakremover(libcerror1) weakremover(libcetcd0) weakremover(libcfg6) weakremover(libcfile-devel) weakremover(libcfile1) weakremover(libcfitsio10) weakremover(libcfitsio5) weakremover(libcfitsio6) weakremover(libcfitsio7) weakremover(libcfitsio8) weakremover(libcfitsio9) weakremover(libcg3-1) weakremover(libcglm0) weakremover(libcgns3_4) weakremover(libcgns4_1) weakremover(libcgns4_3) weakremover(libcgraph6) weakremover(libcgroup-devel) weakremover(libcgroup-tools) weakremover(libcgroup1) weakremover(libchafa0) weakremover(libchamplain-0_12-0) weakremover(libchamplain-devel) weakremover(libchardet-devel) weakremover(libchardet1) weakremover(libcharls2) weakremover(libchck0) weakremover(libchealpix0) weakremover(libcheck0) weakremover(libcheese-gtk25) weakremover(libcheese8) weakremover(libchewing-devel) weakremover(libchewing3) weakremover(libchipcard) weakremover(libchipcard-devel) weakremover(libchipcard6) weakremover(libchm0) weakremover(libcholmod-3_0_11) weakremover(libcholmod-3_0_6) weakremover(libcholmod3) weakremover(libchromaprint-devel) weakremover(libchromaprint1) weakremover(libcilium1) weakremover(libcimcClientXML0) weakremover(libcimcclient0) weakremover(libcinnamon-control-center1) weakremover(libcinnamon-desktop-devel) weakremover(libcinnamon-desktop4) weakremover(libcinnamon-menu-3-0) weakremover(libcinnamon-menu-3-devel) weakremover(libcint3) weakremover(libcint4) weakremover(libcircle-devel) weakremover(libcircle2) weakremover(libcircllhist-devel) weakremover(libcircllhist0_0_1) weakremover(libcivetweb-cpp1_14_0) weakremover(libcivetweb-cpp1_15_0) weakremover(libcivetweb1_11_0) weakremover(libcivetweb1_13_0) weakremover(libcivetweb1_14_0) weakremover(libcivetweb1_15_0) weakremover(libcjose-devel) weakremover(libcjose0) weakremover(libcjs0) weakremover(libcjson1) weakremover(libck0) weakremover(libckteec0) weakremover(libclFFT2) weakremover(libclamav7) weakremover(libclamav9) weakremover(libclammspack0) weakremover(libclang) weakremover(libclang-cpp13) weakremover(libclang-cpp14) weakremover(libclang-cpp15) weakremover(libclang-cpp16) weakremover(libclang10) weakremover(libclang11) weakremover(libclang12) weakremover(libclang13) weakremover(libclang4) weakremover(libclang5) weakremover(libclang6) weakremover(libclang7) weakremover(libclang8) weakremover(libclang9) weakremover(libclastfm-devel) weakremover(libclastfm0) weakremover(libclaw-devel) weakremover(libclaw1) weakremover(libcld2-0) weakremover(libcli-devel) weakremover(libcli1_10) weakremover(libcli1_9) weakremover(libclingo4) weakremover(libcliquer1) weakremover(libclocale-devel) weakremover(libclocale1) weakremover(libcloog-isl4) weakremover(libcloudproviders-devel) weakremover(libcloudproviders0) weakremover(libclthreads2) weakremover(libclucene-contribs-lib1) weakremover(libclucene-core1) weakremover(libclucene-shared1) weakremover(libclutter-1_0-0) weakremover(libclutter-gst-2_0-0) weakremover(libclutter-gst-3_0-0) weakremover(libclutter-gtk-1_0-0) weakremover(libclxclient3) weakremover(libclzma-suse0) weakremover(libcm0) weakremover(libcm1) weakremover(libcmap4) weakremover(libcmark0_25_2) weakremover(libcmark0_27_1) weakremover(libcmark0_28_3) weakremover(libcmark0_29_0) weakremover(libcmark0_30_0) weakremover(libcmark0_30_2) weakremover(libcmark0_30_3) weakremover(libcmh0) weakremover(libcmis-0_5-5) weakremover(libcmis-c-0_5-5) weakremover(libcmis-c-devel) weakremover(libcmis-devel) weakremover(libcmocka-devel) weakremover(libcmocka-devel-static) weakremover(libcmocka0) weakremover(libcmpiCppImpl0) weakremover(libcmpisfcc1) weakremover(libcmpiutil) weakremover(libcmpiutil-devel) weakremover(libcmpiutil0) weakremover(libcmuclmtk-devel) weakremover(libcmuclmtk0) weakremover(libcnotify-devel) weakremover(libcnotify1) weakremover(libcob-devel) weakremover(libcob4) weakremover(libcodec2-0_6) weakremover(libcodec2-0_8) weakremover(libcodec2-0_9) weakremover(libcodec2-1_0) weakremover(libcogl-gles2-20) weakremover(libcogl-pango20) weakremover(libcogl20) weakremover(libcolamd-2_9_1) weakremover(libcolamd-2_9_6) weakremover(libcolamd2) weakremover(libcollectdclient-devel) weakremover(libcollectdclient1) weakremover(libcollection-devel) weakremover(libcollection4) weakremover(libcolm-0_13_0_3) weakremover(libcolm-0_13_0_5) weakremover(libcolm-0_13_0_6) weakremover(libcolm-0_13_0_7) weakremover(libcolm-0_14_7) weakremover(libcolorblind0) weakremover(libcolord-devel) weakremover(libcolord-gtk-devel) weakremover(libcolord-gtk1) weakremover(libcolord-gtk4-1) weakremover(libcolord2) weakremover(libcolorhug2) weakremover(libcom_err-devel) weakremover(libcom_err-devel-static) weakremover(libcom_err2) weakremover(libcommoncpp2-1_8-0) weakremover(libcompel1) weakremover(libcompizconfig) weakremover(libcompizconfig-devel) weakremover(libcomps-devel) weakremover(libcomps0) weakremover(libcomps0_1_11) weakremover(libcomps0_1_6) weakremover(libcomps0_1_9) weakremover(libconfig++-devel) weakremover(libconfig++11) weakremover(libconfig++9) weakremover(libconfig-devel) weakremover(libconfig11) weakremover(libconfig9) weakremover(libconfini-devel) weakremover(libconfini0) weakremover(libconfuse-devel) weakremover(libconfuse0) weakremover(libconfuse0-lang) weakremover(libconfuse2) weakremover(libcorosync-devel) weakremover(libcorosync4) weakremover(libcorosync_common4) weakremover(libcorrect-devel) weakremover(libcorrect0_0_0) weakremover(libcotp-devel) weakremover(libcotp12) weakremover(libcotp2) weakremover(libcourier-unicode1) weakremover(libcourier-unicode4) weakremover(libcourier-unicode7) weakremover(libcpath-devel) weakremover(libcpath1) weakremover(libcpg4) weakremover(libcpluff-devel) weakremover(libcpluff0) weakremover(libcpluffxx-devel) weakremover(libcpluffxx0) weakremover(libcpp-httplib0_12) weakremover(libcppdb0) weakremover(libcppdb_mysql0) weakremover(libcppdb_odbc0) weakremover(libcppdb_postgresql0) weakremover(libcppdb_sqlite3-0) weakremover(libcpprest2_10) weakremover(libcpprest2_6) weakremover(libcppunit-1_13-0) weakremover(libcppunit-1_14-0) weakremover(libcppunit-1_15-1) weakremover(libcppunit_subunit0) weakremover(libcppunit_subunit0-devel) weakremover(libcpuid-devel) weakremover(libcpuid-tools) weakremover(libcpuid14) weakremover(libcpuid15) weakremover(libcpuid16) weakremover(libcpupower0) weakremover(libcpuset-devel) weakremover(libcpuset1) weakremover(libcrack2) weakremover(libcrbtree0) weakremover(libcrc32c-devel) weakremover(libcrc32c1) weakremover(libcreaterepo_c-devel) weakremover(libcreaterepo_c0) weakremover(libcreg-devel) weakremover(libcreg-tools) weakremover(libcreg1) weakremover(libcriterion3) weakremover(libcriterion3-devel) weakremover(libcriu1) weakremover(libcriu2) weakremover(libcroco) weakremover(libcroco-0_6-3) weakremover(libcroco-devel) weakremover(libcrossc1) weakremover(libcrossguid0) weakremover(libcrypt1) weakremover(libcryptmount-devel) weakremover(libcryptmount0) weakremover(libcrypto37) weakremover(libcrypto41) weakremover(libcrypto43) weakremover(libcrypto44) weakremover(libcrypto45) weakremover(libcrypto46) weakremover(libcrypto47) weakremover(libcrypto49) weakremover(libcrypto50) weakremover(libcryptopp-5_6_2-0) weakremover(libcryptopp-devel) weakremover(libcryptopp-devel-static) weakremover(libcryptopp5_6_5) weakremover(libcryptopp7_0_0) weakremover(libcryptopp8_2_0) weakremover(libcryptopp8_4_0) weakremover(libcryptopp8_5_0) weakremover(libcryptopp8_6_0) weakremover(libcryptopp8_7_0) weakremover(libcryptsetup-devel) weakremover(libcryptsetup12) weakremover(libcryptsetup12-hmac) weakremover(libcryptsetup4) weakremover(libcryptsetup4-hmac) weakremover(libcryptui-data) weakremover(libcryptui-devel) weakremover(libcryptui0) weakremover(libcsirocsa0) weakremover(libcsironn0) weakremover(libcsnd6-6_0) weakremover(libcsound64-6_0) weakremover(libcsparse-3_1_9) weakremover(libcsparse3) weakremover(libcsparsever-3_1_4) weakremover(libcsplit-devel) weakremover(libcsplit1) weakremover(libcss-devel) weakremover(libcss0) weakremover(libcstring-devel) weakremover(libcstring1) weakremover(libcsv-devel) weakremover(libcsv3) weakremover(libcsync-devel) weakremover(libcsync-devel-doc) weakremover(libcsync-doc) weakremover(libcsync-plugin-owncloud) weakremover(libcsync-plugin-sftp) weakremover(libcsync-plugin-smb) weakremover(libcsync0) weakremover(libcsystem-devel) weakremover(libcsystem1) weakremover(libct4) weakremover(libctemplate-devel) weakremover(libctemplate3) weakremover(libctf-nobfd0) weakremover(libctf0) weakremover(libcthreads-devel) weakremover(libcthreads1) weakremover(libctl-devel) weakremover(libctl-doc) weakremover(libctl5) weakremover(libctl7) weakremover(libcuckoo-devel) weakremover(libcudd-3_0_0-0) weakremover(libcudd0) weakremover(libcue-devel) weakremover(libcue1) weakremover(libcue2) weakremover(libcuefile-devel) weakremover(libcuefile0) weakremover(libcunit1) weakremover(libcups2) weakremover(libcupscgi1) weakremover(libcupsimage2) weakremover(libcupsmime1) weakremover(libcupsppdc1) weakremover(libcurl-devel) weakremover(libcurl-mini-devel) weakremover(libcurl4) weakremover(libcurl4-mini) weakremover(libcvc-devel) weakremover(libcvc0) weakremover(libcwiid-devel) weakremover(libcwiid1) weakremover(libcwnn0) weakremover(libcxgb3-rdmav2) weakremover(libcxgb4-rdmav2) weakremover(libcxsc2) weakremover(libcxsparse-3_1_4) weakremover(libcxsparse-3_1_9) weakremover(libcxsparse3) weakremover(libcxx-gtk-utils-2-2_2-0) weakremover(libcxx-gtk-utils-2-devel) weakremover(libcxx-gtk-utils-3-2_2-0) weakremover(libcxx-gtk-utils-3-devel) weakremover(libcxx-gtk-utils-4-2_2-0) weakremover(libcxx-gtk-utils-4-devel) weakremover(libcxxtools-bin10) weakremover(libcxxtools-bin9) weakremover(libcxxtools-http10) weakremover(libcxxtools-http9) weakremover(libcxxtools-json10) weakremover(libcxxtools-json9) weakremover(libcxxtools-unit10) weakremover(libcxxtools-unit9) weakremover(libcxxtools-xmlrpc10) weakremover(libcxxtools-xmlrpc9) weakremover(libcxxtools10) weakremover(libcxxtools9) weakremover(libczmq3) weakremover(libczmq4) weakremover(libd0_blind_id0) weakremover(libd0_rijndael0) weakremover(libdSFMT2_2) weakremover(libdaemon-devel) weakremover(libdaemon0) weakremover(libdar-devel) weakremover(libdar5000) weakremover(libdar64-6000) weakremover(libdareader1) weakremover(libdat2-2) weakremover(libdataquay0) weakremover(libdate-tz3) weakremover(libdatovka) weakremover(libdatovka-devel) weakremover(libdatovka0) weakremover(libdatovka2) weakremover(libdatovka4) weakremover(libdatrie-devel) weakremover(libdatrie1) weakremover(libdav1d0) weakremover(libdav1d1) weakremover(libdav1d2) weakremover(libdav1d3) weakremover(libdav1d4) weakremover(libdav1d5) weakremover(libdav1d6) weakremover(libdavix0) weakremover(libdazzle) weakremover(libdazzle-1_0-0) weakremover(libdazzle-devel) weakremover(libdb-4_5) weakremover(libdb-4_5-devel) weakremover(libdb-4_8) weakremover(libdb-4_8-devel) weakremover(libdb_java-4_5) weakremover(libdb_java-4_5-devel) weakremover(libdb_java-4_8) weakremover(libdb_java-4_8-devel) weakremover(libdbh2) weakremover(libdbi-devel) weakremover(libdbi-drivers-dbd-freetds) weakremover(libdbi-drivers-dbd-mysql) weakremover(libdbi-drivers-dbd-pgsql) weakremover(libdbi-drivers-dbd-sqlite) weakremover(libdbi-drivers-dbd-sqlite3) weakremover(libdbi3) weakremover(libdbus-1-3) weakremover(libdbus-1-qt3-0) weakremover(libdbus-1-qt3-0-devel) weakremover(libdbus-c++-1-0) weakremover(libdbus-c++-1-1) weakremover(libdbus-c++-devel) weakremover(libdbus-c++-glib-1-0) weakremover(libdbus-c++-glib-1-1) weakremover(libdbus-c++-glib-devel) weakremover(libdbus-glib-1-2) weakremover(libdbusextended-qt5-1) weakremover(libdbusextended-qt5-devel) weakremover(libdbusmenu-glib-devel) weakremover(libdbusmenu-glib4) weakremover(libdbusmenu-gtk-devel) weakremover(libdbusmenu-gtk-doc) weakremover(libdbusmenu-gtk2-devel) weakremover(libdbusmenu-gtk3-4) weakremover(libdbusmenu-gtk3-devel) weakremover(libdbusmenu-gtk4) weakremover(libdbusmenu-jsonloader-devel) weakremover(libdbusmenu-jsonloader4) weakremover(libdbusmenu-qt-devel) weakremover(libdbusmenu-qt2) weakremover(libdbusmenu-qt5-2) weakremover(libdbusmenu-qt5-devel) weakremover(libdbusmenu-tools) weakremover(libdc1394) weakremover(libdc1394-22) weakremover(libdc1394-25) weakremover(libdc1394-devel) weakremover(libdc1394-tools) weakremover(libdca-devel) weakremover(libdca0) weakremover(libdcerpc-binding0) weakremover(libdcerpc-devel) weakremover(libdcerpc-samr-devel) weakremover(libdcerpc-samr0) weakremover(libdcerpc0) weakremover(libdcmtk16) weakremover(libdcmtk17) weakremover(libdcmtk3_6) weakremover(libdconf1) weakremover(libdd_opentracing0) weakremover(libddccontrol0) weakremover(libddcutil-devel) weakremover(libddcutil0) weakremover(libddcutil2) weakremover(libddcutil3) weakremover(libddcutil4) weakremover(libdde-file-manager5) weakremover(libdde-network-utils1) weakremover(libdde-wayland-client0) weakremover(libdde-wayland-server0) weakremover(libdeal_II9_2_0) weakremover(libdeal_II9_2_0-openmpi2) weakremover(libdeal_II9_2_0-openmpi3) weakremover(libdeal_II9_3_0) weakremover(libdeal_II9_3_0-openmpi2) weakremover(libdeal_II9_3_0-openmpi3) weakremover(libdeal_II9_3_0-openmpi4) weakremover(libdeal_II9_3_1) weakremover(libdeal_II9_3_1-openmpi2) weakremover(libdeal_II9_3_1-openmpi3) weakremover(libdeal_II9_3_1-openmpi4) weakremover(libdeal_II9_3_2) weakremover(libdeal_II9_3_2-openmpi2) weakremover(libdeal_II9_3_2-openmpi3) weakremover(libdeal_II9_3_2-openmpi4) weakremover(libdeal_II9_3_3) weakremover(libdeal_II9_3_3-openmpi2) weakremover(libdeal_II9_3_3-openmpi3) weakremover(libdeal_II9_3_3-openmpi4) weakremover(libdeal_II9_4_0) weakremover(libdeal_II9_4_0-openmpi2) weakremover(libdeal_II9_4_0-openmpi3) weakremover(libdeal_II9_4_0-openmpi4) weakremover(libdeal_II9_4_1) weakremover(libdeal_II9_4_1-openmpi2) weakremover(libdeal_II9_4_1-openmpi3) weakremover(libdeal_II9_4_1-openmpi4) weakremover(libdeal_II9_4_2) weakremover(libdeal_II9_4_2-openmpi2) weakremover(libdeal_II9_4_2-openmpi3) weakremover(libdeal_II9_4_2-openmpi4) weakremover(libdebuginfod-devel) weakremover(libdebuginfod-dummy-devel) weakremover(libdebuginfod1) weakremover(libdebuginfod1-dummy) weakremover(libdecor) weakremover(libdecor-0-0) weakremover(libdecor-devel) weakremover(libdecoration0) weakremover(libdee-1_0-4) weakremover(libdeepin-pdfium1) weakremover(libdeepin-turbo0) weakremover(libdeepin_pw_check1) weakremover(libdeflate-devel) weakremover(libdeflate-tools) weakremover(libdeflate0) weakremover(libdeflt1_0) weakremover(libdevil-tools) weakremover(libdevmapper-event1_03) weakremover(libdevmapper1_03) weakremover(libdex-1-1) weakremover(libdex-devel) weakremover(libdfm-extension5) weakremover(libdframeworkdbus-devel) weakremover(libdframeworkdbus1) weakremover(libdframeworkdbus2) weakremover(libdhash-devel) weakremover(libdhash1) weakremover(libdialog11) weakremover(libdialog12) weakremover(libdialog14) weakremover(libdialog15) weakremover(libdico1) weakremover(libdico2) weakremover(libdict-devel) weakremover(libdict1_0) weakremover(libdigikamcore5) weakremover(libdigikamcore6) weakremover(libdigikamcore7) weakremover(libdigikamcore7_10_0) weakremover(libdigikamcore7_6_0) weakremover(libdigikamcore7_7_0) weakremover(libdigikamcore7_8_0) weakremover(libdigikamcore7_9_0) weakremover(libdigikamcore8_0_0) weakremover(libdirac_decoder0) weakremover(libdirac_encoder0) weakremover(libdirectfb-1_7-1) weakremover(libdirectfb-1_7-6) weakremover(libdiscid-devel) weakremover(libdiscid0) weakremover(libdiscord-rpc) weakremover(libdiscord-rpc3_4_0) weakremover(libdisomaster1) weakremover(libdispatch) weakremover(libdispatch1_3) weakremover(libdisplay-info-devel) weakremover(libdisplay-info1) weakremover(libdjvulibre-devel) weakremover(libdjvulibre21) weakremover(libdleyna-core-1_0-4) weakremover(libdleyna-core-1_0-5) weakremover(libdleyna-core-1_0-6) weakremover(libdlm) weakremover(libdlm-devel) weakremover(libdlm3) weakremover(libdm0) weakremover(libdmapsharing-3_0-2) weakremover(libdmapsharing-4_0-3) weakremover(libdmapsharing-devel) weakremover(libdmapsharing3-devel) weakremover(libdmlc) weakremover(libdmmp-devel) weakremover(libdmmp0_1_0) weakremover(libdmmp0_2_0) weakremover(libdmr0_1) weakremover(libdmtx-devel) weakremover(libdmtx0) weakremover(libdmusic1) weakremover(libdmx-devel) weakremover(libdmx1) weakremover(libdnet-devel) weakremover(libdnet-python) weakremover(libdnet1) weakremover(libdnf-devel) weakremover(libdnf-plugin-txnupd) weakremover(libdnf-repo-config-zypp) weakremover(libdnf1) weakremover(libdnf2) weakremover(libdnnl1) weakremover(libdnnl2) weakremover(libdnnl3) weakremover(libdns1311) weakremover(libdns146) weakremover(libdns160) weakremover(libdns1600) weakremover(libdns1601) weakremover(libdns1603) weakremover(libdns1605) weakremover(libdns1607) weakremover(libdns1608) weakremover(libdns161) weakremover(libdns1610) weakremover(libdns1611) weakremover(libdns169) weakremover(libdns_sd) weakremover(libdnssec8) weakremover(libdnssec9) weakremover(libdocparser1) weakremover(libdolphinvcs5) weakremover(libdotconf0) weakremover(libdouble-conversion1) weakremover(libdouble-conversion2) weakremover(libdouble-conversion3) weakremover(libdovi-devel) weakremover(libdovi3) weakremover(libdpdk-17_11) weakremover(libdpdk-17_11-0) weakremover(libdpdk-18_02) weakremover(libdpdk-18_11) weakremover(libdpdk-20_0) weakremover(libdpdk-22) weakremover(libdpdk-23) weakremover(libdqlite0) weakremover(libdrm-devel) weakremover(libdrm-tools) weakremover(libdrm2) weakremover(libdrm_amdgpu1) weakremover(libdrm_etnaviv1) weakremover(libdrm_exynos1) weakremover(libdrm_freedreno1) weakremover(libdrm_intel1) weakremover(libdrm_nouveau2) weakremover(libdrm_radeon1) weakremover(libdrm_tegra0) weakremover(libdrop_ambient-devel) weakremover(libdrop_ambient0) weakremover(libdrpm-devel) weakremover(libdrpm0) weakremover(libdrumstick-alsa1) weakremover(libdrumstick-alsa2) weakremover(libdrumstick-devel) weakremover(libdrumstick-file1) weakremover(libdrumstick-file2) weakremover(libdrumstick-rt-plugins) weakremover(libdrumstick-rt1) weakremover(libdrumstick-rt2) weakremover(libdrumstick-rt2-plugins) weakremover(libdrumstick-widgets2) weakremover(libdruntime-ldc102) weakremover(libdruntime-ldc83) weakremover(libdruntime-ldc85) weakremover(libdruntime-ldc86) weakremover(libdruntime-ldc91) weakremover(libdruntime-ldc92) weakremover(libdruntime-ldc93) weakremover(libdruntime-ldc94) weakremover(libdruntime-ldc96) weakremover(libdruntime-ldc99) weakremover(libdrvproxy2) weakremover(libdspy-1-1) weakremover(libdtkbase-devel) weakremover(libdtkbase1) weakremover(libdtkcore2) weakremover(libdtkcore5) weakremover(libdtkgui5) weakremover(libdtksettings-devel) weakremover(libdtksettings1) weakremover(libdtksettingsview-devel) weakremover(libdtksettingsview1) weakremover(libdtkutil-devel) weakremover(libdtkutil1) weakremover(libdtkwidget-devel) weakremover(libdtkwidget1) weakremover(libdtkwidget2) weakremover(libdtkwidget5) weakremover(libdtkwm2) weakremover(libdtkwm5) weakremover(libdui-devel) weakremover(libdui1) weakremover(libduktape201) weakremover(libduktape206) weakremover(libduktape207) weakremover(libdumb-0_9_3) weakremover(libdumb-devel) weakremover(libdumb2) weakremover(libdv) weakremover(libdv-devel) weakremover(libdv-playdv) weakremover(libdv4) weakremover(libdvbpsi-0-devel) weakremover(libdvbpsi-devel) weakremover(libdvbpsi10) weakremover(libdvbpsi7) weakremover(libdvbv5-0) weakremover(libdvbv5-0-lang) weakremover(libdvbv5-devel) weakremover(libdvdnav-devel) weakremover(libdvdnav4) weakremover(libdvdread-devel) weakremover(libdvdread4) weakremover(libdvdread7) weakremover(libdvdread8) weakremover(libdw-devel) weakremover(libdw1) weakremover(libdwarf) weakremover(libdwarf-devel) weakremover(libdwarf-devel-static) weakremover(libdwarf-doc) weakremover(libdwarf-tools) weakremover(libdwarf0) weakremover(libdwarf1) weakremover(libdwarves-devel) weakremover(libdwarves1) weakremover(libdxflib-3_17_0-1) weakremover(libdxflib-3_26_4-1) weakremover(libdxflib1) weakremover(libdxfrw-devel) weakremover(libdxfrw-tools) weakremover(libdxfrw0) weakremover(libdxfrw1) weakremover(libe-book-0_1-1) weakremover(libe-book-devel) weakremover(libe-book-tools) weakremover(libe131-1) weakremover(libe131-devel) weakremover(libeXosip2) weakremover(libeXosip2-11) weakremover(libeXosip2-12) weakremover(libeXosip2-15) weakremover(libeXosip2-devel) weakremover(libeantic1) weakremover(libeb16) weakremover(libebackend-1_2-10) weakremover(libebackend-1_2-11) weakremover(libebl-devel) weakremover(libebl-plugins) weakremover(libebl1) weakremover(libebml-devel) weakremover(libebml4) weakremover(libebml5) weakremover(libebook-1_2-16) weakremover(libebook-1_2-19) weakremover(libebook-1_2-20) weakremover(libebook-1_2-21) weakremover(libebook-contacts-1_2-2) weakremover(libebook-contacts-1_2-3) weakremover(libebook-contacts-1_2-4) weakremover(libebtc0) weakremover(libebur128-1) weakremover(libebur128-devel) weakremover(libecal-1_2-19) weakremover(libecal-2_0-1) weakremover(libecal-2_0-2) weakremover(libecholib-devel) weakremover(libecholib1_3) weakremover(libecholib1_3-devel) weakremover(libechonest-devel) weakremover(libechonest-qt5-devel) weakremover(libechonest2_3) weakremover(libechonest5-2_3) weakremover(libecm0) weakremover(libecm1) weakremover(libeconf-devel) weakremover(libeconf-utils) weakremover(libeconf0) weakremover(libecore1) weakremover(libecpg6) weakremover(libecpint-devel) weakremover(libecpint1) weakremover(libecryptfs1) weakremover(libector1) weakremover(libedata-book-1_2-25) weakremover(libedata-book-1_2-26) weakremover(libedata-book-1_2-27) weakremover(libedata-cal-1_2-28) weakremover(libedata-cal-1_2-29) weakremover(libedata-cal-2_0-1) weakremover(libedata-cal-2_0-2) weakremover(libedataserver-1_2-21) weakremover(libedataserver-1_2-22) weakremover(libedataserver-1_2-23) weakremover(libedataserver-1_2-24) weakremover(libedataserver-1_2-25) weakremover(libedataserver-1_2-26) weakremover(libedataserver-1_2-27) weakremover(libedataserverui-1_2-1) weakremover(libedataserverui-1_2-2) weakremover(libedataserverui-1_2-3) weakremover(libedataserverui-1_2-4) weakremover(libedataserverui4-1_0-0) weakremover(libedc_ecc1_0) weakremover(libedc_ecc_dec1_0) weakremover(libedit-devel) weakremover(libedit0) weakremover(libeditorconfig-devel) weakremover(libeditorconfig0) weakremover(libedje1) weakremover(libee-devel) weakremover(libee0) weakremover(libeet1) weakremover(libeews-1_2-0) weakremover(libeeze1) weakremover(libefa1) weakremover(libefivar0) weakremover(libefivar1) weakremover(libefl1) weakremover(libefreet1) weakremover(libefreet_mime1) weakremover(libefreet_trash1) weakremover(libei-devel) weakremover(libei-suse0) weakremover(libei-suse1) weakremover(libei-suse2) weakremover(libei-suse3) weakremover(libei-suse4) weakremover(libeigen2-devel) weakremover(libeina1) weakremover(libeio1) weakremover(libeiskaltdcpp2_4) weakremover(libeldbus1) weakremover(libelektra-augeas) weakremover(libelektra-devel) weakremover(libelektra-devel-doc) weakremover(libelektra4) weakremover(libelementary1) weakremover(libelf-devel) weakremover(libelf0) weakremover(libelf0-devel) weakremover(libelf1) weakremover(libell0) weakremover(libelocation1) weakremover(libelpa2) weakremover(libelput1) weakremover(libelua1) weakremover(libembree3) weakremover(libembryo1) weakremover(libemf2svg-devel) weakremover(libemf2svg1) weakremover(libemile1) weakremover(libemon1_3_1) weakremover(libemotion1) weakremover(libenca0) weakremover(libenchant-2-2) weakremover(libenchant1) weakremover(libenet7) weakremover(libeo1) weakremover(libeolian1) weakremover(libeot-devel) weakremover(libeot-tools) weakremover(libeot0) weakremover(libepc-1_0-2) weakremover(libepc-1_0-3) weakremover(libepc-devel) weakremover(libephysics1) weakremover(libepoxy-devel) weakremover(libepoxy0) weakremover(libeppic-devel) weakremover(libepub-devel) weakremover(libepub0) weakremover(libepubgen-0_0-0) weakremover(libepubgen-0_1-1) weakremover(libepubgen-devel) weakremover(liberasurecode-devel) weakremover(liberasurecode1) weakremover(liberation2-fonts) weakremover(liberfa1) weakremover(libesd-devel) weakremover(libesd0) weakremover(libesedb-devel) weakremover(libesedb-tools) weakremover(libesedb1) weakremover(libesmtp) weakremover(libesmtp-devel) weakremover(libesmtp6) weakremover(libesmtp6_2_0) weakremover(libespeak-ng1) weakremover(libestr-devel) weakremover(libestr0) weakremover(libethumb1) weakremover(libethumb_client1) weakremover(libetonyek-0_1-1) weakremover(libetonyek-devel) weakremover(libetonyek-tools) weakremover(libetpan-devel) weakremover(libetpan17) weakremover(libetpan20) weakremover(libetrophy0) weakremover(libev-devel) weakremover(libev4) weakremover(libevas1) weakremover(libevdev-devel) weakremover(libevdev-tools) weakremover(libevdev2) weakremover(libevdocument3-4) weakremover(libevemu3) weakremover(libevent-2_0-5) weakremover(libevent-2_1-6) weakremover(libevent-2_1-7) weakremover(libevent-2_1-8) weakremover(libevent-devel) weakremover(libevent-devel-static) weakremover(libevt-devel) weakremover(libevt-tools) weakremover(libevt1) weakremover(libevtlog-3_14-0) weakremover(libevtlog-3_19-0) weakremover(libevtlog-3_23-0) weakremover(libevtlog-3_25-0) weakremover(libevtlog-3_26-0) weakremover(libevtlog-3_30-0) weakremover(libevtlog-3_33-0) weakremover(libevtlog-3_35-0) weakremover(libevtlog-3_37-0) weakremover(libevtlog-4_0-0) weakremover(libevtlog-devel) weakremover(libevtlog0) weakremover(libevtx-devel) weakremover(libevtx-tools) weakremover(libevtx1) weakremover(libevview3-3) weakremover(libewf-devel) weakremover(libewf-tools) weakremover(libewf2) weakremover(libewf3) weakremover(libewsutils0) weakremover(libexe-devel) weakremover(libexe-tools) weakremover(libexe1) weakremover(libexempi-devel) weakremover(libexempi3) weakremover(libexempi8) weakremover(libexfat0) weakremover(libexif-devel) weakremover(libexif-gtk) weakremover(libexif-gtk-devel) weakremover(libexif-gtk5) weakremover(libexif12) weakremover(libexiv2-14) weakremover(libexiv2-26) weakremover(libexiv2-27) weakremover(libexiv2-devel) weakremover(libexiv2-doc) weakremover(libexiv2-xmp-static) weakremover(libexmdbpp-devel) weakremover(libexmdbpp0) weakremover(libexo-1-0) weakremover(libexo-1-0-branding-openSUSE) weakremover(libexo-1-0-branding-upstream) weakremover(libexo-2-0) weakremover(libexoIIv2c-5_14_0) weakremover(libexoIIv2for-5_14_0) weakremover(libexodus-5_14_0) weakremover(libexpat-devel) weakremover(libexpat0) weakremover(libexpat1) weakremover(libexplain-devel) weakremover(libexplain51) weakremover(libexslt0) weakremover(libext2fs-devel) weakremover(libext2fs-devel-static) weakremover(libext2fs2) weakremover(libexttextcat) weakremover(libexttextcat-2_0-0) weakremover(libexttextcat-devel) weakremover(libexttextcat-tools) weakremover(libf2c0) weakremover(libf2fs1) weakremover(libf2fs6) weakremover(libf2fs7) weakremover(libf2fs8) weakremover(libf2fs9) weakremover(libf2fs_format0) weakremover(libf2fs_format5) weakremover(libf2fs_format6) weakremover(libf2fs_format7) weakremover(libf2fs_format8) weakremover(libf95getdata2) weakremover(libf95getdata7) weakremover(libfa1) weakremover(libfabric) weakremover(libfabric-devel) weakremover(libfabric1) weakremover(libfactory-4_3_1) weakremover(libfactory-devel) weakremover(libfakekey-devel) weakremover(libfakekey0) weakremover(libfaketime) weakremover(libfallocate-devel) weakremover(libfallocate-devel-static) weakremover(libfallocate0) weakremover(libfam0-gamin) weakremover(libfann-devel) weakremover(libfann2) weakremover(libfarstream-0_2-5) weakremover(libfastjet0) weakremover(libfastjetcontribfragile) weakremover(libfastjson-devel) weakremover(libfastjson4) weakremover(libfastlz1) weakremover(libfaxutil5_5_6) weakremover(libfaxutil5_5_8) weakremover(libfaxutil5_5_9) weakremover(libfaxutil5_6_1) weakremover(libfaxutil7_0_0) weakremover(libfaxutil7_0_1) weakremover(libfaxutil7_0_2) weakremover(libfaxutil7_0_3) weakremover(libfaxutil7_0_4) weakremover(libfaxutil7_0_5) weakremover(libfaxutil7_0_6) weakremover(libfaxutil7_0_7) weakremover(libfbclient-devel) weakremover(libfbclient2) weakremover(libfbclient2-devel) weakremover(libfbembed-devel) weakremover(libfbembed2_5) weakremover(libfcache-devel) weakremover(libfcache1) weakremover(libfcft3) weakremover(libfcft4) weakremover(libfcgi0) weakremover(libfcitx-4_2_9) weakremover(libfcitx-config4) weakremover(libfcitx-core0) weakremover(libfcitx-gclient1) weakremover(libfcitx-utils0) weakremover(libfcrypto-devel) weakremover(libfcrypto1) weakremover(libfdata-devel) weakremover(libfdata1) weakremover(libfdatetime-devel) weakremover(libfdatetime1) weakremover(libfdisk-devel) weakremover(libfdisk-devel-static) weakremover(libfdisk1) weakremover(libfdk-aac-devel) weakremover(libfdk-aac2) weakremover(libfdt-devel) weakremover(libfdt1) weakremover(libfdt1-devel) weakremover(libfec3) weakremover(libfeedback-0_0-0) weakremover(libff-1_0_0) weakremover(libff-devel) weakremover(libffado-devel) weakremover(libffado2) weakremover(libffcall0) weakremover(libffi-devel) weakremover(libffi-devel-gcc5) weakremover(libffi4) weakremover(libffi4-gcc48) weakremover(libffi48-devel) weakremover(libffi7) weakremover(libffi8) weakremover(libffmpegthumbnailer-devel) weakremover(libffmpegthumbnailer4) weakremover(libffms2-4) weakremover(libffms2-5) weakremover(libffms2-devel) weakremover(libfftw3-3) weakremover(libfftw3-gnu-hpc) weakremover(libfftw3-gnu-mpich-hpc) weakremover(libfftw3-gnu-mvapich2-hpc) weakremover(libfftw3-gnu-openmpi1-hpc) weakremover(libfftw3-gnu-openmpi2-hpc) weakremover(libfftw3-gnu-openmpi3-hpc) weakremover(libfftw3-gnu-openmpi4-hpc) weakremover(libfftw3_3_3_10-gnu-hpc) weakremover(libfftw3_3_3_10-gnu-mpich-hpc) weakremover(libfftw3_3_3_10-gnu-mvapich2-hpc) weakremover(libfftw3_3_3_10-gnu-openmpi1-hpc) weakremover(libfftw3_3_3_10-gnu-openmpi2-hpc) weakremover(libfftw3_3_3_10-gnu-openmpi3-hpc) weakremover(libfftw3_3_3_10-gnu-openmpi4-hpc) weakremover(libfftw3_3_3_6-gnu-hpc) weakremover(libfftw3_3_3_6-gnu-mpich-hpc) weakremover(libfftw3_3_3_6-gnu-mvapich2-hpc) weakremover(libfftw3_3_3_6-gnu-openmpi1-hpc) weakremover(libfftw3_3_3_6-gnu-openmpi2-hpc) weakremover(libfftw3_3_3_6-gnu-openmpi3-hpc) weakremover(libfftw3_3_3_8-gnu-hpc) weakremover(libfftw3_3_3_8-gnu-mpich-hpc) weakremover(libfftw3_3_3_8-gnu-mvapich2-hpc) weakremover(libfftw3_3_3_8-gnu-openmpi1-hpc) weakremover(libfftw3_3_3_8-gnu-openmpi2-hpc) weakremover(libfftw3_3_3_8-gnu-openmpi3-hpc) weakremover(libfftw3_3_3_8-gnu-openmpi4-hpc) weakremover(libfftw3_3_3_9-gnu-hpc) weakremover(libfftw3_3_3_9-gnu-mpich-hpc) weakremover(libfftw3_3_3_9-gnu-mvapich2-hpc) weakremover(libfftw3_3_3_9-gnu-openmpi1-hpc) weakremover(libfftw3_3_3_9-gnu-openmpi2-hpc) weakremover(libfftw3_3_3_9-gnu-openmpi3-hpc) weakremover(libfftw3_3_3_9-gnu-openmpi4-hpc) weakremover(libfftw3_mpi3) weakremover(libfftw3_omp3) weakremover(libfftw3_threads3) weakremover(libfgetdata2) weakremover(libfgetdata6) weakremover(libfguid-devel) weakremover(libfguid1) weakremover(libfido2-0_4_0) weakremover(libfido2-1) weakremover(libfido2-1_0_0) weakremover(libfido2-devel) weakremover(libfido2-utils) weakremover(libfife0_4_2) weakremover(libfifechan0_1_4) weakremover(libfifechan0_1_5) weakremover(libfifechan_allegro0_1_4) weakremover(libfifechan_irrlicht0_1_4) weakremover(libfifechan_opengl0_1_4) weakremover(libfifechan_opengl0_1_5) weakremover(libfifechan_sdl0_1_4) weakremover(libfifechan_sdl0_1_5) weakremover(libfile1_0) weakremover(libfilezilla-devel) weakremover(libfilezilla0) weakremover(libfilezilla10) weakremover(libfilezilla11) weakremover(libfilezilla12) weakremover(libfilezilla13) weakremover(libfilezilla14) weakremover(libfilezilla16) weakremover(libfilezilla2) weakremover(libfilezilla22) weakremover(libfilezilla23) weakremover(libfilezilla25) weakremover(libfilezilla29) weakremover(libfilezilla3) weakremover(libfilezilla31) weakremover(libfilezilla32) weakremover(libfilezilla35) weakremover(libfilezilla4) weakremover(libfilezilla7) weakremover(libfilezilla8) weakremover(libfilezilla9) weakremover(libfilteraudio0) weakremover(libfinal-devel) weakremover(libfinal-examples) weakremover(libfinal0) weakremover(libfind3_0) weakremover(libfind4_0) weakremover(libfipscheck1) weakremover(libfishsound-devel) weakremover(libfishsound1) weakremover(libfityk4) weakremover(libfixbuf-devel) weakremover(libfixbuf-tools) weakremover(libfixbuf9) weakremover(libfko-devel) weakremover(libfko3) weakremover(libfl-devel) weakremover(libfl2) weakremover(libflann1_9) weakremover(libflashrom1) weakremover(libflatbuffers1) weakremover(libflatbuffers2) weakremover(libflatbuffers23_3_3) weakremover(libflatpak0) weakremover(libflatzinc9) weakremover(libfli-devel) weakremover(libfli1) weakremover(libflickcurl-devel) weakremover(libflickcurl0) weakremover(libflint0) weakremover(libflint14) weakremover(libflint15) weakremover(libflint16) weakremover(libflint17) weakremover(libflom0) weakremover(libflorence-1_0-1) weakremover(libfltk1) weakremover(libfltk1_3) weakremover(libfluidsynth1) weakremover(libfluidsynth2) weakremover(libfluidsynth3) weakremover(libflux-devel) weakremover(libflux0_161_0) weakremover(libflux0_171_0) weakremover(libflux0_193_0) weakremover(libflxmlrpc1) weakremover(libfm) weakremover(libfm-devel) weakremover(libfm-doc) weakremover(libfm-extra-devel) weakremover(libfm-extra4) weakremover(libfm-gtk-devel) weakremover(libfm-gtk4) weakremover(libfm-qt-devel) weakremover(libfm-qt10) weakremover(libfm-qt11) weakremover(libfm-qt12) weakremover(libfm-qt13) weakremover(libfm-qt3) weakremover(libfm-qt5) weakremover(libfm-qt6) weakremover(libfm-qt7) weakremover(libfm-qt8) weakremover(libfm-qt9) weakremover(libfm4) weakremover(libfmapi-devel) weakremover(libfmapi1) weakremover(libfmos-devel) weakremover(libfmos1) weakremover(libfmt5) weakremover(libfmt6) weakremover(libfmt7) weakremover(libfmt8) weakremover(libfmt9) weakremover(libfole-devel) weakremover(libfole1) weakremover(libfolks-data) weakremover(libfolks-eds25) weakremover(libfolks-eds26) weakremover(libfolks-telepathy25) weakremover(libfolks-telepathy26) weakremover(libfolks-tracker25) weakremover(libfolks25) weakremover(libfolks26) weakremover(libfolly-v2022_01_24_00) weakremover(libfolly-v2022_05_23_00) weakremover(libfolly-v2022_08_29_00) weakremover(libfolly-v2023_02_27_00) weakremover(libfolly-v2023_05_01_00) weakremover(libfoma-hfst0) weakremover(libfoma0) weakremover(libfont-specimen0) weakremover(libfontconfig1) weakremover(libfontenc-devel) weakremover(libfontenc1) weakremover(libfparser-4_5_2) weakremover(libfplist-devel) weakremover(libfplist1) weakremover(libfplll-devel) weakremover(libfplll0) weakremover(libfplll4) weakremover(libfplll5) weakremover(libfplll6) weakremover(libfplll7) weakremover(libfplll8) weakremover(libfpm_helper-devel) weakremover(libfpm_helper0) weakremover(libfpm_pb0) weakremover(libfprint-2-2) weakremover(libfprint-2-tod1) weakremover(libfprint-devel) weakremover(libfprint-examples) weakremover(libfprint-tod-devel) weakremover(libfprint0) weakremover(libframe6) weakremover(libframecpp) weakremover(libframecpp12) weakremover(libframecpp3-6) weakremover(libframecpp4-8) weakremover(libframecpp6-8) weakremover(libframecpp7-4) weakremover(libframecpp8-7) weakremover(libframecppc3) weakremover(libframecppcmn11) weakremover(libframel8) weakremover(libfreebl3) weakremover(libfreebl3-hmac) weakremover(libfreecell-solver0) weakremover(libfreefare-devel) weakremover(libfreefare-tools) weakremover(libfreefare0) weakremover(libfreehand-0_1-1) weakremover(libfreehand-devel) weakremover(libfreehand-tools) weakremover(libfreeimage3) weakremover(libfreeimageplus3) weakremover(libfreeipmi17) weakremover(libfreerdp2) weakremover(libfreerdp2-2) weakremover(libfreesrp0) weakremover(libfreetds) weakremover(libfreetype6) weakremover(libfreexl1) weakremover(libfreshclam2) weakremover(libfribidi0) weakremover(libfrr0) weakremover(libfrr_pb0) weakremover(libfrrcares0) weakremover(libfrrfpm_pb0) weakremover(libfrrgrpc_pb0) weakremover(libfrrospfapiclient0) weakremover(libfrrsnmp0) weakremover(libfrrzmq0) weakremover(libfsapfs) weakremover(libfsapfs-devel) weakremover(libfsapfs1) weakremover(libfsclfs-devel) weakremover(libfsclfs-tools) weakremover(libfsclfs1) weakremover(libfsext-devel) weakremover(libfsext-tools) weakremover(libfsext1) weakremover(libfsfat-devel) weakremover(libfsfat-tools) weakremover(libfsfat1) weakremover(libfshfs-devel) weakremover(libfshfs-tools) weakremover(libfshfs1) weakremover(libfsm-0_14_7) weakremover(libfsm0) weakremover(libfsntfs-devel) weakremover(libfsntfs-tools) weakremover(libfsntfs1) weakremover(libfsrefs-devel) weakremover(libfsrefs-tools) weakremover(libfsrefs1) weakremover(libfst-hfst0) weakremover(libfst25) weakremover(libfstrcmp0) weakremover(libfstrm0) weakremover(libfsxfs-devel) weakremover(libfsxfs-tools) weakremover(libfsxfs1) weakremover(libftdi-devel) weakremover(libftdi0-binding-python) weakremover(libftdi0-devel) weakremover(libftdi1) weakremover(libftdi1-2) weakremover(libftdi1-binding-python) weakremover(libftdi1-devel) weakremover(libftgl2) weakremover(libftoa0_3) weakremover(libftxf-devel) weakremover(libftxf1) weakremover(libftxr-devel) weakremover(libftxr1) weakremover(libftxui4_0_0) weakremover(libfunambol-9_0_1) weakremover(libfunambol-devel) weakremover(libfunambol9) weakremover(libfuse2) weakremover(libfuse3-3) weakremover(libfusn-devel) weakremover(libfusn1) weakremover(libfuzzy-devel) weakremover(libfuzzy2) weakremover(libfvalue-devel) weakremover(libfvalue1) weakremover(libfvde-devel) weakremover(libfvde-tools) weakremover(libfvde1) weakremover(libfwevt-devel) weakremover(libfwevt1) weakremover(libfwnt-devel) weakremover(libfwnt1) weakremover(libfwps-devel) weakremover(libfwps1) weakremover(libfwsi-devel) weakremover(libfwsi1) weakremover(libfwup1) weakremover(libfwupd2) weakremover(libfwupdplugin1) weakremover(libfwupdplugin2) weakremover(libfwupdplugin5) weakremover(libgadu-devel) weakremover(libgadu3) weakremover(libgamemode-devel) weakremover(libgamemode0) weakremover(libgamemodeauto0) weakremover(libgames-support-devel) weakremover(libgames-support-lang) weakremover(libgames-support2) weakremover(libgamin-1-0) weakremover(libgaminggear) weakremover(libgaminggear-devel) weakremover(libgaminggear0) weakremover(libgaminggearfx0) weakremover(libgaminggearwidget0) weakremover(libganesha_nfsd-devel) weakremover(libganesha_nfsd2_8) weakremover(libganesha_nfsd3_2) weakremover(libganesha_nfsd3_3) weakremover(libganglia0) weakremover(libgap-4_8_6-4) weakremover(libgap-devel) weakremover(libgarcon-1-0) weakremover(libgarcon-devel) weakremover(libgasnet-1_28_2) weakremover(libgasnet-1_30_0) weakremover(libgasnet-1_32_0) weakremover(libgav1-1) weakremover(libgav1-devel) weakremover(libgav1-tools) weakremover(libgavl-devel) weakremover(libgavl1) weakremover(libgbm-devel) weakremover(libgbm1) weakremover(libgc1) weakremover(libgcab-1_0-0) weakremover(libgcalc-1-0_0_0) weakremover(libgcalc-2-1_0_1) weakremover(libgcc_s1) weakremover(libgcc_s1-gcc10) weakremover(libgcc_s1-gcc11) weakremover(libgcc_s1-gcc12) weakremover(libgcc_s1-gcc48) weakremover(libgcc_s1-gcc5) weakremover(libgcc_s1-gcc6) weakremover(libgcc_s1-gcc7) weakremover(libgcc_s1-gcc8) weakremover(libgcc_s1-gcc9) weakremover(libgccjit-devel) weakremover(libgccjit0) weakremover(libgccjit0-devel) weakremover(libgccjit0-devel-gcc11) weakremover(libgccjit0-devel-gcc12) weakremover(libgccjit0-devel-gcc13) weakremover(libgccjit0-gcc11) weakremover(libgccjit0-gcc12) weakremover(libgci-1-0_0_0) weakremover(libgcin-im-client1) weakremover(libgcj-devel) weakremover(libgcj-devel-gcc6) weakremover(libgcj-gcc6) weakremover(libgcj-jar-gcc6) weakremover(libgcj48) weakremover(libgcj48-devel) weakremover(libgcj48-jar) weakremover(libgcj_bc1) weakremover(libgcj_bc1-gcc48) weakremover(libgcj_bc1-gcc6) weakremover(libgck-1-0) weakremover(libgck-2-0_0_0) weakremover(libgck-2-2) weakremover(libgck-devel) weakremover(libgck-modules-gnome-keyring) weakremover(libgck1-devel) weakremover(libgconfmm-2_6-1) weakremover(libgcr-3-1) weakremover(libgcr-4-0_0_0) weakremover(libgcr-4-4) weakremover(libgcr-devel) weakremover(libgcr3-devel) weakremover(libgcrypt-cavs) weakremover(libgcrypt-devel) weakremover(libgcrypt20) weakremover(libgcrypt20-hmac) weakremover(libgd3) weakremover(libgda-5_0-4) weakremover(libgda-5_0-4-lang) weakremover(libgda-5_0-bdb) weakremover(libgda-5_0-devel) weakremover(libgda-5_0-doc) weakremover(libgda-5_0-firebird) weakremover(libgda-5_0-jdbc) weakremover(libgda-5_0-ldap) weakremover(libgda-5_0-mdb) weakremover(libgda-5_0-mysql) weakremover(libgda-5_0-postgres) weakremover(libgda-5_0-sqlcipher) weakremover(libgda-5_0-sqlite) weakremover(libgda-5_0-tools) weakremover(libgda-5_0-web) weakremover(libgda-6_0-6_0_0) weakremover(libgda-6_0-devel) weakremover(libgda-6_0-doc) weakremover(libgda-6_0-ldap) weakremover(libgda-6_0-mysql) weakremover(libgda-6_0-postgres) weakremover(libgda-6_0-sqlcipher) weakremover(libgda-6_0-sqlite) weakremover(libgda-6_0-tools) weakremover(libgda-report) weakremover(libgda-report-5_0-4) weakremover(libgda-report-6_0-6_0_0) weakremover(libgda-tools) weakremover(libgda-ui-5_0-4) weakremover(libgda-ui-5_0-plugins) weakremover(libgda-ui-5_0-tools) weakremover(libgda-ui-6_0-6_0_0) weakremover(libgda-ui-6_0-plugins) weakremover(libgda-ui-6_0-tools) weakremover(libgda-xslt-5_0-4) weakremover(libgda-xslt-6_0-6_0_0) weakremover(libgdal20) weakremover(libgdal26) weakremover(libgdal27) weakremover(libgdal28) weakremover(libgdal29) weakremover(libgdal30) weakremover(libgdal32) weakremover(libgdamm-5_0-13) weakremover(libgdamm-devel) weakremover(libgdata-devel) weakremover(libgdata22) weakremover(libgdbm4) weakremover(libgdbm5) weakremover(libgdbm6) weakremover(libgdbm_compat4) weakremover(libgdcm3_0) weakremover(libgdict-1_0-10) weakremover(libgdict-1_0-9) weakremover(libgdict-data) weakremover(libgdict-devel) weakremover(libgdiplus-devel) weakremover(libgdiplus0) weakremover(libgdk_pixbuf-2_0-0) weakremover(libgdk_pixbuf_xlib-2_0-0) weakremover(libgdl-3-5) weakremover(libgdlmm-3_0-2) weakremover(libgdm1) weakremover(libgdruntime1) weakremover(libgdruntime2) weakremover(libgdruntime3) weakremover(libgdruntime4) weakremover(libgdruntime76) weakremover(libgdruntime76-gcc9) weakremover(libgeany0) weakremover(libgecode51) weakremover(libgeda-data) weakremover(libgeda-devel) weakremover(libgeda42) weakremover(libgeda42-data) weakremover(libgeda45) weakremover(libgeda46) weakremover(libgedacairo-devel) weakremover(libgedacairo1) weakremover(libgee-0_8-2) weakremover(libgee-devel) weakremover(libgee06-devel) weakremover(libgee2) weakremover(libgegl-0_2-0) weakremover(libgegl-0_3-0) weakremover(libgegl-0_4-0) weakremover(libgeis1) weakremover(libgenders0) weakremover(libgendersplusplus2) weakremover(libgeners0) weakremover(libgensio0) weakremover(libgensio4) weakremover(libgensio_python_swig0) weakremover(libgensiocpp1) weakremover(libgensiocpp2) weakremover(libgensiocpp4) weakremover(libgensiomdns0) weakremover(libgensioosh0) weakremover(libgeoclue-devel) weakremover(libgeoclue0) weakremover(libgeocode-glib-2-0) weakremover(libgeocode-glib0) weakremover(libgeos-3_6_2) weakremover(libgeos-3_7_1) weakremover(libgeos-3_7_2) weakremover(libgeos-3_8_0) weakremover(libgeos-3_8_1) weakremover(libgeos-3_9_0) weakremover(libgeos-3_9_1) weakremover(libgeos3_10_1) weakremover(libgeos3_10_2) weakremover(libgeos3_10_3) weakremover(libgeos3_11_0) weakremover(libgeos3_11_1) weakremover(libgeos3_11_2) weakremover(libgeos_c1) weakremover(libgeotiff-devel) weakremover(libgeotiff2) weakremover(libgeotiff5) weakremover(libgepub-0_6-0) weakremover(libgepub-0_7-0) weakremover(libgepub-devel) weakremover(libgepub0) weakremover(libgerbv1) weakremover(libges-1_0-0) weakremover(libgetdata++3) weakremover(libgetdata++7) weakremover(libgetdata5) weakremover(libgetdata8) weakremover(libgexiv2-2) weakremover(libgexiv2-devel) weakremover(libgf2x-1_2) weakremover(libgf2x1) weakremover(libgf2x3) weakremover(libgfan-0_5) weakremover(libgfan-devel) weakremover(libgfapi0) weakremover(libgfbgraph-0_2-0) weakremover(libgfchangelog0) weakremover(libgfdb0) weakremover(libgflags2) weakremover(libgflags2_2) weakremover(libgfortran3) weakremover(libgfortran3-gcc48) weakremover(libgfortran3-gcc5) weakremover(libgfortran3-gcc6) weakremover(libgfortran4) weakremover(libgfortran5) weakremover(libgfortran5-gcc10) weakremover(libgfortran5-gcc11) weakremover(libgfortran5-gcc12) weakremover(libgfortran5-gcc8) weakremover(libgfortran5-gcc9) weakremover(libgfrpc0) weakremover(libgfxdr0) weakremover(libggz2) weakremover(libggz2-devel) weakremover(libgiac0) weakremover(libgiblib1) weakremover(libgif6) weakremover(libgif7) weakremover(libgig-devel) weakremover(libgig-tools) weakremover(libgig10) weakremover(libgimp-2_0-0) weakremover(libgimpui-2_0-0) weakremover(libginac-devel) weakremover(libginac11) weakremover(libginac5) weakremover(libginac6) weakremover(libgio-2_0-0) weakremover(libgio-fam) weakremover(libgio-qt0) weakremover(libgiomm-2_4-1) weakremover(libgiomm-2_58-1) weakremover(libgiomm-2_60-1) weakremover(libgiomm-2_62-1) weakremover(libgiomm-2_66-1) weakremover(libgiomm-2_68-1) weakremover(libgirara-gtk3-2) weakremover(libgirara-gtk3-3) weakremover(libgirepository-1_0-1) weakremover(libgit2) weakremover(libgit2-1_0) weakremover(libgit2-1_1) weakremover(libgit2-1_3) weakremover(libgit2-1_4) weakremover(libgit2-1_5) weakremover(libgit2-1_6) weakremover(libgit2-23) weakremover(libgit2-24) weakremover(libgit2-26) weakremover(libgit2-27) weakremover(libgit2-28) weakremover(libgit2-devel) weakremover(libgit2-glib-1_0-0) weakremover(libgit2-glib-devel) weakremover(libgit2-tools) weakremover(libgitg-1_0-0) weakremover(libgitg-devel) weakremover(libgitg-ext-1_0-0) weakremover(libgivaro0) weakremover(libgivaro9) weakremover(libgjs-devel) weakremover(libgjs0) weakremover(libgl2ps1) weakremover(libglade-2_0-0) weakremover(libglade2-devel) weakremover(libglademm) weakremover(libglademm-2_4-1) weakremover(libglademm-devel) weakremover(libgladeui-1-11) weakremover(libgladeui-1-devel) weakremover(libgladeui-2-12) weakremover(libgladeui-2-13) weakremover(libgladeui-2-6) weakremover(libgladeui-2-devel) weakremover(libgle-devel) weakremover(libgle3) weakremover(libglfw-devel) weakremover(libglfw2) weakremover(libglfw3) weakremover(libglfw3-wayland) weakremover(libglib-2_0-0) weakremover(libglib-testing-0-0) weakremover(libglib-testing-devel) weakremover(libglibmm-2_4-1) weakremover(libglibmm-2_58-1) weakremover(libglibmm-2_60-1) weakremover(libglibmm-2_62-1) weakremover(libglibmm-2_66-1) weakremover(libglibmm-2_68-1) weakremover(libglog0) weakremover(libglom-1_32-0) weakremover(libglom-devel) weakremover(libgloox15) weakremover(libgloox17) weakremover(libgloox18) weakremover(libglpk36) weakremover(libglpk40) weakremover(libglslang-suse10) weakremover(libglslang-suse2) weakremover(libglslang-suse3) weakremover(libglslang-suse4) weakremover(libglslang-suse6) weakremover(libglslang-suse7) weakremover(libglslang-suse8) weakremover(libglslang-suse9) weakremover(libglslang10) weakremover(libglslang11) weakremover(libglslang11_12) weakremover(libglslang12) weakremover(libgltf-0_0-0) weakremover(libgltf-0_1-1) weakremover(libgltf-devel) weakremover(libglue-devel) weakremover(libglue2) weakremover(libglusterd0) weakremover(libglusterfs0) weakremover(libglut3) weakremover(libglvnd) weakremover(libglvnd-devel) weakremover(libglyr1) weakremover(libgme-devel) weakremover(libgme0) weakremover(libgmic-devel) weakremover(libgmic1) weakremover(libgmic3) weakremover(libgmime-2_6-0) weakremover(libgmime-3_0-0) weakremover(libgmm++-devel) weakremover(libgmodule-2_0-0) weakremover(libgmp10) weakremover(libgmpxx4) weakremover(libgmsh4_10) weakremover(libgmsh4_11) weakremover(libgmsh4_4) weakremover(libgmsh4_5) weakremover(libgmsh4_7) weakremover(libgmsh4_8) weakremover(libgmsh4_9) weakremover(libgmxapi0) weakremover(libgmxapi_mpi0) weakremover(libgnome) weakremover(libgnome-autoar-0-0) weakremover(libgnome-autoar-gtk-0-0) weakremover(libgnome-bluetooth-3_0-13) weakremover(libgnome-bluetooth-ui-3_0-13) weakremover(libgnome-bluetooth13) weakremover(libgnome-desktop-2-17) weakremover(libgnome-desktop-2-devel) weakremover(libgnome-desktop-3-12) weakremover(libgnome-desktop-3-17) weakremover(libgnome-desktop-3-18) weakremover(libgnome-desktop-3-19) weakremover(libgnome-desktop-3-20) weakremover(libgnome-desktop-3-devel) weakremover(libgnome-desktop-3_0-common) weakremover(libgnome-desktop-4-1) weakremover(libgnome-desktop-4-2) weakremover(libgnome-desktop-4-devel) weakremover(libgnome-devel) weakremover(libgnome-games-support-1-2) weakremover(libgnome-games-support-1-3) weakremover(libgnome-games-support-2-4) weakremover(libgnome-games-support-devel) weakremover(libgnome-games-support1_3-devel) weakremover(libgnome-keyring-devel) weakremover(libgnome-keyring0) weakremover(libgnome-lang) weakremover(libgnome-menu-3-0) weakremover(libgnomecanvas-2-0) weakremover(libgnomecanvas-devel) weakremover(libgnomecanvas-lang) weakremover(libgnomecups) weakremover(libgnomecups-1_0-1) weakremover(libgnomecups-devel) weakremover(libgnomecups-lang) weakremover(libgnomekbd) weakremover(libgnomekbd-devel) weakremover(libgnomekbd8) weakremover(libgnomeprint) weakremover(libgnomeprint-devel) weakremover(libgnomeprint-doc) weakremover(libgnomeprint-lang) weakremover(libgnomeprintui) weakremover(libgnomeprintui-devel) weakremover(libgnomeprintui-doc) weakremover(libgnomeprintui-lang) weakremover(libgnomesoftware-3_38_0) weakremover(libgnomesoftware-3_38_1) weakremover(libgnomesoftware-40_0) weakremover(libgnomesu) weakremover(libgnomesu-devel) weakremover(libgnomesu0) weakremover(libgnomeui) weakremover(libgnomeui-devel) weakremover(libgnomeui-doc) weakremover(libgnomeui-lang) weakremover(libgnt-devel) weakremover(libgnt0) weakremover(libgnuastro11) weakremover(libgnuastro12) weakremover(libgnuastro13) weakremover(libgnuastro14) weakremover(libgnuastro15) weakremover(libgnuastro16) weakremover(libgnuastro17) weakremover(libgnuastro6) weakremover(libgnuastro9) weakremover(libgnuradio-3_10_1) weakremover(libgnuradio-3_10_2) weakremover(libgnuradio-3_10_3) weakremover(libgnuradio-3_10_4) weakremover(libgnuradio-3_10_5) weakremover(libgnuradio-3_10_6) weakremover(libgnuradio-3_7_10-0_0_0) weakremover(libgnuradio-3_7_12-0_0_0) weakremover(libgnuradio-3_8_0) weakremover(libgnuradio-3_8_1) weakremover(libgnuradio-3_8_2) weakremover(libgnuradio-3_8_3) weakremover(libgnuradio-3_8_4) weakremover(libgnuradio-3_8_5) weakremover(libgnuradio-3_9_5) weakremover(libgnuradio-fcdproplus-3_7_2_0-0_0_0) weakremover(libgnuradio-fcdproplus-devel) weakremover(libgnuradio-fcdproplus3_8_0) weakremover(libgnuradio-funcube-devel) weakremover(libgnuradio-funcube3_10_0) weakremover(libgnuradio-iqbalance) weakremover(libgnuradio-iqbalance-devel) weakremover(libgnuradio-iqbalance0_37_2git) weakremover(libgnuradio-iqbalance3_8_0) weakremover(libgnuradio-iqbalance3_9_0) weakremover(libgnuradio-osmosdr-0_1_5git0_0_0) weakremover(libgnuradio-osmosdr0_2_0) weakremover(libgnustep-base1_25) weakremover(libgnustep-base1_26) weakremover(libgnustep-base1_27) weakremover(libgnustep-base1_28) weakremover(libgnustep-base1_29) weakremover(libgnutls-dane-devel) weakremover(libgnutls-dane0) weakremover(libgnutls-devel) weakremover(libgnutls-openssl-devel) weakremover(libgnutls-openssl27) weakremover(libgnutls28) weakremover(libgnutls30) weakremover(libgnutls30-hmac) weakremover(libgnutlsxx-devel) weakremover(libgnutlsxx28) weakremover(libgnutlsxx30) weakremover(libgo11) weakremover(libgo13) weakremover(libgo14) weakremover(libgo16) weakremover(libgo19) weakremover(libgo21) weakremover(libgo22) weakremover(libgo7) weakremover(libgo9) weakremover(libgo9-gcc6) weakremover(libgoa-1_0-0) weakremover(libgoa-backend-1_0-1) weakremover(libgobject-2_0-0) weakremover(libgoffice-0_10-10) weakremover(libgoffice-0_8-8) weakremover(libgom-1_0-0) weakremover(libgomp1) weakremover(libgomp1-gcc10) weakremover(libgomp1-gcc11) weakremover(libgomp1-gcc12) weakremover(libgomp1-gcc48) weakremover(libgomp1-gcc5) weakremover(libgomp1-gcc6) weakremover(libgomp1-gcc7) weakremover(libgomp1-gcc8) weakremover(libgomp1-gcc9) weakremover(libgoocanvas-2_0-9) weakremover(libgoocanvas-3_0-9) weakremover(libgoocanvas3) weakremover(libgoocanvas3-devel) weakremover(libgoocanvas3-lang) weakremover(libgoocanvasmm-2_0-6) weakremover(libgoocanvasmm-devel) weakremover(libgooglepinyin-devel) weakremover(libgooglepinyin0) weakremover(libgovf-0_1) weakremover(libgovirt-devel) weakremover(libgovirt2) weakremover(libgpaste-gtk-3-0) weakremover(libgpaste-gtk4-0) weakremover(libgpaste11) weakremover(libgpaste13) weakremover(libgpaste2) weakremover(libgpaste2-0) weakremover(libgpaste4) weakremover(libgpaste6) weakremover(libgpaste9) weakremover(libgpg-error-devel) weakremover(libgpg-error0) weakremover(libgpgme-devel) weakremover(libgpgme11) weakremover(libgpgmepp-devel) weakremover(libgpgmepp6) weakremover(libgphobos1) weakremover(libgphobos2) weakremover(libgphobos3) weakremover(libgphobos4) weakremover(libgphobos76) weakremover(libgphobos76-gcc9) weakremover(libgphoto2-6) weakremover(libgphoto2-devel) weakremover(libgphoto2_port12) weakremover(libgpiod) weakremover(libgpiod-devel) weakremover(libgpiod-utils) weakremover(libgpiod1) weakremover(libgpiod2) weakremover(libgpiodcxx1) weakremover(libgpiomockup0) weakremover(libgpm2) weakremover(libgpod-devel) weakremover(libgpod-sharp) weakremover(libgpod-tools) weakremover(libgpod4) weakremover(libgps22) weakremover(libgps23) weakremover(libgps24) weakremover(libgps25) weakremover(libgps27) weakremover(libgps28) weakremover(libgps29) weakremover(libgps30) weakremover(libgrail6) weakremover(libgranite3) weakremover(libgranite4) weakremover(libgranite5) weakremover(libgranite6) weakremover(libgrantlee_core0) weakremover(libgrantlee_gui0) weakremover(libgraphblas2) weakremover(libgraphblas3) weakremover(libgraphblas4) weakremover(libgraphblas5) weakremover(libgraphblas6) weakremover(libgraphblas7) weakremover(libgraphene-1_0-0) weakremover(libgraphene-devel) weakremover(libgraphite2-3) weakremover(libgraphviz6) weakremover(libgravatar) weakremover(libgravatar-devel) weakremover(libgravatar-lang) weakremover(libgrilo-0_3-0) weakremover(libgrlnet-0_3-0) weakremover(libgrlpls-0_3-0) weakremover(libgromacs2) weakremover(libgromacs3) weakremover(libgromacs4) weakremover(libgromacs6) weakremover(libgromacs7) weakremover(libgromacs8) weakremover(libgromacs_mpi7) weakremover(libgromacs_mpi8) weakremover(libgroove-devel) weakremover(libgroove4) weakremover(libgroovefingerprinter-devel) weakremover(libgroovefingerprinter4) weakremover(libgrooveloudness-devel) weakremover(libgrooveloudness4) weakremover(libgrooveplayer-devel) weakremover(libgrooveplayer4) weakremover(libgroupsock30) weakremover(libgroupsock8) weakremover(libgrpc++1) weakremover(libgrpc++1_44) weakremover(libgrpc++1_45) weakremover(libgrpc++1_46) weakremover(libgrpc++1_48) weakremover(libgrpc++1_49) weakremover(libgrpc++1_50) weakremover(libgrpc++1_51) weakremover(libgrpc-httpjson-transcoding0) weakremover(libgrpc12) weakremover(libgrpc13) weakremover(libgrpc14) weakremover(libgrpc15) weakremover(libgrpc16) weakremover(libgrpc18) weakremover(libgrpc19) weakremover(libgrpc22) weakremover(libgrpc23) weakremover(libgrpc24) weakremover(libgrpc26) weakremover(libgrpc27) weakremover(libgrpc28) weakremover(libgrpc29) weakremover(libgrpc6) weakremover(libgrpc7) weakremover(libgrpc8) weakremover(libgrpc_plugin_support1) weakremover(libgrpc_plugin_support1_37) weakremover(libgrpc_plugin_support1_38) weakremover(libgrpc_plugin_support1_39) weakremover(libgrpc_plugin_support1_41) weakremover(libgrpc_plugin_support1_44) weakremover(libgrpc_plugin_support1_45) weakremover(libgrpc_plugin_support1_46) weakremover(libgrpc_plugin_support1_48) weakremover(libgrpc_plugin_support1_49) weakremover(libgrpc_plugin_support1_50) weakremover(libgrpc_plugin_support1_51) weakremover(libgrss-devel) weakremover(libgrss0) weakremover(libgsasl-devel) weakremover(libgsasl7) weakremover(libgsequencer0) weakremover(libgsettings-qt1) weakremover(libgsf-1-114) weakremover(libgsf-devel) weakremover(libgsf-tools) weakremover(libgsignon-glib-devel) weakremover(libgsignon-glib-doc) weakremover(libgsignon-glib1) weakremover(libgsignond-common0) weakremover(libgsignond-common1) weakremover(libgsl-gnu-hpc) weakremover(libgsl23) weakremover(libgsl25) weakremover(libgsl27) weakremover(libgsl_2_4-gnu-hpc) weakremover(libgsl_2_5-gnu-hpc) weakremover(libgsl_2_6-gnu-hpc) weakremover(libgsl_2_7_1-gnu-hpc) weakremover(libgslcblas-gnu-hpc) weakremover(libgslcblas0) weakremover(libgslcblas_2_4-gnu-hpc) weakremover(libgslcblas_2_5-gnu-hpc) weakremover(libgslcblas_2_6-gnu-hpc) weakremover(libgslcblas_2_7_1-gnu-hpc) weakremover(libgsm-devel) weakremover(libgsm-utils) weakremover(libgsm1) weakremover(libgsmsd7) weakremover(libgsmsd8) weakremover(libgsoap-2_8_101) weakremover(libgsoap-2_8_102) weakremover(libgsoap-2_8_106) weakremover(libgsoap-2_8_109) weakremover(libgsoap-2_8_110) weakremover(libgsoap-2_8_111) weakremover(libgsoap-2_8_114) weakremover(libgsoap-2_8_115) weakremover(libgsoap-2_8_117) weakremover(libgsoap-2_8_121) weakremover(libgsoap-2_8_122) weakremover(libgsoap-2_8_123) weakremover(libgsoap-2_8_124) weakremover(libgsoap-2_8_127) weakremover(libgsoap-2_8_33) weakremover(libgsoap-2_8_46) weakremover(libgsoap-2_8_66) weakremover(libgsoap-2_8_70) weakremover(libgsoap-2_8_75) weakremover(libgsoap-2_8_80) weakremover(libgsoap-2_8_82) weakremover(libgsoap-2_8_84) weakremover(libgsoap-2_8_87) weakremover(libgsoap-2_8_89) weakremover(libgsoap-2_8_91) weakremover(libgsoap-2_8_92) weakremover(libgsoap-2_8_93) weakremover(libgsoap-2_8_94) weakremover(libgsoap-2_8_95) weakremover(libgsoap-2_8_96) weakremover(libgsoap-2_8_97) weakremover(libgsoap-2_8_98) weakremover(libgsoap-2_8_99) weakremover(libgsound0) weakremover(libgspell-1-1) weakremover(libgspell-1-2) weakremover(libgssapi3) weakremover(libgssdp-1_0-3) weakremover(libgssdp-1_2-0) weakremover(libgssdp-1_6-0) weakremover(libgssdp-devel) weakremover(libgssglue-devel) weakremover(libgssglue1) weakremover(libgstadaptivedemux-1_0-0) weakremover(libgstallocators-1_0-0) weakremover(libgstapp-0_10-0) weakremover(libgstapp-1_0-0) weakremover(libgstaudio-1_0-0) weakremover(libgstbadallocators-1_0-0) weakremover(libgstbadaudio-1_0-0) weakremover(libgstbadbase-1_0-0) weakremover(libgstbadvideo-1_0-0) weakremover(libgstbasecamerabinsrc-0_10-23) weakremover(libgstbasecamerabinsrc-1_0-0) weakremover(libgstbasevideo-0_10-23) weakremover(libgstclapper-1) weakremover(libgstclapper-1_0-0) weakremover(libgstclapperglbaseimporter0) weakremover(libgstcodecparsers-0_10-23) weakremover(libgstcodecparsers-1_0-0) weakremover(libgstcodecs-1_0-0) weakremover(libgstcuda-1_0-0) weakremover(libgstfft-1_0-0) weakremover(libgstgl-1_0-0) weakremover(libgstinsertbin-1_0-0) weakremover(libgstinterfaces-0_10-0) weakremover(libgstisoff-1_0-0) weakremover(libgstmpegts-1_0-0) weakremover(libgstpbutils-1_0-0) weakremover(libgstphotography-0_10-23) weakremover(libgstphotography-1_0-0) weakremover(libgstplay-1_0-0) weakremover(libgstplayer-1_0-0) weakremover(libgstreamer-0_10-0) weakremover(libgstreamer-1_0-0) weakremover(libgstreamerd-3-0) weakremover(libgstreamermm-1_0-1) weakremover(libgstriff-1_0-0) weakremover(libgstrtp-1_0-0) weakremover(libgstrtsp-1_0-0) weakremover(libgstrtspserver-1_0-0) weakremover(libgstsctp-1_0-0) weakremover(libgstsdp-1_0-0) weakremover(libgstsignalprocessor-0_10-23) weakremover(libgsttag-1_0-0) weakremover(libgsttranscoder-1_0-0) weakremover(libgsturidownloader-1_0-0) weakremover(libgstva-1_0-0) weakremover(libgstvalidate-1_0-0) weakremover(libgstvdp-0_10-23) weakremover(libgstvdpau) weakremover(libgstvideo-1_0-0) weakremover(libgstvulkan-1_0-0) weakremover(libgstwayland-1_0-0) weakremover(libgstwebrtc-1_0-0) weakremover(libgstwebrtcnice-1_0-0) weakremover(libgsystem-devel) weakremover(libgsystem0) weakremover(libgt-devel) weakremover(libgtbase0) weakremover(libgtef-2-0) weakremover(libgtest0) weakremover(libgthread-2_0-0) weakremover(libgthttp0) weakremover(libgtk-2_0-0) weakremover(libgtk-3-0) weakremover(libgtk-4-0) weakremover(libgtk-4-1) weakremover(libgtk-frdp-0_1) weakremover(libgtk-layer-shell0) weakremover(libgtk-vnc-1_0-0) weakremover(libgtk-vnc-2_0-0) weakremover(libgtkd-3-0) weakremover(libgtkdatabox-0_9_1-3) weakremover(libgtkdatabox-0_9_3-0) weakremover(libgtkdatabox-0_9_3-1) weakremover(libgtkdatabox-devel) weakremover(libgtkdatabox1) weakremover(libgtkdgl-3-0) weakremover(libgtkdsv-3-0) weakremover(libgtkglext-x11-1_0-0) weakremover(libgtkhex-3-0) weakremover(libgtkhex-4-0) weakremover(libgtkhex-4-1) weakremover(libgtkhotkey-devel) weakremover(libgtkhotkey1) weakremover(libgtkhtml-4_0-0) weakremover(libgtkhtml-editor-4_0-0) weakremover(libgtkimageview0) weakremover(libgtkmm-2_4-1) weakremover(libgtkmm-3_0-1) weakremover(libgtkmm-4_0-0) weakremover(libgtkpod1) weakremover(libgtksourceview-2_0-0) weakremover(libgtksourceview-3_0-1) weakremover(libgtksourceview-4-0) weakremover(libgtksourceview-5-0) weakremover(libgtksourceviewmm-3_0-0) weakremover(libgtksourceviewmm-4_0-0) weakremover(libgtkspell0) weakremover(libgtkspell3-3-0) weakremover(libgtop) weakremover(libgtop-2_0-10) weakremover(libgtop-2_0-11) weakremover(libgtop-devel) weakremover(libgtop-doc) weakremover(libgtp-devel) weakremover(libgtp2) weakremover(libgtp3) weakremover(libgtp4) weakremover(libgtp5) weakremover(libgtp6) weakremover(libgtpng0) weakremover(libgtpnl-devel) weakremover(libgtpnl-tools) weakremover(libgtpnl0) weakremover(libgts-0_7-5) weakremover(libgucharmap_2_90-7) weakremover(libgudev-1_0-0) weakremover(libgudev-1_0-devel) weakremover(libguess-devel) weakremover(libguess1) weakremover(libguestfs) weakremover(libguestfs-appliance) weakremover(libguestfs-devel) weakremover(libguestfs-gobject-1_0) weakremover(libguestfs-gobject-devel) weakremover(libguestfs-rescue) weakremover(libguestfs-rsync) weakremover(libguestfs-test) weakremover(libguestfs-typelib-Guestfs-1_0) weakremover(libguestfs-winsupport) weakremover(libguestfs-xfs) weakremover(libguestfs0) weakremover(libguestfsd) weakremover(libguile-2_0-22) weakremover(libguile-2_2-1) weakremover(libguile-3_0-1) weakremover(libguile-cairo0) weakremover(libguile-srfi-srfi-1-v-3-3) weakremover(libguile-srfi-srfi-13-14-v-3-3) weakremover(libguile-srfi-srfi-4-v-3-3) weakremover(libguile-srfi-srfi-60-v-2-2) weakremover(libguile-ssh11) weakremover(libguile-ssh12) weakremover(libguile-ssh13) weakremover(libguile-ssh14) weakremover(libguile1-devel) weakremover(libguile17) weakremover(libguilereadline-v-17-17) weakremover(libguilereadline-v-18-18) weakremover(libgumbo-devel) weakremover(libgumbo1) weakremover(libgupnp-1_0-4) weakremover(libgupnp-1_2-0) weakremover(libgupnp-1_2-1) weakremover(libgupnp-1_6-0) weakremover(libgupnp-av-1_0-2) weakremover(libgupnp-av-1_0-3) weakremover(libgupnp-av-devel) weakremover(libgupnp-devel) weakremover(libgupnp-dlna-2_0-3) weakremover(libgupnp-dlna-2_0-4) weakremover(libgupnp-dlna-backend-gstreamer) weakremover(libgupnp-dlna-devel) weakremover(libgupnp-igd-1_0-4) weakremover(libgupnp-igd-1_6-0) weakremover(libgupnp-igd-devel) weakremover(libgupnp-ui-1_0-0) weakremover(libgupnp-ui-devel) weakremover(libgusb-devel) weakremover(libgusb2) weakremover(libgvc6) weakremover(libgviewaudio-2_0-2) weakremover(libgviewencoder-2_0-2) weakremover(libgviewencoder-2_1-2) weakremover(libgviewrender-2_0-2) weakremover(libgviewrender-2_1-2) weakremover(libgviewv4l2core-2_0-2) weakremover(libgviewv4l2core-2_1-2) weakremover(libgvnc-1_0-0) weakremover(libgvncpulse-1_0-0) weakremover(libgvpr2) weakremover(libgweather-3-15) weakremover(libgweather-3-16) weakremover(libgweather-3-6) weakremover(libgweather-4-0) weakremover(libgweather-data) weakremover(libgweather-devel) weakremover(libgweather-lang) weakremover(libgweather4-devel) weakremover(libgwengui-cpp0) weakremover(libgwengui-cpp79) weakremover(libgwengui-fox16-0) weakremover(libgwengui-fox16-79) weakremover(libgwengui-gtk2-0) weakremover(libgwengui-gtk2-79) weakremover(libgwengui-gtk3-0) weakremover(libgwengui-gtk3-79) weakremover(libgwengui-qt4-0) weakremover(libgwengui-qt5-0) weakremover(libgwengui-qt5-79) weakremover(libgwenhywfar60) weakremover(libgwenhywfar60-plugins) weakremover(libgwenhywfar78) weakremover(libgwenhywfar78-plugins) weakremover(libgwenhywfar79) weakremover(libgwenhywfar79-plugins) weakremover(libgxps-devel) weakremover(libgxps-tools) weakremover(libgxps2) weakremover(libgxw0) weakremover(libgxwmm0) weakremover(libgypsy-devel) weakremover(libgypsy0) weakremover(libh323-1_26_5) weakremover(libhackrf0) weakremover(libhal1) weakremover(libhamlib++2) weakremover(libhamlib++4) weakremover(libhamlib2) weakremover(libhamlib4) weakremover(libhandle1) weakremover(libhandy-0_0-0) weakremover(libhandy-1-0) weakremover(libhandy-devel) weakremover(libhandy0-devel) weakremover(libhangul-devel) weakremover(libhangul1) weakremover(libharfbuzz-cairo0) weakremover(libharfbuzz-gobject0) weakremover(libharfbuzz-icu0) weakremover(libharfbuzz-subset0) weakremover(libharfbuzz0) weakremover(libharminv2) weakremover(libharminv3) weakremover(libharu-2_2_1) weakremover(libharu-devel) weakremover(libhavege1) weakremover(libhavege2) weakremover(libhbalinux2) weakremover(libhbalinux2-devel) weakremover(libhcrypto4) weakremover(libhd22) weakremover(libhdb9) weakremover(libhdf4) weakremover(libhdf4-openmpi) weakremover(libhdf5-10) weakremover(libhdf5-10-openmpi) weakremover(libhdf5-101) weakremover(libhdf5-101-mvapich2) weakremover(libhdf5-101-openmpi) weakremover(libhdf5-103) weakremover(libhdf5-103-mvapich2) weakremover(libhdf5-103-openmpi) weakremover(libhdf5-103-openmpi1) weakremover(libhdf5-103-openmpi2) weakremover(libhdf5-103-openmpi3) weakremover(libhdf5-103-openmpi4) weakremover(libhdf5-11) weakremover(libhdf5-200) weakremover(libhdf5-200-mvapich2) weakremover(libhdf5-200-openmpi1) weakremover(libhdf5-200-openmpi2) weakremover(libhdf5-200-openmpi3) weakremover(libhdf5-200-openmpi4) weakremover(libhdf5-gnu-hpc) weakremover(libhdf5-gnu-mpich-hpc) weakremover(libhdf5-gnu-mvapich2-hpc) weakremover(libhdf5-gnu-openmpi1-hpc) weakremover(libhdf5-gnu-openmpi2-hpc) weakremover(libhdf5-gnu-openmpi3-hpc) weakremover(libhdf5-gnu-openmpi4-hpc) weakremover(libhdf5_1_10_1-gnu-hpc) weakremover(libhdf5_1_10_1-gnu-mpich-hpc) weakremover(libhdf5_1_10_1-gnu-mvapich2-hpc) weakremover(libhdf5_1_10_1-gnu-openmpi1-hpc) weakremover(libhdf5_1_10_1-gnu-openmpi2-hpc) weakremover(libhdf5_1_10_1-gnu-openmpi3-hpc) weakremover(libhdf5_1_10_4-gnu-hpc) weakremover(libhdf5_1_10_4-gnu-mpich-hpc) weakremover(libhdf5_1_10_4-gnu-mvapich2-hpc) weakremover(libhdf5_1_10_4-gnu-openmpi1-hpc) weakremover(libhdf5_1_10_4-gnu-openmpi2-hpc) weakremover(libhdf5_1_10_4-gnu-openmpi3-hpc) weakremover(libhdf5_1_10_5-gnu-hpc) weakremover(libhdf5_1_10_5-gnu-mpich-hpc) weakremover(libhdf5_1_10_5-gnu-mvapich2-hpc) weakremover(libhdf5_1_10_5-gnu-openmpi1-hpc) weakremover(libhdf5_1_10_5-gnu-openmpi2-hpc) weakremover(libhdf5_1_10_5-gnu-openmpi3-hpc) weakremover(libhdf5_1_10_5-gnu-openmpi4-hpc) weakremover(libhdf5_1_10_7-gnu-hpc) weakremover(libhdf5_1_10_7-gnu-mpich-hpc) weakremover(libhdf5_1_10_7-gnu-mvapich2-hpc) weakremover(libhdf5_1_10_7-gnu-openmpi1-hpc) weakremover(libhdf5_1_10_7-gnu-openmpi2-hpc) weakremover(libhdf5_1_10_7-gnu-openmpi3-hpc) weakremover(libhdf5_1_10_7-gnu-openmpi4-hpc) weakremover(libhdf5_1_10_8-gnu-hpc) weakremover(libhdf5_1_10_8-gnu-mpich-hpc) weakremover(libhdf5_1_10_8-gnu-mvapich2-hpc) weakremover(libhdf5_1_10_8-gnu-openmpi1-hpc) weakremover(libhdf5_1_10_8-gnu-openmpi2-hpc) weakremover(libhdf5_1_10_8-gnu-openmpi3-hpc) weakremover(libhdf5_1_10_8-gnu-openmpi4-hpc) weakremover(libhdf5_1_12_2-gnu-hpc) weakremover(libhdf5_1_12_2-gnu-mpich-hpc) weakremover(libhdf5_1_12_2-gnu-mvapich2-hpc) weakremover(libhdf5_1_12_2-gnu-openmpi1-hpc) weakremover(libhdf5_1_12_2-gnu-openmpi2-hpc) weakremover(libhdf5_1_12_2-gnu-openmpi3-hpc) weakremover(libhdf5_1_12_2-gnu-openmpi4-hpc) weakremover(libhdf5_cpp-gnu-hpc) weakremover(libhdf5_cpp-gnu-mpich-hpc) weakremover(libhdf5_cpp-gnu-mvapich2-hpc) weakremover(libhdf5_cpp-gnu-openmpi1-hpc) weakremover(libhdf5_cpp-gnu-openmpi2-hpc) weakremover(libhdf5_cpp-gnu-openmpi3-hpc) weakremover(libhdf5_cpp-gnu-openmpi4-hpc) weakremover(libhdf5_cpp101) weakremover(libhdf5_cpp103) weakremover(libhdf5_cpp103-mvapich2) weakremover(libhdf5_cpp103-openmpi) weakremover(libhdf5_cpp103-openmpi1) weakremover(libhdf5_cpp103-openmpi2) weakremover(libhdf5_cpp103-openmpi3) weakremover(libhdf5_cpp103-openmpi4) weakremover(libhdf5_cpp200) weakremover(libhdf5_cpp200-mvapich2) weakremover(libhdf5_cpp200-openmpi1) weakremover(libhdf5_cpp200-openmpi2) weakremover(libhdf5_cpp200-openmpi3) weakremover(libhdf5_cpp200-openmpi4) weakremover(libhdf5_cpp_1_10_1-gnu-hpc) weakremover(libhdf5_cpp_1_10_4-gnu-hpc) weakremover(libhdf5_cpp_1_10_4-gnu-mpich-hpc) weakremover(libhdf5_cpp_1_10_4-gnu-mvapich2-hpc) weakremover(libhdf5_cpp_1_10_4-gnu-openmpi1-hpc) weakremover(libhdf5_cpp_1_10_4-gnu-openmpi2-hpc) weakremover(libhdf5_cpp_1_10_4-gnu-openmpi3-hpc) weakremover(libhdf5_cpp_1_10_5-gnu-hpc) weakremover(libhdf5_cpp_1_10_5-gnu-mpich-hpc) weakremover(libhdf5_cpp_1_10_5-gnu-mvapich2-hpc) weakremover(libhdf5_cpp_1_10_5-gnu-openmpi1-hpc) weakremover(libhdf5_cpp_1_10_5-gnu-openmpi2-hpc) weakremover(libhdf5_cpp_1_10_5-gnu-openmpi3-hpc) weakremover(libhdf5_cpp_1_10_5-gnu-openmpi4-hpc) weakremover(libhdf5_cpp_1_10_7-gnu-hpc) weakremover(libhdf5_cpp_1_10_7-gnu-mpich-hpc) weakremover(libhdf5_cpp_1_10_7-gnu-mvapich2-hpc) weakremover(libhdf5_cpp_1_10_7-gnu-openmpi1-hpc) weakremover(libhdf5_cpp_1_10_7-gnu-openmpi2-hpc) weakremover(libhdf5_cpp_1_10_7-gnu-openmpi3-hpc) weakremover(libhdf5_cpp_1_10_7-gnu-openmpi4-hpc) weakremover(libhdf5_cpp_1_10_8-gnu-hpc) weakremover(libhdf5_cpp_1_10_8-gnu-mpich-hpc) weakremover(libhdf5_cpp_1_10_8-gnu-mvapich2-hpc) weakremover(libhdf5_cpp_1_10_8-gnu-openmpi1-hpc) weakremover(libhdf5_cpp_1_10_8-gnu-openmpi2-hpc) weakremover(libhdf5_cpp_1_10_8-gnu-openmpi3-hpc) weakremover(libhdf5_cpp_1_10_8-gnu-openmpi4-hpc) weakremover(libhdf5_cpp_1_12_2-gnu-hpc) weakremover(libhdf5_cpp_1_12_2-gnu-mpich-hpc) weakremover(libhdf5_cpp_1_12_2-gnu-mvapich2-hpc) weakremover(libhdf5_cpp_1_12_2-gnu-openmpi1-hpc) weakremover(libhdf5_cpp_1_12_2-gnu-openmpi2-hpc) weakremover(libhdf5_cpp_1_12_2-gnu-openmpi3-hpc) weakremover(libhdf5_cpp_1_12_2-gnu-openmpi4-hpc) weakremover(libhdf5_fortran-gnu-hpc) weakremover(libhdf5_fortran-gnu-mpich-hpc) weakremover(libhdf5_fortran-gnu-mvapich2-hpc) weakremover(libhdf5_fortran-gnu-openmpi1-hpc) weakremover(libhdf5_fortran-gnu-openmpi2-hpc) weakremover(libhdf5_fortran-gnu-openmpi3-hpc) weakremover(libhdf5_fortran-gnu-openmpi4-hpc) weakremover(libhdf5_fortran100) weakremover(libhdf5_fortran100-mvapich2) weakremover(libhdf5_fortran100-openmpi) weakremover(libhdf5_fortran100-openmpi2) weakremover(libhdf5_fortran100-openmpi3) weakremover(libhdf5_fortran102) weakremover(libhdf5_fortran102-mvapich2) weakremover(libhdf5_fortran102-openmpi) weakremover(libhdf5_fortran102-openmpi1) weakremover(libhdf5_fortran102-openmpi2) weakremover(libhdf5_fortran102-openmpi3) weakremover(libhdf5_fortran102-openmpi4) weakremover(libhdf5_fortran200) weakremover(libhdf5_fortran200-mvapich2) weakremover(libhdf5_fortran200-openmpi1) weakremover(libhdf5_fortran200-openmpi2) weakremover(libhdf5_fortran200-openmpi3) weakremover(libhdf5_fortran200-openmpi4) weakremover(libhdf5_fortran_1_10_1-gnu-hpc) weakremover(libhdf5_fortran_1_10_1-gnu-mpich-hpc) weakremover(libhdf5_fortran_1_10_1-gnu-mvapich2-hpc) weakremover(libhdf5_fortran_1_10_1-gnu-openmpi1-hpc) weakremover(libhdf5_fortran_1_10_1-gnu-openmpi2-hpc) weakremover(libhdf5_fortran_1_10_1-gnu-openmpi3-hpc) weakremover(libhdf5_fortran_1_10_4-gnu-hpc) weakremover(libhdf5_fortran_1_10_4-gnu-mpich-hpc) weakremover(libhdf5_fortran_1_10_4-gnu-mvapich2-hpc) weakremover(libhdf5_fortran_1_10_4-gnu-openmpi1-hpc) weakremover(libhdf5_fortran_1_10_4-gnu-openmpi2-hpc) weakremover(libhdf5_fortran_1_10_4-gnu-openmpi3-hpc) weakremover(libhdf5_fortran_1_10_5-gnu-hpc) weakremover(libhdf5_fortran_1_10_5-gnu-mpich-hpc) weakremover(libhdf5_fortran_1_10_5-gnu-mvapich2-hpc) weakremover(libhdf5_fortran_1_10_5-gnu-openmpi1-hpc) weakremover(libhdf5_fortran_1_10_5-gnu-openmpi2-hpc) weakremover(libhdf5_fortran_1_10_5-gnu-openmpi3-hpc) weakremover(libhdf5_fortran_1_10_5-gnu-openmpi4-hpc) weakremover(libhdf5_fortran_1_10_7-gnu-hpc) weakremover(libhdf5_fortran_1_10_7-gnu-mpich-hpc) weakremover(libhdf5_fortran_1_10_7-gnu-mvapich2-hpc) weakremover(libhdf5_fortran_1_10_7-gnu-openmpi1-hpc) weakremover(libhdf5_fortran_1_10_7-gnu-openmpi2-hpc) weakremover(libhdf5_fortran_1_10_7-gnu-openmpi3-hpc) weakremover(libhdf5_fortran_1_10_7-gnu-openmpi4-hpc) weakremover(libhdf5_fortran_1_10_8-gnu-hpc) weakremover(libhdf5_fortran_1_10_8-gnu-mpich-hpc) weakremover(libhdf5_fortran_1_10_8-gnu-mvapich2-hpc) weakremover(libhdf5_fortran_1_10_8-gnu-openmpi1-hpc) weakremover(libhdf5_fortran_1_10_8-gnu-openmpi2-hpc) weakremover(libhdf5_fortran_1_10_8-gnu-openmpi3-hpc) weakremover(libhdf5_fortran_1_10_8-gnu-openmpi4-hpc) weakremover(libhdf5_fortran_1_12_2-gnu-hpc) weakremover(libhdf5_fortran_1_12_2-gnu-mpich-hpc) weakremover(libhdf5_fortran_1_12_2-gnu-mvapich2-hpc) weakremover(libhdf5_fortran_1_12_2-gnu-openmpi1-hpc) weakremover(libhdf5_fortran_1_12_2-gnu-openmpi2-hpc) weakremover(libhdf5_fortran_1_12_2-gnu-openmpi3-hpc) weakremover(libhdf5_fortran_1_12_2-gnu-openmpi4-hpc) weakremover(libhdf5_hl-gnu-hpc) weakremover(libhdf5_hl-gnu-mpich-hpc) weakremover(libhdf5_hl-gnu-mvapich2-hpc) weakremover(libhdf5_hl-gnu-openmpi1-hpc) weakremover(libhdf5_hl-gnu-openmpi2-hpc) weakremover(libhdf5_hl-gnu-openmpi3-hpc) weakremover(libhdf5_hl-gnu-openmpi4-hpc) weakremover(libhdf5_hl10) weakremover(libhdf5_hl10-openmpi) weakremover(libhdf5_hl100) weakremover(libhdf5_hl100-mvapich2) weakremover(libhdf5_hl100-openmpi) weakremover(libhdf5_hl100-openmpi1) weakremover(libhdf5_hl100-openmpi2) weakremover(libhdf5_hl100-openmpi3) weakremover(libhdf5_hl100-openmpi4) weakremover(libhdf5_hl11) weakremover(libhdf5_hl200) weakremover(libhdf5_hl200-mvapich2) weakremover(libhdf5_hl200-openmpi1) weakremover(libhdf5_hl200-openmpi2) weakremover(libhdf5_hl200-openmpi3) weakremover(libhdf5_hl200-openmpi4) weakremover(libhdf5_hl_1_10_1-gnu-hpc) weakremover(libhdf5_hl_1_10_1-gnu-mpich-hpc) weakremover(libhdf5_hl_1_10_1-gnu-mvapich2-hpc) weakremover(libhdf5_hl_1_10_1-gnu-openmpi1-hpc) weakremover(libhdf5_hl_1_10_1-gnu-openmpi2-hpc) weakremover(libhdf5_hl_1_10_1-gnu-openmpi3-hpc) weakremover(libhdf5_hl_1_10_4-gnu-hpc) weakremover(libhdf5_hl_1_10_4-gnu-mpich-hpc) weakremover(libhdf5_hl_1_10_4-gnu-mvapich2-hpc) weakremover(libhdf5_hl_1_10_4-gnu-openmpi1-hpc) weakremover(libhdf5_hl_1_10_4-gnu-openmpi2-hpc) weakremover(libhdf5_hl_1_10_4-gnu-openmpi3-hpc) weakremover(libhdf5_hl_1_10_5-gnu-hpc) weakremover(libhdf5_hl_1_10_5-gnu-mpich-hpc) weakremover(libhdf5_hl_1_10_5-gnu-mvapich2-hpc) weakremover(libhdf5_hl_1_10_5-gnu-openmpi1-hpc) weakremover(libhdf5_hl_1_10_5-gnu-openmpi2-hpc) weakremover(libhdf5_hl_1_10_5-gnu-openmpi3-hpc) weakremover(libhdf5_hl_1_10_5-gnu-openmpi4-hpc) weakremover(libhdf5_hl_1_10_7-gnu-hpc) weakremover(libhdf5_hl_1_10_7-gnu-mpich-hpc) weakremover(libhdf5_hl_1_10_7-gnu-mvapich2-hpc) weakremover(libhdf5_hl_1_10_7-gnu-openmpi1-hpc) weakremover(libhdf5_hl_1_10_7-gnu-openmpi2-hpc) weakremover(libhdf5_hl_1_10_7-gnu-openmpi3-hpc) weakremover(libhdf5_hl_1_10_7-gnu-openmpi4-hpc) weakremover(libhdf5_hl_1_10_8-gnu-hpc) weakremover(libhdf5_hl_1_10_8-gnu-mpich-hpc) weakremover(libhdf5_hl_1_10_8-gnu-mvapich2-hpc) weakremover(libhdf5_hl_1_10_8-gnu-openmpi1-hpc) weakremover(libhdf5_hl_1_10_8-gnu-openmpi2-hpc) weakremover(libhdf5_hl_1_10_8-gnu-openmpi3-hpc) weakremover(libhdf5_hl_1_10_8-gnu-openmpi4-hpc) weakremover(libhdf5_hl_1_12_2-gnu-hpc) weakremover(libhdf5_hl_1_12_2-gnu-mpich-hpc) weakremover(libhdf5_hl_1_12_2-gnu-mvapich2-hpc) weakremover(libhdf5_hl_1_12_2-gnu-openmpi1-hpc) weakremover(libhdf5_hl_1_12_2-gnu-openmpi2-hpc) weakremover(libhdf5_hl_1_12_2-gnu-openmpi3-hpc) weakremover(libhdf5_hl_1_12_2-gnu-openmpi4-hpc) weakremover(libhdf5_hl_cpp-gnu-hpc) weakremover(libhdf5_hl_cpp-gnu-mpich-hpc) weakremover(libhdf5_hl_cpp-gnu-mvapich2-hpc) weakremover(libhdf5_hl_cpp-gnu-openmpi1-hpc) weakremover(libhdf5_hl_cpp-gnu-openmpi2-hpc) weakremover(libhdf5_hl_cpp-gnu-openmpi3-hpc) weakremover(libhdf5_hl_cpp-gnu-openmpi4-hpc) weakremover(libhdf5_hl_cpp100) weakremover(libhdf5_hl_cpp100-mvapich2) weakremover(libhdf5_hl_cpp100-openmpi) weakremover(libhdf5_hl_cpp100-openmpi1) weakremover(libhdf5_hl_cpp100-openmpi2) weakremover(libhdf5_hl_cpp100-openmpi3) weakremover(libhdf5_hl_cpp100-openmpi4) weakremover(libhdf5_hl_cpp200) weakremover(libhdf5_hl_cpp200-mvapich2) weakremover(libhdf5_hl_cpp200-openmpi1) weakremover(libhdf5_hl_cpp200-openmpi2) weakremover(libhdf5_hl_cpp200-openmpi3) weakremover(libhdf5_hl_cpp200-openmpi4) weakremover(libhdf5_hl_cpp_1_10_1-gnu-hpc) weakremover(libhdf5_hl_cpp_1_10_4-gnu-hpc) weakremover(libhdf5_hl_cpp_1_10_4-gnu-mpich-hpc) weakremover(libhdf5_hl_cpp_1_10_4-gnu-mvapich2-hpc) weakremover(libhdf5_hl_cpp_1_10_4-gnu-openmpi1-hpc) weakremover(libhdf5_hl_cpp_1_10_4-gnu-openmpi2-hpc) weakremover(libhdf5_hl_cpp_1_10_4-gnu-openmpi3-hpc) weakremover(libhdf5_hl_cpp_1_10_5-gnu-hpc) weakremover(libhdf5_hl_cpp_1_10_5-gnu-mpich-hpc) weakremover(libhdf5_hl_cpp_1_10_5-gnu-mvapich2-hpc) weakremover(libhdf5_hl_cpp_1_10_5-gnu-openmpi1-hpc) weakremover(libhdf5_hl_cpp_1_10_5-gnu-openmpi2-hpc) weakremover(libhdf5_hl_cpp_1_10_5-gnu-openmpi3-hpc) weakremover(libhdf5_hl_cpp_1_10_5-gnu-openmpi4-hpc) weakremover(libhdf5_hl_cpp_1_10_7-gnu-hpc) weakremover(libhdf5_hl_cpp_1_10_7-gnu-mpich-hpc) weakremover(libhdf5_hl_cpp_1_10_7-gnu-mvapich2-hpc) weakremover(libhdf5_hl_cpp_1_10_7-gnu-openmpi1-hpc) weakremover(libhdf5_hl_cpp_1_10_7-gnu-openmpi2-hpc) weakremover(libhdf5_hl_cpp_1_10_7-gnu-openmpi3-hpc) weakremover(libhdf5_hl_cpp_1_10_7-gnu-openmpi4-hpc) weakremover(libhdf5_hl_cpp_1_10_8-gnu-hpc) weakremover(libhdf5_hl_cpp_1_10_8-gnu-mpich-hpc) weakremover(libhdf5_hl_cpp_1_10_8-gnu-mvapich2-hpc) weakremover(libhdf5_hl_cpp_1_10_8-gnu-openmpi1-hpc) weakremover(libhdf5_hl_cpp_1_10_8-gnu-openmpi2-hpc) weakremover(libhdf5_hl_cpp_1_10_8-gnu-openmpi3-hpc) weakremover(libhdf5_hl_cpp_1_10_8-gnu-openmpi4-hpc) weakremover(libhdf5_hl_cpp_1_12_2-gnu-hpc) weakremover(libhdf5_hl_cpp_1_12_2-gnu-mpich-hpc) weakremover(libhdf5_hl_cpp_1_12_2-gnu-mvapich2-hpc) weakremover(libhdf5_hl_cpp_1_12_2-gnu-openmpi1-hpc) weakremover(libhdf5_hl_cpp_1_12_2-gnu-openmpi2-hpc) weakremover(libhdf5_hl_cpp_1_12_2-gnu-openmpi3-hpc) weakremover(libhdf5_hl_cpp_1_12_2-gnu-openmpi4-hpc) weakremover(libhdf5_hl_fortran-gnu-hpc) weakremover(libhdf5_hl_fortran-gnu-mpich-hpc) weakremover(libhdf5_hl_fortran-gnu-mvapich2-hpc) weakremover(libhdf5_hl_fortran-gnu-openmpi1-hpc) weakremover(libhdf5_hl_fortran-gnu-openmpi2-hpc) weakremover(libhdf5_hl_fortran-gnu-openmpi3-hpc) weakremover(libhdf5_hl_fortran-gnu-openmpi4-hpc) weakremover(libhdf5hl_fortran100) weakremover(libhdf5hl_fortran100-mvapich2) weakremover(libhdf5hl_fortran100-openmpi) weakremover(libhdf5hl_fortran100-openmpi1) weakremover(libhdf5hl_fortran100-openmpi2) weakremover(libhdf5hl_fortran100-openmpi3) weakremover(libhdf5hl_fortran100-openmpi4) weakremover(libhdf5hl_fortran200) weakremover(libhdf5hl_fortran200-mvapich2) weakremover(libhdf5hl_fortran200-openmpi1) weakremover(libhdf5hl_fortran200-openmpi2) weakremover(libhdf5hl_fortran200-openmpi3) weakremover(libhdf5hl_fortran200-openmpi4) weakremover(libhdf5hl_fortran_1_10_1-gnu-hpc) weakremover(libhdf5hl_fortran_1_10_1-gnu-mpich-hpc) weakremover(libhdf5hl_fortran_1_10_1-gnu-mvapich2-hpc) weakremover(libhdf5hl_fortran_1_10_1-gnu-openmpi1-hpc) weakremover(libhdf5hl_fortran_1_10_1-gnu-openmpi2-hpc) weakremover(libhdf5hl_fortran_1_10_1-gnu-openmpi3-hpc) weakremover(libhdf5hl_fortran_1_10_4-gnu-hpc) weakremover(libhdf5hl_fortran_1_10_4-gnu-mpich-hpc) weakremover(libhdf5hl_fortran_1_10_4-gnu-mvapich2-hpc) weakremover(libhdf5hl_fortran_1_10_4-gnu-openmpi1-hpc) weakremover(libhdf5hl_fortran_1_10_4-gnu-openmpi2-hpc) weakremover(libhdf5hl_fortran_1_10_4-gnu-openmpi3-hpc) weakremover(libhdf5hl_fortran_1_10_5-gnu-hpc) weakremover(libhdf5hl_fortran_1_10_5-gnu-mpich-hpc) weakremover(libhdf5hl_fortran_1_10_5-gnu-mvapich2-hpc) weakremover(libhdf5hl_fortran_1_10_5-gnu-openmpi1-hpc) weakremover(libhdf5hl_fortran_1_10_5-gnu-openmpi2-hpc) weakremover(libhdf5hl_fortran_1_10_5-gnu-openmpi3-hpc) weakremover(libhdf5hl_fortran_1_10_5-gnu-openmpi4-hpc) weakremover(libhdf5hl_fortran_1_10_7-gnu-hpc) weakremover(libhdf5hl_fortran_1_10_7-gnu-mpich-hpc) weakremover(libhdf5hl_fortran_1_10_7-gnu-mvapich2-hpc) weakremover(libhdf5hl_fortran_1_10_7-gnu-openmpi1-hpc) weakremover(libhdf5hl_fortran_1_10_7-gnu-openmpi2-hpc) weakremover(libhdf5hl_fortran_1_10_7-gnu-openmpi3-hpc) weakremover(libhdf5hl_fortran_1_10_7-gnu-openmpi4-hpc) weakremover(libhdf5hl_fortran_1_10_8-gnu-hpc) weakremover(libhdf5hl_fortran_1_10_8-gnu-mpich-hpc) weakremover(libhdf5hl_fortran_1_10_8-gnu-mvapich2-hpc) weakremover(libhdf5hl_fortran_1_10_8-gnu-openmpi1-hpc) weakremover(libhdf5hl_fortran_1_10_8-gnu-openmpi2-hpc) weakremover(libhdf5hl_fortran_1_10_8-gnu-openmpi3-hpc) weakremover(libhdf5hl_fortran_1_10_8-gnu-openmpi4-hpc) weakremover(libhdf5hl_fortran_1_12_2-gnu-hpc) weakremover(libhdf5hl_fortran_1_12_2-gnu-mpich-hpc) weakremover(libhdf5hl_fortran_1_12_2-gnu-mvapich2-hpc) weakremover(libhdf5hl_fortran_1_12_2-gnu-openmpi1-hpc) weakremover(libhdf5hl_fortran_1_12_2-gnu-openmpi2-hpc) weakremover(libhdf5hl_fortran_1_12_2-gnu-openmpi3-hpc) weakremover(libhdf5hl_fortran_1_12_2-gnu-openmpi4-hpc) weakremover(libhdhomerun-devel) weakremover(libhdhomerun1) weakremover(libhdhomerun2) weakremover(libhealpix_cxx2) weakremover(libhealpix_cxx3) weakremover(libheif-devel) weakremover(libheif1) weakremover(libheimbase1) weakremover(libheimdal) weakremover(libheimdal-devel) weakremover(libheimedit0) weakremover(libheimntlm0) weakremover(libhfst49) weakremover(libhfst52) weakremover(libhfst53) weakremover(libhfstospell10) weakremover(libhfstospell11) weakremover(libhibr-devel) weakremover(libhibr-tools) weakremover(libhibr1) weakremover(libhidapi-devel) weakremover(libhidapi-hidraw0) weakremover(libhidapi-libusb0) weakremover(libhinawa-devel) weakremover(libhinawa1) weakremover(libhinawa2) weakremover(libhiredis0_12) weakremover(libhiredis0_13) weakremover(libhiredis1_0_0) weakremover(libhiredis1_1_0) weakremover(libhivex0) weakremover(libhl1) weakremover(libhmac-devel) weakremover(libhmac-tools) weakremover(libhmac1) weakremover(libhogweed2) weakremover(libhogweed4) weakremover(libhogweed5) weakremover(libhogweed6) weakremover(libhomfly-devel) weakremover(libhomfly0) weakremover(libhowl0) weakremover(libhpdf2_3_0) weakremover(libhpdf2_4_2) weakremover(libhpx1) weakremover(libhs5-vectorscan5) weakremover(libhtp-devel) weakremover(libhtp2) weakremover(libhts-devel) weakremover(libhts3) weakremover(libhtscodecs2) weakremover(libhttp-parser-suse0) weakremover(libhttp_parser2_7_1) weakremover(libhttp_parser2_9) weakremover(libhttrack2) weakremover(libhubbub-devel) weakremover(libhubbub-doc) weakremover(libhubbub0) weakremover(libhugetlbfs) weakremover(libhugetlbfs-devel) weakremover(libhugetlbfs-libhugetlb-devel) weakremover(libhugetlbfs-tests) weakremover(libhunspell-1_6-0) weakremover(libhunspell-1_7-0) weakremover(libhwasan0) weakremover(libhwasan0-gcc11) weakremover(libhwasan0-gcc12) weakremover(libhwloc15) weakremover(libhwloc5) weakremover(libhwy0) weakremover(libhwy1) weakremover(libhx509-5) weakremover(libhydrogen-core-1_1_1) weakremover(libhydrogen-core-1_2_0) weakremover(libhydrogen-core-devel) weakremover(libhydrogen-core0) weakremover(libhydrogen-core1) weakremover(libhyphen0) weakremover(libi2c0) weakremover(libi2c0-devel) weakremover(libib_util) weakremover(libib_util-devel) weakremover(libibcm-devel) weakremover(libibcm1) weakremover(libibdm1) weakremover(libibmad-devel) weakremover(libibmad-devel-static) weakremover(libibmad5) weakremover(libibmtss0) weakremover(libibmtss1) weakremover(libibnetdisc5) weakremover(libibumad-devel) weakremover(libibumad-devel-static) weakremover(libibumad3) weakremover(libibus-1_0-5) weakremover(libibverbs) weakremover(libibverbs-devel) weakremover(libibverbs-devel-static) weakremover(libibverbs-runtime) weakremover(libibverbs-utils) weakremover(libibverbs1) weakremover(libica-1_3_9) weakremover(libical-devel) weakremover(libical-devel-static) weakremover(libical-glib-1_0-0) weakremover(libical-glib-devel) weakremover(libical-glib3) weakremover(libical1) weakremover(libical2) weakremover(libical3) weakremover(libicecream-devel) weakremover(libicns-devel) weakremover(libicns1) weakremover(libicns1-devel) weakremover(libiconv_hook-devel) weakremover(libiconv_hook1) weakremover(libicu-devel) weakremover(libicu-doc) weakremover(libicu-suse63_1) weakremover(libicu-suse64_1) weakremover(libicu-suse64_2) weakremover(libicu-suse65_1) weakremover(libicu52_1) weakremover(libicu52_1-data) weakremover(libicu54_1) weakremover(libicu54_1-ledata) weakremover(libicu55_1) weakremover(libicu55_1-ledata) weakremover(libicu56_1) weakremover(libicu56_1-ledata) weakremover(libicu60_2) weakremover(libicu60_2-bedata) weakremover(libicu60_2-ledata) weakremover(libicu63_1-bedata) weakremover(libicu63_1-ledata) weakremover(libicu64_1-bedata) weakremover(libicu64_1-ledata) weakremover(libicu64_2-bedata) weakremover(libicu64_2-ledata) weakremover(libicu65_1-bedata) weakremover(libicu65_1-ledata) weakremover(libicu66) weakremover(libicu66-bedata) weakremover(libicu66-ledata) weakremover(libicu67) weakremover(libicu67-bedata) weakremover(libicu67-ledata) weakremover(libicu68) weakremover(libicu68-bedata) weakremover(libicu68-ledata) weakremover(libicu69) weakremover(libicu69-bedata) weakremover(libicu69-ledata) weakremover(libicu70) weakremover(libicu70-bedata) weakremover(libicu70-ledata) weakremover(libicu71) weakremover(libicu71-bedata) weakremover(libicu71-ledata) weakremover(libicu72) weakremover(libid3-3_8-3) weakremover(libid3tag-devel) weakremover(libid3tag0) weakremover(libid3tag0_16_1) weakremover(libid3tag0_16_2) weakremover(libidl-devel) weakremover(libidmef-devel) weakremover(libidmef1) weakremover(libidn-devel) weakremover(libidn-tools) weakremover(libidn11) weakremover(libidn12) weakremover(libidn2-0) weakremover(libidn2-4) weakremover(libidn2-devel) weakremover(libidn2-tools) weakremover(libido3-0_1-0) weakremover(libiec16022-0) weakremover(libiec16022-devel) weakremover(libiec61883) weakremover(libiec61883-0) weakremover(libiec61883-devel) weakremover(libiec61883-tools) weakremover(libieee1284) weakremover(libieee1284-devel) weakremover(libieee12843) weakremover(libiio) weakremover(libiio-daemon) weakremover(libiio-devel) weakremover(libiio-usb-udev-rules) weakremover(libiio0) weakremover(libiir-devel) weakremover(libiir1) weakremover(libiksemel3) weakremover(libilbc0) weakremover(libimaevm0) weakremover(libimaevm1) weakremover(libimaevm2) weakremover(libimaevm3) weakremover(libimaevm4) weakremover(libimagequant-devel) weakremover(libimagequant0) weakremover(libimageviewer-devel) weakremover(libimageviewer0_1) weakremover(libimagevisualresult-data) weakremover(libimagevisualresult-devel) weakremover(libimagevisualresult0_1) weakremover(libime-devel) weakremover(libime-dicts) weakremover(libime-tools) weakremover(libiml0) weakremover(libimobiledevice-1_0-6) weakremover(libimobiledevice-devel) weakremover(libimobiledevice-doc) weakremover(libimobiledevice-glue-1_0-0) weakremover(libimobiledevice-glue-devel) weakremover(libimobiledevice5) weakremover(libimobiledevice6) weakremover(libinchi0) weakremover(libinchi1) weakremover(libindi) weakremover(libindi-devel) weakremover(libindi-plugins) weakremover(libindi1) weakremover(libindiAlignmentDriver1) weakremover(libindiAlignmentDriver2) weakremover(libindicator-devel) weakremover(libindicator3-7) weakremover(libindicator3-devel) weakremover(libindicator7) weakremover(libindiclient1) weakremover(libindiclient2) weakremover(libindiclientqt1) weakremover(libindiclientqt2) weakremover(libindidriver1) weakremover(libindidriver2) weakremover(libindilx200-1) weakremover(libindilx200-2) weakremover(libinfinity-0_7-0) weakremover(libinfinity-1_0-0) weakremover(libinfinity-devel) weakremover(libini_config-devel) weakremover(libini_config5) weakremover(libinih-devel) weakremover(libinih0) weakremover(libiniparser-devel) weakremover(libiniparser0) weakremover(libiniparser1) weakremover(libinjeqt0) weakremover(libinjeqt1) weakremover(libinotifytools0) weakremover(libinput-debug-gui) weakremover(libinput-devel) weakremover(libinput-tools) weakremover(libinput-udev) weakremover(libinput10) weakremover(libinputsynth-devel) weakremover(libinputsynth0_15-0) weakremover(libinsane-devel) weakremover(libinsane1) weakremover(libinsane_gobject-devel) weakremover(libinsane_gobject1) weakremover(libinsighttoolkit4) weakremover(libinsighttoolkit5) weakremover(libinsighttoolkit5_2-1) weakremover(libinsighttoolkit5_3-1) weakremover(libinstpatch-1_0-0) weakremover(libinstpatch-1_0-2) weakremover(libinstpatch-devel) weakremover(libint-devel) weakremover(libint2-2) weakremover(libiodbc-devel) weakremover(libiodbc2) weakremover(libiodbc3) weakremover(libiodbcadm2) weakremover(libip4tc2) weakremover(libip6tc2) weakremover(libipa_hbac-devel) weakremover(libipa_hbac0) weakremover(libipathverbs-rdmav2) weakremover(libiperf0) weakremover(libipmiconsole2) weakremover(libipmidetect0) weakremover(libipmimonitoring6) weakremover(libipopt0) weakremover(libipopt3) weakremover(libipq-devel) weakremover(libipq0) weakremover(libipset11) weakremover(libipset13) weakremover(libipset3) weakremover(libiptc-devel) weakremover(libiptc0) weakremover(libiptcdata) weakremover(libiptcdata-devel) weakremover(libiptcdata-doc) weakremover(libiptcdata0) weakremover(libircclient-devel) weakremover(libircclient-doc) weakremover(libircclient1) weakremover(libirman-devel) weakremover(libirman-utils) weakremover(libirman0) weakremover(libirml1) weakremover(libirrecord0) weakremover(libirs-devel) weakremover(libirs1301) weakremover(libirs160) weakremover(libirs1600) weakremover(libirs1601) weakremover(libisc1310) weakremover(libisc142) weakremover(libisc148) weakremover(libisc1600) weakremover(libisc1601) weakremover(libisc1603) weakremover(libisc1605) weakremover(libisc1606) weakremover(libisc1607) weakremover(libisc1608) weakremover(libisc1609) weakremover(libisc166) weakremover(libisccc1302) weakremover(libisccc160) weakremover(libisccc1600) weakremover(libisccfg1302) weakremover(libisccfg160) weakremover(libisccfg1600) weakremover(libisccfg1601) weakremover(libisccfg1602) weakremover(libisccfg1603) weakremover(libiscsi-devel) weakremover(libiscsi-test) weakremover(libiscsi-utils) weakremover(libiscsi7) weakremover(libiscsi8) weakremover(libiscsi9) weakremover(libisds-devel) weakremover(libisds5) weakremover(libisl10) weakremover(libisl13) weakremover(libisl15) weakremover(libisl19) weakremover(libisl22) weakremover(libisl23) weakremover(libiso9660++0) weakremover(libiso9660-10) weakremover(libiso9660-11) weakremover(libisoburn-devel) weakremover(libisoburn1) weakremover(libisofs-devel) weakremover(libisofs6) weakremover(libispcrt1) weakremover(libite-devel) weakremover(libite5) weakremover(libiterm-devel) weakremover(libiterm1) weakremover(libitm1) weakremover(libitm1-gcc10) weakremover(libitm1-gcc11) weakremover(libitm1-gcc12) weakremover(libitm1-gcc5) weakremover(libitm1-gcc6) weakremover(libitm1-gcc7) weakremover(libitm1-gcc8) weakremover(libitm1-gcc9) weakremover(libitpp8) weakremover(libivykis0) weakremover(libiw-devel) weakremover(libiw30) weakremover(libixion-0_10-0) weakremover(libixion-0_11-0) weakremover(libixion-0_12-0) weakremover(libixion-0_13-0) weakremover(libixion-0_14-0) weakremover(libixion-0_15-0) weakremover(libixion-0_16-0) weakremover(libixion-0_17-0) weakremover(libixion-devel) weakremover(libixion-python3) weakremover(libixion-tools) weakremover(libixml10) weakremover(libixml11) weakremover(libjack-devel) weakremover(libjack-pw0_3_1) weakremover(libjack-pw0_3_2) weakremover(libjack0) weakremover(libjackasyn) weakremover(libjacknet0) weakremover(libjackserver0) weakremover(libjansson-devel) weakremover(libjansson4) weakremover(libjasper-devel) weakremover(libjasper1) weakremover(libjasper4) weakremover(libjasper6) weakremover(libjasper7) weakremover(libjavamapscript) weakremover(libjavascriptcoregtk-1_0-0) weakremover(libjavascriptcoregtk-3_0-0) weakremover(libjavascriptcoregtk-4_0-18) weakremover(libjavascriptcoregtk-4_1-0) weakremover(libjavascriptcoregtk-5_0-0) weakremover(libjavascriptcoregtk6_0-1) weakremover(libjaylink) weakremover(libjaylink-devel) weakremover(libjaylink0) weakremover(libjbig-devel) weakremover(libjbig2) weakremover(libjbig2dec0) weakremover(libjcat-devel) weakremover(libjcat1) weakremover(libjd0) weakremover(libjemalloc2) weakremover(libjim0_75) weakremover(libjim0_81) weakremover(libjitterentropy3) weakremover(libjnidispatch) weakremover(libjose-devel) weakremover(libjose0) weakremover(libjpeg-turbo) weakremover(libjpeg62) weakremover(libjpeg62-devel) weakremover(libjpeg62-turbo) weakremover(libjpeg8) weakremover(libjpeg8-devel) weakremover(libjpegxr0) weakremover(libjpgalleg-devel) weakremover(libjpgalleg44-devel) weakremover(libjpgalleg4_4) weakremover(libjq-devel) weakremover(libjq1) weakremover(libjreen-devel) weakremover(libjreen-qt5-1) weakremover(libjreen-qt5-devel) weakremover(libjreen1) weakremover(libjrtp3_11_1) weakremover(libjsmn0) weakremover(libjson-c-devel) weakremover(libjson-c2) weakremover(libjson-c3) weakremover(libjson-c4) weakremover(libjson-c5) weakremover(libjson-glib-1_0-0) weakremover(libjsoncpp1) weakremover(libjsoncpp19) weakremover(libjsoncpp21) weakremover(libjsoncpp22) weakremover(libjsoncpp24) weakremover(libjsoncpp25) weakremover(libjsonrpc-glib-1_0-1) weakremover(libjsonrpc_glib-1_0-0) weakremover(libjte-devel) weakremover(libjte1) weakremover(libjte2) weakremover(libjthread1_3_3) weakremover(libjwt_verify_lib0) weakremover(libjxl-devel) weakremover(libjxl-tools) weakremover(libjxl0_7) weakremover(libjxl0_8) weakremover(libjxrglue0) weakremover(libkColorPicker0) weakremover(libkColorPicker0_1_0) weakremover(libkColorPicker0_1_1) weakremover(libkColorPicker0_1_4) weakremover(libkImageAnnotator0) weakremover(libkImageAnnotator0_1_0) weakremover(libkImageAnnotator0_2_0) weakremover(libkImageAnnotator0_2_1) weakremover(libkImageAnnotator0_3_0) weakremover(libkImageAnnotator0_3_1) weakremover(libkImageAnnotator0_3_2) weakremover(libkImageAnnotator0_4_0) weakremover(libkaccounts1) weakremover(libkaccounts2) weakremover(libkactivities-devel) weakremover(libkactivities6) weakremover(libkadm5clnt7) weakremover(libkadm5srv8) weakremover(libkafs0) weakremover(libkate-devel) weakremover(libkate-tools) weakremover(libkate1) weakremover(libkatepartinterfaces4) weakremover(libkcapi-devel) weakremover(libkcapi-tools) weakremover(libkcapi0) weakremover(libkcapi1) weakremover(libkcarchiver0) weakremover(libkcarchivercore0) weakremover(libkcddb) weakremover(libkcddb-devel) weakremover(libkcddb4) weakremover(libkcddb4-devel) weakremover(libkcfreebusy0) weakremover(libkchl0) weakremover(libkcicalmapi0) weakremover(libkcindex0) weakremover(libkcinetmapi0) weakremover(libkcmapi0) weakremover(libkcompactdisc-devel) weakremover(libkcompactdisc4) weakremover(libkcompactdisc4-devel) weakremover(libkcpyplug0) weakremover(libkcrosie0) weakremover(libkcserver0) weakremover(libkcsoap0) weakremover(libkcssl0) weakremover(libkcsync0) weakremover(libkcutil0) weakremover(libkdc2) weakremover(libkdcraw-devel) weakremover(libkddockwidgets-qt6-1_6) weakremover(libkddockwidgets1_6) weakremover(libkde4) weakremover(libkde4-devel) weakremover(libkdecoration2-devel) weakremover(libkdecorations2-5) weakremover(libkdecorations2private10) weakremover(libkdecorations2private5) weakremover(libkdecorations2private6) weakremover(libkdecorations2private7) weakremover(libkdecorations2private8) weakremover(libkdecorations2private9) weakremover(libkdecore4) weakremover(libkdecore4-devel) weakremover(libkdegames) weakremover(libkdegames-devel) weakremover(libkdegames-qt5-imports) weakremover(libkdegames4) weakremover(libkdegames4-devel) weakremover(libkdegames6) weakremover(libkdepim) weakremover(libkdepim-devel) weakremover(libkdepim4) weakremover(libkdepimlibs4) weakremover(libkdepimlibs4-devel) weakremover(libkdevplatform10) weakremover(libkdevplatform4-devel) weakremover(libkdevplatform510) weakremover(libkdevplatform511) weakremover(libkdevplatform53) weakremover(libkdevplatform54) weakremover(libkdevplatform55) weakremover(libkdevplatform56) weakremover(libkdevplatform57) weakremover(libkdevplatform58) weakremover(libkdevplatform59) weakremover(libkdevplatform8) weakremover(libkdsoap-qt6-2) weakremover(libkdsoap-server-qt6-2) weakremover(libkdsoap-server1_9_0) weakremover(libkdsoap-server2) weakremover(libkdsoap1_9_0) weakremover(libkdsoap2) weakremover(libkdstatemachineeditor_core1) weakremover(libkdstatemachineeditor_core1_2_0) weakremover(libkdstatemachineeditor_core1_2_1) weakremover(libkdstatemachineeditor_core1_2_3) weakremover(libkdstatemachineeditor_core1_2_4) weakremover(libkdstatemachineeditor_core1_2_5) weakremover(libkdstatemachineeditor_core1_2_7) weakremover(libkdstatemachineeditor_debuginterfaceclient1) weakremover(libkdstatemachineeditor_debuginterfaceclient1_2_7) weakremover(libkdstatemachineeditor_debuginterfacesource-static) weakremover(libkdstatemachineeditor_view1) weakremover(libkdstatemachineeditor_view1_2_0) weakremover(libkdstatemachineeditor_view1_2_1) weakremover(libkdstatemachineeditor_view1_2_3) weakremover(libkdstatemachineeditor_view1_2_4) weakremover(libkdstatemachineeditor_view1_2_5) weakremover(libkdstatemachineeditor_view1_2_7) weakremover(libkdumpfile-devel) weakremover(libkdumpfile0) weakremover(libkdumpfile10) weakremover(libkdumpfile7) weakremover(libkdumpfile8) weakremover(libkdumpfile9) weakremover(libkea-asiodns0) weakremover(libkea-asiodns1) weakremover(libkea-asiodns12) weakremover(libkea-asiodns13) weakremover(libkea-asiodns24) weakremover(libkea-asiolink19) weakremover(libkea-asiolink25) weakremover(libkea-asiolink26) weakremover(libkea-asiolink27) weakremover(libkea-asiolink40) weakremover(libkea-asiolink7) weakremover(libkea-asiolink9) weakremover(libkea-cc23) weakremover(libkea-cc25) weakremover(libkea-cc39) weakremover(libkea-cc8) weakremover(libkea-cfgclient10) weakremover(libkea-cfgclient23) weakremover(libkea-cfgclient24) weakremover(libkea-cfgclient25) weakremover(libkea-cfgclient36) weakremover(libkea-cfgclient7) weakremover(libkea-cryptolink16) weakremover(libkea-cryptolink28) weakremover(libkea-cryptolink4) weakremover(libkea-cryptolink5) weakremover(libkea-d2srv16) weakremover(libkea-d2srv3) weakremover(libkea-database22) weakremover(libkea-database23) weakremover(libkea-database3) weakremover(libkea-database35) weakremover(libkea-database6) weakremover(libkea-dhcp++13) weakremover(libkea-dhcp++19) weakremover(libkea-dhcp++30) weakremover(libkea-dhcp++33) weakremover(libkea-dhcp++34) weakremover(libkea-dhcp++36) weakremover(libkea-dhcp++54) weakremover(libkea-dhcp_ddns1) weakremover(libkea-dhcp_ddns14) weakremover(libkea-dhcp_ddns16) weakremover(libkea-dhcp_ddns17) weakremover(libkea-dhcp_ddns29) weakremover(libkea-dhcp_ddns3) weakremover(libkea-dhcpsrv16) weakremover(libkea-dhcpsrv27) weakremover(libkea-dhcpsrv39) weakremover(libkea-dhcpsrv45) weakremover(libkea-dhcpsrv46) weakremover(libkea-dhcpsrv50) weakremover(libkea-dhcpsrv69) weakremover(libkea-dns++16) weakremover(libkea-dns++17) weakremover(libkea-dns++19) weakremover(libkea-dns++3) weakremover(libkea-dns++30) weakremover(libkea-dns++5) weakremover(libkea-eval10) weakremover(libkea-eval11) weakremover(libkea-eval12) weakremover(libkea-eval22) weakremover(libkea-eval25) weakremover(libkea-eval26) weakremover(libkea-eval27) weakremover(libkea-eval39) weakremover(libkea-exceptions0) weakremover(libkea-exceptions13) weakremover(libkea-hooks15) weakremover(libkea-hooks27) weakremover(libkea-hooks33) weakremover(libkea-hooks34) weakremover(libkea-hooks38) weakremover(libkea-hooks57) weakremover(libkea-hooks7) weakremover(libkea-http20) weakremover(libkea-http25) weakremover(libkea-http26) weakremover(libkea-http29) weakremover(libkea-http42) weakremover(libkea-http6) weakremover(libkea-http7) weakremover(libkea-log19) weakremover(libkea-log20) weakremover(libkea-log22) weakremover(libkea-log3) weakremover(libkea-log35) weakremover(libkea-log4) weakremover(libkea-log6) weakremover(libkea-mysql1) weakremover(libkea-mysql17) weakremover(libkea-mysql22) weakremover(libkea-mysql23) weakremover(libkea-mysql26) weakremover(libkea-mysql38) weakremover(libkea-mysql6) weakremover(libkea-pgsql0) weakremover(libkea-pgsql15) weakremover(libkea-pgsql19) weakremover(libkea-pgsql20) weakremover(libkea-pgsql36) weakremover(libkea-pgsql4) weakremover(libkea-process11) weakremover(libkea-process22) weakremover(libkea-process27) weakremover(libkea-process28) weakremover(libkea-process29) weakremover(libkea-process4) weakremover(libkea-process40) weakremover(libkea-stats16) weakremover(libkea-stats18) weakremover(libkea-stats3) weakremover(libkea-stats6) weakremover(libkea-threads2) weakremover(libkea-util-io0) weakremover(libkea-util16) weakremover(libkea-util28) weakremover(libkea-util32) weakremover(libkea-util33) weakremover(libkea-util36) weakremover(libkea-util52) weakremover(libkea-util6) weakremover(libkea-util7) weakremover(libkea1_4) weakremover(libkea1_5) weakremover(libkeccak-devel) weakremover(libkeccak1) weakremover(libkeduvocdocument-devel) weakremover(libkerfuffle16) weakremover(libkerfuffle17) weakremover(libkerfuffle18) weakremover(libkerfuffle19) weakremover(libkerfuffle20) weakremover(libkerfuffle21) weakremover(libkerfuffle22) weakremover(libkerfuffle23) weakremover(libkexiv2-devel) weakremover(libkeybinder-3_0-0) weakremover(libkeybinder0) weakremover(libkeyutils1) weakremover(libkf5kdegames6) weakremover(libkface) weakremover(libkface-devel) weakremover(libkfbapi-devel) weakremover(libkfbapi-lang) weakremover(libkfbapi1) weakremover(libkgapi) weakremover(libkgapi-devel) weakremover(libkgeomap) weakremover(libkgeomap-devel) weakremover(libkgeomap-lang) weakremover(libkim-api2) weakremover(libkioarchive-devel) weakremover(libkioarchive5) weakremover(libkipi-data) weakremover(libkipi-devel) weakremover(libkissfft-float131) weakremover(libkkc-devel) weakremover(libkkc2) weakremover(libkleo) weakremover(libkleo-devel) weakremover(libklfbackend-devel) weakremover(libklfbackend-qt3-3_2) weakremover(libklfbackend-qt3-devel) weakremover(libklfbackend3_2) weakremover(libklfbackend4) weakremover(libklftools-devel) weakremover(libklftools3_2) weakremover(libklftools4) weakremover(libklu-1_3_3) weakremover(libklu-1_3_8) weakremover(libklu-doc) weakremover(libklu1) weakremover(libkmahjongg) weakremover(libkmahjongg-devel) weakremover(libkmahjongg4) weakremover(libkmahjongg4-devel) weakremover(libkmahjongglib4) weakremover(libkmip-devel) weakremover(libkmip-tools) weakremover(libkmip0) weakremover(libkmod-devel) weakremover(libkmod2) weakremover(libkms-devel) weakremover(libkms1) weakremover(libknet1) weakremover(libknet1-compress-bzip2-plugin) weakremover(libknet1-compress-lz4-plugin) weakremover(libknet1-compress-lzma-plugin) weakremover(libknet1-compress-lzo2-plugin) weakremover(libknet1-compress-plugins-all) weakremover(libknet1-compress-zlib-plugin) weakremover(libknet1-compress-zstd-plugin) weakremover(libknet1-crypto-nss-plugin) weakremover(libknet1-crypto-openssl-plugin) weakremover(libknet1-crypto-plugins-all) weakremover(libknet1-devel) weakremover(libknet1-plugins-all) weakremover(libknot11) weakremover(libknot12) weakremover(libknot13) weakremover(libkokkos3) weakremover(libkokkos3_3_0) weakremover(libkolab-devel) weakremover(libkolab-qt5-devel) weakremover(libkolab0) weakremover(libkolab1) weakremover(libkolabxml-devel) weakremover(libkolabxml1) weakremover(libkomparediff2-5) weakremover(libkomparediff2-devel) weakremover(libkonkretcmpi0) weakremover(libkonq-devel) weakremover(libkonq5) weakremover(libkpathsea6) weakremover(libkpmcore11) weakremover(libkpmcore12) weakremover(libkpmcore4) weakremover(libkpmcore7) weakremover(libkqoauth-devel) weakremover(libkqoauth0) weakremover(libkrb5-26) weakremover(libkrun) weakremover(libkrun-devel) weakremover(libkrun0) weakremover(libkrun1) weakremover(libkrunfw) weakremover(libkrunfw-devel) weakremover(libkrunfw0) weakremover(libkrunfw3) weakremover(libksane-devel) weakremover(libksba-devel) weakremover(libksba8) weakremover(libkscreen) weakremover(libkscreen-devel) weakremover(libkscreen1) weakremover(libkscreen2-devel) weakremover(libkscreen2-plugin) weakremover(libksi-devel) weakremover(libksi1) weakremover(libksieve) weakremover(libksieve-devel) weakremover(libksieve5) weakremover(libksuseinstall-devel) weakremover(libksuseinstall1) weakremover(libksysguard5) weakremover(libksysguard5-devel) weakremover(libksysguard5-helper) weakremover(libksysguard5-imports) weakremover(libksysguard5-plugins) weakremover(libktoblzcheck1) weakremover(libktoblzcheck1-devel) weakremover(libktorrent-devel) weakremover(libktorrent6) weakremover(libktorrent6-lang) weakremover(libktpaccountskcminternal9) weakremover(libkvkontakte-devel) weakremover(libkvkontakte-lang) weakremover(libkvkontakte1) weakremover(libkwalletbackend5-5) weakremover(libkwin-xcb0) weakremover(libkwnn0) weakremover(libkyotocabinet-devel) weakremover(libkyotocabinet16) weakremover(liblab_gamut1) weakremover(liblal20) weakremover(liblalburst6) weakremover(liblalframe11) weakremover(liblalframe13) weakremover(liblalinference21) weakremover(liblalinference22) weakremover(liblalinference23) weakremover(liblalinspiral15) weakremover(liblalinspiral16) weakremover(liblalinspiral17) weakremover(liblalmetaio10) weakremover(liblalmetaio8) weakremover(liblalpulsar21) weakremover(liblalpulsar23) weakremover(liblalpulsar26) weakremover(liblalsimulation23) weakremover(liblalsimulation29) weakremover(liblalsimulation31) weakremover(liblalsupport14) weakremover(liblammps0) weakremover(liblangtag-devel) weakremover(liblangtag1) weakremover(liblapack3) weakremover(liblapacke3) weakremover(liblasem-0_4-4) weakremover(liblash1) weakremover(liblasso-devel) weakremover(liblasso3) weakremover(liblastfm-devel) weakremover(liblastfm-qt5-devel) weakremover(liblastfm1) weakremover(liblastfm5-1) weakremover(liblastfm_fingerprint5-1) weakremover(liblastlog2-0) weakremover(liblastlog2-1) weakremover(liblaszip3) weakremover(liblaszip6) weakremover(liblaszip8) weakremover(liblaszip_api3) weakremover(liblaszip_api8) weakremover(liblavfile-2_0-0) weakremover(liblavfile-2_2-0) weakremover(liblavjpeg-2_0-0) weakremover(liblavjpeg-2_2-0) weakremover(liblavplay-2_0-0) weakremover(liblavplay-2_2-0) weakremover(liblavrec-2_0-0) weakremover(liblavrec-2_2-0) weakremover(liblazy-devel) weakremover(liblazy1) weakremover(liblbxutil-devel) weakremover(liblbxutil1) weakremover(liblc3-1) weakremover(liblc3-devel) weakremover(liblc3-tools) weakremover(liblcf0) weakremover(liblcf0-devel) weakremover(liblcms-devel) weakremover(liblcms1) weakremover(liblcms2-2) weakremover(liblcms2-devel) weakremover(libldac2) weakremover(libldap-2_4-2) weakremover(libldap-2_5-0) weakremover(libldap2) weakremover(libldapcpp-devel) weakremover(libldapcpp0) weakremover(libldapcpp1) weakremover(libldastoolsal7) weakremover(libldb-devel) weakremover(libldb1) weakremover(libldb2) weakremover(libldc-jit91) weakremover(libldc-jit92) weakremover(libldc-jit93) weakremover(libldc-jit94) weakremover(libldc-jit96) weakremover(libldc-jit99) weakremover(libldl-2_2_1) weakremover(libldl-2_2_6) weakremover(libldl-doc) weakremover(libldl2) weakremover(libldm-1_0-0) weakremover(libldm-1_0-0-devel) weakremover(libldns1) weakremover(libldns2) weakremover(libldns3) weakremover(libleechcraft-util-db-qt5-0_6_75_1) weakremover(libleechcraft-util-db0_6_75_1) weakremover(libleechcraft-util-gui-qt5-0_6_75_1) weakremover(libleechcraft-util-gui0_6_75_1) weakremover(libleechcraft-util-models-qt5-0_6_75_1) weakremover(libleechcraft-util-models0_6_75_1) weakremover(libleechcraft-util-network-qt5-0_6_75_1) weakremover(libleechcraft-util-network0_6_75_1) weakremover(libleechcraft-util-qml-qt5-0_6_75_2) weakremover(libleechcraft-util-qml0_6_75_2) weakremover(libleechcraft-util-shortcuts-qt5-0_6_75) weakremover(libleechcraft-util-shortcuts0_6_75) weakremover(libleechcraft-util-sll-qt5-0_6_75_1) weakremover(libleechcraft-util-sll0_6_75_1) weakremover(libleechcraft-util-svcauth-qt5-0_6_75) weakremover(libleechcraft-util-svcauth0_6_75) weakremover(libleechcraft-util-sys-qt5-0_6_75_1) weakremover(libleechcraft-util-sys0_6_75_1) weakremover(libleechcraft-util-tags-qt5-0_6_75_1) weakremover(libleechcraft-util-tags0_6_75_1) weakremover(libleechcraft-util-threads-qt5-0_6_75) weakremover(libleechcraft-util-threads0_6_75) weakremover(libleechcraft-util-x11-0_6_75) weakremover(libleechcraft-util-x11-qt5-0_6_75) weakremover(libleechcraft-util-xdg-qt5-0_6_75) weakremover(libleechcraft-util-xdg0_6_75) weakremover(libleechcraft-util-xpc-qt5-0_6_75_2) weakremover(libleechcraft-util-xpc0_6_75_2) weakremover(libleechcraft-util-xsd-qt5-0_6_75) weakremover(libleechcraft-util-xsd0_6_75) weakremover(liblegion1) weakremover(liblensfun0) weakremover(liblensfun1) weakremover(liblept4) weakremover(liblept5) weakremover(libleptonica6) weakremover(libleveldb1) weakremover(liblevmar2) weakremover(liblhasa0) weakremover(liblibkremotecontrol1) weakremover(liblibmanette-0_2) weakremover(libliftoff-devel) weakremover(libliftoff0) weakremover(liblightdm-gobject-1-0) weakremover(liblightdm-qt-3-0) weakremover(liblightdm-qt5-3-0) weakremover(liblightgrep-devel) weakremover(liblightgrep0) weakremover(liblightlycommon5-5) weakremover(liblightmediascanner0) weakremover(liblightstep_tracer0) weakremover(liblilv-0-0) weakremover(liblilv-0-devel) weakremover(liblime0) weakremover(liblinbox0) weakremover(liblinebreak-devel) weakremover(liblinebreak2) weakremover(liblink-grammar5) weakremover(liblinphone++10) weakremover(liblinphone++9) weakremover(liblinphone-devel) weakremover(liblinphone10) weakremover(liblinphone9) weakremover(libliquid-devel) weakremover(liblirc0) weakremover(liblirc_client0) weakremover(liblirc_driver0) weakremover(liblittleb0) weakremover(libliveMedia102) weakremover(libliveMedia106) weakremover(libliveMedia107) weakremover(libliveMedia66) weakremover(libliveMedia78) weakremover(libliveMedia79) weakremover(libliveMedia81) weakremover(libliveMedia94) weakremover(libliveMedia97) weakremover(liblldb16) weakremover(liblldp_clif1) weakremover(liblldpctl4) weakremover(liblmdb-0_9_14) weakremover(liblmdb-0_9_16) weakremover(liblmdb-0_9_17) weakremover(liblmdb-0_9_22) weakremover(liblmdb-0_9_23) weakremover(liblmdb-0_9_24) weakremover(liblmdb-0_9_28) weakremover(liblmdb-0_9_29) weakremover(liblmdb-0_9_30) weakremover(liblmicclogger1) weakremover(liblms7002m-devel) weakremover(liblms7compact0) weakremover(liblnk-devel) weakremover(liblnk-tools) weakremover(liblnk1) weakremover(liblo-devel) weakremover(liblo10k1-0) weakremover(liblo7) weakremover(libloadpng-devel) weakremover(libloadpng44-devel) weakremover(libloadpng4_4) weakremover(liblockdev1) weakremover(liblockfile-devel) weakremover(liblockfile1) weakremover(liblodepng-r207) weakremover(liblodepng-r208) weakremover(liblodepng-r84) weakremover(liblog4c-devel) weakremover(liblog4c-doc) weakremover(liblog4c3) weakremover(liblog4cplus-1_1-5) weakremover(liblog4cplus-1_2-5) weakremover(liblog4cplus-2_0-3) weakremover(liblog4cpp5) weakremover(liblog4cxx-devel) weakremover(liblog4cxx10) weakremover(liblog4cxx11) weakremover(liblog4cxx13) weakremover(liblog4shib-devel) weakremover(liblog4shib1) weakremover(liblog4shib2) weakremover(liblogg-devel) weakremover(liblogg44-devel) weakremover(liblogg4_4) weakremover(liblogging-devel) weakremover(liblogging0) weakremover(liblognorm-devel) weakremover(liblognorm5) weakremover(libloki-devel) weakremover(libloki-doc) weakremover(libloki0_1_7) weakremover(libloudmouth-1-0) weakremover(liblouis-devel) weakremover(liblouis-doc) weakremover(liblouis-tools) weakremover(liblouis14) weakremover(liblouis17) weakremover(liblouis19) weakremover(liblouis20) weakremover(liblouis9) weakremover(liblpsolve55-0) weakremover(liblqr-1-0) weakremover(liblqr-devel) weakremover(liblrdf-devel) weakremover(liblrdf2) weakremover(liblrs-7_0-0) weakremover(liblrs-7_0a0) weakremover(liblrs1) weakremover(liblrsgmp-062) weakremover(liblrzip-devel) weakremover(liblrzip0) weakremover(liblsan0) weakremover(liblsan0-gcc10) weakremover(liblsan0-gcc11) weakremover(liblsan0-gcc12) weakremover(liblsan0-gcc6) weakremover(liblsan0-gcc7) weakremover(liblsan0-gcc8) weakremover(liblsan0-gcc9) weakremover(liblscp-devel) weakremover(liblscp6) weakremover(libltc-devel) weakremover(libltc11) weakremover(libltdl7) weakremover(liblttng-ctl0) weakremover(liblttng-ust-ctl4) weakremover(liblttng-ust-ctl5) weakremover(liblttng-ust-python-agent0) weakremover(liblttng-ust-python-agent1) weakremover(liblttng-ust0) weakremover(liblttng-ust1) weakremover(liblttoolbox3) weakremover(liblttoolbox3-3_5-1) weakremover(liblttoolbox3-3_6-1) weakremover(liblua5_1) weakremover(liblua5_1-5) weakremover(liblua5_2) weakremover(liblua5_3-5) weakremover(liblua5_4-5) weakremover(libluabind0_9_1) weakremover(libluajit-5_1-2) weakremover(liblucene++0) weakremover(libluksde-devel) weakremover(libluksde-tools) weakremover(libluksde1) weakremover(libluksmeta-devel) weakremover(libluksmeta0) weakremover(liblunar-calendar-3_0-1) weakremover(liblunar-date-3_0-1) weakremover(liblur3) weakremover(libluv-devel) weakremover(libluv1) weakremover(liblvm2app2_2) weakremover(liblvm2cmd2_02) weakremover(liblvm2cmd2_03) weakremover(liblwres160) weakremover(liblxc-devel) weakremover(liblxc1) weakremover(liblxpanel0) weakremover(liblxqt) weakremover(liblxqt-devel) weakremover(liblxqt-globalkeys-ui0) weakremover(liblxqt-globalkeys-ui1) weakremover(liblxqt-globalkeys0) weakremover(liblxqt-globalkeys1) weakremover(liblxqt0) weakremover(liblxqt1) weakremover(liblz1) weakremover(liblz4-1) weakremover(liblz4-1_4) weakremover(liblz4-devel) weakremover(liblzma5) weakremover(liblzo2-2) weakremover(libm17n0) weakremover(libm2cor18) weakremover(libm2iso18) weakremover(libm2log18) weakremover(libm2min18) weakremover(libm2pim18) weakremover(libm4ri-0_0_20140914) weakremover(libm4ri-0_0_20200125) weakremover(libm4ri-devel) weakremover(libm4rie-0_0_20140914) weakremover(libm4rie-0_0_20150908) weakremover(libm4rie-0_0_20200125) weakremover(libm4rie-devel) weakremover(libmaa-devel) weakremover(libmaa4) weakremover(libmad-devel) weakremover(libmad0) weakremover(libmaeparser1) weakremover(libmagic1) weakremover(libmaia-devel) weakremover(libmaia1) weakremover(libmailutils5) weakremover(libmailutils8) weakremover(libmailutils9) weakremover(libmal-devel) weakremover(libmal1) weakremover(libmalaga-devel) weakremover(libmalaga7) weakremover(libmalcontent-0-0) weakremover(libmalcontent-ui-0-0) weakremover(libmanette-0_2-0) weakremover(libmanette-devel) weakremover(libmapi1) weakremover(libmapidb-devel) weakremover(libmapidb1) weakremover(libmapserver2) weakremover(libmarblewidget-devel) weakremover(libmarblewidget-qt5-25) weakremover(libmarblewidget-qt5-27) weakremover(libmarblewidget-qt5-28) weakremover(libmarblewidget22) weakremover(libmarco-private0) weakremover(libmarco-private1) weakremover(libmarco-private2) weakremover(libmariadb-devel) weakremover(libmariadb2) weakremover(libmariadb3) weakremover(libmariadb_plugins) weakremover(libmariadbd-devel) weakremover(libmariadbd19) weakremover(libmariadbprivate) weakremover(libmarisa0) weakremover(libmarkdown-devel) weakremover(libmarkdown2) weakremover(libmarkdown3) weakremover(libmate-desktop-2-17) weakremover(libmate-menu2) weakremover(libmate-panel-applet-4-1) weakremover(libmate-sensors-applet-plugin0) weakremover(libmate-slab-devel) weakremover(libmate-slab0) weakremover(libmate-window-settings1) weakremover(libmatedict-devel) weakremover(libmatedict6) weakremover(libmatekbd-devel) weakremover(libmatekbd4) weakremover(libmatemixer-devel) weakremover(libmatemixer0) weakremover(libmateweather-devel) weakremover(libmateweather1) weakremover(libmatio-devel) weakremover(libmatio11) weakremover(libmatio2) weakremover(libmatio4) weakremover(libmatio9) weakremover(libmatroska-devel) weakremover(libmatroska6) weakremover(libmatroska7) weakremover(libmaxminddb-devel) weakremover(libmaxminddb0) weakremover(libmaya-calendar0) weakremover(libmbd) weakremover(libmbd-devel) weakremover(libmbd-mvapich2) weakremover(libmbd-mvapich2-devel) weakremover(libmbd-openmpi4) weakremover(libmbd-openmpi4-devel) weakremover(libmbedcrypto1) weakremover(libmbedcrypto14) weakremover(libmbedcrypto3) weakremover(libmbedcrypto5) weakremover(libmbedcrypto6) weakremover(libmbedcrypto7) weakremover(libmbedtls10) weakremover(libmbedtls12) weakremover(libmbedtls13) weakremover(libmbedtls14) weakremover(libmbedtls19) weakremover(libmbedtls9) weakremover(libmbedx509-0) weakremover(libmbedx509-1) weakremover(libmbedx509-5) weakremover(libmbim) weakremover(libmbim-devel) weakremover(libmbim-glib4) weakremover(libmbus) weakremover(libmbus-devel) weakremover(libmbus0) weakremover(libmca_common_dstore1) weakremover(libmcpp0) weakremover(libmcrypt) weakremover(libmcrypt-devel) weakremover(libmd-devel) weakremover(libmd0) weakremover(libmdb2) weakremover(libmdb3) weakremover(libmdbsql2) weakremover(libmdbsql3) weakremover(libmdmp-devel) weakremover(libmdmp-tools) weakremover(libmdmp1) weakremover(libmeanwhile1) weakremover(libmed-devel) weakremover(libmed-python) weakremover(libmed11) weakremover(libmedC11) weakremover(libmedfwrap11) weakremover(libmediaart-1_0-0) weakremover(libmediaart-1_0-devel) weakremover(libmediaart-2_0-0) weakremover(libmediaart-devel) weakremover(libmediacheck-devel) weakremover(libmediacheck4) weakremover(libmediacheck5) weakremover(libmediacheck6) weakremover(libmediainfo-devel) weakremover(libmediainfo0) weakremover(libmediastreamer10) weakremover(libmediastreamer11) weakremover(libmediastreamer_base10) weakremover(libmediastreamer_base6) weakremover(libmediastreamer_base7) weakremover(libmediastreamer_voip10) weakremover(libmediastreamer_voip6) weakremover(libmediastreamer_voip7) weakremover(libmediawiki-devel) weakremover(libmedimport0) weakremover(libmeep12) weakremover(libmeep13) weakremover(libmeep14) weakremover(libmeep27) weakremover(libmeep30) weakremover(libmeep31) weakremover(libmeep7) weakremover(libmeepgeom12) weakremover(libmemcache-devel) weakremover(libmemcache0) weakremover(libmemcached) weakremover(libmemcached-devel) weakremover(libmemcached11) weakremover(libmemcachedprotocol0) weakremover(libmemcachedutil2) weakremover(libmemkind0) weakremover(libmemphis-0_2-0) weakremover(libmenu-cache3) weakremover(libmesode-devel) weakremover(libmesode0) weakremover(libmetacity-private3) weakremover(libmetacity1) weakremover(libmetacity3) weakremover(libmetaio1) weakremover(libmetal-devel) weakremover(libmetal0) weakremover(libmetalink-devel) weakremover(libmetalink3) weakremover(libmetis-gnu-hpc) weakremover(libmetis5) weakremover(libmetis_5_1_0-gnu-hpc) weakremover(libmetrics-devel) weakremover(libmetrics0) weakremover(libmgl-fltk7_4_1) weakremover(libmgl-fltk7_5_0) weakremover(libmgl-fltk7_6_0) weakremover(libmgl-fltk8) weakremover(libmgl-glut7_4_1) weakremover(libmgl-glut7_5_0) weakremover(libmgl-glut7_6_0) weakremover(libmgl-glut8) weakremover(libmgl-mpi7_4_1) weakremover(libmgl-mpi7_5_0) weakremover(libmgl-mpi7_6_0) weakremover(libmgl-mpi8) weakremover(libmgl-qt4-7_4_1) weakremover(libmgl-qt5-7_4_1) weakremover(libmgl-qt5-7_5_0) weakremover(libmgl-qt5-7_6_0) weakremover(libmgl-qt5-8) weakremover(libmgl-wnd7_4_1) weakremover(libmgl-wnd7_5_0) weakremover(libmgl-wnd7_6_0) weakremover(libmgl-wnd8) weakremover(libmgl-wx7_4_1) weakremover(libmgl-wx7_5_0) weakremover(libmgl-wx7_6_0) weakremover(libmgl-wx8) weakremover(libmgl7_4_1) weakremover(libmgl7_5_0) weakremover(libmgl7_6_0) weakremover(libmgl8) weakremover(libmhash2) weakremover(libmicro) weakremover(libmicrodns-devel) weakremover(libmicrodns1) weakremover(libmicrohttpd-devel) weakremover(libmicrohttpd10) weakremover(libmicrohttpd11) weakremover(libmicrohttpd12) weakremover(libmicrospdy-devel) weakremover(libmicrospdy0) weakremover(libmidori-core0) weakremover(libmidori-core1) weakremover(libmikmod-devel) weakremover(libmikmod3) weakremover(libmilter1_0) weakremover(libmimalloc2) weakremover(libmimalloc2_0) weakremover(libmimetic-devel) weakremover(libmimetic0) weakremover(libminisat2) weakremover(libminiupnpc-devel) weakremover(libminiupnpc10) weakremover(libminiupnpc15) weakremover(libminiupnpc16) weakremover(libminiupnpc17) weakremover(libminizinc-devel) weakremover(libminizip1) weakremover(libmirage-3_0) weakremover(libmirage-3_1) weakremover(libmirage-3_2) weakremover(libmirage-devel) weakremover(libmirage10) weakremover(libmirage11) weakremover(libmirisdr-devel) weakremover(libmirisdr0) weakremover(libmisdn1) weakremover(libmission-control-plugins0) weakremover(libmjpegutils-2_0-0) weakremover(libmjpegutils-2_2-0) weakremover(libmjpegutils-devel) weakremover(libmlag_pb0) weakremover(libmlt++-7-7) weakremover(libmlt++-devel) weakremover(libmlt++3) weakremover(libmlt-7-7) weakremover(libmlt-devel) weakremover(libmlt6) weakremover(libmlt6-data) weakremover(libmlt6-devel) weakremover(libmlt6-modules) weakremover(libmlt7-module-qt6) weakremover(libmlt7-modules) weakremover(libmlx4-1) weakremover(libmlx5-1) weakremover(libmlx5-rdmav2) weakremover(libmm-devel) weakremover(libmm-glib0) weakremover(libmm14) weakremover(libmms-devel) weakremover(libmms0) weakremover(libmng-devel) weakremover(libmng1) weakremover(libmng2) weakremover(libmnl-devel) weakremover(libmnl0) weakremover(libmodbus-devel) weakremover(libmodbus5) weakremover(libmodbuspp-devel) weakremover(libmodbuspp1_0-0) weakremover(libmodglue1) weakremover(libmodi-devel) weakremover(libmodi-tools) weakremover(libmodi1) weakremover(libmodman-devel) weakremover(libmodman1) weakremover(libmodplug-devel) weakremover(libmodplug1) weakremover(libmodsecurity3) weakremover(libmodulemd-devel) weakremover(libmodulemd1) weakremover(libmodulemd1-devel) weakremover(libmodulemd2) weakremover(libmolsketch-qt5-1) weakremover(libmongoose-doc) weakremover(libmongoose2) weakremover(libmono-2_0-1) weakremover(libmono-2_0-devel) weakremover(libmono-profiler-gui-thread-check0) weakremover(libmono-profiler-gui-thread-check0-devel) weakremover(libmonosgen-2_0-1) weakremover(libmonosgen-2_0-devel) weakremover(libmopac7-1) weakremover(libmopac7-1-devel) weakremover(libmosquitto1) weakremover(libmosquittopp1) weakremover(libmount-devel) weakremover(libmount-devel-static) weakremover(libmount1) weakremover(libmousepad0) weakremover(libmovit6) weakremover(libmovit8) weakremover(libmowgli-2-0) weakremover(libmowgli-devel) weakremover(libmowgli2) weakremover(libmowgli2-devel) weakremover(libmozjs-102-0) weakremover(libmozjs-17_0) weakremover(libmozjs-24) weakremover(libmozjs-38) weakremover(libmozjs-52) weakremover(libmozjs-60) weakremover(libmozjs-68) weakremover(libmozjs-78-0) weakremover(libmozjs-91-0) weakremover(libmp3lame-devel) weakremover(libmp3lame0) weakremover(libmpath0) weakremover(libmpc3) weakremover(libmpcdec-devel) weakremover(libmpcdec5) weakremover(libmpcdec6) weakremover(libmpd-devel) weakremover(libmpd1) weakremover(libmpdclient-devel) weakremover(libmpdclient2) weakremover(libmpdec++3) weakremover(libmpdec3) weakremover(libmpeg2-0) weakremover(libmpeg2-devel) weakremover(libmpeg2convert0) weakremover(libmpeg2encpp-2_0-0) weakremover(libmpeg2encpp-2_2-0) weakremover(libmpfi0) weakremover(libmpfpx0) weakremover(libmpfr4) weakremover(libmpfr6) weakremover(libmpfrcx1) weakremover(libmpg123-0) weakremover(libmpir-devel) weakremover(libmpir23) weakremover(libmpirxx8) weakremover(libmplex2-2_0-0) weakremover(libmplex2-2_2-0) weakremover(libmpris-qt5-1) weakremover(libmpris-qt5-devel) weakremover(libmpv1) weakremover(libmpv2) weakremover(libmraa1) weakremover(libmraa2) weakremover(libmrss-devel) weakremover(libmrss0) weakremover(libmruby3) weakremover(libmruby3_0_0) weakremover(libmruby3_1_0) weakremover(libmruby_core3_0_0) weakremover(libmruby_core3_1_0) weakremover(libmsgpackc2) weakremover(libmsi0) weakremover(libmsiecf-devel) weakremover(libmsiecf-tools) weakremover(libmsiecf1) weakremover(libmsn-devel) weakremover(libmsn0_3) weakremover(libmspack-devel) weakremover(libmspack0) weakremover(libmspub-0_1-1) weakremover(libmspub-devel) weakremover(libmspub-tools) weakremover(libmsym-devel) weakremover(libmsym0_2) weakremover(libmt32emu-devel) weakremover(libmt32emu2) weakremover(libmtdev1) weakremover(libmthca-rdmav2) weakremover(libmtp-devel) weakremover(libmtp-udev) weakremover(libmtp9) weakremover(libmuffin0) weakremover(libmumps-gnu-mpich-hpc) weakremover(libmumps-gnu-mvapich2-hpc) weakremover(libmumps-gnu-openmpi1-hpc) weakremover(libmumps-gnu-openmpi2-hpc) weakremover(libmumps-gnu-openmpi3-hpc) weakremover(libmumps-gnu-openmpi4-hpc) weakremover(libmumps-ptscotch5-openmpi) weakremover(libmumps-ptscotch5-openmpi1) weakremover(libmumps-ptscotch5-openmpi1-compat) weakremover(libmumps-ptscotch5-openmpi2) weakremover(libmumps-ptscotch5-openmpi2-compat) weakremover(libmumps-ptscotch5_3_5-openmpi1) weakremover(libmumps-ptscotch5_3_5-openmpi1-compat) weakremover(libmumps-ptscotch5_3_5-openmpi2) weakremover(libmumps-ptscotch5_3_5-openmpi2-compat) weakremover(libmumps-ptscotch5_3_5-openmpi3) weakremover(libmumps-ptscotch5_3_5-openmpi3-compat) weakremover(libmumps-ptscotch5_3_5-openmpi4) weakremover(libmumps-ptscotch5_3_5-openmpi4-compat) weakremover(libmumps-scotch5) weakremover(libmumps-scotch5_3_5) weakremover(libmumps5) weakremover(libmumps5-mvapich2) weakremover(libmumps5-mvapich2-compat) weakremover(libmumps5-openmpi) weakremover(libmumps5-openmpi1) weakremover(libmumps5-openmpi1-compat) weakremover(libmumps5-openmpi2) weakremover(libmumps5-openmpi2-compat) weakremover(libmumps5-openmpi3) weakremover(libmumps5-openmpi3-compat) weakremover(libmumps5-openmpi4) weakremover(libmumps5-openmpi4-compat) weakremover(libmumps5_3_5) weakremover(libmumps5_3_5-mvapich2) weakremover(libmumps5_3_5-mvapich2-compat) weakremover(libmumps5_3_5-openmpi1) weakremover(libmumps5_3_5-openmpi1-compat) weakremover(libmumps5_3_5-openmpi2) weakremover(libmumps5_3_5-openmpi2-compat) weakremover(libmumps5_3_5-openmpi3) weakremover(libmumps5_3_5-openmpi3-compat) weakremover(libmumps5_3_5-openmpi4) weakremover(libmumps5_3_5-openmpi4-compat) weakremover(libmumps_5_1_2-gnu-mpich-hpc) weakremover(libmumps_5_1_2-gnu-mvapich2-hpc) weakremover(libmumps_5_1_2-gnu-openmpi1-hpc) weakremover(libmumps_5_1_2-gnu-openmpi2-hpc) weakremover(libmumps_5_1_2-gnu-openmpi3-hpc) weakremover(libmumps_5_2_1-gnu-mpich-hpc) weakremover(libmumps_5_2_1-gnu-mvapich2-hpc) weakremover(libmumps_5_2_1-gnu-openmpi1-hpc) weakremover(libmumps_5_2_1-gnu-openmpi2-hpc) weakremover(libmumps_5_2_1-gnu-openmpi3-hpc) weakremover(libmumps_5_2_1-gnu-openmpi4-hpc) weakremover(libmumps_5_3_5-gnu-mpich-hpc) weakremover(libmumps_5_3_5-gnu-mvapich2-hpc) weakremover(libmumps_5_3_5-gnu-openmpi1-hpc) weakremover(libmumps_5_3_5-gnu-openmpi2-hpc) weakremover(libmumps_5_3_5-gnu-openmpi3-hpc) weakremover(libmumps_5_3_5-gnu-openmpi4-hpc) weakremover(libmunge2) weakremover(libmunit0suse0) weakremover(libmuparser2_2_4) weakremover(libmuparser2_2_5) weakremover(libmuparser2_2_6) weakremover(libmuparser2_3_2) weakremover(libmuparser2_3_3) weakremover(libmuparser2_3_4) weakremover(libmuparserx4_0_11) weakremover(libmuparserx4_0_12) weakremover(libmuparserx4_0_8) weakremover(libmupen64plus-devel) weakremover(libmupen64plus2) weakremover(libmusicbrainz-devel) weakremover(libmusicbrainz3-6) weakremover(libmusicbrainz3-devel) weakremover(libmusicbrainz4) weakremover(libmusicbrainz4-3) weakremover(libmusicbrainz4-devel) weakremover(libmusicbrainz5-1) weakremover(libmusicbrainz5-devel) weakremover(libmutter-1-0) weakremover(libmutter-3-0) weakremover(libmutter-4-0) weakremover(libmutter-5-0) weakremover(libmutter-6-0) weakremover(libmutter-7-0) weakremover(libmutter-8-0) weakremover(libmutter0) weakremover(libmwaw-0_3-3) weakremover(libmwaw-devel) weakremover(libmwaw-tools) weakremover(libmxml1) weakremover(libmygpo-qt-devel) weakremover(libmygpo-qt1) weakremover(libmygpo-qt5-1) weakremover(libmygpo-qt5-devel) weakremover(libmypaint-1_3-0) weakremover(libmypaint-1_4-0) weakremover(libmypaint-1_5-1) weakremover(libmypaint-1_6-1) weakremover(libmypaint-devel) weakremover(libmypaint-gegl-devel) weakremover(libmypaint-gegl0) weakremover(libmypaint0) weakremover(libmysofa-devel) weakremover(libmysofa0) weakremover(libmysofa1) weakremover(libmysql56client18) weakremover(libmysql56client_r18) weakremover(libmysqlclient-devel) weakremover(libmysqlclient18) weakremover(libmysqlclient_r18) weakremover(libmysqlcppconn-devel) weakremover(libmysqlcppconn7) weakremover(libmysqlcppconn8-1) weakremover(libmysqlcppconn8-2) weakremover(libmysqlcppconn8-devel) weakremover(libmysqlcppconn9) weakremover(libmysqld-devel) weakremover(libmysqld18) weakremover(libmysqld19) weakremover(libmythes-1_2-0) weakremover(libnanomsg5) weakremover(libnanomsg5_1_0) weakremover(libnanomsg6) weakremover(libnautilus-extension1) weakremover(libnautilus-extension4) weakremover(libnauty-2_6_10) weakremover(libnauty-2_6_11) weakremover(libnauty-2_7_1) weakremover(libnauty-2_7_4) weakremover(libnauty-2_7_rc2) weakremover(libnauty-2_8_6) weakremover(libnbcompat-devel) weakremover(libnbcompat0) weakremover(libnbd) weakremover(libnbd-devel) weakremover(libnbd0) weakremover(libnblib0) weakremover(libnblib_gmx0) weakremover(libnco-4_9_7) weakremover(libnco-4_9_8) weakremover(libnco-5_0_0) weakremover(libnco-5_0_3) weakremover(libnco-5_0_6) weakremover(libnco-5_1_0) weakremover(libnco-5_1_3) weakremover(libnco-5_1_4) weakremover(libnco-devel) weakremover(libnco_c++-4_9_7) weakremover(libnco_c++-4_9_8) weakremover(libnco_c++-5_0_0) weakremover(libnco_c++-5_0_3) weakremover(libnco_c++-5_0_6) weakremover(libnco_c++-5_1_0) weakremover(libnco_c++-5_1_3) weakremover(libnco_c++-5_1_4) weakremover(libncurses5) weakremover(libncurses6) weakremover(libndctl-devel) weakremover(libndctl6) weakremover(libndp) weakremover(libndp-devel) weakremover(libndp0) weakremover(libndpi-devel) weakremover(libndpi2) weakremover(libndpi3) weakremover(libndpi4) weakremover(libndr-devel) weakremover(libndr-krb5pac-devel) weakremover(libndr-krb5pac0) weakremover(libndr-nbt-devel) weakremover(libndr-nbt0) weakremover(libndr-standard-devel) weakremover(libndr-standard0) weakremover(libndr0) weakremover(libndr1) weakremover(libndr2) weakremover(libneatvnc0) weakremover(libneko1) weakremover(libneko2) weakremover(libnemo-extension1) weakremover(libneon-devel) weakremover(libneon27) weakremover(libnes-rdmav2) weakremover(libnest2d-devel) weakremover(libnet-devel) weakremover(libnet-doc) weakremover(libnet9) weakremover(libnetapi-devel) weakremover(libnetapi0) weakremover(libnetcdf-cxx4-gnu-hpc) weakremover(libnetcdf-cxx4-gnu-hpc-devel) weakremover(libnetcdf-cxx4_4_3_0-gnu-hpc) weakremover(libnetcdf-cxx4_4_3_0-gnu-hpc-devel) weakremover(libnetcdf-cxx4_4_3_0-gnu-hpc-devel-static) weakremover(libnetcdf-cxx4_4_3_1-gnu-hpc) weakremover(libnetcdf-cxx4_4_3_1-gnu-hpc-devel) weakremover(libnetcdf-cxx4_4_3_1-gnu-hpc-devel-static) weakremover(libnetcdf-fortran-gnu-hpc) weakremover(libnetcdf-fortran-gnu-mpich-hpc) weakremover(libnetcdf-fortran-gnu-mvapich2-hpc) weakremover(libnetcdf-fortran-gnu-openmpi1-hpc) weakremover(libnetcdf-fortran-gnu-openmpi2-hpc) weakremover(libnetcdf-fortran-gnu-openmpi3-hpc) weakremover(libnetcdf-fortran-gnu-openmpi4-hpc) weakremover(libnetcdf-fortran_4_4_4-gnu-hpc) weakremover(libnetcdf-fortran_4_4_4-gnu-mpich-hpc) weakremover(libnetcdf-fortran_4_4_4-gnu-openmpi1-hpc) weakremover(libnetcdf-fortran_4_4_4-gnu-openmpi2-hpc) weakremover(libnetcdf-fortran_4_4_4-gnu-openmpi3-hpc) weakremover(libnetcdf-fortran_4_4_5-gnu-mpich-hpc) weakremover(libnetcdf-fortran_4_4_5-gnu-openmpi1-hpc) weakremover(libnetcdf-fortran_4_4_5-gnu-openmpi2-hpc) weakremover(libnetcdf-fortran_4_4_5-gnu-openmpi3-hpc) weakremover(libnetcdf-fortran_4_5_2-gnu-hpc) weakremover(libnetcdf-fortran_4_5_2-gnu-mpich-hpc) weakremover(libnetcdf-fortran_4_5_2-gnu-mvapich2-hpc) weakremover(libnetcdf-fortran_4_5_2-gnu-openmpi1-hpc) weakremover(libnetcdf-fortran_4_5_2-gnu-openmpi2-hpc) weakremover(libnetcdf-fortran_4_5_2-gnu-openmpi3-hpc) weakremover(libnetcdf-fortran_4_5_2-gnu-openmpi4-hpc) weakremover(libnetcdf-fortran_4_5_3-gnu-hpc) weakremover(libnetcdf-fortran_4_5_3-gnu-mpich-hpc) weakremover(libnetcdf-fortran_4_5_3-gnu-mvapich2-hpc) weakremover(libnetcdf-fortran_4_5_3-gnu-openmpi1-hpc) weakremover(libnetcdf-fortran_4_5_3-gnu-openmpi2-hpc) weakremover(libnetcdf-fortran_4_5_3-gnu-openmpi3-hpc) weakremover(libnetcdf-fortran_4_5_3-gnu-openmpi4-hpc) weakremover(libnetcdf-gnu-hpc) weakremover(libnetcdf-gnu-mpich-hpc) weakremover(libnetcdf-gnu-mvapich2-hpc) weakremover(libnetcdf-gnu-openmpi1-hpc) weakremover(libnetcdf-gnu-openmpi2-hpc) weakremover(libnetcdf-gnu-openmpi3-hpc) weakremover(libnetcdf-gnu-openmpi4-hpc) weakremover(libnetcdf13) weakremover(libnetcdf13-openmpi) weakremover(libnetcdf13-openmpi2) weakremover(libnetcdf15) weakremover(libnetcdf15-openmpi) weakremover(libnetcdf15-openmpi1) weakremover(libnetcdf15-openmpi2) weakremover(libnetcdf15-openmpi3) weakremover(libnetcdf15-openmpi4) weakremover(libnetcdf18) weakremover(libnetcdf18-openmpi1) weakremover(libnetcdf18-openmpi2) weakremover(libnetcdf18-openmpi3) weakremover(libnetcdf18-openmpi4) weakremover(libnetcdf19) weakremover(libnetcdf19-openmpi1) weakremover(libnetcdf19-openmpi2) weakremover(libnetcdf19-openmpi3) weakremover(libnetcdf19-openmpi4) weakremover(libnetcdf7) weakremover(libnetcdf_4_6_1-gnu-hpc) weakremover(libnetcdf_4_6_1-gnu-mpich-hpc) weakremover(libnetcdf_4_6_1-gnu-mvapich2-hpc) weakremover(libnetcdf_4_6_1-gnu-openmpi1-hpc) weakremover(libnetcdf_4_6_1-gnu-openmpi2-hpc) weakremover(libnetcdf_4_6_1-gnu-openmpi3-hpc) weakremover(libnetcdf_4_7_0-gnu-hpc) weakremover(libnetcdf_4_7_0-gnu-mpich-hpc) weakremover(libnetcdf_4_7_0-gnu-mvapich2-hpc) weakremover(libnetcdf_4_7_0-gnu-openmpi1-hpc) weakremover(libnetcdf_4_7_0-gnu-openmpi2-hpc) weakremover(libnetcdf_4_7_0-gnu-openmpi3-hpc) weakremover(libnetcdf_4_7_1-gnu-hpc) weakremover(libnetcdf_4_7_1-gnu-mpich-hpc) weakremover(libnetcdf_4_7_1-gnu-mvapich2-hpc) weakremover(libnetcdf_4_7_1-gnu-openmpi1-hpc) weakremover(libnetcdf_4_7_1-gnu-openmpi2-hpc) weakremover(libnetcdf_4_7_1-gnu-openmpi3-hpc) weakremover(libnetcdf_4_7_3-gnu-hpc) weakremover(libnetcdf_4_7_3-gnu-mpich-hpc) weakremover(libnetcdf_4_7_3-gnu-mvapich2-hpc) weakremover(libnetcdf_4_7_3-gnu-openmpi1-hpc) weakremover(libnetcdf_4_7_3-gnu-openmpi2-hpc) weakremover(libnetcdf_4_7_3-gnu-openmpi3-hpc) weakremover(libnetcdf_4_7_3-gnu-openmpi4-hpc) weakremover(libnetcdf_4_7_4-gnu-hpc) weakremover(libnetcdf_4_7_4-gnu-mpich-hpc) weakremover(libnetcdf_4_7_4-gnu-mvapich2-hpc) weakremover(libnetcdf_4_7_4-gnu-openmpi1-hpc) weakremover(libnetcdf_4_7_4-gnu-openmpi2-hpc) weakremover(libnetcdf_4_7_4-gnu-openmpi3-hpc) weakremover(libnetcdf_4_7_4-gnu-openmpi4-hpc) weakremover(libnetcdf_4_8_0-gnu-hpc) weakremover(libnetcdf_4_8_0-gnu-mpich-hpc) weakremover(libnetcdf_4_8_0-gnu-mvapich2-hpc) weakremover(libnetcdf_4_8_0-gnu-openmpi1-hpc) weakremover(libnetcdf_4_8_0-gnu-openmpi2-hpc) weakremover(libnetcdf_4_8_0-gnu-openmpi3-hpc) weakremover(libnetcdf_4_8_0-gnu-openmpi4-hpc) weakremover(libnetcdf_4_8_1-gnu-hpc) weakremover(libnetcdf_4_8_1-gnu-mpich-hpc) weakremover(libnetcdf_4_8_1-gnu-mvapich2-hpc) weakremover(libnetcdf_4_8_1-gnu-openmpi1-hpc) weakremover(libnetcdf_4_8_1-gnu-openmpi2-hpc) weakremover(libnetcdf_4_8_1-gnu-openmpi3-hpc) weakremover(libnetcdf_4_8_1-gnu-openmpi4-hpc) weakremover(libnetcdf_4_9_0-gnu-hpc) weakremover(libnetcdf_4_9_0-gnu-mpich-hpc) weakremover(libnetcdf_4_9_0-gnu-mvapich2-hpc) weakremover(libnetcdf_4_9_0-gnu-openmpi1-hpc) weakremover(libnetcdf_4_9_0-gnu-openmpi2-hpc) weakremover(libnetcdf_4_9_0-gnu-openmpi3-hpc) weakremover(libnetcdf_4_9_0-gnu-openmpi4-hpc) weakremover(libnetcdf_4_9_2-gnu-hpc) weakremover(libnetcdf_4_9_2-gnu-mpich-hpc) weakremover(libnetcdf_4_9_2-gnu-mvapich2-hpc) weakremover(libnetcdf_4_9_2-gnu-openmpi1-hpc) weakremover(libnetcdf_4_9_2-gnu-openmpi2-hpc) weakremover(libnetcdf_4_9_2-gnu-openmpi3-hpc) weakremover(libnetcdf_4_9_2-gnu-openmpi4-hpc) weakremover(libnetcdf_c++-devel) weakremover(libnetcdf_c++4) weakremover(libnetcdf_c++4-1) weakremover(libnetcdf_c++4-devel) weakremover(libnetcontrol-devel) weakremover(libnetcontrol0) weakremover(libnetfilter_acct-devel) weakremover(libnetfilter_acct1) weakremover(libnetfilter_conntrack-devel) weakremover(libnetfilter_conntrack3) weakremover(libnetfilter_cthelper-devel) weakremover(libnetfilter_cthelper0) weakremover(libnetfilter_cttimeout-devel) weakremover(libnetfilter_cttimeout1) weakremover(libnetfilter_log-devel) weakremover(libnetfilter_log1) weakremover(libnetfilter_queue-devel) weakremover(libnetfilter_queue1) weakremover(libnetlink-devel) weakremover(libnetpbm-devel) weakremover(libnetpbm11) weakremover(libnettle-devel) weakremover(libnettle4) weakremover(libnettle6) weakremover(libnettle7) weakremover(libnettle8) weakremover(libnewt0_52) weakremover(libnextcloudsync-devel) weakremover(libnextcloudsync0) weakremover(libnf2ff0) weakremover(libnfc-devel) weakremover(libnfc-tools) weakremover(libnfc5) weakremover(libnfc6) weakremover(libnfdump1_7_0) weakremover(libnfdump1_7_1) weakremover(libnfnetlink-devel) weakremover(libnfnetlink0) weakremover(libnfs-devel) weakremover(libnfs12) weakremover(libnfs13) weakremover(libnfs14) weakremover(libnfs8) weakremover(libnfsidmap-sss) weakremover(libnfsidmap1) weakremover(libnfsjunct0) weakremover(libnftables0) weakremover(libnftables1) weakremover(libnftnl-devel) weakremover(libnftnl11) weakremover(libnftnl4) weakremover(libnftnl7) weakremover(libnghttp2-14) weakremover(libnghttp2-devel) weakremover(libnghttp2_asio-devel) weakremover(libnghttp2_asio1) weakremover(libngspice-devel) weakremover(libngspice0) weakremover(libnice) weakremover(libnice-devel) weakremover(libnice10) weakremover(libnilfs0) weakremover(libnilfscleaner0) weakremover(libnilfsgc0) weakremover(libnis1) weakremover(libnitrokey-devel) weakremover(libnitrokey3) weakremover(libnjb) weakremover(libnjb-devel) weakremover(libnjb5) weakremover(libnk2-1) weakremover(libnk2-devel) weakremover(libnk2-tools) weakremover(libnl-1_1-devel) weakremover(libnl-tools) weakremover(libnl1) weakremover(libnl3-200) weakremover(libnl3-devel) weakremover(libnlopt0) weakremover(libnm-glib-vpn1) weakremover(libnm-glib4) weakremover(libnm-gtk-devel) weakremover(libnm-gtk0) weakremover(libnm-util2) weakremover(libnm0) weakremover(libnma-devel) weakremover(libnma-gtk4-0) weakremover(libnma-gtk4-devel) weakremover(libnma0) weakremover(libnng1) weakremover(libnoise-core0) weakremover(libnormaliz0) weakremover(libnormaliz3) weakremover(libnoson1) weakremover(libnoson2) weakremover(libnotcurses++1) weakremover(libnotcurses++2) weakremover(libnotcurses++3) weakremover(libnotcurses-core2) weakremover(libnotcurses-core3) weakremover(libnotcurses-ffi3) weakremover(libnotcurses1) weakremover(libnotcurses2) weakremover(libnotcurses3) weakremover(libnotify-devel) weakremover(libnotify-tools) weakremover(libnotify4) weakremover(libnotmuch4) weakremover(libnotmuch5) weakremover(libnova-0_15-0) weakremover(libnova-devel) weakremover(libnozzle1) weakremover(libnozzle1-devel) weakremover(libnpth0) weakremover(libnpupnp-devel) weakremover(libnpupnp4) weakremover(libnpupnp9) weakremover(libns1604) weakremover(libns1605) weakremover(libns1606) weakremover(libns1607) weakremover(libnscd-devel) weakremover(libnscd1) weakremover(libnsfdb-devel) weakremover(libnsfdb-tools) weakremover(libnsfdb1) weakremover(libnsl-devel) weakremover(libnsl2) weakremover(libnsl3) weakremover(libnss_filesd2) weakremover(libnss_nis2) weakremover(libnss_slurm2) weakremover(libnss_usrfiles2) weakremover(libnsssharedhelper0) weakremover(libnsync-devel) weakremover(libnsync1) weakremover(libnsync_cpp1) weakremover(libntfs-3g-devel) weakremover(libntfs-3g84) weakremover(libntfs-3g86) weakremover(libntfs-3g87) weakremover(libntfs-3g88) weakremover(libntfs-3g89) weakremover(libntirpc-devel) weakremover(libntirpc1_7) weakremover(libntirpc3_2) weakremover(libntirpc3_3) weakremover(libntk1) weakremover(libntl15) weakremover(libntl33) weakremover(libntl39) weakremover(libntl42) weakremover(libntl43) weakremover(libntl44) weakremover(libntlm-devel) weakremover(libntlm0) weakremover(libntpc1) weakremover(libnuma-devel) weakremover(libnuma1) weakremover(libnumbertext-1_0-0) weakremover(libnumbertext-data) weakremover(libnumbertext-devel) weakremover(libnumbertext-tools) weakremover(libnuspell3) weakremover(libnuspell4) weakremover(libnuspell5) weakremover(libnutclient0) weakremover(libnutclient2) weakremover(libnutclientstub1) weakremover(libnutscan1) weakremover(libnutscan2) weakremover(libnvidia-container-devel) weakremover(libnvidia-container-static) weakremover(libnvidia-container-tools) weakremover(libnvidia-container1) weakremover(libnvidia-egl-wayland-devel) weakremover(libnvidia-egl-wayland1) weakremover(libnvme-devel) weakremover(libnvme-mi1) weakremover(libnvme1) weakremover(libnxcl) weakremover(libnxcl-devel) weakremover(libnxcl1) weakremover(libnxml-devel) weakremover(libnxml0) weakremover(libo2scl0) weakremover(liboaml1) weakremover(liboaml_shared1) weakremover(liboath-devel) weakremover(liboath0) weakremover(liboauth-devel) weakremover(liboauth0) weakremover(libobby-0_4-1) weakremover(libobjc2) weakremover(libobjc2-devel) weakremover(libobjc4) weakremover(libobjc4-gcc10) weakremover(libobjc4-gcc11) weakremover(libobjc4-gcc12) weakremover(libobjc4-gcc6) weakremover(libobjc4-gcc7) weakremover(libobjc4-gcc8) weakremover(libobjc4-gcc9) weakremover(libobjc4_6) weakremover(libobrender32) weakremover(libobt2) weakremover(libocrdma-rdmav2) weakremover(libodbc2) weakremover(libode3) weakremover(libode8) weakremover(libodfgen-0_1-1) weakremover(libodfgen-devel) weakremover(libodp-122_0_0) weakremover(libodraw-devel) weakremover(libodraw-tools) weakremover(libodraw1) weakremover(libofa-devel) weakremover(libofa0) weakremover(libofetion-devel) weakremover(libofetion1) weakremover(libofx) weakremover(libofx-devel) weakremover(libofx6) weakremover(libofx7) weakremover(libogg-devel) weakremover(libogg0) weakremover(liboggkate1) weakremover(liboggz-devel) weakremover(liboggz2) weakremover(libohcount) weakremover(liboil) weakremover(liboil-0_3-0) weakremover(liboil-devel) weakremover(liboldX-devel) weakremover(liboldX6) weakremover(libolecf-devel) weakremover(libolecf-tools) weakremover(libolecf1) weakremover(libolm3) weakremover(libomalloc-4_3_1) weakremover(libomalloc-devel) weakremover(libomemo-c-devel) weakremover(libomemo-c0) weakremover(libomniORB4) weakremover(libomniORB4-3) weakremover(libomnithread4) weakremover(libomp10-devel) weakremover(libomp11-devel) weakremover(libomp12-devel) weakremover(libomp13-devel) weakremover(libomp14-devel) weakremover(libomp15-devel) weakremover(libomp16-devel) weakremover(libomp7-devel) weakremover(libomp8-devel) weakremover(libomp9-devel) weakremover(libonig2) weakremover(libonig4) weakremover(libonig5) weakremover(libonnx) weakremover(libonnx_proto) weakremover(libonnxifi_dummy) weakremover(liboop-devel) weakremover(liboop4) weakremover(libopagent1) weakremover(libopal-devel) weakremover(libopal3_10_10) weakremover(libopal3_18_8) weakremover(libopenCOLLADA-devel) weakremover(libopenCOLLADA-utils) weakremover(libopenEMS0) weakremover(libopen_amp0) weakremover(libopenal0) weakremover(libopenal1) weakremover(libopenbabel-devel) weakremover(libopenbabel4) weakremover(libopenbabel5) weakremover(libopenbabel7) weakremover(libopenblas-gnu-hpc) weakremover(libopenblas-gnu-hpc-devel) weakremover(libopenblas-pthreads-gnu-hpc) weakremover(libopenblas-pthreads-gnu-hpc-devel) weakremover(libopenblas-pthreads_0_2_20-gnu-hpc) weakremover(libopenblas-pthreads_0_2_20-gnu-hpc-devel) weakremover(libopenblas-pthreads_0_3_10-gnu-hpc) weakremover(libopenblas-pthreads_0_3_10-gnu-hpc-devel) weakremover(libopenblas-pthreads_0_3_12-gnu-hpc) weakremover(libopenblas-pthreads_0_3_12-gnu-hpc-devel) weakremover(libopenblas-pthreads_0_3_13-gnu-hpc) weakremover(libopenblas-pthreads_0_3_13-gnu-hpc-devel) weakremover(libopenblas-pthreads_0_3_14-gnu-hpc) weakremover(libopenblas-pthreads_0_3_14-gnu-hpc-devel) weakremover(libopenblas-pthreads_0_3_16-gnu-hpc) weakremover(libopenblas-pthreads_0_3_16-gnu-hpc-devel) weakremover(libopenblas-pthreads_0_3_17-gnu-hpc) weakremover(libopenblas-pthreads_0_3_17-gnu-hpc-devel) weakremover(libopenblas-pthreads_0_3_20-gnu-hpc) weakremover(libopenblas-pthreads_0_3_20-gnu-hpc-devel) weakremover(libopenblas-pthreads_0_3_21-gnu-hpc) weakremover(libopenblas-pthreads_0_3_21-gnu-hpc-devel) weakremover(libopenblas-pthreads_0_3_4-gnu-hpc) weakremover(libopenblas-pthreads_0_3_4-gnu-hpc-devel) weakremover(libopenblas-pthreads_0_3_5-gnu-hpc) weakremover(libopenblas-pthreads_0_3_5-gnu-hpc-devel) weakremover(libopenblas-pthreads_0_3_6-gnu-hpc) weakremover(libopenblas-pthreads_0_3_6-gnu-hpc-devel) weakremover(libopenblas-pthreads_0_3_7-gnu-hpc) weakremover(libopenblas-pthreads_0_3_7-gnu-hpc-devel) weakremover(libopenblas-pthreads_0_3_8-gnu-hpc) weakremover(libopenblas-pthreads_0_3_8-gnu-hpc-devel) weakremover(libopenblas-pthreads_0_3_9-gnu-hpc) weakremover(libopenblas-pthreads_0_3_9-gnu-hpc-devel) weakremover(libopenblas_0_2_20-gnu-hpc) weakremover(libopenblas_0_2_20-gnu-hpc-devel) weakremover(libopenblas_0_3_10-gnu-hpc) weakremover(libopenblas_0_3_10-gnu-hpc-devel) weakremover(libopenblas_0_3_12-gnu-hpc) weakremover(libopenblas_0_3_12-gnu-hpc-devel) weakremover(libopenblas_0_3_13-gnu-hpc) weakremover(libopenblas_0_3_13-gnu-hpc-devel) weakremover(libopenblas_0_3_14-gnu-hpc) weakremover(libopenblas_0_3_14-gnu-hpc-devel) weakremover(libopenblas_0_3_16-gnu-hpc) weakremover(libopenblas_0_3_16-gnu-hpc-devel) weakremover(libopenblas_0_3_17-gnu-hpc) weakremover(libopenblas_0_3_17-gnu-hpc-devel) weakremover(libopenblas_0_3_20-gnu-hpc) weakremover(libopenblas_0_3_20-gnu-hpc-devel) weakremover(libopenblas_0_3_21-gnu-hpc) weakremover(libopenblas_0_3_21-gnu-hpc-devel) weakremover(libopenblas_0_3_4-gnu-hpc) weakremover(libopenblas_0_3_4-gnu-hpc-devel) weakremover(libopenblas_0_3_5-gnu-hpc) weakremover(libopenblas_0_3_5-gnu-hpc-devel) weakremover(libopenblas_0_3_6-gnu-hpc) weakremover(libopenblas_0_3_6-gnu-hpc-devel) weakremover(libopenblas_0_3_7-gnu-hpc) weakremover(libopenblas_0_3_7-gnu-hpc-devel) weakremover(libopenblas_0_3_8-gnu-hpc) weakremover(libopenblas_0_3_8-gnu-hpc-devel) weakremover(libopenblas_0_3_9-gnu-hpc) weakremover(libopenblas_0_3_9-gnu-hpc-devel) weakremover(libopenblas_openmp-devel) weakremover(libopenblas_openmp0) weakremover(libopenblas_pthreads-devel) weakremover(libopenblas_pthreads0) weakremover(libopenblas_serial-devel) weakremover(libopenblas_serial0) weakremover(libopenblaso0) weakremover(libopenblasp0) weakremover(libopencascade-applicationframework7_7) weakremover(libopencascade-dataexchange7_7) weakremover(libopencascade-draw7_7) weakremover(libopencascade-foundationclasses7_7) weakremover(libopencascade-modelingalgorithms7_7) weakremover(libopencascade-modelingdata7_7) weakremover(libopencascade-visualization7_7) weakremover(libopencascade7) weakremover(libopencascade7_6) weakremover(libopencc1_1) weakremover(libopencc2) weakremover(libopencdk-devel) weakremover(libopencdk10) weakremover(libopencensus-cpp0) weakremover(libopenconnect5) weakremover(libopencore-amr-devel) weakremover(libopencore-amrnb0) weakremover(libopencore-amrwb0) weakremover(libopencsd0) weakremover(libopencsd1) weakremover(libopencsd_c_api0) weakremover(libopencsd_c_api1) weakremover(libopencsg1) weakremover(libopenct1) weakremover(libopencv-qt56_3) weakremover(libopencv3_1) weakremover(libopencv3_3) weakremover(libopencv3_4) weakremover(libopencv405) weakremover(libopencv406) weakremover(libopencv407) weakremover(libopencv4_1) weakremover(libopencv4_2) weakremover(libopencv4_3) weakremover(libopencv4_4) weakremover(libopencv4_5) weakremover(libopencv_aruco405) weakremover(libopencv_aruco406) weakremover(libopencv_aruco407) weakremover(libopencv_aruco4_5) weakremover(libopencv_face405) weakremover(libopencv_face406) weakremover(libopencv_face407) weakremover(libopencv_face4_5) weakremover(libopencv_gapi406) weakremover(libopencv_gapi407) weakremover(libopencv_highgui405) weakremover(libopencv_highgui406) weakremover(libopencv_highgui407) weakremover(libopencv_highgui4_5) weakremover(libopencv_imgcodecs405) weakremover(libopencv_imgcodecs406) weakremover(libopencv_imgcodecs407) weakremover(libopencv_imgcodecs4_5) weakremover(libopencv_objdetect405) weakremover(libopencv_objdetect406) weakremover(libopencv_objdetect407) weakremover(libopencv_objdetect4_5) weakremover(libopencv_optflow406) weakremover(libopencv_optflow407) weakremover(libopencv_superres405) weakremover(libopencv_superres406) weakremover(libopencv_superres407) weakremover(libopencv_superres4_5) weakremover(libopencv_videoio405) weakremover(libopencv_videoio406) weakremover(libopencv_videoio407) weakremover(libopencv_videoio4_5) weakremover(libopencv_videostab405) weakremover(libopencv_videostab406) weakremover(libopencv_videostab407) weakremover(libopencv_videostab4_5) weakremover(libopencv_ximgproc405) weakremover(libopencv_ximgproc406) weakremover(libopencv_ximgproc407) weakremover(libopencv_ximgproc4_5) weakremover(libopendkim10) weakremover(libopendkim11) weakremover(libopenhpi4) weakremover(libopeniscsiusr0) weakremover(libopeniscsiusr0_1_0) weakremover(libopeniscsiusr0_2_0) weakremover(libopenjp2-7) weakremover(libopenjpeg1) weakremover(libopenlibm2) weakremover(libopenlibm3) weakremover(libopenlibm4) weakremover(libopenmpi1-gnu-hpc) weakremover(libopenmpi2-gnu-hpc) weakremover(libopenmpi3-gnu-hpc) weakremover(libopenmpi4-gnu-hpc) weakremover(libopenmpi5-gnu-hpc) weakremover(libopenmpi_1_10_7-gnu-hpc) weakremover(libopenmpi_2_1_3-gnu-hpc) weakremover(libopenmpi_2_1_5-gnu-hpc) weakremover(libopenmpi_2_1_6-gnu-hpc) weakremover(libopenmpi_3_0_0-gnu-hpc) weakremover(libopenmpi_3_1_1-gnu-hpc) weakremover(libopenmpi_3_1_3-gnu-hpc) weakremover(libopenmpi_3_1_4-gnu-hpc) weakremover(libopenmpi_3_1_6-gnu-hpc) weakremover(libopenmpi_4_0_2-gnu-hpc) weakremover(libopenmpi_4_0_3-gnu-hpc) weakremover(libopenmpi_4_0_4-gnu-hpc) weakremover(libopenmpi_4_0_5-gnu-hpc) weakremover(libopenmpi_4_1_0-gnu-hpc) weakremover(libopenmpi_4_1_1-gnu-hpc) weakremover(libopenmpi_4_1_4-gnu-hpc) weakremover(libopenmpi_5_0_0-gnu-hpc) weakremover(libopenmpt-devel) weakremover(libopenmpt-modplug-devel) weakremover(libopenmpt0) weakremover(libopenmpt_modplug1) weakremover(libopenobex2) weakremover(libopenpgl0) weakremover(libopenraw-devel) weakremover(libopenraw1) weakremover(libopenraw9) weakremover(libopenscap25) weakremover(libopenscap8) weakremover(libopenscap_sce25) weakremover(libopenscap_sce8) weakremover(libopenshot-audio-devel) weakremover(libopenshot-audio3) weakremover(libopenshot-audio6) weakremover(libopenshot-audio7) weakremover(libopenshot-audio8) weakremover(libopenshot-audio9) weakremover(libopenshot-devel) weakremover(libopenshot14) weakremover(libopenshot16) weakremover(libopenshot17) weakremover(libopenshot19) weakremover(libopenshot20) weakremover(libopenshot21) weakremover(libopenshot23) weakremover(libopenshot24) weakremover(libopenslide-devel) weakremover(libopenslide0) weakremover(libopensm5) weakremover(libopensm8) weakremover(libopensm9) weakremover(libopenspecfun1) weakremover(libopenssl-1_0_0-devel) weakremover(libopenssl-1_1-devel) weakremover(libopenssl-3-devel) weakremover(libopenssl0_9_8) weakremover(libopenssl10) weakremover(libopenssl1_0_0) weakremover(libopenssl1_0_0-hmac) weakremover(libopenssl1_0_0-steam) weakremover(libopenssl1_1) weakremover(libopenssl1_1-hmac) weakremover(libopenssl3) weakremover(libopenssl3-hmac) weakremover(libopenssl_cbs_lib0) weakremover(libopensync) weakremover(libopensync-devel) weakremover(libopensync-tools) weakremover(libopentracing-cpp1) weakremover(libopenvas) weakremover(libopenvas-devel) weakremover(libopenvas_base6) weakremover(libopenvas_hg6) weakremover(libopenvas_misc6) weakremover(libopenvas_nasl6) weakremover(libopenvas_omp6) weakremover(libopenvas_wincmd-devel) weakremover(libopenvas_wincmd1) weakremover(libopenvas_wmiclient-devel) weakremover(libopenvas_wmiclient1) weakremover(libopenvdb6_1) weakremover(libopenvdb6_2) weakremover(libopenvdb7_0) weakremover(libopenvdb7_1) weakremover(libopenvdb8_1) weakremover(libopenvdb9_0) weakremover(libopenvswitch-2_10-0) weakremover(libopenvswitch-2_11-0) weakremover(libopenvswitch-2_12-0) weakremover(libopenvswitch-2_13-0) weakremover(libopenvswitch-2_14-0) weakremover(libopenvswitch-2_17-0) weakremover(libopenvswitch-2_8-0) weakremover(libopenvswitch-3_1-0) weakremover(liboping-devel) weakremover(liboping0) weakremover(libopts-devel) weakremover(libopts25) weakremover(libopus-devel) weakremover(libopus-devel-static) weakremover(libopus0) weakremover(libopusenc-devel) weakremover(libopusenc0) weakremover(libopusfile0) weakremover(liboqs-devel) weakremover(liboqs0) weakremover(liborc-0_4-0) weakremover(liborcania1_2) weakremover(liborcania2_0) weakremover(liborcania2_1) weakremover(liborcania2_2) weakremover(liborcania2_3) weakremover(liborcus-0_10-0) weakremover(liborcus-0_11-0) weakremover(liborcus-0_12-0) weakremover(liborcus-0_13-0) weakremover(liborcus-0_14-0) weakremover(liborcus-0_15-0) weakremover(liborcus-0_16-0) weakremover(liborcus-0_17-0) weakremover(liborcus-devel) weakremover(liborcus-python3) weakremover(liborcus-tools) weakremover(liborigin-devel) weakremover(liborigin-tools) weakremover(liborigin0) weakremover(liborigin2) weakremover(liborigin3) weakremover(libortools9) weakremover(libortools_flatzinc9) weakremover(libortp10) weakremover(libortp12) weakremover(libortp13) weakremover(libortp14) weakremover(libortp15) weakremover(libosdCPU3_4_0) weakremover(libosdCPU3_4_3) weakremover(libosdCPU3_4_4) weakremover(libosinfo) weakremover(libosinfo-1_0-0) weakremover(libosinfo-devel) weakremover(libosinfo-vala) weakremover(libosip2) weakremover(libosip2-12) weakremover(libosip2-15) weakremover(libosip2-devel) weakremover(liboslcomp1_10) weakremover(liboslcomp1_11) weakremover(liboslcomp1_12) weakremover(liboslcomp1_9) weakremover(liboslexec1_10) weakremover(liboslexec1_11) weakremover(liboslexec1_12) weakremover(liboslexec1_9) weakremover(liboslnoise1_10) weakremover(liboslnoise1_11) weakremover(liboslnoise1_12) weakremover(liboslnoise1_9) weakremover(liboslquery1_10) weakremover(liboslquery1_11) weakremover(liboslquery1_12) weakremover(liboslquery1_9) weakremover(libosmcomp3) weakremover(libosmcomp4) weakremover(libosmcomp5) weakremover(libosmgpsmap-1_0-0) weakremover(libosmgpsmap-1_0-1) weakremover(libosmgpsmap-devel) weakremover(libosmo-dsp-devel) weakremover(libosmo-e1d-devel) weakremover(libosmo-e1d0) weakremover(libosmo-e1d1) weakremover(libosmo-fl2k0) weakremover(libosmo-gsup-client-devel) weakremover(libosmo-gsup-client0) weakremover(libosmo-hnbap-devel) weakremover(libosmo-hnbap0) weakremover(libosmo-mgcp-client-devel) weakremover(libosmo-mgcp-client5) weakremover(libosmo-mgcp-client6) weakremover(libosmo-mgcp-client9) weakremover(libosmo-mgcp-devel) weakremover(libosmo-mslookup-devel) weakremover(libosmo-mslookup0) weakremover(libosmo-mtp-0_10_0) weakremover(libosmo-mtp-0_7_0) weakremover(libosmo-mtp-0_8_1) weakremover(libosmo-mtp-1_0_0) weakremover(libosmo-mtp-1_1_0) weakremover(libosmo-mtp-1_2_0) weakremover(libosmo-mtp-1_2_1) weakremover(libosmo-mtp-1_3_0) weakremover(libosmo-mtp-1_4_0) weakremover(libosmo-mtp-1_5_0) weakremover(libosmo-mtp-1_6_0) weakremover(libosmo-mtp-devel) weakremover(libosmo-octoi0) weakremover(libosmo-ranap-devel) weakremover(libosmo-ranap1) weakremover(libosmo-ranap2) weakremover(libosmo-ranap3) weakremover(libosmo-ranap5) weakremover(libosmo-rspro-devel) weakremover(libosmo-rspro1) weakremover(libosmo-rua-devel) weakremover(libosmo-rua0) weakremover(libosmo-sabp-devel) weakremover(libosmo-sabp0) weakremover(libosmo-sabp1) weakremover(libosmo-sccp-0_10_0) weakremover(libosmo-sccp-0_7_0) weakremover(libosmo-sccp-0_8_1) weakremover(libosmo-sccp-1_0_0) weakremover(libosmo-sccp-1_1_0) weakremover(libosmo-sccp-1_2_0) weakremover(libosmo-sccp-1_2_1) weakremover(libosmo-sccp-1_3_0) weakremover(libosmo-sccp-1_4_0) weakremover(libosmo-sccp-1_5_0) weakremover(libosmo-sccp-1_6_0) weakremover(libosmo-sccp-devel) weakremover(libosmo-sigtran-devel) weakremover(libosmo-sigtran0) weakremover(libosmo-sigtran3) weakremover(libosmo-sigtran5) weakremover(libosmo-sigtran7) weakremover(libosmo-simtrace2-0) weakremover(libosmo-simtrace2-1) weakremover(libosmo-simtrace2-devel) weakremover(libosmo-xua-0_10_0) weakremover(libosmo-xua-0_7_0) weakremover(libosmo-xua-0_8_1) weakremover(libosmo-xua-1_0_0) weakremover(libosmo-xua-1_1_0) weakremover(libosmo-xua-1_2_0) weakremover(libosmo-xua-1_2_1) weakremover(libosmo-xua-1_3_0) weakremover(libosmo-xua-1_4_0) weakremover(libosmo-xua-1_5_0) weakremover(libosmo-xua-1_6_0) weakremover(libosmo-xua-devel) weakremover(libosmoabis-devel) weakremover(libosmoabis10) weakremover(libosmoabis4) weakremover(libosmoabis5) weakremover(libosmoabis6) weakremover(libosmoabis9) weakremover(libosmocodec-devel) weakremover(libosmocodec0) weakremover(libosmocoding-devel) weakremover(libosmocoding0) weakremover(libosmocore-devel) weakremover(libosmocore-tools) weakremover(libosmocore11) weakremover(libosmocore12) weakremover(libosmocore16) weakremover(libosmocore17) weakremover(libosmocore18) weakremover(libosmocore19) weakremover(libosmocore6) weakremover(libosmocore9) weakremover(libosmoctrl-devel) weakremover(libosmoctrl0) weakremover(libosmodsp0) weakremover(libosmogb-devel) weakremover(libosmogb11) weakremover(libosmogb12) weakremover(libosmogb14) weakremover(libosmogb4) weakremover(libosmogb5) weakremover(libosmogb6) weakremover(libosmogb9) weakremover(libosmogsm-devel) weakremover(libosmogsm10) weakremover(libosmogsm11) weakremover(libosmogsm13) weakremover(libosmogsm15) weakremover(libosmogsm16) weakremover(libosmogsm17) weakremover(libosmogsm18) weakremover(libosmogsm5) weakremover(libosmogsm8) weakremover(libosmonetif-devel) weakremover(libosmonetif3) weakremover(libosmonetif4) weakremover(libosmonetif6) weakremover(libosmonetif8) weakremover(libosmosdr0) weakremover(libosmosim-devel) weakremover(libosmosim0) weakremover(libosmosim2) weakremover(libosmotrau-devel) weakremover(libosmotrau0) weakremover(libosmotrau1) weakremover(libosmotrau2) weakremover(libosmousb-devel) weakremover(libosmousb0) weakremover(libosmovty-devel) weakremover(libosmovty2) weakremover(libosmovty4) weakremover(libosmovty9) weakremover(libosmvendor4) weakremover(libosmvendor5) weakremover(libospf0) weakremover(libospfapiclient0) weakremover(libossim1) weakremover(libossp-uuid++16) weakremover(libossp-uuid16) weakremover(libossp-uuid_dce16) weakremover(libostree) weakremover(libostree-1-1) weakremover(libostree-devel) weakremover(libostree-grub2) weakremover(libotb7) weakremover(libotf) weakremover(libotf-devel) weakremover(libotf0) weakremover(libotf1) weakremover(libotp0) weakremover(libotr-devel) weakremover(libotr-tools) weakremover(libotr5) weakremover(libout123-0) weakremover(libovf-glib-devel) weakremover(libovn-20_03-0) weakremover(libovn-20_06-0) weakremover(libovn-21_09-0) weakremover(libovn-23_03-0) weakremover(libowncloudsync-devel) weakremover(libowncloudsync0) weakremover(liboyranos-alpha-devel) weakremover(liboyranos-alpha-devel-doc) weakremover(liboyranos-devel) weakremover(liboyranos0) weakremover(liboyranos0-cups) weakremover(liboyranos0-lraw) weakremover(liboyranos0-monitor) weakremover(liboyranos0-sane) weakremover(libp11-2) weakremover(libp11-3) weakremover(libp11-devel) weakremover(libp11-kit0) weakremover(libp8-platform2) weakremover(libp8-platform2_0) weakremover(libpacemaker-devel) weakremover(libpacemaker3) weakremover(libpackagekit-glib2-18) weakremover(libpackagekit-glib2-devel) weakremover(libpackagekitqt4-0) weakremover(libpackagekitqt5-0) weakremover(libpackagekitqt5-1) weakremover(libpackagekitqt6-1) weakremover(libpagemaker-0_0-0) weakremover(libpagemaker-devel) weakremover(libpagemaker-tools) weakremover(libpaho-mqtt-devel) weakremover(libpaho-mqtt1) weakremover(libpainter0) weakremover(libpamtest-devel) weakremover(libpamtest-devel-doc) weakremover(libpamtest0) weakremover(libpanel-devel) weakremover(libpanel1-1) weakremover(libpango-1_0-0) weakremover(libpangomm-1_4-1) weakremover(libpangomm-2_42-1) weakremover(libpangomm-2_44-1) weakremover(libpangomm-2_48-1) weakremover(libpangox-1_0-0) weakremover(libpano-devel) weakremover(libpano-utils) weakremover(libpano13-3) weakremover(libpantheon-files-core-devel) weakremover(libpantheon-files-core0) weakremover(libpantheon-files-widgets-devel) weakremover(libpantheon-files-widgets0) weakremover(libpaper) weakremover(libpaper-devel) weakremover(libpaper-tools) weakremover(libpaper-utils) weakremover(libpaper1) weakremover(libpaper2) weakremover(libpapi) weakremover(libpapi-hpc) weakremover(libpapi_5_5_1-hpc) weakremover(libpapi_5_6_0-hpc) weakremover(libpapi_5_7_0-hpc) weakremover(libpapi_6_0_0-hpc) weakremover(libpapi_6_0_0_1-hpc) weakremover(libpapi_7_0_0-hpc) weakremover(libparanoia1_0) weakremover(libpari-gmp-tls6) weakremover(libpari-gmp-tls7) weakremover(libpari-gmp-tls8) weakremover(libpari-gmp4) weakremover(libpari-gmp5) weakremover(libpari-gmp6) weakremover(libparlatype-devel) weakremover(libparlatype1) weakremover(libparlatype2) weakremover(libparlatype3) weakremover(libparlatype5) weakremover(libparpack2-openmpi) weakremover(libparpack2-openmpi1) weakremover(libparpack2-openmpi2) weakremover(libparpack2-openmpi3) weakremover(libparpack2-openmpi4) weakremover(libparquet1100) weakremover(libparserutils-devel) weakremover(libparserutils-doc) weakremover(libparserutils0) weakremover(libparted-fs-resize0) weakremover(libparted0) weakremover(libparted2) weakremover(libpartio1) weakremover(libpasswdqc0) weakremover(libpath_utils-devel) weakremover(libpath_utils1) weakremover(libpathplan4) weakremover(libpcap-devel) weakremover(libpcap-devel-static) weakremover(libpcap1) weakremover(libpcaudio0) weakremover(libpcd-devel) weakremover(libpcd2) weakremover(libpci3) weakremover(libpciaccess-devel) weakremover(libpciaccess0) weakremover(libpcp-devel) weakremover(libpcp3) weakremover(libpcp_gui2) weakremover(libpcp_import1) weakremover(libpcp_mmv1) weakremover(libpcp_trace2) weakremover(libpcp_web1) weakremover(libpcre1) weakremover(libpcre16-0) weakremover(libpcre2-16-0) weakremover(libpcre2-32-0) weakremover(libpcre2-8-0) weakremover(libpcre2-posix1) weakremover(libpcre2-posix2) weakremover(libpcre2-posix3) weakremover(libpcrecpp0) weakremover(libpcreposix0) weakremover(libpcsclite1) weakremover(libpcscspy0) weakremover(libpeas-1_0-0) weakremover(libpeas-demo) weakremover(libpeas-devel) weakremover(libpeas-gtk-1_0-0) weakremover(libpeas-loader-python) weakremover(libpeas-loader-python3) weakremover(libpeasd-3-0) weakremover(libpegclient1) weakremover(libpegcommon1) weakremover(libpegexportserver1) weakremover(libpeglistener1) weakremover(libperseus-sdr-devel) weakremover(libperseus-sdr-udev) weakremover(libperseus-sdr0) weakremover(libpetsc-gnu-mpich-hpc) weakremover(libpetsc-gnu-mvapich2-hpc) weakremover(libpetsc-gnu-openmpi1-hpc) weakremover(libpetsc-gnu-openmpi2-hpc) weakremover(libpetsc-gnu-openmpi3-hpc) weakremover(libpetsc-gnu-openmpi4-hpc) weakremover(libpetsc3) weakremover(libpetsc3-openmpi) weakremover(libpetsc3-openmpi1) weakremover(libpetsc3-openmpi2) weakremover(libpetsc3-openmpi3) weakremover(libpetsc3-openmpi4) weakremover(libpetsc3_14) weakremover(libpetsc3_14-openmpi2) weakremover(libpetsc3_14-openmpi3) weakremover(libpetsc3_14-openmpi4) weakremover(libpetsc3_18) weakremover(libpetsc3_18-openmpi2) weakremover(libpetsc3_18-openmpi3) weakremover(libpetsc3_18-openmpi4) weakremover(libpetsc_3_11_3-gnu-mpich-hpc) weakremover(libpetsc_3_11_3-gnu-mvapich2-hpc) weakremover(libpetsc_3_11_3-gnu-openmpi1-hpc) weakremover(libpetsc_3_11_3-gnu-openmpi2-hpc) weakremover(libpetsc_3_11_3-gnu-openmpi3-hpc) weakremover(libpetsc_3_12_2-gnu-mpich-hpc) weakremover(libpetsc_3_12_2-gnu-mvapich2-hpc) weakremover(libpetsc_3_12_2-gnu-openmpi1-hpc) weakremover(libpetsc_3_12_2-gnu-openmpi2-hpc) weakremover(libpetsc_3_12_2-gnu-openmpi3-hpc) weakremover(libpetsc_3_14_1-gnu-mpich-hpc) weakremover(libpetsc_3_14_1-gnu-mvapich2-hpc) weakremover(libpetsc_3_14_1-gnu-openmpi1-hpc) weakremover(libpetsc_3_14_1-gnu-openmpi2-hpc) weakremover(libpetsc_3_14_1-gnu-openmpi3-hpc) weakremover(libpetsc_3_14_1-gnu-openmpi4-hpc) weakremover(libpetsc_3_14_4-gnu-mpich-hpc) weakremover(libpetsc_3_14_4-gnu-mvapich2-hpc) weakremover(libpetsc_3_14_4-gnu-openmpi1-hpc) weakremover(libpetsc_3_14_4-gnu-openmpi2-hpc) weakremover(libpetsc_3_14_4-gnu-openmpi3-hpc) weakremover(libpetsc_3_14_4-gnu-openmpi4-hpc) weakremover(libpetsc_3_14_5-gnu-mpich-hpc) weakremover(libpetsc_3_14_5-gnu-mvapich2-hpc) weakremover(libpetsc_3_14_5-gnu-openmpi1-hpc) weakremover(libpetsc_3_14_5-gnu-openmpi2-hpc) weakremover(libpetsc_3_14_5-gnu-openmpi3-hpc) weakremover(libpetsc_3_14_5-gnu-openmpi4-hpc) weakremover(libpetsc_3_18_4-gnu-mpich-hpc) weakremover(libpetsc_3_18_4-gnu-mvapich2-hpc) weakremover(libpetsc_3_18_4-gnu-openmpi1-hpc) weakremover(libpetsc_3_18_4-gnu-openmpi2-hpc) weakremover(libpetsc_3_18_4-gnu-openmpi3-hpc) weakremover(libpetsc_3_18_4-gnu-openmpi4-hpc) weakremover(libpetsc_3_18_5-gnu-mpich-hpc) weakremover(libpetsc_3_18_5-gnu-mvapich2-hpc) weakremover(libpetsc_3_18_5-gnu-openmpi1-hpc) weakremover(libpetsc_3_18_5-gnu-openmpi2-hpc) weakremover(libpetsc_3_18_5-gnu-openmpi3-hpc) weakremover(libpetsc_3_18_5-gnu-openmpi4-hpc) weakremover(libpetsc_3_8_3-gnu-mpich-hpc) weakremover(libpetsc_3_8_3-gnu-mvapich2-hpc) weakremover(libpetsc_3_8_3-gnu-openmpi1-hpc) weakremover(libpetsc_3_8_3-gnu-openmpi2-hpc) weakremover(libpetsc_3_8_3-gnu-openmpi3-hpc) weakremover(libpff-devel) weakremover(libpff-tools) weakremover(libpff1) weakremover(libpfm-devel) weakremover(libpfm-devel-static) weakremover(libpfm4) weakremover(libpfs2) weakremover(libpgeasy) weakremover(libpgeasy-devel) weakremover(libpgeasy3) weakremover(libpgf-devel) weakremover(libpgf6) weakremover(libpgf7) weakremover(libpgm-5_2-0) weakremover(libphdi-devel) weakremover(libphdi-tools) weakremover(libphdi1) weakremover(libphobos2-ldc102) weakremover(libphobos2-ldc83) weakremover(libphobos2-ldc85) weakremover(libphobos2-ldc86) weakremover(libphobos2-ldc91) weakremover(libphobos2-ldc92) weakremover(libphobos2-ldc93) weakremover(libphobos2-ldc94) weakremover(libphobos2-ldc96) weakremover(libphobos2-ldc99) weakremover(libphodav-2_0-0) weakremover(libphodav-3_0-0) weakremover(libphonenumber-devel) weakremover(libphonenumber8) weakremover(libphonon4) weakremover(libphonon4qt5) weakremover(libphysfs-devel) weakremover(libphysfs1) weakremover(libpihwm0) weakremover(libpinyin-data) weakremover(libpinyin-devel) weakremover(libpinyin-tools) weakremover(libpinyin10) weakremover(libpinyin13) weakremover(libpinyin15) weakremover(libpinyin9) weakremover(libpipeline-devel) weakremover(libpipeline1) weakremover(libpipewire-0_2-1) weakremover(libpipewire-0_3-0) weakremover(libpisock-devel) weakremover(libpisock9) weakremover(libpisync-devel) weakremover(libpisync1) weakremover(libpixman-1-0) weakremover(libpixman-1-0-devel) weakremover(libpkcs11-helper1) weakremover(libpkgconf-devel) weakremover(libpkgconf3) weakremover(libplacebo-devel) weakremover(libplacebo104) weakremover(libplacebo120) weakremover(libplacebo157) weakremover(libplacebo18) weakremover(libplacebo192) weakremover(libplacebo208) weakremover(libplacebo229) weakremover(libplacebo264) weakremover(libplacebo29) weakremover(libplacebo43) weakremover(libplacebo5) weakremover(libplacebo7) weakremover(libplacebo72) weakremover(libplanarity0) weakremover(libplank1) weakremover(libplasma1100) weakremover(libplatform-devel) weakremover(libplatform1_0) weakremover(libplayerctl-1_0-0) weakremover(libplayerctl2) weakremover(libplib0) weakremover(libplist++-2_0-3) weakremover(libplist++-2_0-devel) weakremover(libplist++-devel) weakremover(libplist++3) weakremover(libplist-2_0-3) weakremover(libplist-2_0-devel) weakremover(libplist-devel) weakremover(libplist3) weakremover(libplot2) weakremover(libplotter2) weakremover(libplplot15) weakremover(libplplot16) weakremover(libplplot17) weakremover(libplplotada2) weakremover(libplplotada4) weakremover(libplplotcxx13) weakremover(libplplotcxx14) weakremover(libplplotcxx15) weakremover(libplplotfortran0) weakremover(libplplotqt2) weakremover(libplplotwxwidgets1) weakremover(libply-boot-client4) weakremover(libply-boot-client5) weakremover(libply-splash-core4) weakremover(libply-splash-core5) weakremover(libply-splash-graphics4) weakremover(libply-splash-graphics5) weakremover(libply4) weakremover(libply5) weakremover(libpmem-devel) weakremover(libpmem1) weakremover(libpmem2-1) weakremover(libpmem2-devel) weakremover(libpmemblk-devel) weakremover(libpmemblk1) weakremover(libpmemkv1) weakremover(libpmemkv_json_config1) weakremover(libpmemlog-devel) weakremover(libpmemlog1) weakremover(libpmemobj-cpp-devel) weakremover(libpmemobj-cpp-devel-doc) weakremover(libpmemobj-devel) weakremover(libpmemobj1) weakremover(libpmempool-devel) weakremover(libpmempool1) weakremover(libpmi0) weakremover(libpmix2) weakremover(libpnetcdf-gnu-mpich-hpc) weakremover(libpnetcdf-gnu-mvapich2-hpc) weakremover(libpnetcdf-gnu-openmpi2-hpc) weakremover(libpnetcdf-gnu-openmpi3-hpc) weakremover(libpnetcdf-gnu-openmpi4-hpc) weakremover(libpnetcdf1-mvapich2) weakremover(libpnetcdf1-openmpi) weakremover(libpnetcdf1-openmpi1) weakremover(libpnetcdf1-openmpi2) weakremover(libpnetcdf1-openmpi3) weakremover(libpnetcdf4-mpich) weakremover(libpnetcdf4-mvapich2) weakremover(libpnetcdf4-openmpi1) weakremover(libpnetcdf4-openmpi2) weakremover(libpnetcdf4-openmpi3) weakremover(libpnetcdf4-openmpi4) weakremover(libpnetcdf_1_12_1-gnu-mpich-hpc) weakremover(libpnetcdf_1_12_1-gnu-mvapich2-hpc) weakremover(libpnetcdf_1_12_1-gnu-openmpi2-hpc) weakremover(libpnetcdf_1_12_1-gnu-openmpi3-hpc) weakremover(libpnetcdf_1_12_1-gnu-openmpi4-hpc) weakremover(libpnetcdf_1_12_2-gnu-mpich-hpc) weakremover(libpnetcdf_1_12_2-gnu-mvapich2-hpc) weakremover(libpnetcdf_1_12_2-gnu-openmpi2-hpc) weakremover(libpnetcdf_1_12_2-gnu-openmpi3-hpc) weakremover(libpnetcdf_1_12_2-gnu-openmpi4-hpc) weakremover(libpnetcdf_1_12_3-gnu-mpich-hpc) weakremover(libpnetcdf_1_12_3-gnu-mvapich2-hpc) weakremover(libpnetcdf_1_12_3-gnu-openmpi2-hpc) weakremover(libpnetcdf_1_12_3-gnu-openmpi3-hpc) weakremover(libpnetcdf_1_12_3-gnu-openmpi4-hpc) weakremover(libpng12-0) weakremover(libpng12-compat-devel) weakremover(libpng12-devel) weakremover(libpng15-15) weakremover(libpng16-16) weakremover(libpng16-compat-devel) weakremover(libpng16-devel) weakremover(libpng16-tools) weakremover(libpnglite0) weakremover(libpocketsphinx1) weakremover(libpocketsphinx3) weakremover(libpocl2) weakremover(libpodofo-devel) weakremover(libpodofo0_9_3) weakremover(libpodofo0_9_5) weakremover(libpodofo0_9_6) weakremover(libpodofo0_9_7) weakremover(libpodofo0_9_8) weakremover(libpoke0) weakremover(libpolkit-agent-1-0) weakremover(libpolkit-gobject-1-0) weakremover(libpolkit-gtk-mate-1-0) weakremover(libpolkit-qt-1-1) weakremover(libpolkit-qt-1-devel) weakremover(libpolkit-qt5-1-1) weakremover(libpolkit-qt5-1-devel) weakremover(libpolkit0) weakremover(libpolyclipping-devel) weakremover(libpolyclipping22) weakremover(libpolylibgmp8) weakremover(libpolymake4_7) weakremover(libpolymake4_9) weakremover(libpolys-4_3_1) weakremover(libpolys-devel) weakremover(libpoppler-cpp0) weakremover(libpoppler-devel) weakremover(libpoppler-glib-devel) weakremover(libpoppler-glib8) weakremover(libpoppler-qt4-4) weakremover(libpoppler-qt4-devel) weakremover(libpoppler-qt5-1) weakremover(libpoppler-qt5-devel) weakremover(libpoppler-qt6-1) weakremover(libpoppler-qt6-2) weakremover(libpoppler-qt6-3) weakremover(libpoppler-qt6-devel) weakremover(libpoppler100) weakremover(libpoppler101) weakremover(libpoppler103) weakremover(libpoppler105) weakremover(libpoppler106) weakremover(libpoppler107) weakremover(libpoppler108) weakremover(libpoppler109) weakremover(libpoppler110) weakremover(libpoppler111) weakremover(libpoppler112) weakremover(libpoppler114) weakremover(libpoppler116) weakremover(libpoppler117) weakremover(libpoppler119) weakremover(libpoppler120) weakremover(libpoppler121) weakremover(libpoppler122) weakremover(libpoppler123) weakremover(libpoppler124) weakremover(libpoppler125) weakremover(libpoppler126) weakremover(libpoppler127) weakremover(libpoppler47) weakremover(libpoppler48) weakremover(libpoppler49) weakremover(libpoppler50) weakremover(libpoppler51) weakremover(libpoppler52) weakremover(libpoppler53) weakremover(libpoppler54) weakremover(libpoppler55) weakremover(libpoppler56) weakremover(libpoppler57) weakremover(libpoppler58) weakremover(libpoppler59) weakremover(libpoppler60) weakremover(libpoppler61) weakremover(libpoppler62) weakremover(libpoppler63) weakremover(libpoppler64) weakremover(libpoppler65) weakremover(libpoppler73) weakremover(libpoppler79) weakremover(libpoppler83) weakremover(libpoppler89) weakremover(libpoppler91) weakremover(libpoppler94) weakremover(libpoppler97) weakremover(libpoppler98) weakremover(libpoppler99) weakremover(libpopt0) weakremover(libportal-1) weakremover(libportal-devel) weakremover(libportal-gtk3-1) weakremover(libportal-gtk3-devel) weakremover(libportal-gtk4-1) weakremover(libportal-gtk4-devel) weakremover(libportal-qt5-1) weakremover(libportal-qt5-devel) weakremover(libportal0) weakremover(libportaudio2) weakremover(libportaudiocpp0) weakremover(libportmidi0) weakremover(libportmidi2) weakremover(libpostproc-devel) weakremover(libpostproc53) weakremover(libpostproc54) weakremover(libpostproc55) weakremover(libpostproc55_7) weakremover(libpostproc55_9) weakremover(libpostproc56) weakremover(libpostproc57) weakremover(libpotrace0) weakremover(libpowerman0) weakremover(libppl14) weakremover(libppl_c4) weakremover(libpplite1) weakremover(libpq5) weakremover(libpqxx-4_0) weakremover(libpqxx-5_0) weakremover(libpqxx-6_4) weakremover(libpqxx-devel) weakremover(libpqxx-doc) weakremover(libprelude-devel) weakremover(libprelude-devel-bindings) weakremover(libprelude-doc) weakremover(libprelude23) weakremover(libprelude28) weakremover(libpreludecpp12) weakremover(libpreludecpp8) weakremover(libpreludedb-devel) weakremover(libpreludedb-devel-bindings) weakremover(libpreludedb-doc) weakremover(libpreludedb-mysql) weakremover(libpreludedb-pgsql) weakremover(libpreludedb-plugins) weakremover(libpreludedb-sqlite) weakremover(libpreludedb7) weakremover(libpreludedbcpp2) weakremover(libpresage-devel) weakremover(libpresage1) weakremover(libprimecount-devel) weakremover(libprimecount6) weakremover(libprimecount7) weakremover(libprimesieve-devel) weakremover(libprimesieve10) weakremover(libprimesieve11) weakremover(libprimesieve9) weakremover(libprison-devel) weakremover(libprison0) weakremover(libproc-2-0) weakremover(libproc2-0) weakremover(libprocps3) weakremover(libprocps4) weakremover(libprocps5) weakremover(libprocps6) weakremover(libprocps7) weakremover(libprocps8) weakremover(libprofiler0) weakremover(libproj-devel) weakremover(libproj12) weakremover(libproj13) weakremover(libproj15) weakremover(libproj19) weakremover(libproj22) weakremover(libproj25) weakremover(libproj9) weakremover(libprojectM-libvisual) weakremover(libprojectM-qt1) weakremover(libprojectM2) weakremover(libprojectM3) weakremover(libprometheus-cpp0) weakremover(libpromises-devel) weakremover(libpromises3) weakremover(libprotobuf-c-devel) weakremover(libprotobuf-c1) weakremover(libprotobuf-lite15) weakremover(libprotobuf-lite17) weakremover(libprotobuf-lite19) weakremover(libprotobuf-lite20) weakremover(libprotobuf-lite22) weakremover(libprotobuf-lite23) weakremover(libprotobuf-lite25) weakremover(libprotobuf-lite26) weakremover(libprotobuf-lite28) weakremover(libprotobuf-lite30) weakremover(libprotobuf-lite31) weakremover(libprotobuf-lite32) weakremover(libprotobuf-lite3_21_11) weakremover(libprotobuf-lite3_21_12) weakremover(libprotobuf-lite3_21_4) weakremover(libprotobuf-lite3_21_5) weakremover(libprotobuf-lite3_21_6) weakremover(libprotobuf-lite3_21_9) weakremover(libprotobuf-lite9) weakremover(libprotobuf-mutator-devel) weakremover(libprotobuf-mutator0) weakremover(libprotobuf-nanopb0) weakremover(libprotobuf15) weakremover(libprotobuf17) weakremover(libprotobuf19) weakremover(libprotobuf20) weakremover(libprotobuf22) weakremover(libprotobuf23) weakremover(libprotobuf25) weakremover(libprotobuf26) weakremover(libprotobuf28) weakremover(libprotobuf30) weakremover(libprotobuf31) weakremover(libprotobuf32) weakremover(libprotobuf3_21_11) weakremover(libprotobuf3_21_12) weakremover(libprotobuf3_21_4) weakremover(libprotobuf3_21_5) weakremover(libprotobuf3_21_6) weakremover(libprotobuf3_21_9) weakremover(libprotobuf9) weakremover(libprotoc15) weakremover(libprotoc17) weakremover(libprotoc19) weakremover(libprotoc20) weakremover(libprotoc22) weakremover(libprotoc23) weakremover(libprotoc25) weakremover(libprotoc26) weakremover(libprotoc28) weakremover(libprotoc30) weakremover(libprotoc31) weakremover(libprotoc32) weakremover(libprotoc3_21_11) weakremover(libprotoc3_21_12) weakremover(libprotoc3_21_4) weakremover(libprotoc3_21_5) weakremover(libprotoc3_21_6) weakremover(libprotoc3_21_9) weakremover(libprotoc9) weakremover(libproxy-devel) weakremover(libproxy-sharp) weakremover(libproxy-tools) weakremover(libproxy1) weakremover(libproxy1-config-gnome3) weakremover(libproxy1-config-kde) weakremover(libproxy1-config-pacrunner) weakremover(libproxy1-networkmanager) weakremover(libproxy1-pacrunner-duktape) weakremover(libproxy1-pacrunner-webkit) weakremover(libpsiconv6) weakremover(libpskc-devel) weakremover(libpskc0) weakremover(libpsl-devel) weakremover(libpsl0) weakremover(libpsl5) weakremover(libpspell15) weakremover(libpst) weakremover(libpst-devel) weakremover(libpst4) weakremover(libpsx2) weakremover(libpt-devel) weakremover(libpt1_11) weakremover(libpt2_10_10) weakremover(libpt2_10_10-plugins-avc) weakremover(libpt2_10_10-plugins-esd) weakremover(libpt2_10_10-plugins-pulse) weakremover(libpt2_10_11) weakremover(libpt2_10_11-plugins-avc) weakremover(libpt2_10_11-plugins-pulse) weakremover(libpt2_18_8) weakremover(libpt2_18_8-plugins-avc) weakremover(libpt2_18_8-plugins-pulse) weakremover(libptexenc1) weakremover(libpth-devel) weakremover(libpth20) weakremover(libptl1) weakremover(libptl2) weakremover(libptscotch-gnu-mpich-hpc) weakremover(libptscotch-gnu-mvapich2-hpc) weakremover(libptscotch-gnu-openmpi1-hpc) weakremover(libptscotch-gnu-openmpi2-hpc) weakremover(libptscotch-gnu-openmpi3-hpc) weakremover(libptscotch-gnu-openmpi4-hpc) weakremover(libptscotch0-mpich) weakremover(libptscotch0-mvapich2) weakremover(libptscotch0-openmpi) weakremover(libptscotch0-openmpi1) weakremover(libptscotch0-openmpi2) weakremover(libptscotch0-openmpi3) weakremover(libptscotch0-openmpi4) weakremover(libptscotch_6_0_6-gnu-mpich-hpc) weakremover(libptscotch_6_0_6-gnu-mvapich2-hpc) weakremover(libptscotch_6_0_6-gnu-openmpi1-hpc) weakremover(libptscotch_6_0_6-gnu-openmpi2-hpc) weakremover(libptscotch_6_0_6-gnu-openmpi3-hpc) weakremover(libptscotch_6_0_7-gnu-mpich-hpc) weakremover(libptscotch_6_0_7-gnu-mvapich2-hpc) weakremover(libptscotch_6_0_7-gnu-openmpi1-hpc) weakremover(libptscotch_6_0_7-gnu-openmpi2-hpc) weakremover(libptscotch_6_0_7-gnu-openmpi3-hpc) weakremover(libptscotch_6_0_9-gnu-mpich-hpc) weakremover(libptscotch_6_0_9-gnu-mvapich2-hpc) weakremover(libptscotch_6_0_9-gnu-openmpi1-hpc) weakremover(libptscotch_6_0_9-gnu-openmpi2-hpc) weakremover(libptscotch_6_0_9-gnu-openmpi3-hpc) weakremover(libptscotch_6_1_0-gnu-mpich-hpc) weakremover(libptscotch_6_1_0-gnu-mvapich2-hpc) weakremover(libptscotch_6_1_0-gnu-openmpi1-hpc) weakremover(libptscotch_6_1_0-gnu-openmpi2-hpc) weakremover(libptscotch_6_1_0-gnu-openmpi3-hpc) weakremover(libptscotch_6_1_0-gnu-openmpi4-hpc) weakremover(libptytty-devel) weakremover(libptytty0) weakremover(libpugixml1) weakremover(libpulse-devel) weakremover(libpulse-mainloop-glib-pw0_3_1) weakremover(libpulse-mainloop-glib-pw0_3_2) weakremover(libpulse-mainloop-glib0) weakremover(libpulse-pw0_3_1) weakremover(libpulse-pw0_3_2) weakremover(libpulse-simple-pw0_3_1) weakremover(libpulse-simple-pw0_3_2) weakremover(libpulse0) weakremover(libpurple) weakremover(libpurple-client0) weakremover(libpurple-devel) weakremover(libpurple-meanwhile) weakremover(libpurple-plugin-bot-sentry) weakremover(libpurple-plugin-carbons) weakremover(libpurple-plugin-facebook) weakremover(libpurple-plugin-gnome-keyring) weakremover(libpurple-plugin-import-empathy) weakremover(libpurple-plugin-libsteam) weakremover(libpurple-plugin-lurch) weakremover(libpurple-plugin-mattermost) weakremover(libpurple-plugin-mrim) weakremover(libpurple-plugin-mrim-lang) weakremover(libpurple-plugin-openfetion) weakremover(libpurple-plugin-openfetion-lang) weakremover(libpurple-plugin-pack) weakremover(libpurple-plugin-pack-extras) weakremover(libpurple-plugin-prpltwtr) weakremover(libpurple-plugin-rocketchat) weakremover(libpurple-plugin-sametime) weakremover(libpurple-plugin-sipe) weakremover(libpurple-plugin-skype) weakremover(libpurple-plugin-skype-lang) weakremover(libpurple-plugin-skypeweb) weakremover(libpurple-plugin-telegram) weakremover(libpurple-plugin-xmpp-http-upload) weakremover(libpurple-tcl) weakremover(libpurple0) weakremover(libpw3270-5_1) weakremover(libpw3270-5_2) weakremover(libpwquality-devel) weakremover(libpwquality-tools) weakremover(libpwquality1) weakremover(libpystring0_0) weakremover(libpythia8) weakremover(libpythia8lhapdf6) weakremover(libpython2_7-1_0) weakremover(libpython3_10-1_0) weakremover(libpython3_11-1_0) weakremover(libpython3_12-1_0) weakremover(libpython3_4m1_0) weakremover(libpython3_6m1_0) weakremover(libpython3_7m1_0) weakremover(libpython3_8-1_0) weakremover(libpython3_9-1_0) weakremover(libpyzy-1_0-0) weakremover(libqaccessibilityclient-qt5-0) weakremover(libqaccessibilityclient-qt5-devel) weakremover(libqalculate-devel) weakremover(libqalculate14) weakremover(libqalculate20) weakremover(libqalculate21) weakremover(libqalculate22) weakremover(libqalculate5) weakremover(libqalculate6) weakremover(libqb-devel) weakremover(libqb-tests) weakremover(libqb-tools) weakremover(libqb0) weakremover(libqb100) weakremover(libqb20) weakremover(libqca-qt5) weakremover(libqca-qt5-2) weakremover(libqca-qt5-devel) weakremover(libqca-qt5-plugins) weakremover(libqca-qt6-2) weakremover(libqca2) weakremover(libqca2-devel) weakremover(libqca2-plugin-cyrus-sasl) weakremover(libqca2-plugin-gcrypt) weakremover(libqca2-plugin-nss) weakremover(libqca2-plugin-pkcs11) weakremover(libqcow-devel) weakremover(libqcow-tools) weakremover(libqcow1) weakremover(libqcustomplot2) weakremover(libqd0) weakremover(libqgpgme-devel) weakremover(libqgpgme15) weakremover(libqgpgme7) weakremover(libqgpgmeqt6-15) weakremover(libqgpgmeqt6-devel) weakremover(libqhexedit2) weakremover(libqhexedit4) weakremover(libqhull6-6_3_1_1494) weakremover(libqhull7) weakremover(libqhull7-7_2_0) weakremover(libqhull7-7_3_2) weakremover(libqhull_r8_0) weakremover(libqimageblitz-devel) weakremover(libqimageblitz4) weakremover(libqimageblitz5-1) weakremover(libqimageblitz5-devel) weakremover(libqjack-devel) weakremover(libqjack0) weakremover(libqjson-devel) weakremover(libqjson0) weakremover(libqmatrixclient-devel) weakremover(libqmi-devel) weakremover(libqmi-glib1) weakremover(libqmi-glib5) weakremover(libqmi-tools) weakremover(libqmmp-devel) weakremover(libqmmp-plugins) weakremover(libqmmp1) weakremover(libqmobipocket2) weakremover(libqoauth1) weakremover(libqoauth2) weakremover(libqobs-devel) weakremover(libqobs1) weakremover(libqobs2) weakremover(libqore12) weakremover(libqore5) weakremover(libqore6) weakremover(libqore7) weakremover(libqpdf13) weakremover(libqpdf18) weakremover(libqpdf21) weakremover(libqpdf26) weakremover(libqpdf28) weakremover(libqpdf29) weakremover(libqpid-proton-core10) weakremover(libqpid-proton-cpp10) weakremover(libqpid-proton-cpp12) weakremover(libqpid-proton-proactor1) weakremover(libqpid-proton10) weakremover(libqpid-proton11) weakremover(libqpid-proton3) weakremover(libqqwing2) weakremover(libqrcodegen1) weakremover(libqrcodegencpp1) weakremover(libqrencode3) weakremover(libqrencode4) weakremover(libqross0_1) weakremover(libqrosspython) weakremover(libqrtr-glib-devel) weakremover(libqrtr-glib0) weakremover(libqrupdate1) weakremover(libqsastime0) weakremover(libqscintilla-devel) weakremover(libqscintilla-qt5-devel) weakremover(libqscintilla2-12) weakremover(libqscintilla2-qt5-13) weakremover(libqscintilla2_qt4-13) weakremover(libqscintilla2_qt5-13) weakremover(libqscintilla2_qt5-15) weakremover(libqscintilla2_qt6-15) weakremover(libqscintilla_qt4-devel) weakremover(libqscintilla_qt5-devel) weakremover(libqt4) weakremover(libqt4-devel) weakremover(libqt4-devel-doc) weakremover(libqt4-devel-doc-data) weakremover(libqt4-linguist) weakremover(libqt4-private-headers-devel) weakremover(libqt4-qt3support) weakremover(libqt4-sql) weakremover(libqt4-sql-mysql) weakremover(libqt4-sql-postgresql) weakremover(libqt4-sql-sqlite) weakremover(libqt4-sql-unixODBC) weakremover(libqt4-x11) weakremover(libqt5-creator) weakremover(libqt5-creator-plugin-devel) weakremover(libqt5-dwaylandplugin) weakremover(libqt5-dxcbplugin) weakremover(libqt5-kwayland-shellplugin) weakremover(libqt5-linguist) weakremover(libqt5-linguist-devel) weakremover(libqt5-qdbus) weakremover(libqt5-qt3d-devel) weakremover(libqt5-qt3d-examples) weakremover(libqt5-qt3d-imports) weakremover(libqt5-qt3d-tools) weakremover(libqt5-qtbase-common-devel) weakremover(libqt5-qtbase-devel) weakremover(libqt5-qtbase-examples) weakremover(libqt5-qtbase-platformtheme-gtk3) weakremover(libqt5-qtbase-platformtheme-xdgdesktopportal) weakremover(libqt5-qtcanvas3d) weakremover(libqt5-qtcanvas3d-examples) weakremover(libqt5-qtcharts-examples) weakremover(libqt5-qtcharts-imports) weakremover(libqt5-qtconnectivity-devel) weakremover(libqt5-qtconnectivity-examples) weakremover(libqt5-qtconnectivity-tools) weakremover(libqt5-qtdatavis3d) weakremover(libqt5-qtdatavis3d-examples) weakremover(libqt5-qtdatavis3d-imports) weakremover(libqt5-qtdeclarative-devel) weakremover(libqt5-qtdeclarative-examples) weakremover(libqt5-qtdeclarative-tools) weakremover(libqt5-qtgamepad-devel) weakremover(libqt5-qtgamepad-examples) weakremover(libqt5-qtgamepad-imports) weakremover(libqt5-qtgraphicaleffects) weakremover(libqt5-qtimageformats) weakremover(libqt5-qtimageformats-devel) weakremover(libqt5-qtlocation-devel) weakremover(libqt5-qtlocation-examples) weakremover(libqt5-qtlottie) weakremover(libqt5-qtmultimedia-devel) weakremover(libqt5-qtmultimedia-examples) weakremover(libqt5-qtnetworkauth-devel) weakremover(libqt5-qtnetworkauth-examples) weakremover(libqt5-qtpaths) weakremover(libqt5-qtpdf-devel) weakremover(libqt5-qtpdf-examples) weakremover(libqt5-qtpdf-imports) weakremover(libqt5-qtquick3d-devel) weakremover(libqt5-qtquick3d-examples) weakremover(libqt5-qtquick3d-imports) weakremover(libqt5-qtquick3d-private-headers-devel) weakremover(libqt5-qtquick3d-tools) weakremover(libqt5-qtquickcontrols) weakremover(libqt5-qtquickcontrols-examples) weakremover(libqt5-qtquickcontrols2) weakremover(libqt5-qtquickcontrols2-examples) weakremover(libqt5-qtquickcontrols2-private-headers-devel) weakremover(libqt5-qtquicktimeline) weakremover(libqt5-qtremoteobjects-devel) weakremover(libqt5-qtremoteobjects-examples) weakremover(libqt5-qtremoteobjects-tools) weakremover(libqt5-qtscript-devel) weakremover(libqt5-qtscript-examples) weakremover(libqt5-qtscxml-devel) weakremover(libqt5-qtscxml-examples) weakremover(libqt5-qtscxml-tools) weakremover(libqt5-qtsensors-devel) weakremover(libqt5-qtsensors-examples) weakremover(libqt5-qtserialbus) weakremover(libqt5-qtserialbus-devel) weakremover(libqt5-qtserialbus-examples) weakremover(libqt5-qtserialport-devel) weakremover(libqt5-qtserialport-examples) weakremover(libqt5-qtspeech-devel) weakremover(libqt5-qtspeech-examples) weakremover(libqt5-qtspeech-plugin-speechd) weakremover(libqt5-qtstyleplugins) weakremover(libqt5-qtstyleplugins-devel) weakremover(libqt5-qtstyleplugins-platformtheme-gtk2) weakremover(libqt5-qtsvg-devel) weakremover(libqt5-qtsvg-examples) weakremover(libqt5-qttools) weakremover(libqt5-qttools-devel) weakremover(libqt5-qttools-doc) weakremover(libqt5-qttools-example-plugins) weakremover(libqt5-qttools-examples) weakremover(libqt5-qttools-qhelpgenerator) weakremover(libqt5-qttranslations) weakremover(libqt5-qtvirtualkeyboard) weakremover(libqt5-qtvirtualkeyboard-devel) weakremover(libqt5-qtvirtualkeyboard-examples) weakremover(libqt5-qtvirtualkeyboard-hunspell) weakremover(libqt5-qtvirtualkeyboard-private-headers-devel) weakremover(libqt5-qtwayland) weakremover(libqt5-qtwayland-devel) weakremover(libqt5-qtwayland-examples) weakremover(libqt5-qtwebchannel-devel) weakremover(libqt5-qtwebchannel-examples) weakremover(libqt5-qtwebengine) weakremover(libqt5-qtwebengine-devel) weakremover(libqt5-qtwebengine-examples) weakremover(libqt5-qtwebkit-examples) weakremover(libqt5-qtwebsockets-devel) weakremover(libqt5-qtwebsockets-examples) weakremover(libqt5-qtwebview-devel) weakremover(libqt5-qtwebview-examples) weakremover(libqt5-qtx11extras-devel) weakremover(libqt5-qtxmlpatterns-devel) weakremover(libqt5-qtxmlpatterns-examples) weakremover(libqt5-qtxmlpatterns-imports) weakremover(libqt5keychain1) weakremover(libqt5xdg-devel) weakremover(libqt6keychain1) weakremover(libqtcurve-cairo1) weakremover(libqtcurve-utils2) weakremover(libqtermwidget4-0) weakremover(libqtermwidget5-0) weakremover(libqtermwidget5-1) weakremover(libqtkeychain0) weakremover(libqtkeychain1) weakremover(libqtolm-devel) weakremover(libqtpod-devel) weakremover(libqtpod-doc) weakremover(libqtpod0) weakremover(libqtweetlib-devel) weakremover(libqtweetlib1_0) weakremover(libquagga_pb0) weakremover(libquazip-qt5-devel) weakremover(libquazip1) weakremover(libquazip1-qt5-1_0_0) weakremover(libquazip1-qt5-1_3_0) weakremover(libquazip1-qt5-1_4_0) weakremover(libquazip1-qt6-1_3_0) weakremover(libquazip1-qt6-1_4_0) weakremover(libquazip5-1) weakremover(libqucs0) weakremover(libquicktime) weakremover(libquicktime-devel) weakremover(libquicktime-tools) weakremover(libquicktime0) weakremover(libquo-devel) weakremover(libquo3) weakremover(libquo6) weakremover(libquo7) weakremover(libquorum5) weakremover(libquvi-0_9-0_9_4) weakremover(libquvi-devel) weakremover(libquvi-scripts) weakremover(libquvi-scripts-devel) weakremover(libquvi-scripts-nsfw) weakremover(libqwt-qt5-6) weakremover(libqwt5) weakremover(libqwt5-qt5-5) weakremover(libqwt6) weakremover(libqwt6-qt5-6_2) weakremover(libqwt6-qt6-6_2) weakremover(libqwt6_2) weakremover(libqwtplot3d-qt5-0) weakremover(libqwtplot3d0) weakremover(libqxmledit-0_9_16-0) weakremover(libqxmledit-0_9_17-0) weakremover(libqxmledit0) weakremover(libqxmpp-devel) weakremover(libqxmpp-qt5-0) weakremover(libqxmpp-qt5-devel) weakremover(libqxmpp-qt5-doc) weakremover(libqxmpp0) weakremover(libqxmpp2) weakremover(libqxmpp3) weakremover(libqxmpp4) weakremover(libqxp-0_0-0) weakremover(libqxp-devel) weakremover(libqxp-tools) weakremover(libqxt-devel) weakremover(libqxt1) weakremover(libqxtglobalshortcut0) weakremover(librabbitmq-devel) weakremover(librabbitmq4) weakremover(libradcli4) weakremover(libradcli5) weakremover(librados-devel) weakremover(librados2) weakremover(librados3) weakremover(libradospp-devel) weakremover(libradospp1) weakremover(libradosstriper-devel) weakremover(libradosstriper1) weakremover(libraft0) weakremover(libraft2) weakremover(libraft3) weakremover(libragel0) weakremover(libraptor-devel) weakremover(libraptor2-0) weakremover(libraqm-devel) weakremover(libraqm0) weakremover(librasqal-devel) weakremover(librasqal-devel-doc) weakremover(librasqal3) weakremover(libratbag-devel) weakremover(libratbag-tools) weakremover(libratbag3) weakremover(librav1e0) weakremover(libraven0) weakremover(libraw-devel) weakremover(libraw-devel-static) weakremover(libraw-tools) weakremover(libraw1394) weakremover(libraw1394-11) weakremover(libraw1394-devel) weakremover(libraw1394-tools) weakremover(libraw15) weakremover(libraw16) weakremover(libraw19) weakremover(libraw20) weakremover(libraw23) weakremover(librawstudio-2_1) weakremover(librawstudio-devel) weakremover(libraylib1) weakremover(libraylib2) weakremover(libraylib301) weakremover(libraylib351) weakremover(libraylib400) weakremover(libraylib420) weakremover(librbd-devel) weakremover(librbd1) weakremover(librbio-2_2_1) weakremover(librbio-2_2_6) weakremover(librbio2) weakremover(librbl1) weakremover(librcc-devel) weakremover(librcc0) weakremover(librcd-devel) weakremover(librcd0) weakremover(librcps-devel) weakremover(librcps0) weakremover(librdf0) weakremover(librdkafka-devel) weakremover(librdkafka1) weakremover(librdmacm-devel) weakremover(librdmacm-tools) weakremover(librdmacm-utils) weakremover(librdmacm1) weakremover(libre0suse0) weakremover(libre1) weakremover(libre10) weakremover(libre12) weakremover(libre2-0) weakremover(libre2-10) weakremover(libre2-6) weakremover(libre2-7) weakremover(libre2-8) weakremover(libre2-9) weakremover(libre5) weakremover(libre6) weakremover(libre7) weakremover(libreadline-java) weakremover(libreadline-java-javadoc) weakremover(libreadline5) weakremover(libreadline6) weakremover(libreadline7) weakremover(libreadline8) weakremover(librealsense) weakremover(librealsense-devel) weakremover(librealsense-examples) weakremover(librealsense2) weakremover(librealsense2_50) weakremover(librealsense2_51) weakremover(librealsense2_53) weakremover(librec1) weakremover(librecad) weakremover(librecode0) weakremover(librecode3) weakremover(libredfish) weakremover(libredfish-devel) weakremover(libredfish1) weakremover(libredis++) weakremover(libredis++1) weakremover(libredland-devel) weakremover(libredwg-devel) weakremover(libredwg-tools) weakremover(libredwg0) weakremover(libref_array-devel) weakremover(libref_array1) weakremover(libregf-devel) weakremover(libregf-tools) weakremover(libregf1) weakremover(libregina3) weakremover(libregraphapi-devel) weakremover(libreiser4-1_1-0) weakremover(libreiser4-1_2-1) weakremover(libreiser4-2_0-0) weakremover(libreiser4-2_0-4) weakremover(libreiser4-2_0-5) weakremover(libreiser4-minimal-1_1-0) weakremover(libreiser4-minimal-1_2-1) weakremover(libreiser4-minimal-2_0-0) weakremover(libreiser4-minimal-2_0-4) weakremover(libreiser4-minimal-2_0-5) weakremover(libreiserfs-0_3-0) weakremover(libreiserfs-devel) weakremover(libreiserfs-progs) weakremover(libreiserfscore-devel) weakremover(libreiserfscore0) weakremover(librelp-devel) weakremover(librelp0) weakremover(librem0) weakremover(librem3) weakremover(librem4) weakremover(libreoffice) weakremover(libreoffice-base) weakremover(libreoffice-base-drivers-firebird) weakremover(libreoffice-base-drivers-mysql) weakremover(libreoffice-base-drivers-postgresql) weakremover(libreoffice-calc) weakremover(libreoffice-calc-extensions) weakremover(libreoffice-draw) weakremover(libreoffice-filters-optional) weakremover(libreoffice-gnome) weakremover(libreoffice-gtk2) weakremover(libreoffice-gtk3) weakremover(libreoffice-icon-theme-oxygen) weakremover(libreoffice-impress) weakremover(libreoffice-kde4) weakremover(libreoffice-librelogo) weakremover(libreoffice-mailmerge) weakremover(libreoffice-math) weakremover(libreoffice-officebean) weakremover(libreoffice-pyuno) weakremover(libreoffice-qt5) weakremover(libreoffice-sdk) weakremover(libreoffice-sdk-doc) weakremover(libreoffice-templates-de) weakremover(libreoffice-templates-en) weakremover(libreoffice-templates-labels-a4) weakremover(libreoffice-templates-labels-letter) weakremover(libreoffice-templates-presentation-layouts) weakremover(libreoffice-templates-ru) weakremover(libreoffice-voikko) weakremover(libreoffice-writer) weakremover(libreoffice-writer-extensions) weakremover(libreofficekit) weakremover(libreofficekit-devel) weakremover(librep) weakremover(librep-devel) weakremover(librep16) weakremover(librepair-1_1-0) weakremover(librepair-1_2-1) weakremover(librepair-2_0-0) weakremover(librepair-2_0-4) weakremover(librepair-2_0-5) weakremover(librepilot) weakremover(libreplaygain-devel) weakremover(libreplaygain1) weakremover(librepo-devel) weakremover(librepo0) weakremover(libreproc++14) weakremover(libreproc14) weakremover(librepute1) weakremover(libresprite) weakremover(libressl) weakremover(libressl-devel) weakremover(librest-0_7-0) weakremover(librest-1_0-0) weakremover(librest-devel) weakremover(librest0) weakremover(librest0_7-devel) weakremover(libretro-2048) weakremover(libretro-3dengine) weakremover(libretro-81) weakremover(libretro-atari800) weakremover(libretro-beetle-gba) weakremover(libretro-beetle-lynx) weakremover(libretro-beetle-ngp) weakremover(libretro-beetle-pce-fast) weakremover(libretro-beetle-pcfx) weakremover(libretro-beetle-psx) weakremover(libretro-beetle-psx-hw) weakremover(libretro-beetle-saturn) weakremover(libretro-beetle-supergrafx) weakremover(libretro-beetle-vb) weakremover(libretro-beetle-wswan) weakremover(libretro-bluemsx) weakremover(libretro-bsnes) weakremover(libretro-cap32) weakremover(libretro-core-info) weakremover(libretro-craft) weakremover(libretro-crocods) weakremover(libretro-database) weakremover(libretro-dolphin) weakremover(libretro-dosbox) weakremover(libretro-easyrpg) weakremover(libretro-fceumm) weakremover(libretro-ffmpeg) weakremover(libretro-flycast) weakremover(libretro-freechaf) weakremover(libretro-freeintv) weakremover(libretro-fuse) weakremover(libretro-gambatte) weakremover(libretro-gtk-0_14-0) weakremover(libretro-gtk-1-0) weakremover(libretro-gtk0) weakremover(libretro-handy) weakremover(libretro-mame) weakremover(libretro-mgba) weakremover(libretro-nestopia) weakremover(libretro-parallel-n64) weakremover(libretro-pcsx-rearmed) weakremover(libretro-pcsx_rearmed) weakremover(libretro-play) weakremover(libretro-ppsspp) weakremover(libretro-prosystem) weakremover(libretro-stella) weakremover(libretro-virtualjaguar) weakremover(libretro-yabause) weakremover(librevenge-0_0-0) weakremover(librevenge-devel) weakremover(librevenge-generators-0_0-0) weakremover(librevenge-stream-0_0-0) weakremover(librfxencode0) weakremover(librgw-devel) weakremover(librgw2) weakremover(librhash0) weakremover(librime-devel) weakremover(librime-lua) weakremover(librime-private-devel) weakremover(librime1) weakremover(librist-devel) weakremover(librist4) weakremover(librk0) weakremover(librlog-devel) weakremover(librlog5) weakremover(librlog5-doc) weakremover(librmt1_0) weakremover(librnnoise0) weakremover(librnp-0-0) weakremover(librnp0) weakremover(librocksdb8) weakremover(librocsgraphtheory0) weakremover(libroken18) weakremover(librpcsecgss-devel) weakremover(librpcsecgss3) weakremover(librpma0) weakremover(librpmbuild8) weakremover(librpmbuild9) weakremover(librpmem-devel) weakremover(librpmem1) weakremover(librrd8) weakremover(librsb-devel) weakremover(librsb0) weakremover(librscg1_0) weakremover(librssguard-3_6_0) weakremover(librssguard-3_6_1) weakremover(librssguard-3_6_3) weakremover(librssguard-3_7_0) weakremover(librssguard-3_7_2) weakremover(librssguard-3_8_0) weakremover(librssguard-3_8_2) weakremover(librssguard-3_8_3) weakremover(librssguard-3_8_4) weakremover(librssguard-3_9_0) weakremover(librssguard-3_9_1) weakremover(librssguard-3_9_2) weakremover(librssguard-4_0_3) weakremover(librssguard-4_0_4) weakremover(librssguard-4_1_1) weakremover(librssguard-4_1_2) weakremover(librssguard-4_2_0) weakremover(librssguard-4_2_1) weakremover(librssguard-4_2_2) weakremover(librssguard-4_2_3) weakremover(librssguard-4_2_5) weakremover(librssguard-4_3_2) weakremover(librssguard-4_3_3) weakremover(librssguard-4_3_4) weakremover(librssguard-devel) weakremover(librsvg-2-2) weakremover(librsvg-devel) weakremover(librsvg-lang) weakremover(librsync-devel) weakremover(librsync2) weakremover(librtaudio6) weakremover(librtlsdr0) weakremover(librtmidi4) weakremover(librtmidi5) weakremover(librtmidi6) weakremover(librtprocess-devel) weakremover(librtprocess0) weakremover(librtr0) weakremover(librttopo-devel) weakremover(librttopo1) weakremover(librttr_core0_9_6) weakremover(librubberband-devel) weakremover(librubberband2) weakremover(libruby2_1-2_1) weakremover(libruby2_2-2_2) weakremover(libruby2_3-2_3) weakremover(libruby2_4-2_4) weakremover(libruby2_5-2_5) weakremover(libruby2_6-2_6) weakremover(libruby2_7-2_7) weakremover(libruby3_0-3_0) weakremover(libruby3_1-3_1) weakremover(libruby3_2-3_2) weakremover(librvngabw-0_0-0) weakremover(librvngabw-devel) weakremover(librxtx2) weakremover(librygel-core-2_6-2) weakremover(librygel-core-2_8-0) weakremover(librygel-db-2_6-2) weakremover(librygel-db-2_8-0) weakremover(librygel-renderer-2_6-2) weakremover(librygel-renderer-2_8-0) weakremover(librygel-renderer-gst-2_6-2) weakremover(librygel-renderer-gst-2_8-0) weakremover(librygel-ruih-2_0-1) weakremover(librygel-ruih-2_8-0) weakremover(librygel-server-2_6-2) weakremover(librygel-server-2_8-0) weakremover(libryml0_4_1) weakremover(libryml0_5_0) weakremover(libs3-2) weakremover(libs3-3) weakremover(libs3-4) weakremover(libs3-devel) weakremover(libs3-tools) weakremover(libsam4) weakremover(libsamba-credentials-devel) weakremover(libsamba-credentials0) weakremover(libsamba-credentials1) weakremover(libsamba-errors-devel) weakremover(libsamba-errors0) weakremover(libsamba-hostconfig-devel) weakremover(libsamba-hostconfig0) weakremover(libsamba-passdb-devel) weakremover(libsamba-passdb0) weakremover(libsamba-policy-devel) weakremover(libsamba-policy-python-devel) weakremover(libsamba-policy-python3-devel) weakremover(libsamba-policy0) weakremover(libsamba-policy0-python3) weakremover(libsamba-util-devel) weakremover(libsamba-util0) weakremover(libsamdb-devel) weakremover(libsamdb0) weakremover(libsaml-devel) weakremover(libsaml10) weakremover(libsaml11) weakremover(libsaml12) weakremover(libsaml8) weakremover(libsaml9) weakremover(libsamplerate-devel) weakremover(libsamplerate-progs) weakremover(libsamplerate0) weakremover(libsane1) weakremover(libsanlock1) weakremover(libsapi0) weakremover(libsasl2-3) weakremover(libsass-3_3_2-0) weakremover(libsass-3_5_3-1) weakremover(libsass-3_6_1-1) weakremover(libsass-3_6_4-1) weakremover(libsass-3_6_5-1) weakremover(libsass-devel) weakremover(libsbc1) weakremover(libsblim-cmpiutil1) weakremover(libscalapack2-gnu-mpich-hpc) weakremover(libscalapack2-gnu-mpich-hpc-devel) weakremover(libscalapack2-gnu-mvapich2-hpc) weakremover(libscalapack2-gnu-mvapich2-hpc-devel) weakremover(libscalapack2-gnu-openmpi1-hpc) weakremover(libscalapack2-gnu-openmpi1-hpc-devel) weakremover(libscalapack2-gnu-openmpi2-hpc) weakremover(libscalapack2-gnu-openmpi2-hpc-devel) weakremover(libscalapack2-gnu-openmpi3-hpc) weakremover(libscalapack2-gnu-openmpi3-hpc-devel) weakremover(libscalapack2-gnu-openmpi4-hpc) weakremover(libscalapack2-gnu-openmpi4-hpc-devel) weakremover(libscalapack2-mvapich2) weakremover(libscalapack2-mvapich2-devel) weakremover(libscalapack2-mvapich2-devel-static) weakremover(libscalapack2-openmpi) weakremover(libscalapack2-openmpi-devel) weakremover(libscalapack2-openmpi-devel-static) weakremover(libscalapack2-openmpi1) weakremover(libscalapack2-openmpi1-devel) weakremover(libscalapack2-openmpi1-devel-static) weakremover(libscalapack2-openmpi2) weakremover(libscalapack2-openmpi2-devel) weakremover(libscalapack2-openmpi2-devel-static) weakremover(libscalapack2-openmpi3) weakremover(libscalapack2-openmpi3-devel) weakremover(libscalapack2-openmpi3-devel-static) weakremover(libscalapack2-openmpi4) weakremover(libscalapack2-openmpi4-devel) weakremover(libscalapack2-openmpi4-devel-static) weakremover(libscalapack2_2_0_2-gnu-mpich-hpc) weakremover(libscalapack2_2_0_2-gnu-mpich-hpc-devel) weakremover(libscalapack2_2_0_2-gnu-mpich-hpc-devel-static) weakremover(libscalapack2_2_0_2-gnu-mvapich2-hpc) weakremover(libscalapack2_2_0_2-gnu-mvapich2-hpc-devel) weakremover(libscalapack2_2_0_2-gnu-mvapich2-hpc-devel-static) weakremover(libscalapack2_2_0_2-gnu-openmpi1-hpc) weakremover(libscalapack2_2_0_2-gnu-openmpi1-hpc-devel) weakremover(libscalapack2_2_0_2-gnu-openmpi1-hpc-devel-static) weakremover(libscalapack2_2_0_2-gnu-openmpi2-hpc) weakremover(libscalapack2_2_0_2-gnu-openmpi2-hpc-devel) weakremover(libscalapack2_2_0_2-gnu-openmpi2-hpc-devel-static) weakremover(libscalapack2_2_0_2-gnu-openmpi3-hpc) weakremover(libscalapack2_2_0_2-gnu-openmpi3-hpc-devel) weakremover(libscalapack2_2_0_2-gnu-openmpi3-hpc-devel-static) weakremover(libscalapack2_2_1_0-gnu-mpich-hpc) weakremover(libscalapack2_2_1_0-gnu-mpich-hpc-devel) weakremover(libscalapack2_2_1_0-gnu-mpich-hpc-devel-static) weakremover(libscalapack2_2_1_0-gnu-mvapich2-hpc) weakremover(libscalapack2_2_1_0-gnu-mvapich2-hpc-devel) weakremover(libscalapack2_2_1_0-gnu-mvapich2-hpc-devel-static) weakremover(libscalapack2_2_1_0-gnu-openmpi1-hpc) weakremover(libscalapack2_2_1_0-gnu-openmpi1-hpc-devel) weakremover(libscalapack2_2_1_0-gnu-openmpi1-hpc-devel-static) weakremover(libscalapack2_2_1_0-gnu-openmpi2-hpc) weakremover(libscalapack2_2_1_0-gnu-openmpi2-hpc-devel) weakremover(libscalapack2_2_1_0-gnu-openmpi2-hpc-devel-static) weakremover(libscalapack2_2_1_0-gnu-openmpi3-hpc) weakremover(libscalapack2_2_1_0-gnu-openmpi3-hpc-devel) weakremover(libscalapack2_2_1_0-gnu-openmpi3-hpc-devel-static) weakremover(libscalapack2_2_1_0-gnu-openmpi4-hpc) weakremover(libscalapack2_2_1_0-gnu-openmpi4-hpc-devel) weakremover(libscalapack2_2_1_0-gnu-openmpi4-hpc-devel-static) weakremover(libscamperctrl-devel) weakremover(libscamperctrl1) weakremover(libscamperfile-devel) weakremover(libscamperfile0) weakremover(libscamperfile1) weakremover(libscamperfile2) weakremover(libscamperfile3) weakremover(libscamperfile4) weakremover(libscamperfile5) weakremover(libscca-devel) weakremover(libscca-tools) weakremover(libscca1) weakremover(libscg-devel) weakremover(libscg1_0) weakremover(libscgcmd1_0) weakremover(libschily-devel) weakremover(libschily1_0) weakremover(libschily2_0) weakremover(libschroedinger-1_0-0) weakremover(libscilab6) weakremover(libscintilla-devel) weakremover(libscintilla3) weakremover(libscintilla5) weakremover(libscotch-gnu-hpc) weakremover(libscotch0) weakremover(libscotch_6_1_0-gnu-hpc) weakremover(libscratchcore0) weakremover(libscrypt-devel) weakremover(libscrypt0) weakremover(libsdbus-c++0) weakremover(libsdbus-c++1) weakremover(libseafile0) weakremover(libsearpc-devel) weakremover(libsearpc1) weakremover(libseat1) weakremover(libseccomp-devel) weakremover(libseccomp-tools) weakremover(libseccomp2) weakremover(libsecprog-devel) weakremover(libsecprog0) weakremover(libsecret-1-0) weakremover(libsecret-devel) weakremover(libsecret-tools) weakremover(libselinux-devel) weakremover(libselinux-devel-static) weakremover(libselinux1) weakremover(libsemanage-conf) weakremover(libsemanage-devel) weakremover(libsemanage-devel-static) weakremover(libsemanage-migrate-store) weakremover(libsemanage1) weakremover(libsemanage2) weakremover(libsemigroups-devel) weakremover(libsemigroups1) weakremover(libsemigroups2) weakremover(libsensors4) weakremover(libsensors4-devel) weakremover(libsepol-devel) weakremover(libsepol-devel-static) weakremover(libsepol-utils) weakremover(libsepol1) weakremover(libsepol2) weakremover(libserd-0-0) weakremover(libserd-0-devel) weakremover(libserf-1-1) weakremover(libserf-devel) weakremover(libserialdv1) weakremover(libserialport-devel) weakremover(libserialport0) weakremover(libsexy) weakremover(libsexy-devel) weakremover(libsexy-doc) weakremover(libsexy2) weakremover(libsfcUtil0) weakremover(libsfml2-2_3) weakremover(libsfml2-2_4) weakremover(libsfml2-2_5) weakremover(libsfst-hfst0) weakremover(libsgutils-devel) weakremover(libsgutils2-1_40-2) weakremover(libsgutils2-1_41-2) weakremover(libsgutils2-1_43-2) weakremover(libsgutils2-1_45-2) weakremover(libsgutils2-1_46-2) weakremover(libsgutils2-1_47-2) weakremover(libsgutils2-1_48-2) weakremover(libsgutils2-2) weakremover(libsha1detectcoll-devel) weakremover(libsha1detectcoll1) weakremover(libshaderc_shared1) weakremover(libshadowdive0_0_0-suse) weakremover(libshadowsocks-libev2) weakremover(libsharp-devel) weakremover(libsharp0) weakremover(libsharpyuv0) weakremover(libshiboken-1_2_cpython-34m1_2) weakremover(libshiboken-1_2_cpython-36m-aarch64-linux-gnu1_2) weakremover(libshiboken-devel) weakremover(libshiboken-python2_7-1_2) weakremover(libshiboken-python3-devel) weakremover(libshibsp-lite10) weakremover(libshibsp-lite11) weakremover(libshibsp-lite6) weakremover(libshibsp-lite7) weakremover(libshibsp-lite8) weakremover(libshibsp10) weakremover(libshibsp11) weakremover(libshibsp6) weakremover(libshibsp7) weakremover(libshibsp8) weakremover(libshibsp9) weakremover(libshine-devel) weakremover(libshine3) weakremover(libshout-devel) weakremover(libshout3) weakremover(libshp-devel) weakremover(libshp1) weakremover(libshp2) weakremover(libshumate-1_0-1) weakremover(libshumate-devel) weakremover(libsidplay1) weakremover(libsidplay1-devel) weakremover(libsidplayfp-devel) weakremover(libsidplayfp3) weakremover(libsidplayfp4) weakremover(libsidplayfp6) weakremover(libsigc++12) weakremover(libsigc++12-devel) weakremover(libsigc++2-devel) weakremover(libsigc++3-devel) weakremover(libsigc-1_2-5) weakremover(libsigc-2_0-0) weakremover(libsigc-3_0-0) weakremover(libsignal-protocol-c-devel) weakremover(libsignal-protocol-c2) weakremover(libsignon-glib-devel) weakremover(libsignon-glib1) weakremover(libsignon-glib2) weakremover(libsignon-qt5-1) weakremover(libsignon-qt5-devel) weakremover(libsigrok-devel) weakremover(libsigrok2) weakremover(libsigrok4) weakremover(libsigrok4DSL-devel) weakremover(libsigrok4DSL1) weakremover(libsigrokcxx4) weakremover(libsigrokdecode-devel) weakremover(libsigrokdecode2) weakremover(libsigrokdecode4) weakremover(libsigscan-devel) weakremover(libsigscan-tools) weakremover(libsigscan1) weakremover(libsigsegv-devel) weakremover(libsigsegv-doc) weakremover(libsigsegv2) weakremover(libsilc-1_1-4) weakremover(libsilcclient-1_1-4) weakremover(libsingular_resources-4_3_1) weakremover(libsingular_resources-devel) weakremover(libsingularity1) weakremover(libsirocco0) weakremover(libsispmctl0) weakremover(libsixel-devel) weakremover(libsixel-utils) weakremover(libsixel1) weakremover(libskk-devel) weakremover(libskk0) weakremover(libsl0) weakremover(libslang2) weakremover(libsliplu1) weakremover(libslirp-devel) weakremover(libslirp0) weakremover(libslopy7_4) weakremover(libslopy7_5) weakremover(libslopy7_6) weakremover(libslp1) weakremover(libslurm29) weakremover(libslurm32) weakremover(libslurm33) weakremover(libslurm34) weakremover(libslurm35) weakremover(libslurm36) weakremover(libslurm37) weakremover(libslurm38) weakremover(libslurm39) weakremover(libsmartcols-devel) weakremover(libsmartcols-devel-static) weakremover(libsmartcols1) weakremover(libsmbclient-devel) weakremover(libsmbclient0) weakremover(libsmbconf-devel) weakremover(libsmbconf0) weakremover(libsmbldap-devel) weakremover(libsmbldap0) weakremover(libsmbldap2) weakremover(libsmdev-devel) weakremover(libsmdev-tools) weakremover(libsmdev1) weakremover(libsmi) weakremover(libsmi-devel) weakremover(libsmi2) weakremover(libsmokegen-devel) weakremover(libsmokekde-devel) weakremover(libsmokekde3) weakremover(libsmokeqt) weakremover(libsmokeqt-devel) weakremover(libsmooth-0_9-0) weakremover(libsmpeg-0_4-0) weakremover(libsmpp34-0) weakremover(libsmpp34-0-devel) weakremover(libsmpp34-1) weakremover(libsmpp34-devel) weakremover(libsmputils-devel) weakremover(libsmputils1-1) weakremover(libsmraw-devel) weakremover(libsmraw-tools) weakremover(libsmraw1) weakremover(libsnapper-devel) weakremover(libsnapper3) weakremover(libsnapper4) weakremover(libsnapper5) weakremover(libsnapper6) weakremover(libsnapper7) weakremover(libsnappy1) weakremover(libsndfile-devel) weakremover(libsndfile-progs) weakremover(libsndfile1) weakremover(libsndio6_0) weakremover(libsndio7_0) weakremover(libsndio7_1) weakremover(libsnmp30) weakremover(libsnmp39) weakremover(libsnmp40) weakremover(libsoc-common) weakremover(libsoc-devel) weakremover(libsoc2) weakremover(libsoci_core4_0) weakremover(libsoci_empty4_0) weakremover(libsoci_mysql4_0) weakremover(libsoci_odbc4_0) weakremover(libsoci_postgresql4_0) weakremover(libsoci_sqlite3-4_0) weakremover(libsocialweb) weakremover(libsocialweb-branding-openSUSE) weakremover(libsocialweb-branding-upstream) weakremover(libsocialweb-client2) weakremover(libsocialweb-devel) weakremover(libsocialweb-lang) weakremover(libsocialweb0) weakremover(libsocket_wrapper_noop-devel) weakremover(libsocket_wrapper_noop0) weakremover(libsocketcan-devel) weakremover(libsocketcan2) weakremover(libsocketxx1_2) weakremover(libsocks0) weakremover(libsodium-devel) weakremover(libsodium13) weakremover(libsodium18) weakremover(libsodium23) weakremover(libsofia-sip-ua-glib3) weakremover(libsofia-sip-ua0) weakremover(libsoftokn3) weakremover(libsoftokn3-hmac) weakremover(libsolarus-gui1) weakremover(libsolarus1) weakremover(libsolv-demo) weakremover(libsolv-devel) weakremover(libsolv-tools) weakremover(libsonivox3) weakremover(libsoprano-devel) weakremover(libsoprano4) weakremover(libsord-0-0) weakremover(libsord-0-devel) weakremover(libsord-docs) weakremover(libsoundio-devel) weakremover(libsoundio2) weakremover(libsoup-2_4-1) weakremover(libsoup-3_0-0) weakremover(libsoup-devel) weakremover(libsoup2-devel) weakremover(libsource-highlight-devel) weakremover(libsource-highlight4) weakremover(libsox3) weakremover(libsoxr-lsr0) weakremover(libsoxr0) weakremover(libspa-lib1) weakremover(libspandsp2) weakremover(libspandsp3) weakremover(libspatialindex4) weakremover(libspatialindex6) weakremover(libspatialite-devel) weakremover(libspatialite7) weakremover(libspdlog1) weakremover(libspdlog1_11) weakremover(libspdylay7) weakremover(libspectre-devel) weakremover(libspectre1) weakremover(libspeechd-devel) weakremover(libspeechd2) weakremover(libspeex1) weakremover(libspeexdsp1) weakremover(libspf2-2) weakremover(libspf2-devel) weakremover(libspf2-tools) weakremover(libsphinxad0) weakremover(libsphinxbase1) weakremover(libsphinxbase3) weakremover(libsphinxclient-0_0_1) weakremover(libsphinxclient-devel) weakremover(libspice-client-glib-2_0-8) weakremover(libspice-client-glib-helper) weakremover(libspice-client-gtk-2_0-4) weakremover(libspice-client-gtk-3_0-4) weakremover(libspice-client-gtk-3_0-5) weakremover(libspice-controller0) weakremover(libspice-server-devel) weakremover(libspice-server1) weakremover(libspiro-devel) weakremover(libspiro0) weakremover(libspiro1) weakremover(libspirv-cross-c-shared-devel) weakremover(libspirv-cross-c-shared0) weakremover(libsplinter-3-0) weakremover(libspnav-devel) weakremover(libspnav0) weakremover(libspooles2_2) weakremover(libspooles2_2-openmpi1) weakremover(libspooles2_2-openmpi2) weakremover(libspqr-2_0_1) weakremover(libspqr-2_0_8) weakremover(libspqr2) weakremover(libspread-sheet-widget0) weakremover(libsqlcipher-3_11_0-0) weakremover(libsqlcipher-3_20_1-0) weakremover(libsqlcipher-3_27_2-0) weakremover(libsqlcipher-3_28_0-0) weakremover(libsqlcipher-3_30_1-0) weakremover(libsqlcipher-3_31_0-0) weakremover(libsqlcipher-3_33_0-0) weakremover(libsqlcipher-3_34_1-0) weakremover(libsqlcipher-3_36_0-0) weakremover(libsqlcipher-3_37_2-0) weakremover(libsqlcipher-3_39_2-0) weakremover(libsqlcipher-3_39_4-0) weakremover(libsqlite3-0) weakremover(libsqlparser1) weakremover(libsquirrel1001) weakremover(libsratom-0-0) weakremover(libsratom-0-devel) weakremover(libsrecord0) weakremover(libsrt1) weakremover(libsrt1_4) weakremover(libsrt1_5) weakremover(libsrtp-devel) weakremover(libsrtp1) weakremover(libsrtp2-1) weakremover(libsrtp2-devel) weakremover(libsrtp2-linphone-devel) weakremover(libsrtp2-linphone1) weakremover(libssh-config) weakremover(libssh-devel) weakremover(libssh-devel-doc) weakremover(libssh2-1) weakremover(libssh2-devel) weakremover(libssh4) weakremover(libssl38) weakremover(libssl43) weakremover(libssl45) weakremover(libssl46) weakremover(libssl47) weakremover(libssl48) weakremover(libssl50) weakremover(libssl52) weakremover(libssl53) weakremover(libsss_certmap-devel) weakremover(libsss_certmap0) weakremover(libsss_idmap-devel) weakremover(libsss_idmap0) weakremover(libsss_nss_idmap-devel) weakremover(libsss_nss_idmap0) weakremover(libsss_simpleifp-devel) weakremover(libsss_simpleifp0) weakremover(libsss_sudo) weakremover(libstaroffice-0_0-0) weakremover(libstaroffice-devel) weakremover(libstaroffice-tools) weakremover(libstartup-notification-1-0) weakremover(libstatgrab-devel) weakremover(libstatgrab10) weakremover(libstatgrab6) weakremover(libstdc++-devel) weakremover(libstdc++48-devel) weakremover(libstdc++48-doc) weakremover(libstdc++6) weakremover(libstdc++6-devel-gcc10) weakremover(libstdc++6-devel-gcc11) weakremover(libstdc++6-devel-gcc12) weakremover(libstdc++6-devel-gcc13) weakremover(libstdc++6-devel-gcc5) weakremover(libstdc++6-devel-gcc6) weakremover(libstdc++6-devel-gcc7) weakremover(libstdc++6-devel-gcc8) weakremover(libstdc++6-devel-gcc9) weakremover(libstdc++6-gcc10) weakremover(libstdc++6-gcc10-locale) weakremover(libstdc++6-gcc11) weakremover(libstdc++6-gcc11-locale) weakremover(libstdc++6-gcc12) weakremover(libstdc++6-gcc12-locale) weakremover(libstdc++6-gcc48) weakremover(libstdc++6-gcc48-locale) weakremover(libstdc++6-gcc5) weakremover(libstdc++6-gcc5-locale) weakremover(libstdc++6-gcc6) weakremover(libstdc++6-gcc6-doc) weakremover(libstdc++6-gcc6-locale) weakremover(libstdc++6-gcc7) weakremover(libstdc++6-gcc7-locale) weakremover(libstdc++6-gcc8) weakremover(libstdc++6-gcc8-locale) weakremover(libstdc++6-gcc9) weakremover(libstdc++6-gcc9-locale) weakremover(libstdc++6-locale) weakremover(libstdc++6-pp) weakremover(libstdc++6-pp-gcc10) weakremover(libstdc++6-pp-gcc11) weakremover(libstdc++6-pp-gcc12) weakremover(libstdc++6-pp-gcc9) weakremover(libstellarsolver1) weakremover(libstellarsolver2) weakremover(libstemmer0d) weakremover(libstfl-devel) weakremover(libstfl0) weakremover(libstilview-devel) weakremover(libstilview0) weakremover(libstk-devel) weakremover(libstk4) weakremover(libstk4.6.2) weakremover(libstl-thumb) weakremover(libstlink-shared1) weakremover(libstlink1) weakremover(libstoken1) weakremover(libstorage-devel) weakremover(libstorage-ng-devel) weakremover(libstorage-ng-python3) weakremover(libstorage-ng-ruby) weakremover(libstorage-ng-utils) weakremover(libstorage-ng1) weakremover(libstorage-python) weakremover(libstorage-ruby) weakremover(libstorage-testsuite) weakremover(libstorage7) weakremover(libstoragemgmt) weakremover(libstoragemgmt-devel) weakremover(libstoragemgmt-netapp-plugin) weakremover(libstoragemgmt-nfs-plugin) weakremover(libstoragemgmt-nfs-plugin-clibs) weakremover(libstoragemgmt-nstor-plugin) weakremover(libstoragemgmt-udev) weakremover(libstoragemgmt1) weakremover(libstp2_1) weakremover(libstp2_3) weakremover(libstroke) weakremover(libstroke-devel) weakremover(libstroke0) weakremover(libstrophe-devel) weakremover(libstrophe0) weakremover(libsubid-devel) weakremover(libsubid3) weakremover(libsubid4) weakremover(libsubtitleeditor-devel) weakremover(libsubtitleeditor0) weakremover(libsubunit0) weakremover(libsuil-0-0) weakremover(libsuitesparseconfig-4_4_5) weakremover(libsuitesparseconfig-4_5_5) weakremover(libsuitesparseconfig5) weakremover(libsundials3) weakremover(libsundials3-mvapich2) weakremover(libsundials3-openmpi1) weakremover(libsundials3-openmpi2) weakremover(libsundials3-openmpi3) weakremover(libsundials3-openmpi4) weakremover(libsundials4) weakremover(libsundials4-mvapich2) weakremover(libsundials4-openmpi1) weakremover(libsundials4-openmpi2) weakremover(libsundials4-openmpi3) weakremover(libsundials4-openmpi4) weakremover(libsundials_arkode4) weakremover(libsundials_arkode4-mvapich2) weakremover(libsundials_arkode4-openmpi1) weakremover(libsundials_arkode4-openmpi2) weakremover(libsundials_arkode4-openmpi3) weakremover(libsundials_arkode4-openmpi4) weakremover(libsundials_arkode5) weakremover(libsundials_arkode5-mvapich2) weakremover(libsundials_arkode5-openmpi1) weakremover(libsundials_arkode5-openmpi2) weakremover(libsundials_arkode5-openmpi3) weakremover(libsundials_arkode5-openmpi4) weakremover(libsundials_cvode5) weakremover(libsundials_cvode5-mvapich2) weakremover(libsundials_cvode5-openmpi1) weakremover(libsundials_cvode5-openmpi2) weakremover(libsundials_cvode5-openmpi3) weakremover(libsundials_cvode5-openmpi4) weakremover(libsundials_cvode6) weakremover(libsundials_cvode6-mvapich2) weakremover(libsundials_cvode6-openmpi1) weakremover(libsundials_cvode6-openmpi2) weakremover(libsundials_cvode6-openmpi3) weakremover(libsundials_cvode6-openmpi4) weakremover(libsundials_cvodes5) weakremover(libsundials_cvodes5-mvapich2) weakremover(libsundials_cvodes5-openmpi1) weakremover(libsundials_cvodes5-openmpi2) weakremover(libsundials_cvodes5-openmpi3) weakremover(libsundials_cvodes5-openmpi4) weakremover(libsundials_cvodes6) weakremover(libsundials_cvodes6-mvapich2) weakremover(libsundials_cvodes6-openmpi1) weakremover(libsundials_cvodes6-openmpi2) weakremover(libsundials_cvodes6-openmpi3) weakremover(libsundials_cvodes6-openmpi4) weakremover(libsundials_generic5) weakremover(libsundials_generic5-mvapich2) weakremover(libsundials_generic5-openmpi1) weakremover(libsundials_generic5-openmpi2) weakremover(libsundials_generic5-openmpi3) weakremover(libsundials_generic5-openmpi4) weakremover(libsundials_generic6) weakremover(libsundials_generic6-mvapich2) weakremover(libsundials_generic6-openmpi1) weakremover(libsundials_generic6-openmpi2) weakremover(libsundials_generic6-openmpi3) weakremover(libsundials_generic6-openmpi4) weakremover(libsundials_ida5) weakremover(libsundials_ida5-mvapich2) weakremover(libsundials_ida5-openmpi1) weakremover(libsundials_ida5-openmpi2) weakremover(libsundials_ida5-openmpi3) weakremover(libsundials_ida5-openmpi4) weakremover(libsundials_ida6) weakremover(libsundials_ida6-mvapich2) weakremover(libsundials_ida6-openmpi1) weakremover(libsundials_ida6-openmpi2) weakremover(libsundials_ida6-openmpi3) weakremover(libsundials_ida6-openmpi4) weakremover(libsundials_idas4) weakremover(libsundials_idas4-mvapich2) weakremover(libsundials_idas4-openmpi1) weakremover(libsundials_idas4-openmpi2) weakremover(libsundials_idas4-openmpi3) weakremover(libsundials_idas4-openmpi4) weakremover(libsundials_idas5) weakremover(libsundials_idas5-mvapich2) weakremover(libsundials_idas5-openmpi1) weakremover(libsundials_idas5-openmpi2) weakremover(libsundials_idas5-openmpi3) weakremover(libsundials_idas5-openmpi4) weakremover(libsundials_kinsol5) weakremover(libsundials_kinsol5-mvapich2) weakremover(libsundials_kinsol5-openmpi1) weakremover(libsundials_kinsol5-openmpi2) weakremover(libsundials_kinsol5-openmpi3) weakremover(libsundials_kinsol5-openmpi4) weakremover(libsundials_kinsol6) weakremover(libsundials_kinsol6-mvapich2) weakremover(libsundials_kinsol6-openmpi1) weakremover(libsundials_kinsol6-openmpi2) weakremover(libsundials_kinsol6-openmpi3) weakremover(libsundials_kinsol6-openmpi4) weakremover(libsundials_nvec5) weakremover(libsundials_nvec5-mvapich2) weakremover(libsundials_nvec5-openmpi1) weakremover(libsundials_nvec5-openmpi2) weakremover(libsundials_nvec5-openmpi3) weakremover(libsundials_nvec5-openmpi4) weakremover(libsundials_nvec6) weakremover(libsundials_nvec6-mvapich2) weakremover(libsundials_nvec6-openmpi1) weakremover(libsundials_nvec6-openmpi2) weakremover(libsundials_nvec6-openmpi3) weakremover(libsundials_nvec6-openmpi4) weakremover(libsundials_sunlinsol4_3_0) weakremover(libsundials_sunlinsol4_3_0-mvapich2) weakremover(libsundials_sunlinsol4_3_0-openmpi1) weakremover(libsundials_sunlinsol4_3_0-openmpi2) weakremover(libsundials_sunlinsol4_3_0-openmpi3) weakremover(libsundials_sunlinsol4_3_0-openmpi4) weakremover(libsundials_sunmatrix4) weakremover(libsundials_sunmatrix4-mvapich2) weakremover(libsundials_sunmatrix4-openmpi1) weakremover(libsundials_sunmatrix4-openmpi2) weakremover(libsundials_sunmatrix4-openmpi3) weakremover(libsundials_sunmatrix4-openmpi4) weakremover(libsundials_sunnonlin3_3_0) weakremover(libsundials_sunnonlin3_3_0-mvapich2) weakremover(libsundials_sunnonlin3_3_0-openmpi1) weakremover(libsundials_sunnonlin3_3_0-openmpi2) weakremover(libsundials_sunnonlin3_3_0-openmpi3) weakremover(libsundials_sunnonlin3_3_0-openmpi4) weakremover(libsunpinyin3) weakremover(libsuperlu) weakremover(libsuperlu-gnu-hpc) weakremover(libsuperlu5) weakremover(libsuperlu6) weakremover(libsuperlu_5_2_1-gnu-hpc) weakremover(libsuperlu_5_2_2-gnu-hpc) weakremover(libsuperlu_5_3_0-gnu-hpc) weakremover(libsuperlu_6_0_0-gnu-hpc) weakremover(libsurgescript0_5_5) weakremover(libsurgescript0_5_6) weakremover(libsuseconnect) weakremover(libsvm-devel) weakremover(libsvm2) weakremover(libsvm3) weakremover(libsvn_auth_gnome_keyring-1-0) weakremover(libsvn_auth_kwallet-1-0) weakremover(libsvrcore0) weakremover(libswitchboard-2_0-0) weakremover(libsword-1_7_4) weakremover(libsword-1_7_5) weakremover(libsword-1_8_1) weakremover(libswresample-devel) weakremover(libswresample1) weakremover(libswresample2) weakremover(libswresample3) weakremover(libswresample3_7) weakremover(libswresample3_9) weakremover(libswresample4) weakremover(libswresample4_ff5) weakremover(libswscale-devel) weakremover(libswscale3) weakremover(libswscale4) weakremover(libswscale5) weakremover(libswscale5_7) weakremover(libswscale5_9) weakremover(libswscale6) weakremover(libswscale7) weakremover(libsybdb5) weakremover(libsymmetrica2) weakremover(libsympol0_1) weakremover(libsymspg1) weakremover(libsyn123-0) weakremover(libsynce-devel) weakremover(libsynce0) weakremover(libsynctex1) weakremover(libsynctex2) weakremover(libsysfs2) weakremover(libsysstat-qt5-0) weakremover(libsysstat-qt5-devel) weakremover(libsystemd0) weakremover(libsystemd0-mini) weakremover(libsz2) weakremover(libt3config-devel) weakremover(libt3config0) weakremover(libt3highlight-devel) weakremover(libt3highlight-utils) weakremover(libt3highlight1) weakremover(libt3highlight2) weakremover(libt3key-devel) weakremover(libt3key-utils) weakremover(libt3key1) weakremover(libt3widget-devel) weakremover(libt3widget1) weakremover(libt3widget2) weakremover(libt3window-devel) weakremover(libt3window0) weakremover(libta-devel) weakremover(libta_lib0) weakremover(libtachyon-0_99_4) weakremover(libtachyon-0_99_5) weakremover(libtachyon-0_99b6) weakremover(libtachyon-devel) weakremover(libtag-devel) weakremover(libtag-extras1) weakremover(libtag1) weakremover(libtag_c0) weakremover(libtaginfo-devel) weakremover(libtaginfo1) weakremover(libtaginfo_c0) weakremover(libtalloc-devel) weakremover(libtalloc2) weakremover(libtar) weakremover(libtar-devel) weakremover(libtar1) weakremover(libtasn1) weakremover(libtasn1-6) weakremover(libtasn1-devel) weakremover(libtasn1-tools) weakremover(libtbb12) weakremover(libtbb2) weakremover(libtbbbind_2_5-3) weakremover(libtbbmalloc2) weakremover(libtcmalloc4) weakremover(libtcmalloc_and_profiler4) weakremover(libtcmalloc_debug4) weakremover(libtcmalloc_minimal4) weakremover(libtcmalloc_minimal_debug4) weakremover(libtcmu-devel) weakremover(libtcmu1) weakremover(libtcmu2) weakremover(libtcnative-1-0) weakremover(libtcnative-1-0-devel) weakremover(libtcti-device0) weakremover(libtcti-socket0) weakremover(libtcti-tabrmd0) weakremover(libtdb-devel) weakremover(libtdb1) weakremover(libtdsodbc0) weakremover(libteam-devel) weakremover(libteam-tools) weakremover(libteam5) weakremover(libteamdctl0) weakremover(libtecla_r1) weakremover(libteec1) weakremover(libtelepathy-farstream3) weakremover(libtelepathy-glib0) weakremover(libtelepathy-logger-qt5) weakremover(libtelepathy-logger3) weakremover(libtelepathy-qt4-2) weakremover(libtelepathy-qt4-farstream2) weakremover(libtelepathy-qt5-0) weakremover(libtelepathy-qt5-farstream0) weakremover(libtelepathy-qt5-service0) weakremover(libtelepathy-qt5-service1) weakremover(libtemplate_glib-1_0-0) weakremover(libtensorflow1) weakremover(libtensorflow2) weakremover(libtensorflow2-gnu-hpc) weakremover(libtensorflow2-gnu-mvapich2-hpc) weakremover(libtensorflow2-gnu-openmpi2-hpc) weakremover(libtensorflow_cc1) weakremover(libtensorflow_cc2) weakremover(libtensorflow_cc2-gnu-hpc) weakremover(libtensorflow_cc2-gnu-mvapich2-hpc) weakremover(libtensorflow_cc2-gnu-openmpi2-hpc) weakremover(libtensorflow_framework1) weakremover(libtensorflow_framework2) weakremover(libtensorflow_framework2-gnu-hpc) weakremover(libtensorflow_framework2-gnu-mvapich2-hpc) weakremover(libtensorflow_framework2-gnu-openmpi2-hpc) weakremover(libtepl-3-0) weakremover(libtepl-4-0) weakremover(libtepl-5-0) weakremover(libtepl-6-0) weakremover(libtepl-6-1) weakremover(libtepl-6-2) weakremover(libteredo5) weakremover(libterminalwidget5-0) weakremover(libtermkey-devel) weakremover(libtermkey1) weakremover(libtesseract-5_3_0) weakremover(libtesseract3) weakremover(libtesseract4) weakremover(libtestshade1_10) weakremover(libtestshade1_11) weakremover(libtestshade1_12) weakremover(libtestshade1_9) weakremover(libtevent-devel) weakremover(libtevent-util-devel) weakremover(libtevent-util0) weakremover(libtevent0) weakremover(libtexlua52-5) weakremover(libtexlua53-5) weakremover(libtexluajit2) weakremover(libtexpdf-devel) weakremover(libtexpdf0) weakremover(libtextstyle-devel) weakremover(libtextstyle0) weakremover(libtfm1) weakremover(libthai-data) weakremover(libthai-devel) weakremover(libthai0) weakremover(libtheora-devel) weakremover(libtheora0) weakremover(libtheoradec1) weakremover(libtheoraenc1) weakremover(libthrift-0_10_0) weakremover(libthrift-0_11_0) weakremover(libthrift-0_12_0) weakremover(libthrift-0_13_0) weakremover(libthrift-0_14_1) weakremover(libthrift-0_15_0) weakremover(libthrift-0_16_0) weakremover(libthrift-0_17_0) weakremover(libthrift-0_9_2) weakremover(libthrift-devel) weakremover(libthrift_c_glib0) weakremover(libthriftnb-0_12_0) weakremover(libthriftnb-0_13_0) weakremover(libthriftnb-0_14_1) weakremover(libthriftnb-0_15_0) weakremover(libthriftnb-0_16_0) weakremover(libthriftnb-0_17_0) weakremover(libthriftz-0_12_0) weakremover(libthriftz-0_13_0) weakremover(libthriftz-0_14_1) weakremover(libthriftz-0_15_0) weakremover(libthriftz-0_16_0) weakremover(libthriftz-0_17_0) weakremover(libthunarx-2-0) weakremover(libthunarx-3-0) weakremover(libtidy-0_99-0) weakremover(libtidy-0_99-0-devel) weakremover(libtidy-devel) weakremover(libtidy5) weakremover(libtidy58) weakremover(libtidyp-1_04-0) weakremover(libtidyp-devel) weakremover(libtiff-devel) weakremover(libtiff5) weakremover(libtiff6) weakremover(libtiger-devel) weakremover(libtiger5) weakremover(libtiled1) weakremover(libtimelineDecoder21) weakremover(libtimelineDecoder21-opencl) weakremover(libtimelineDecoder22) weakremover(libtimelineDecoder22-opencl) weakremover(libtimelineDecoder23) weakremover(libtimelineDecoder23-opencl) weakremover(libtimelineDecoder24) weakremover(libtimelineDecoder24-opencl) weakremover(libtimelineDecoder25) weakremover(libtimelineDecoder25-opencl) weakremover(libtimelineDecoder27) weakremover(libtimelineDecoder27-opencl) weakremover(libtimelineDecoder28) weakremover(libtimelineDecoder28-opencl) weakremover(libtimelineDecoder31) weakremover(libtimelineDecoder31-opencl) weakremover(libtimelineDecoder32) weakremover(libtimelineDecoder32-opencl) weakremover(libtimelineDecoderJson22) weakremover(libtimelineDecoderJson22-opencl) weakremover(libtimelineDecoderJson23) weakremover(libtimelineDecoderJson23-opencl) weakremover(libtimelineDecoderJson24) weakremover(libtimelineDecoderJson24-opencl) weakremover(libtimelineDecoderJson25) weakremover(libtimelineDecoderJson25-opencl) weakremover(libtimelineDecoderJson27) weakremover(libtimelineDecoderJson27-opencl) weakremover(libtimelineDecoderJson28) weakremover(libtimelineDecoderJson28-opencl) weakremover(libtimelineDecoderJson31) weakremover(libtimelineDecoderJson31-opencl) weakremover(libtimelineDecoderJson32) weakremover(libtimelineDecoderJson32-opencl) weakremover(libtimezonemap1) weakremover(libtimidity-0_1-0) weakremover(libtimidity-devel) weakremover(libtimidity2) weakremover(libtins-devel) weakremover(libtins3) weakremover(libtins4_2) weakremover(libtins4_4) weakremover(libtinyb0) weakremover(libtinygettext0) weakremover(libtinyobjloader1) weakremover(libtinyobjloader2) weakremover(libtinyxml0) weakremover(libtinyxml2-3) weakremover(libtinyxml2-6) weakremover(libtinyxml2-8) weakremover(libtinyxml2-9) weakremover(libtirpc-devel) weakremover(libtirpc-netconfig) weakremover(libtirpc3) weakremover(libtls10) weakremover(libtls15) weakremover(libtls17) weakremover(libtls18) weakremover(libtls19) weakremover(libtls20) weakremover(libtls22) weakremover(libtls25) weakremover(libtls26) weakremover(libtntdb-devel) weakremover(libtntdb4) weakremover(libtntdb5) weakremover(libtokyocabinet-devel) weakremover(libtokyocabinet9) weakremover(libtolua++-5_1-1) weakremover(libtolua++-5_1-devel) weakremover(libtolua++-5_3-1) weakremover(libtolua++-5_3-devel) weakremover(libtolua++-5_4-1) weakremover(libtolua++-5_4-devel) weakremover(libtolua-devel) weakremover(libtolua5) weakremover(libtomahawk-devel) weakremover(libtomahawk-playdarapi0_8_4) weakremover(libtomahawk-playdarapi0_8_99) weakremover(libtomahawk-plugins) weakremover(libtomahawk-plugins-telepathy) weakremover(libtomahawk-plugins-telepathy-kde) weakremover(libtomahawk-widgets0_8_4) weakremover(libtomahawk-widgets0_8_99) weakremover(libtomahawk0_8_4) weakremover(libtomahawk0_8_99) weakremover(libtomcrypt-devel) weakremover(libtomcrypt-examples) weakremover(libtomcrypt0) weakremover(libtomcrypt1) weakremover(libtommath-devel) weakremover(libtommath-examples) weakremover(libtommath1) weakremover(libtomoe-gtk0) weakremover(libtool) weakremover(libtorch) weakremover(libtorrent-devel) weakremover(libtorrent-rasterbar-1-devel) weakremover(libtorrent-rasterbar-1-doc) weakremover(libtorrent-rasterbar-devel) weakremover(libtorrent-rasterbar10) weakremover(libtorrent-rasterbar2_0) weakremover(libtorrent-rasterbar9) weakremover(libtorrent18) weakremover(libtorrent19) weakremover(libtorrent21) weakremover(libtotem-plparser-mini18) weakremover(libtotem-plparser18) weakremover(libtotem_pg5) weakremover(libtowitoko2) weakremover(libtoxav2) weakremover(libtoxcore2) weakremover(libtoxencryptsave2) weakremover(libtpl-extensions3) weakremover(libtpm2_pkcs11-0) weakremover(libtpm_unseal1) weakremover(libtpms-devel) weakremover(libtpms0) weakremover(libtracecmd-devel) weakremover(libtracecmd1) weakremover(libtraceevent-devel) weakremover(libtraceevent1) weakremover(libtraceevent1-plugins) weakremover(libtracefs-devel) weakremover(libtracefs-tools) weakremover(libtracefs1) weakremover(libtracker-common-1_0) weakremover(libtracker-common-2_0) weakremover(libtracker-control-1_0-0) weakremover(libtracker-control-2_0-0) weakremover(libtracker-miner-1_0-0) weakremover(libtracker-miner-2_0-0) weakremover(libtracker-sparql-1_0-0) weakremover(libtracker-sparql-2_0-0) weakremover(libtracker-sparql-3_0-0) weakremover(libtrampoline1) weakremover(libtranscript-devel) weakremover(libtranscript1) weakremover(libtranslate-devel) weakremover(libtranslate-progs) weakremover(libtranslate0) weakremover(libtre5) weakremover(libtree-sitter0) weakremover(libtrilinos-gnu-mpich-hpc) weakremover(libtrilinos-gnu-mvapich2-hpc) weakremover(libtrilinos-gnu-openmpi2-hpc) weakremover(libtrilinos-gnu-openmpi3-hpc) weakremover(libtrilinos-gnu-openmpi4-hpc) weakremover(libtrilinos12) weakremover(libtrilinos12-openmpi2) weakremover(libtrilinos13) weakremover(libtrilinos13-openmpi2) weakremover(libtrilinos13-openmpi4) weakremover(libtrilinos14) weakremover(libtrilinos14-openmpi2) weakremover(libtrilinos14-openmpi4) weakremover(libtrilinos_12_10_1-gnu-mpich-hpc) weakremover(libtrilinos_12_10_1-gnu-mvapich2-hpc) weakremover(libtrilinos_12_10_1-gnu-openmpi2-hpc) weakremover(libtrilinos_12_14_1-gnu-mpich-hpc) weakremover(libtrilinos_12_14_1-gnu-mvapich2-hpc) weakremover(libtrilinos_12_14_1-gnu-openmpi2-hpc) weakremover(libtrilinos_12_14_1-gnu-openmpi3-hpc) weakremover(libtrilinos_12_14_1-gnu-openmpi4-hpc) weakremover(libtrilinos_13_0_0-gnu-mpich-hpc) weakremover(libtrilinos_13_0_0-gnu-mvapich2-hpc) weakremover(libtrilinos_13_0_0-gnu-openmpi2-hpc) weakremover(libtrilinos_13_0_0-gnu-openmpi3-hpc) weakremover(libtrilinos_13_0_0-gnu-openmpi4-hpc) weakremover(libtrilinos_13_0_1-gnu-mpich-hpc) weakremover(libtrilinos_13_0_1-gnu-mvapich2-hpc) weakremover(libtrilinos_13_0_1-gnu-openmpi2-hpc) weakremover(libtrilinos_13_0_1-gnu-openmpi3-hpc) weakremover(libtrilinos_13_0_1-gnu-openmpi4-hpc) weakremover(libtrilinos_13_2_0-gnu-mpich-hpc) weakremover(libtrilinos_13_2_0-gnu-mvapich2-hpc) weakremover(libtrilinos_13_2_0-gnu-openmpi2-hpc) weakremover(libtrilinos_13_2_0-gnu-openmpi3-hpc) weakremover(libtrilinos_13_2_0-gnu-openmpi4-hpc) weakremover(libtrilinos_14_0_0-gnu-mvapich2-hpc) weakremover(libtrilinos_14_0_0-gnu-openmpi2-hpc) weakremover(libtrilinos_14_0_0-gnu-openmpi3-hpc) weakremover(libtrilinos_14_0_0-gnu-openmpi4-hpc) weakremover(libtrng4-24) weakremover(libts-1_0-0) weakremover(libts0) weakremover(libtsan0) weakremover(libtsan0-gcc10) weakremover(libtsan0-gcc6) weakremover(libtsan0-gcc7) weakremover(libtsan0-gcc8) weakremover(libtsan0-gcc9) weakremover(libtsan2) weakremover(libtsan2-gcc12) weakremover(libtsk10) weakremover(libtsk13) weakremover(libtsk19) weakremover(libtsm-devel) weakremover(libtsm3) weakremover(libtsm4) weakremover(libtspi1) weakremover(libtss0) weakremover(libtss2-0) weakremover(libtss2-esys0) weakremover(libtss2-fapi1) weakremover(libtss2-mu0) weakremover(libtss2-policy0) weakremover(libtss2-rc0) weakremover(libtss2-sys0) weakremover(libtss2-sys1) weakremover(libtss2-tcti-cmd0) weakremover(libtss2-tcti-device0) weakremover(libtss2-tcti-mssim0) weakremover(libtss2-tcti-pcap0) weakremover(libtss2-tcti-spi-helper0) weakremover(libtss2-tcti-swtpm0) weakremover(libtss2-tcti-tabrmd0) weakremover(libtss2-tctildr0) weakremover(libtstl1) weakremover(libttf2) weakremover(libttsmimic0) weakremover(libtty-devel) weakremover(libtty1) weakremover(libtukit-devel) weakremover(libtukit0) weakremover(libtukit4) weakremover(libtumbler-1-0) weakremover(libtun6-0) weakremover(libtunepimp) weakremover(libtunepimp-devel) weakremover(libtunepimp5) weakremover(libturbojpeg0) weakremover(libturpial) weakremover(libturris-spectator-devel) weakremover(libturris-spectator0) weakremover(libtutf-devel) weakremover(libtutf1) weakremover(libtvm) weakremover(libtw-devel) weakremover(libtw1) weakremover(libtwolame-devel) weakremover(libtwolame0) weakremover(libtxc_dxtn) weakremover(libtxc_dxtn-devel) weakremover(libu2f-host-devel) weakremover(libu2f-host-doc) weakremover(libu2f-host0) weakremover(libu2f-server-devel) weakremover(libu2f-server-doc) weakremover(libu2f-server0) weakremover(libubsan0) weakremover(libubsan0-gcc5) weakremover(libubsan0-gcc6) weakremover(libubsan1) weakremover(libubsan1-gcc10) weakremover(libubsan1-gcc11) weakremover(libubsan1-gcc12) weakremover(libubsan1-gcc8) weakremover(libubsan1-gcc9) weakremover(libuchardet-devel) weakremover(libuchardet0) weakremover(libucil-devel) weakremover(libucil-doc) weakremover(libucil2) weakremover(libucl1) weakremover(libucl1-devel) weakremover(libucm-devel) weakremover(libucm0) weakremover(libucommon7) weakremover(libucommon8) weakremover(libucp-devel) weakremover(libucp0) weakremover(libucp2) weakremover(libucpp13) weakremover(libucs-devel) weakremover(libucs0) weakremover(libucs2) weakremover(libuct-devel) weakremover(libuct0) weakremover(libuct2) weakremover(libudev-devel) weakremover(libudev-mini-devel) weakremover(libudev-mini1) weakremover(libudev1) weakremover(libudf0) weakremover(libudisks2-0) weakremover(libudisks2-0-devel) weakremover(libudisks2-0_bcache) weakremover(libudisks2-0_btrfs) weakremover(libudisks2-0_lsm) weakremover(libudisks2-0_lvm2) weakremover(libudisks2-0_vdo) weakremover(libudisks2-0_zram) weakremover(libudisks2-qt5-0) weakremover(libudns0) weakremover(libudt-devel) weakremover(libudt0) weakremover(libudunits2-0) weakremover(libuev-devel) weakremover(libuev2) weakremover(libuev3) weakremover(libuhd003) weakremover(libuhd4_0_0) weakremover(libuhd4_1_0) weakremover(libuhd4_2_0) weakremover(libuhd4_3_0) weakremover(libuhd4_4_0) weakremover(libuhttpmock-0_0-0) weakremover(libuhttpmock-1_0-1) weakremover(libulfius2_5) weakremover(libulfius2_6) weakremover(libulfius2_7) weakremover(libulockmgr1) weakremover(libumfpack-5_7_1) weakremover(libumfpack-5_7_6) weakremover(libumfpack5) weakremover(libumockdev-preload0) weakremover(libumockdev0) weakremover(libuna-devel) weakremover(libuna-mini-devel) weakremover(libuna-tools) weakremover(libuna1) weakremover(libuna1-mini) weakremover(libunbound-devel-mini) weakremover(libunbound2) weakremover(libunbound8) weakremover(libunibilium0) weakremover(libunibilium4) weakremover(libunibreak-devel) weakremover(libunibreak3) weakremover(libunibreak5) weakremover(libunicap-devel) weakremover(libunicap2) weakremover(libuninameslist-devel) weakremover(libuninameslist0) weakremover(libuninameslist1) weakremover(libunique-1_0-0) weakremover(libunique-3_0-0) weakremover(libunique-devel) weakremover(libunique1-devel) weakremover(libunistring-devel) weakremover(libunistring0) weakremover(libunistring2) weakremover(libunistring5) weakremover(libunity-devel) weakremover(libunity-gtk-parser-devel) weakremover(libunity-gtk2-parser0) weakremover(libunity-gtk3-parser0) weakremover(libunity-tools) weakremover(libunity9) weakremover(libunshield-devel) weakremover(libunshield0) weakremover(libunshield1_3) weakremover(libunwind) weakremover(libunwind-coredump0) weakremover(libunwind-devel) weakremover(libunwind-ptrace0) weakremover(libunwind-setjmp0) weakremover(libunwind8) weakremover(libupb0) weakremover(libupb12) weakremover(libupb13) weakremover(libupb14) weakremover(libupb15) weakremover(libupb16) weakremover(libupb18) weakremover(libupb19) weakremover(libupb22) weakremover(libupb23) weakremover(libupb24) weakremover(libupb26) weakremover(libupb27) weakremover(libupb28) weakremover(libupb29) weakremover(libupm1) weakremover(libupnp-devel) weakremover(libupnp13) weakremover(libupnp15) weakremover(libupnp16) weakremover(libupnp17) weakremover(libupnp6) weakremover(libupnpp-devel) weakremover(libupnpp11) weakremover(libupnpp12) weakremover(libupnpp9) weakremover(libupower-glib-devel) weakremover(libupower-glib3) weakremover(libupsclient1) weakremover(libupsclient4) weakremover(libupsclient6) weakremover(liburcu-devel) weakremover(liburcu0) weakremover(liburcu2) weakremover(liburcu6) weakremover(liburcu8) weakremover(liburfkill-glib-devel) weakremover(liburfkill-glib0) weakremover(liburing-devel) weakremover(liburing1) weakremover(liburing2) weakremover(liburiparser-devel) weakremover(liburiparser1) weakremover(libusb-0_1-4) weakremover(libusb-1_0-0) weakremover(libusb-1_0-devel) weakremover(libusb-compat-devel) weakremover(libusb3380-0) weakremover(libusb3380-devel) weakremover(libusbauth-configparser-devel) weakremover(libusbauth-configparser1) weakremover(libusbg-devel) weakremover(libusbg-tools) weakremover(libusbg0) weakremover(libusbguard0) weakremover(libusbguard1) weakremover(libusbgx-devel) weakremover(libusbgx-tools) weakremover(libusbgx1) weakremover(libusbgx2) weakremover(libusbmuxd-2_0-6) weakremover(libusbmuxd-devel) weakremover(libusbmuxd-tools) weakremover(libusbmuxd4) weakremover(libusbmuxd6) weakremover(libusbprog0) weakremover(libusbredirhost1) weakremover(libusbredirparser1) weakremover(libuser) weakremover(libuser-devel) weakremover(libuser-lang) weakremover(libuser-python) weakremover(libuser1) weakremover(libusnic_verbs-rdmav2) weakremover(libusrp-3_4_2-0) weakremover(libusrp-3_4_4+git_20190808-0) weakremover(libusrp-devel) weakremover(libusrp1) weakremover(libusrsctp2) weakremover(libustr-1_0-1) weakremover(libustr-devel) weakremover(libustr-devel-static) weakremover(libut1) weakremover(libut2) weakremover(libutempter0) weakremover(libutf8proc1) weakremover(libutf8proc2) weakremover(libuuid-devel) weakremover(libuuid-devel-static) weakremover(libuuid1) weakremover(libuv-devel) weakremover(libuv1) weakremover(libuwac0-0) weakremover(libv3270-5_2) weakremover(libv3270-5_3) weakremover(libv3270-5_4) weakremover(libv3270-devel) weakremover(libv4l) weakremover(libv4l-devel) weakremover(libv4l1-0) weakremover(libv4l2-0) weakremover(libv4l2rds0) weakremover(libv4lconvert0) weakremover(libva-devel) weakremover(libva-drm1) weakremover(libva-drm2) weakremover(libva-egl1) weakremover(libva-gl-devel) weakremover(libva-glx1) weakremover(libva-glx2) weakremover(libva-utils) weakremover(libva-vdpau-driver) weakremover(libva-wayland1) weakremover(libva-wayland2) weakremover(libva-x11-1) weakremover(libva-x11-2) weakremover(libva1) weakremover(libva2) weakremover(libvacuumutils17) weakremover(libvacuumutils37) weakremover(libvala-0_32-0) weakremover(libvala-0_32-devel) weakremover(libvala-0_38-0) weakremover(libvala-0_38-devel) weakremover(libvala-0_42-0) weakremover(libvala-0_42-devel) weakremover(libvala-0_44-0) weakremover(libvala-0_44-devel) weakremover(libvala-0_46-0) weakremover(libvala-0_46-devel) weakremover(libvala-0_48-0) weakremover(libvala-0_48-devel) weakremover(libvala-0_50-0) weakremover(libvala-0_50-devel) weakremover(libvala-0_52-0) weakremover(libvala-0_52-devel) weakremover(libvala-0_54-0) weakremover(libvala-0_54-devel) weakremover(libvala-0_56-0) weakremover(libvala-0_56-devel) weakremover(libvaladoc-0_38-0) weakremover(libvaladoc-0_38-devel) weakremover(libvaladoc-0_42-0) weakremover(libvaladoc-0_42-devel) weakremover(libvaladoc-0_44-0) weakremover(libvaladoc-0_44-devel) weakremover(libvaladoc-0_46-0) weakremover(libvaladoc-0_46-devel) weakremover(libvaladoc-0_48-0) weakremover(libvaladoc-0_48-devel) weakremover(libvaladoc-0_50-0) weakremover(libvaladoc-0_50-devel) weakremover(libvaladoc-0_52-0) weakremover(libvaladoc-0_52-devel) weakremover(libvaladoc-0_54-0) weakremover(libvaladoc-0_54-devel) weakremover(libvaladoc-0_56-0) weakremover(libvaladoc-0_56-devel) weakremover(libvamp-hostsdk3) weakremover(libvamp-sdk2) weakremover(libvapoursynth-43) weakremover(libvapoursynth-45) weakremover(libvapoursynth-46) weakremover(libvapoursynth-49) weakremover(libvapoursynth-50) weakremover(libvapoursynth-51) weakremover(libvapoursynth-52) weakremover(libvapoursynth-53) weakremover(libvapoursynth-54) weakremover(libvapoursynth-62) weakremover(libvapoursynth-script0) weakremover(libvarnishapi1) weakremover(libvarnishapi2) weakremover(libvarnishapi3) weakremover(libvbr2) weakremover(libvc-devel) weakremover(libvc0) weakremover(libvcdinfo0) weakremover(libvdehist-devel) weakremover(libvdehist0) weakremover(libvdehist0-devel) weakremover(libvdemgmt-devel) weakremover(libvdemgmt0) weakremover(libvdemgmt0-devel) weakremover(libvdeplug-devel) weakremover(libvdeplug3) weakremover(libvdeplug3-devel) weakremover(libvdesnmp-devel) weakremover(libvdesnmp0) weakremover(libvdesnmp0-devel) weakremover(libvdpau-devel) weakremover(libvdpau1) weakremover(libvdpau_nouveau) weakremover(libvdpau_r300) weakremover(libvdpau_r600) weakremover(libvdpau_radeonsi) weakremover(libvdpau_trace1) weakremover(libvdpau_va_gl1) weakremover(libvdpau_virtio_gpu) weakremover(libventrilo3-0) weakremover(libventrilo3-devel) weakremover(libverdict1_4) weakremover(libverto-devel) weakremover(libverto-glib-devel) weakremover(libverto-glib1) weakremover(libverto-libev-devel) weakremover(libverto-libev1) weakremover(libverto-tevent-devel) weakremover(libverto-tevent1) weakremover(libverto1) weakremover(libvhdi-devel) weakremover(libvhdi-tools) weakremover(libvhdi1) weakremover(libvidstab-devel) weakremover(libvidstab1_1) weakremover(libvigraimpex11) weakremover(libvigraimpex5) weakremover(libvips-devel) weakremover(libvips42) weakremover(libvirglrenderer0) weakremover(libvirglrenderer1) weakremover(libvirt) weakremover(libvirt-admin) weakremover(libvirt-bash-completion) weakremover(libvirt-cim) weakremover(libvirt-client) weakremover(libvirt-client-qemu) weakremover(libvirt-daemon) weakremover(libvirt-daemon-common) weakremover(libvirt-daemon-config-network) weakremover(libvirt-daemon-config-nwfilter) weakremover(libvirt-daemon-driver-interface) weakremover(libvirt-daemon-driver-libxl) weakremover(libvirt-daemon-driver-lxc) weakremover(libvirt-daemon-driver-network) weakremover(libvirt-daemon-driver-nodedev) weakremover(libvirt-daemon-driver-nwfilter) weakremover(libvirt-daemon-driver-qemu) weakremover(libvirt-daemon-driver-secret) weakremover(libvirt-daemon-driver-storage) weakremover(libvirt-daemon-driver-storage-core) weakremover(libvirt-daemon-driver-storage-disk) weakremover(libvirt-daemon-driver-storage-gluster) weakremover(libvirt-daemon-driver-storage-iscsi) weakremover(libvirt-daemon-driver-storage-iscsi-direct) weakremover(libvirt-daemon-driver-storage-logical) weakremover(libvirt-daemon-driver-storage-mpath) weakremover(libvirt-daemon-driver-storage-rbd) weakremover(libvirt-daemon-driver-storage-scsi) weakremover(libvirt-daemon-driver-uml) weakremover(libvirt-daemon-hooks) weakremover(libvirt-daemon-lock) weakremover(libvirt-daemon-log) weakremover(libvirt-daemon-lxc) weakremover(libvirt-daemon-plugin-lockd) weakremover(libvirt-daemon-plugin-sanlock) weakremover(libvirt-daemon-proxy) weakremover(libvirt-daemon-qemu) weakremover(libvirt-daemon-uml) weakremover(libvirt-daemon-xen) weakremover(libvirt-dbus) weakremover(libvirt-devel) weakremover(libvirt-glib-1_0-0) weakremover(libvirt-glib-devel) weakremover(libvirt-libs) weakremover(libvirt-lock-sanlock) weakremover(libvirt-nss) weakremover(libvirt-python) weakremover(libvirt-sandbox-1_0-5) weakremover(libvirt-sandbox-devel) weakremover(libvisio-0_1-1) weakremover(libvisio-devel) weakremover(libvisio-tools) weakremover(libvisio2svg-devel) weakremover(libvisio2svg0) weakremover(libvisual) weakremover(libvisual-0_4-0) weakremover(libvisual-devel) weakremover(libvisual-plugins) weakremover(libvkd3d-shader1) weakremover(libvkd3d-utils1) weakremover(libvkd3d1) weakremover(libvlc5) weakremover(libvlccore8) weakremover(libvlccore9) weakremover(libvma) weakremover(libvma-devel) weakremover(libvma8) weakremover(libvma9) weakremover(libvmaf0) weakremover(libvmaf1) weakremover(libvmdk-devel) weakremover(libvmdk-tools) weakremover(libvmdk1) weakremover(libvmem-devel) weakremover(libvmem1) weakremover(libvmime-0_9_2-2) weakremover(libvmime-devel) weakremover(libvmime-kopano2) weakremover(libvmime-kopano3) weakremover(libvmime-suse4) weakremover(libvmime-suse5) weakremover(libvmime1) weakremover(libvmime_zarafa7-0) weakremover(libvmime_zarafa7-devel) weakremover(libvmmalloc-devel) weakremover(libvmmalloc1) weakremover(libvmtools-devel) weakremover(libvmtools0) weakremover(libvncclient0) weakremover(libvncclient1) weakremover(libvncserver0) weakremover(libvncserver1) weakremover(libvo-amrwbenc-devel) weakremover(libvo-amrwbenc0) weakremover(libvoikko-devel) weakremover(libvoikko1) weakremover(libvolk1_3) weakremover(libvolk1_4) weakremover(libvolk2_0) weakremover(libvolk2_1) weakremover(libvolk2_2_1) weakremover(libvolk2_3) weakremover(libvolk2_4) weakremover(libvolk2_5) weakremover(libvolk3_0) weakremover(libvomsapi1) weakremover(libvorbis-devel) weakremover(libvorbis0) weakremover(libvorbisenc2) weakremover(libvorbisfile3) weakremover(libvoro++0) weakremover(libvotca2022) weakremover(libvotca_csg2021) weakremover(libvotca_csg2022) weakremover(libvotca_csg4) weakremover(libvotca_csg5) weakremover(libvotca_csg6) weakremover(libvotca_ctp5) weakremover(libvotca_tools2) weakremover(libvotca_tools2021) weakremover(libvotca_tools2022) weakremover(libvotca_tools4) weakremover(libvotca_tools5) weakremover(libvotca_tools6) weakremover(libvotca_xtp2021) weakremover(libvotca_xtp2022) weakremover(libvotca_xtp5) weakremover(libvotca_xtp6) weakremover(libvotequorum8) weakremover(libvpd-2_2-3) weakremover(libvpd-base) weakremover(libvpd-devel) weakremover(libvpd2) weakremover(libvpd2-devel) weakremover(libvpl) weakremover(libvpl-devel) weakremover(libvpl-samples) weakremover(libvpl2) weakremover(libvpx-1_6-devel) weakremover(libvpx-devel) weakremover(libvpx1) weakremover(libvpx2) weakremover(libvpx4) weakremover(libvpx5) weakremover(libvpx6) weakremover(libvpx7) weakremover(libvpx8) weakremover(libvsapm-devel) weakremover(libvsapm-tools) weakremover(libvsapm1) weakremover(libvsgpt-devel) weakremover(libvsgpt-tools) weakremover(libvsgpt1) weakremover(libvshadow-devel) weakremover(libvshadow-tools) weakremover(libvshadow1) weakremover(libvslvm-devel) weakremover(libvslvm-tools) weakremover(libvslvm1) weakremover(libvsmbr-devel) weakremover(libvsmbr-tools) weakremover(libvsmbr1) weakremover(libvsqlitepp3) weakremover(libvte-2_91-0) weakremover(libvte9) weakremover(libvted-3-0) weakremover(libvterm-devel) weakremover(libvterm-tools) weakremover(libvterm0) weakremover(libvtk-m-1_9) weakremover(libvtk-m-1_9-mpich) weakremover(libvtk-m-1_9-openmpi3) weakremover(libvtk-m-1_9-openmpi4) weakremover(libvtk-m-2_0) weakremover(libvtk-m-mpich-2_0) weakremover(libvtk-m-openmpi3-2_0) weakremover(libvtk-m-openmpi4-2_0) weakremover(libvtk1) weakremover(libvtk1-openmpi) weakremover(libvtk1-openmpi1) weakremover(libvtk1-openmpi2) weakremover(libvtk1-openmpi3) weakremover(libvtk1-openmpi4) weakremover(libvulkan1) weakremover(libvulkan_broadcom) weakremover(libvulkan_freedreno) weakremover(libvulkan_lvp) weakremover(libvulkan_radeon) weakremover(libwacom-data) weakremover(libwacom-devel) weakremover(libwacom-tools) weakremover(libwacom2) weakremover(libwacom9) weakremover(libwaffle-1-0) weakremover(libwaltham0) weakremover(libwapcaplet-devel) weakremover(libwapcaplet0) weakremover(libwavpack1) weakremover(libwayland-client0) weakremover(libwayland-cursor0) weakremover(libwayland-egl-devel) weakremover(libwayland-egl1) weakremover(libwayland-server0) weakremover(libwaylandpp0) weakremover(libwbclient-devel) weakremover(libwbclient0) weakremover(libwbxml2-0) weakremover(libwbxml2-1) weakremover(libwbxml2-devel) weakremover(libwcs5) weakremover(libwcs6) weakremover(libwcs7) weakremover(libwebcam-devel) weakremover(libwebcam0) weakremover(libwebkit2gtk-4_0-37) weakremover(libwebkit2gtk-4_1-0) weakremover(libwebkit2gtk-5_0-0) weakremover(libwebkitgtk-1_0-0) weakremover(libwebkitgtk-3_0-0) weakremover(libwebkitgtk-devel) weakremover(libwebkitgtk2-lang) weakremover(libwebkitgtk3-devel) weakremover(libwebkitgtk3-lang) weakremover(libwebkitgtk6_0-4) weakremover(libwebp-devel) weakremover(libwebp-tools) weakremover(libwebp2-0_1_0) weakremover(libwebp2-devel) weakremover(libwebp2-tools) weakremover(libwebp5) weakremover(libwebp6) weakremover(libwebp7) weakremover(libwebpdecoder1) weakremover(libwebpdecoder2) weakremover(libwebpdecoder3) weakremover(libwebpdemux1) weakremover(libwebpdemux2) weakremover(libwebpextras0) weakremover(libwebpmux1) weakremover(libwebpmux2) weakremover(libwebpmux3) weakremover(libwebrtc_audio_processing-devel) weakremover(libwebrtc_audio_processing-devel-static) weakremover(libwebrtc_audio_processing1) weakremover(libwebsockets-devel) weakremover(libwebsockets12) weakremover(libwebsockets13) weakremover(libwebsockets15) weakremover(libwebsockets16) weakremover(libwebsockets17) weakremover(libwebsockets18) weakremover(libwebsockets19) weakremover(libweston-10) weakremover(libweston-10-0) weakremover(libweston-11) weakremover(libweston-11-0) weakremover(libweston-3) weakremover(libweston-3-0) weakremover(libweston-5) weakremover(libweston-5-0) weakremover(libweston-6) weakremover(libweston-6-0) weakremover(libweston-7) weakremover(libweston-7-0) weakremover(libweston-8) weakremover(libweston-8-0) weakremover(libweston-9) weakremover(libweston-9-0) weakremover(libweston-desktop-10-0) weakremover(libweston-desktop-3-0) weakremover(libweston-desktop-5-0) weakremover(libweston-desktop-6-0) weakremover(libweston-desktop-7-0) weakremover(libweston-desktop-8-0) weakremover(libweston-desktop-9-0) weakremover(libwget-devel) weakremover(libwget0) weakremover(libwget1) weakremover(libwhich) weakremover(libwicked-0-6) weakremover(libwiiuse0) weakremover(libwim15) weakremover(libwind0) weakremover(libwinpr2) weakremover(libwinpr2-2) weakremover(libwireplumber-0_4-0) weakremover(libwireshark10) weakremover(libwireshark12) weakremover(libwireshark13) weakremover(libwireshark14) weakremover(libwireshark15) weakremover(libwireshark16) weakremover(libwireshark9) weakremover(libwiretap10) weakremover(libwiretap11) weakremover(libwiretap12) weakremover(libwiretap13) weakremover(libwiretap7) weakremover(libwiretap8) weakremover(libwiretap9) weakremover(libwkhtmltox0) weakremover(libwlc0) weakremover(libwlroots1) weakremover(libwlroots10) weakremover(libwlroots11) weakremover(libwlroots2) weakremover(libwlroots3) weakremover(libwlroots5) weakremover(libwlroots6) weakremover(libwlroots7) weakremover(libwlroots8) weakremover(libwlroots9) weakremover(libwmf-0_2-7) weakremover(libwmf-devel) weakremover(libwmf-gnome) weakremover(libwmf-tools) weakremover(libwnck-1-22) weakremover(libwnck-3-0) weakremover(libwnck-devel) weakremover(libwnck-tools) weakremover(libwnck2-devel) weakremover(libwnn0) weakremover(libwoff2common1_0_2) weakremover(libwoff2dec1_0_2) weakremover(libwoff2enc1_0_2) weakremover(libwordcut0) weakremover(libwpd-0_10-10) weakremover(libwpd-devel) weakremover(libwpd-tools) weakremover(libwpe-1_0-1) weakremover(libwpe-devel) weakremover(libwpg-0_3-3) weakremover(libwpg-devel) weakremover(libwpg-tools) weakremover(libwps-0_4-4) weakremover(libwps-devel) weakremover(libwps-tools) weakremover(libwrap0) weakremover(libwrc-devel) weakremover(libwrc-tools) weakremover(libwrc1) weakremover(libwscodecs1) weakremover(libwscodecs2) weakremover(libwslay0) weakremover(libwsman-devel) weakremover(libwsman1) weakremover(libwsman3) weakremover(libwsman_client5) weakremover(libwsman_clientpp-devel) weakremover(libwsman_clientpp1) weakremover(libwsutil10) weakremover(libwsutil11) weakremover(libwsutil12) weakremover(libwsutil13) weakremover(libwsutil14) weakremover(libwsutil8) weakremover(libwsutil9) weakremover(libwtcdb-devel) weakremover(libwtcdb-tools) weakremover(libwtcdb1) weakremover(libwtdbo45) weakremover(libwtdbo4_2_0) weakremover(libwtdbo4_2_2) weakremover(libwtdbo4_4_0) weakremover(libwtdbo4_5_0) weakremover(libwtdbo4_5_1) weakremover(libwtdbo4_6_1) weakremover(libwtdbo4_8_1) weakremover(libwtdbo51) weakremover(libwtdbomysql38) weakremover(libwtdbomysql45) weakremover(libwtdbomysql4_2_0) weakremover(libwtdbomysql4_2_2) weakremover(libwtdbomysql4_4_0) weakremover(libwtdbomysql4_5_0) weakremover(libwtdbomysql4_5_1) weakremover(libwtdbomysql4_6_1) weakremover(libwtdbomysql4_8_1) weakremover(libwtdbomysql51) weakremover(libwtdbopostgres38) weakremover(libwtdbopostgres45) weakremover(libwtdbopostgres4_2_0) weakremover(libwtdbopostgres4_2_2) weakremover(libwtdbopostgres4_4_0) weakremover(libwtdbopostgres4_5_0) weakremover(libwtdbopostgres4_5_1) weakremover(libwtdbopostgres4_6_1) weakremover(libwtdbopostgres4_8_1) weakremover(libwtdbopostgres51) weakremover(libwtmpdb0) weakremover(libwv-1_2-3) weakremover(libwv-1_2-4) weakremover(libwv2-4) weakremover(libwx_base-2_8-0-compat-lib-wxcontainer) weakremover(libwx_base-2_8-0-wxcontainer) weakremover(libwx_base-suse-devel) weakremover(libwx_base-suse-nostl-devel) weakremover(libwx_base_net-2_8-0-compat-lib-wxcontainer) weakremover(libwx_base_net-2_8-0-wxcontainer) weakremover(libwx_base_xml-2_8-0-compat-lib-wxcontainer) weakremover(libwx_base_xml-2_8-0-wxcontainer) weakremover(libwx_baseu-2_8-0-compat-lib-stl) weakremover(libwx_baseu-2_8-0-compat-lib-wxcontainer) weakremover(libwx_baseu-2_8-0-compat-lib-wxcontainer24c) weakremover(libwx_baseu-2_8-0-stl) weakremover(libwx_baseu-2_8-0-wxcontainer) weakremover(libwx_baseu-2_8-0-wxcontainer24c) weakremover(libwx_baseu-suse-nostl1) weakremover(libwx_baseu-suse-nostl3) weakremover(libwx_baseu-suse-nostl3_0_4) weakremover(libwx_baseu-suse-nostl3_0_5) weakremover(libwx_baseu-suse-nostl3_1_3) weakremover(libwx_baseu-suse-nostl4_0_0) weakremover(libwx_baseu-suse-nostl5_0_0) weakremover(libwx_baseu-suse-nostl8_0_0) weakremover(libwx_baseu-suse-nostl9_0_0) weakremover(libwx_baseu-suse1) weakremover(libwx_baseu-suse3) weakremover(libwx_baseu-suse3_0_4) weakremover(libwx_baseu-suse3_0_5) weakremover(libwx_baseu-suse3_1_1) weakremover(libwx_baseu-suse3_1_2) weakremover(libwx_baseu-suse3_1_3) weakremover(libwx_baseu-suse4_0_0) weakremover(libwx_baseu-suse5_0_0) weakremover(libwx_baseu-suse8_0_0) weakremover(libwx_baseu-suse9_0_0) weakremover(libwx_baseu_net-2_8-0-compat-lib-stl) weakremover(libwx_baseu_net-2_8-0-compat-lib-wxcontainer) weakremover(libwx_baseu_net-2_8-0-compat-lib-wxcontainer24c) weakremover(libwx_baseu_net-2_8-0-stl) weakremover(libwx_baseu_net-2_8-0-wxcontainer) weakremover(libwx_baseu_net-2_8-0-wxcontainer24c) weakremover(libwx_baseu_net-suse-nostl1) weakremover(libwx_baseu_net-suse-nostl3) weakremover(libwx_baseu_net-suse-nostl3_0_4) weakremover(libwx_baseu_net-suse-nostl3_0_5) weakremover(libwx_baseu_net-suse-nostl3_1_3) weakremover(libwx_baseu_net-suse-nostl4_0_0) weakremover(libwx_baseu_net-suse-nostl5_0_0) weakremover(libwx_baseu_net-suse-nostl8_0_0) weakremover(libwx_baseu_net-suse-nostl9_0_0) weakremover(libwx_baseu_net-suse1) weakremover(libwx_baseu_net-suse3) weakremover(libwx_baseu_net-suse3_0_4) weakremover(libwx_baseu_net-suse3_0_5) weakremover(libwx_baseu_net-suse3_1_1) weakremover(libwx_baseu_net-suse3_1_2) weakremover(libwx_baseu_net-suse3_1_3) weakremover(libwx_baseu_net-suse4_0_0) weakremover(libwx_baseu_net-suse5_0_0) weakremover(libwx_baseu_net-suse8_0_0) weakremover(libwx_baseu_net-suse9_0_0) weakremover(libwx_baseu_xml-2_8-0-compat-lib-stl) weakremover(libwx_baseu_xml-2_8-0-compat-lib-wxcontainer) weakremover(libwx_baseu_xml-2_8-0-compat-lib-wxcontainer24c) weakremover(libwx_baseu_xml-2_8-0-stl) weakremover(libwx_baseu_xml-2_8-0-wxcontainer) weakremover(libwx_baseu_xml-2_8-0-wxcontainer24c) weakremover(libwx_baseu_xml-suse-nostl1) weakremover(libwx_baseu_xml-suse-nostl3) weakremover(libwx_baseu_xml-suse-nostl3_0_4) weakremover(libwx_baseu_xml-suse-nostl3_0_5) weakremover(libwx_baseu_xml-suse-nostl3_1_3) weakremover(libwx_baseu_xml-suse-nostl4_0_0) weakremover(libwx_baseu_xml-suse-nostl5_0_0) weakremover(libwx_baseu_xml-suse-nostl8_0_0) weakremover(libwx_baseu_xml-suse-nostl9_0_0) weakremover(libwx_baseu_xml-suse1) weakremover(libwx_baseu_xml-suse3) weakremover(libwx_baseu_xml-suse3_0_4) weakremover(libwx_baseu_xml-suse3_0_5) weakremover(libwx_baseu_xml-suse3_1_1) weakremover(libwx_baseu_xml-suse3_1_2) weakremover(libwx_baseu_xml-suse3_1_3) weakremover(libwx_baseu_xml-suse4_0_0) weakremover(libwx_baseu_xml-suse5_0_0) weakremover(libwx_baseu_xml-suse8_0_0) weakremover(libwx_baseu_xml-suse9_0_0) weakremover(libwx_gtk2_adv-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2_adv-2_8-0-wxcontainer) weakremover(libwx_gtk2_aui-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2_aui-2_8-0-wxcontainer) weakremover(libwx_gtk2_core-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2_core-2_8-0-wxcontainer) weakremover(libwx_gtk2_fl-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2_fl-2_8-0-wxcontainer) weakremover(libwx_gtk2_gizmos-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2_gizmos-2_8-0-wxcontainer) weakremover(libwx_gtk2_gizmos_xrc-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2_gizmos_xrc-2_8-0-wxcontainer) weakremover(libwx_gtk2_gl-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2_gl-2_8-0-wxcontainer) weakremover(libwx_gtk2_html-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2_html-2_8-0-wxcontainer) weakremover(libwx_gtk2_media-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2_media-2_8-0-wxcontainer) weakremover(libwx_gtk2_mmedia-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2_mmedia-2_8-0-wxcontainer) weakremover(libwx_gtk2_ogl-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2_ogl-2_8-0-wxcontainer) weakremover(libwx_gtk2_plot-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2_plot-2_8-0-wxcontainer) weakremover(libwx_gtk2_qa-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2_qa-2_8-0-wxcontainer) weakremover(libwx_gtk2_richtext-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2_richtext-2_8-0-wxcontainer) weakremover(libwx_gtk2_stc-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2_stc-2_8-0-wxcontainer) weakremover(libwx_gtk2_svg-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2_svg-2_8-0-wxcontainer) weakremover(libwx_gtk2_xrc-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2_xrc-2_8-0-wxcontainer) weakremover(libwx_gtk2u_adv-2_8-0-compat-lib-stl) weakremover(libwx_gtk2u_adv-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2u_adv-2_8-0-compat-lib-wxcontainer24c) weakremover(libwx_gtk2u_adv-2_8-0-stl) weakremover(libwx_gtk2u_adv-2_8-0-wxcontainer) weakremover(libwx_gtk2u_adv-2_8-0-wxcontainer24c) weakremover(libwx_gtk2u_adv-suse-nostl1) weakremover(libwx_gtk2u_adv-suse-nostl3) weakremover(libwx_gtk2u_adv-suse-nostl3_0_4) weakremover(libwx_gtk2u_adv-suse-nostl3_0_5) weakremover(libwx_gtk2u_adv-suse-nostl3_1_3) weakremover(libwx_gtk2u_adv-suse1) weakremover(libwx_gtk2u_adv-suse3) weakremover(libwx_gtk2u_adv-suse3_0_4) weakremover(libwx_gtk2u_adv-suse3_0_5) weakremover(libwx_gtk2u_adv-suse3_1_1) weakremover(libwx_gtk2u_adv-suse3_1_2) weakremover(libwx_gtk2u_adv-suse3_1_3) weakremover(libwx_gtk2u_adv-suse4_0_0) weakremover(libwx_gtk2u_adv-suse5_0_0) weakremover(libwx_gtk2u_adv-suse8_0_0) weakremover(libwx_gtk2u_adv-suse9_0_0) weakremover(libwx_gtk2u_aui-2_8-0-compat-lib-stl) weakremover(libwx_gtk2u_aui-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2u_aui-2_8-0-compat-lib-wxcontainer24c) weakremover(libwx_gtk2u_aui-2_8-0-stl) weakremover(libwx_gtk2u_aui-2_8-0-wxcontainer) weakremover(libwx_gtk2u_aui-2_8-0-wxcontainer24c) weakremover(libwx_gtk2u_aui-suse-nostl1) weakremover(libwx_gtk2u_aui-suse-nostl3) weakremover(libwx_gtk2u_aui-suse-nostl3_0_4) weakremover(libwx_gtk2u_aui-suse-nostl3_0_5) weakremover(libwx_gtk2u_aui-suse-nostl3_1_3) weakremover(libwx_gtk2u_aui-suse1) weakremover(libwx_gtk2u_aui-suse3) weakremover(libwx_gtk2u_aui-suse3_0_4) weakremover(libwx_gtk2u_aui-suse3_0_5) weakremover(libwx_gtk2u_aui-suse3_1_1) weakremover(libwx_gtk2u_aui-suse3_1_2) weakremover(libwx_gtk2u_aui-suse3_1_3) weakremover(libwx_gtk2u_aui-suse4_0_0) weakremover(libwx_gtk2u_aui-suse5_0_0) weakremover(libwx_gtk2u_aui-suse8_0_0) weakremover(libwx_gtk2u_aui-suse9_0_0) weakremover(libwx_gtk2u_core-2_8-0-compat-lib-stl) weakremover(libwx_gtk2u_core-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2u_core-2_8-0-compat-lib-wxcontainer24c) weakremover(libwx_gtk2u_core-2_8-0-stl) weakremover(libwx_gtk2u_core-2_8-0-wxcontainer) weakremover(libwx_gtk2u_core-2_8-0-wxcontainer24c) weakremover(libwx_gtk2u_core-suse-nostl1) weakremover(libwx_gtk2u_core-suse-nostl3) weakremover(libwx_gtk2u_core-suse-nostl3_0_4) weakremover(libwx_gtk2u_core-suse-nostl3_0_5) weakremover(libwx_gtk2u_core-suse-nostl3_1_3) weakremover(libwx_gtk2u_core-suse1) weakremover(libwx_gtk2u_core-suse3) weakremover(libwx_gtk2u_core-suse3_0_4) weakremover(libwx_gtk2u_core-suse3_0_5) weakremover(libwx_gtk2u_core-suse3_1_1) weakremover(libwx_gtk2u_core-suse3_1_2) weakremover(libwx_gtk2u_core-suse3_1_3) weakremover(libwx_gtk2u_core-suse4_0_0) weakremover(libwx_gtk2u_core-suse5_0_0) weakremover(libwx_gtk2u_core-suse8_0_0) weakremover(libwx_gtk2u_core-suse9_0_0) weakremover(libwx_gtk2u_fl-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2u_fl-2_8-0-compat-lib-wxcontainer24c) weakremover(libwx_gtk2u_fl-2_8-0-wxcontainer) weakremover(libwx_gtk2u_fl-2_8-0-wxcontainer24c) weakremover(libwx_gtk2u_gizmos-2_8-0-compat-lib-stl) weakremover(libwx_gtk2u_gizmos-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2u_gizmos-2_8-0-compat-lib-wxcontainer24c) weakremover(libwx_gtk2u_gizmos-2_8-0-stl) weakremover(libwx_gtk2u_gizmos-2_8-0-wxcontainer) weakremover(libwx_gtk2u_gizmos-2_8-0-wxcontainer24c) weakremover(libwx_gtk2u_gizmos_xrc-2_8-0-compat-lib-stl) weakremover(libwx_gtk2u_gizmos_xrc-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2u_gizmos_xrc-2_8-0-compat-lib-wxcontainer24c) weakremover(libwx_gtk2u_gizmos_xrc-2_8-0-stl) weakremover(libwx_gtk2u_gizmos_xrc-2_8-0-wxcontainer) weakremover(libwx_gtk2u_gizmos_xrc-2_8-0-wxcontainer24c) weakremover(libwx_gtk2u_gl-2_8-0-compat-lib-stl) weakremover(libwx_gtk2u_gl-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2u_gl-2_8-0-compat-lib-wxcontainer24c) weakremover(libwx_gtk2u_gl-2_8-0-stl) weakremover(libwx_gtk2u_gl-2_8-0-wxcontainer) weakremover(libwx_gtk2u_gl-2_8-0-wxcontainer24c) weakremover(libwx_gtk2u_gl-suse-nostl1) weakremover(libwx_gtk2u_gl-suse-nostl3) weakremover(libwx_gtk2u_gl-suse-nostl3_0_4) weakremover(libwx_gtk2u_gl-suse-nostl3_0_5) weakremover(libwx_gtk2u_gl-suse-nostl3_1_3) weakremover(libwx_gtk2u_gl-suse1) weakremover(libwx_gtk2u_gl-suse3) weakremover(libwx_gtk2u_gl-suse3_0_4) weakremover(libwx_gtk2u_gl-suse3_0_5) weakremover(libwx_gtk2u_gl-suse3_1_1) weakremover(libwx_gtk2u_gl-suse3_1_2) weakremover(libwx_gtk2u_gl-suse3_1_3) weakremover(libwx_gtk2u_gl-suse4_0_0) weakremover(libwx_gtk2u_gl-suse5_0_0) weakremover(libwx_gtk2u_gl-suse8_0_0) weakremover(libwx_gtk2u_gl-suse9_0_0) weakremover(libwx_gtk2u_html-2_8-0-compat-lib-stl) weakremover(libwx_gtk2u_html-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2u_html-2_8-0-compat-lib-wxcontainer24c) weakremover(libwx_gtk2u_html-2_8-0-stl) weakremover(libwx_gtk2u_html-2_8-0-wxcontainer) weakremover(libwx_gtk2u_html-2_8-0-wxcontainer24c) weakremover(libwx_gtk2u_html-suse-nostl1) weakremover(libwx_gtk2u_html-suse-nostl3) weakremover(libwx_gtk2u_html-suse-nostl3_0_4) weakremover(libwx_gtk2u_html-suse-nostl3_0_5) weakremover(libwx_gtk2u_html-suse-nostl3_1_3) weakremover(libwx_gtk2u_html-suse1) weakremover(libwx_gtk2u_html-suse3) weakremover(libwx_gtk2u_html-suse3_0_4) weakremover(libwx_gtk2u_html-suse3_0_5) weakremover(libwx_gtk2u_html-suse3_1_1) weakremover(libwx_gtk2u_html-suse3_1_2) weakremover(libwx_gtk2u_html-suse3_1_3) weakremover(libwx_gtk2u_html-suse4_0_0) weakremover(libwx_gtk2u_html-suse5_0_0) weakremover(libwx_gtk2u_html-suse8_0_0) weakremover(libwx_gtk2u_html-suse9_0_0) weakremover(libwx_gtk2u_media-2_8-0-compat-lib-stl) weakremover(libwx_gtk2u_media-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2u_media-2_8-0-compat-lib-wxcontainer24c) weakremover(libwx_gtk2u_media-2_8-0-stl) weakremover(libwx_gtk2u_media-2_8-0-wxcontainer) weakremover(libwx_gtk2u_media-2_8-0-wxcontainer24c) weakremover(libwx_gtk2u_media-suse-nostl1) weakremover(libwx_gtk2u_media-suse-nostl3) weakremover(libwx_gtk2u_media-suse-nostl3_0_4) weakremover(libwx_gtk2u_media-suse-nostl3_0_5) weakremover(libwx_gtk2u_media-suse-nostl3_1_3) weakremover(libwx_gtk2u_media-suse1) weakremover(libwx_gtk2u_media-suse3) weakremover(libwx_gtk2u_media-suse3_0_4) weakremover(libwx_gtk2u_media-suse3_0_5) weakremover(libwx_gtk2u_media-suse3_1_1) weakremover(libwx_gtk2u_media-suse3_1_2) weakremover(libwx_gtk2u_media-suse3_1_3) weakremover(libwx_gtk2u_media-suse4_0_0) weakremover(libwx_gtk2u_media-suse5_0_0) weakremover(libwx_gtk2u_media-suse8_0_0) weakremover(libwx_gtk2u_media-suse9_0_0) weakremover(libwx_gtk2u_mmedia-2_8-0-compat-lib-stl) weakremover(libwx_gtk2u_mmedia-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2u_mmedia-2_8-0-compat-lib-wxcontainer24c) weakremover(libwx_gtk2u_mmedia-2_8-0-stl) weakremover(libwx_gtk2u_mmedia-2_8-0-wxcontainer) weakremover(libwx_gtk2u_mmedia-2_8-0-wxcontainer24c) weakremover(libwx_gtk2u_ogl-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2u_ogl-2_8-0-compat-lib-wxcontainer24c) weakremover(libwx_gtk2u_ogl-2_8-0-wxcontainer) weakremover(libwx_gtk2u_ogl-2_8-0-wxcontainer24c) weakremover(libwx_gtk2u_plot-2_8-0-compat-lib-stl) weakremover(libwx_gtk2u_plot-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2u_plot-2_8-0-compat-lib-wxcontainer24c) weakremover(libwx_gtk2u_plot-2_8-0-stl) weakremover(libwx_gtk2u_plot-2_8-0-wxcontainer) weakremover(libwx_gtk2u_plot-2_8-0-wxcontainer24c) weakremover(libwx_gtk2u_propgrid-suse-nostl1) weakremover(libwx_gtk2u_propgrid-suse-nostl3) weakremover(libwx_gtk2u_propgrid-suse-nostl3_0_4) weakremover(libwx_gtk2u_propgrid-suse-nostl3_0_5) weakremover(libwx_gtk2u_propgrid-suse-nostl3_1_3) weakremover(libwx_gtk2u_propgrid-suse1) weakremover(libwx_gtk2u_propgrid-suse3) weakremover(libwx_gtk2u_propgrid-suse3_0_4) weakremover(libwx_gtk2u_propgrid-suse3_0_5) weakremover(libwx_gtk2u_propgrid-suse3_1_1) weakremover(libwx_gtk2u_propgrid-suse3_1_2) weakremover(libwx_gtk2u_propgrid-suse3_1_3) weakremover(libwx_gtk2u_propgrid-suse4_0_0) weakremover(libwx_gtk2u_propgrid-suse5_0_0) weakremover(libwx_gtk2u_propgrid-suse8_0_0) weakremover(libwx_gtk2u_propgrid-suse9_0_0) weakremover(libwx_gtk2u_qa-2_8-0-compat-lib-stl) weakremover(libwx_gtk2u_qa-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2u_qa-2_8-0-compat-lib-wxcontainer24c) weakremover(libwx_gtk2u_qa-2_8-0-stl) weakremover(libwx_gtk2u_qa-2_8-0-wxcontainer) weakremover(libwx_gtk2u_qa-2_8-0-wxcontainer24c) weakremover(libwx_gtk2u_qa-suse-nostl1) weakremover(libwx_gtk2u_qa-suse-nostl3) weakremover(libwx_gtk2u_qa-suse-nostl3_0_4) weakremover(libwx_gtk2u_qa-suse-nostl3_0_5) weakremover(libwx_gtk2u_qa-suse-nostl3_1_3) weakremover(libwx_gtk2u_qa-suse1) weakremover(libwx_gtk2u_qa-suse3) weakremover(libwx_gtk2u_qa-suse3_0_4) weakremover(libwx_gtk2u_qa-suse3_0_5) weakremover(libwx_gtk2u_qa-suse3_1_1) weakremover(libwx_gtk2u_qa-suse3_1_2) weakremover(libwx_gtk2u_qa-suse3_1_3) weakremover(libwx_gtk2u_qa-suse4_0_0) weakremover(libwx_gtk2u_qa-suse5_0_0) weakremover(libwx_gtk2u_qa-suse8_0_0) weakremover(libwx_gtk2u_qa-suse9_0_0) weakremover(libwx_gtk2u_ribbon-suse-nostl1) weakremover(libwx_gtk2u_ribbon-suse-nostl3) weakremover(libwx_gtk2u_ribbon-suse-nostl3_0_4) weakremover(libwx_gtk2u_ribbon-suse-nostl3_0_5) weakremover(libwx_gtk2u_ribbon-suse-nostl3_1_3) weakremover(libwx_gtk2u_ribbon-suse1) weakremover(libwx_gtk2u_ribbon-suse3) weakremover(libwx_gtk2u_ribbon-suse3_0_4) weakremover(libwx_gtk2u_ribbon-suse3_0_5) weakremover(libwx_gtk2u_ribbon-suse3_1_1) weakremover(libwx_gtk2u_ribbon-suse3_1_2) weakremover(libwx_gtk2u_ribbon-suse3_1_3) weakremover(libwx_gtk2u_ribbon-suse4_0_0) weakremover(libwx_gtk2u_ribbon-suse5_0_0) weakremover(libwx_gtk2u_ribbon-suse8_0_0) weakremover(libwx_gtk2u_ribbon-suse9_0_0) weakremover(libwx_gtk2u_richtext-2_8-0-compat-lib-stl) weakremover(libwx_gtk2u_richtext-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2u_richtext-2_8-0-compat-lib-wxcontainer24c) weakremover(libwx_gtk2u_richtext-2_8-0-stl) weakremover(libwx_gtk2u_richtext-2_8-0-wxcontainer) weakremover(libwx_gtk2u_richtext-2_8-0-wxcontainer24c) weakremover(libwx_gtk2u_richtext-suse-nostl1) weakremover(libwx_gtk2u_richtext-suse-nostl3) weakremover(libwx_gtk2u_richtext-suse-nostl3_0_4) weakremover(libwx_gtk2u_richtext-suse-nostl3_0_5) weakremover(libwx_gtk2u_richtext-suse-nostl3_1_3) weakremover(libwx_gtk2u_richtext-suse1) weakremover(libwx_gtk2u_richtext-suse3) weakremover(libwx_gtk2u_richtext-suse3_0_4) weakremover(libwx_gtk2u_richtext-suse3_0_5) weakremover(libwx_gtk2u_richtext-suse3_1_1) weakremover(libwx_gtk2u_richtext-suse3_1_2) weakremover(libwx_gtk2u_richtext-suse3_1_3) weakremover(libwx_gtk2u_richtext-suse4_0_0) weakremover(libwx_gtk2u_richtext-suse5_0_0) weakremover(libwx_gtk2u_richtext-suse8_0_0) weakremover(libwx_gtk2u_richtext-suse9_0_0) weakremover(libwx_gtk2u_stc-2_8-0-compat-lib-stl) weakremover(libwx_gtk2u_stc-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2u_stc-2_8-0-compat-lib-wxcontainer24c) weakremover(libwx_gtk2u_stc-2_8-0-stl) weakremover(libwx_gtk2u_stc-2_8-0-wxcontainer) weakremover(libwx_gtk2u_stc-2_8-0-wxcontainer24c) weakremover(libwx_gtk2u_stc-suse-nostl1) weakremover(libwx_gtk2u_stc-suse-nostl3) weakremover(libwx_gtk2u_stc-suse-nostl3_0_4) weakremover(libwx_gtk2u_stc-suse-nostl3_0_5) weakremover(libwx_gtk2u_stc-suse-nostl3_1_3) weakremover(libwx_gtk2u_stc-suse1) weakremover(libwx_gtk2u_stc-suse3) weakremover(libwx_gtk2u_stc-suse3_0_4) weakremover(libwx_gtk2u_stc-suse3_0_5) weakremover(libwx_gtk2u_stc-suse3_1_1) weakremover(libwx_gtk2u_stc-suse3_1_2) weakremover(libwx_gtk2u_stc-suse3_1_3) weakremover(libwx_gtk2u_stc-suse4_0_0) weakremover(libwx_gtk2u_stc-suse5_0_0) weakremover(libwx_gtk2u_stc-suse8_0_0) weakremover(libwx_gtk2u_stc-suse9_0_0) weakremover(libwx_gtk2u_svg-2_8-0-compat-lib-stl) weakremover(libwx_gtk2u_svg-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2u_svg-2_8-0-compat-lib-wxcontainer24c) weakremover(libwx_gtk2u_svg-2_8-0-stl) weakremover(libwx_gtk2u_svg-2_8-0-wxcontainer) weakremover(libwx_gtk2u_svg-2_8-0-wxcontainer24c) weakremover(libwx_gtk2u_webview-suse-nostl1) weakremover(libwx_gtk2u_webview-suse1) weakremover(libwx_gtk2u_xrc-2_8-0-compat-lib-stl) weakremover(libwx_gtk2u_xrc-2_8-0-compat-lib-wxcontainer) weakremover(libwx_gtk2u_xrc-2_8-0-compat-lib-wxcontainer24c) weakremover(libwx_gtk2u_xrc-2_8-0-stl) weakremover(libwx_gtk2u_xrc-2_8-0-wxcontainer) weakremover(libwx_gtk2u_xrc-2_8-0-wxcontainer24c) weakremover(libwx_gtk2u_xrc-suse-nostl1) weakremover(libwx_gtk2u_xrc-suse-nostl3) weakremover(libwx_gtk2u_xrc-suse-nostl3_0_4) weakremover(libwx_gtk2u_xrc-suse-nostl3_0_5) weakremover(libwx_gtk2u_xrc-suse-nostl3_1_3) weakremover(libwx_gtk2u_xrc-suse1) weakremover(libwx_gtk2u_xrc-suse3) weakremover(libwx_gtk2u_xrc-suse3_0_4) weakremover(libwx_gtk2u_xrc-suse3_0_5) weakremover(libwx_gtk2u_xrc-suse3_1_1) weakremover(libwx_gtk2u_xrc-suse3_1_2) weakremover(libwx_gtk2u_xrc-suse3_1_3) weakremover(libwx_gtk2u_xrc-suse4_0_0) weakremover(libwx_gtk2u_xrc-suse5_0_0) weakremover(libwx_gtk2u_xrc-suse8_0_0) weakremover(libwx_gtk2u_xrc-suse9_0_0) weakremover(libwx_gtk3u_adv-suse-nostl3_1_3) weakremover(libwx_gtk3u_adv-suse-nostl4_0_0) weakremover(libwx_gtk3u_adv-suse-nostl5_0_0) weakremover(libwx_gtk3u_adv-suse-nostl8_0_0) weakremover(libwx_gtk3u_adv-suse-nostl9_0_0) weakremover(libwx_gtk3u_adv-suse3_1_1) weakremover(libwx_gtk3u_adv-suse3_1_2) weakremover(libwx_gtk3u_adv-suse3_1_3) weakremover(libwx_gtk3u_adv-suse4_0_0) weakremover(libwx_gtk3u_adv-suse5_0_0) weakremover(libwx_gtk3u_adv-suse8_0_0) weakremover(libwx_gtk3u_adv-suse9_0_0) weakremover(libwx_gtk3u_aui-suse-nostl3_1_3) weakremover(libwx_gtk3u_aui-suse-nostl4_0_0) weakremover(libwx_gtk3u_aui-suse-nostl5_0_0) weakremover(libwx_gtk3u_aui-suse-nostl8_0_0) weakremover(libwx_gtk3u_aui-suse-nostl9_0_0) weakremover(libwx_gtk3u_aui-suse3_1_1) weakremover(libwx_gtk3u_aui-suse3_1_2) weakremover(libwx_gtk3u_aui-suse3_1_3) weakremover(libwx_gtk3u_aui-suse4_0_0) weakremover(libwx_gtk3u_aui-suse5_0_0) weakremover(libwx_gtk3u_aui-suse8_0_0) weakremover(libwx_gtk3u_aui-suse9_0_0) weakremover(libwx_gtk3u_core-suse-nostl3_1_3) weakremover(libwx_gtk3u_core-suse-nostl4_0_0) weakremover(libwx_gtk3u_core-suse-nostl5_0_0) weakremover(libwx_gtk3u_core-suse-nostl8_0_0) weakremover(libwx_gtk3u_core-suse-nostl9_0_0) weakremover(libwx_gtk3u_core-suse3_1_1) weakremover(libwx_gtk3u_core-suse3_1_2) weakremover(libwx_gtk3u_core-suse3_1_3) weakremover(libwx_gtk3u_core-suse4_0_0) weakremover(libwx_gtk3u_core-suse5_0_0) weakremover(libwx_gtk3u_core-suse8_0_0) weakremover(libwx_gtk3u_core-suse9_0_0) weakremover(libwx_gtk3u_gl-suse-nostl3_1_3) weakremover(libwx_gtk3u_gl-suse-nostl4_0_0) weakremover(libwx_gtk3u_gl-suse-nostl5_0_0) weakremover(libwx_gtk3u_gl-suse-nostl8_0_0) weakremover(libwx_gtk3u_gl-suse-nostl9_0_0) weakremover(libwx_gtk3u_gl-suse3_1_1) weakremover(libwx_gtk3u_gl-suse3_1_2) weakremover(libwx_gtk3u_gl-suse3_1_3) weakremover(libwx_gtk3u_gl-suse4_0_0) weakremover(libwx_gtk3u_gl-suse5_0_0) weakremover(libwx_gtk3u_gl-suse8_0_0) weakremover(libwx_gtk3u_gl-suse9_0_0) weakremover(libwx_gtk3u_html-suse-nostl3_1_3) weakremover(libwx_gtk3u_html-suse-nostl4_0_0) weakremover(libwx_gtk3u_html-suse-nostl5_0_0) weakremover(libwx_gtk3u_html-suse-nostl8_0_0) weakremover(libwx_gtk3u_html-suse-nostl9_0_0) weakremover(libwx_gtk3u_html-suse3_1_1) weakremover(libwx_gtk3u_html-suse3_1_2) weakremover(libwx_gtk3u_html-suse3_1_3) weakremover(libwx_gtk3u_html-suse4_0_0) weakremover(libwx_gtk3u_html-suse5_0_0) weakremover(libwx_gtk3u_html-suse8_0_0) weakremover(libwx_gtk3u_html-suse9_0_0) weakremover(libwx_gtk3u_media-suse-nostl3_1_3) weakremover(libwx_gtk3u_media-suse-nostl4_0_0) weakremover(libwx_gtk3u_media-suse-nostl5_0_0) weakremover(libwx_gtk3u_media-suse-nostl8_0_0) weakremover(libwx_gtk3u_media-suse-nostl9_0_0) weakremover(libwx_gtk3u_media-suse3_1_1) weakremover(libwx_gtk3u_media-suse3_1_2) weakremover(libwx_gtk3u_media-suse3_1_3) weakremover(libwx_gtk3u_media-suse4_0_0) weakremover(libwx_gtk3u_media-suse5_0_0) weakremover(libwx_gtk3u_media-suse8_0_0) weakremover(libwx_gtk3u_media-suse9_0_0) weakremover(libwx_gtk3u_propgrid-suse-nostl3_1_3) weakremover(libwx_gtk3u_propgrid-suse-nostl4_0_0) weakremover(libwx_gtk3u_propgrid-suse-nostl5_0_0) weakremover(libwx_gtk3u_propgrid-suse-nostl8_0_0) weakremover(libwx_gtk3u_propgrid-suse-nostl9_0_0) weakremover(libwx_gtk3u_propgrid-suse3_1_1) weakremover(libwx_gtk3u_propgrid-suse3_1_2) weakremover(libwx_gtk3u_propgrid-suse3_1_3) weakremover(libwx_gtk3u_propgrid-suse4_0_0) weakremover(libwx_gtk3u_propgrid-suse5_0_0) weakremover(libwx_gtk3u_propgrid-suse8_0_0) weakremover(libwx_gtk3u_propgrid-suse9_0_0) weakremover(libwx_gtk3u_qa-suse-nostl3_1_3) weakremover(libwx_gtk3u_qa-suse-nostl4_0_0) weakremover(libwx_gtk3u_qa-suse-nostl5_0_0) weakremover(libwx_gtk3u_qa-suse-nostl8_0_0) weakremover(libwx_gtk3u_qa-suse-nostl9_0_0) weakremover(libwx_gtk3u_qa-suse3_1_1) weakremover(libwx_gtk3u_qa-suse3_1_2) weakremover(libwx_gtk3u_qa-suse3_1_3) weakremover(libwx_gtk3u_qa-suse4_0_0) weakremover(libwx_gtk3u_qa-suse5_0_0) weakremover(libwx_gtk3u_qa-suse8_0_0) weakremover(libwx_gtk3u_qa-suse9_0_0) weakremover(libwx_gtk3u_ribbon-suse-nostl3_1_3) weakremover(libwx_gtk3u_ribbon-suse-nostl4_0_0) weakremover(libwx_gtk3u_ribbon-suse-nostl5_0_0) weakremover(libwx_gtk3u_ribbon-suse-nostl8_0_0) weakremover(libwx_gtk3u_ribbon-suse-nostl9_0_0) weakremover(libwx_gtk3u_ribbon-suse3_1_1) weakremover(libwx_gtk3u_ribbon-suse3_1_2) weakremover(libwx_gtk3u_ribbon-suse3_1_3) weakremover(libwx_gtk3u_ribbon-suse4_0_0) weakremover(libwx_gtk3u_ribbon-suse5_0_0) weakremover(libwx_gtk3u_ribbon-suse8_0_0) weakremover(libwx_gtk3u_ribbon-suse9_0_0) weakremover(libwx_gtk3u_richtext-suse-nostl3_1_3) weakremover(libwx_gtk3u_richtext-suse-nostl4_0_0) weakremover(libwx_gtk3u_richtext-suse-nostl5_0_0) weakremover(libwx_gtk3u_richtext-suse-nostl8_0_0) weakremover(libwx_gtk3u_richtext-suse-nostl9_0_0) weakremover(libwx_gtk3u_richtext-suse3_1_1) weakremover(libwx_gtk3u_richtext-suse3_1_2) weakremover(libwx_gtk3u_richtext-suse3_1_3) weakremover(libwx_gtk3u_richtext-suse4_0_0) weakremover(libwx_gtk3u_richtext-suse5_0_0) weakremover(libwx_gtk3u_richtext-suse8_0_0) weakremover(libwx_gtk3u_richtext-suse9_0_0) weakremover(libwx_gtk3u_stc-suse-nostl3_1_3) weakremover(libwx_gtk3u_stc-suse-nostl4_0_0) weakremover(libwx_gtk3u_stc-suse-nostl5_0_0) weakremover(libwx_gtk3u_stc-suse-nostl8_0_0) weakremover(libwx_gtk3u_stc-suse-nostl9_0_0) weakremover(libwx_gtk3u_stc-suse3_1_1) weakremover(libwx_gtk3u_stc-suse3_1_2) weakremover(libwx_gtk3u_stc-suse3_1_3) weakremover(libwx_gtk3u_stc-suse4_0_0) weakremover(libwx_gtk3u_stc-suse5_0_0) weakremover(libwx_gtk3u_stc-suse8_0_0) weakremover(libwx_gtk3u_stc-suse9_0_0) weakremover(libwx_gtk3u_webview-suse3_1_3) weakremover(libwx_gtk3u_webview-suse4_0_0) weakremover(libwx_gtk3u_webview-suse5_0_0) weakremover(libwx_gtk3u_webview-suse8_0_0) weakremover(libwx_gtk3u_webview-suse9_0_0) weakremover(libwx_gtk3u_xrc-suse-nostl3_1_3) weakremover(libwx_gtk3u_xrc-suse-nostl4_0_0) weakremover(libwx_gtk3u_xrc-suse-nostl5_0_0) weakremover(libwx_gtk3u_xrc-suse-nostl8_0_0) weakremover(libwx_gtk3u_xrc-suse-nostl9_0_0) weakremover(libwx_gtk3u_xrc-suse3_1_1) weakremover(libwx_gtk3u_xrc-suse3_1_2) weakremover(libwx_gtk3u_xrc-suse3_1_3) weakremover(libwx_gtk3u_xrc-suse4_0_0) weakremover(libwx_gtk3u_xrc-suse5_0_0) weakremover(libwx_gtk3u_xrc-suse8_0_0) weakremover(libwx_gtk3u_xrc-suse9_0_0) weakremover(libwx_qtu_adv-suse3_1_1) weakremover(libwx_qtu_adv-suse3_1_2) weakremover(libwx_qtu_adv-suse3_1_3) weakremover(libwx_qtu_adv-suse4_0_0) weakremover(libwx_qtu_adv-suse5_0_0) weakremover(libwx_qtu_adv-suse8_0_0) weakremover(libwx_qtu_adv-suse9_0_0) weakremover(libwx_qtu_aui-suse3_1_1) weakremover(libwx_qtu_aui-suse3_1_2) weakremover(libwx_qtu_aui-suse3_1_3) weakremover(libwx_qtu_aui-suse4_0_0) weakremover(libwx_qtu_aui-suse5_0_0) weakremover(libwx_qtu_aui-suse8_0_0) weakremover(libwx_qtu_aui-suse9_0_0) weakremover(libwx_qtu_core-suse3_1_1) weakremover(libwx_qtu_core-suse3_1_2) weakremover(libwx_qtu_core-suse3_1_3) weakremover(libwx_qtu_core-suse4_0_0) weakremover(libwx_qtu_core-suse5_0_0) weakremover(libwx_qtu_core-suse8_0_0) weakremover(libwx_qtu_core-suse9_0_0) weakremover(libwx_qtu_gl-suse3_1_1) weakremover(libwx_qtu_gl-suse3_1_2) weakremover(libwx_qtu_gl-suse3_1_3) weakremover(libwx_qtu_gl-suse4_0_0) weakremover(libwx_qtu_gl-suse5_0_0) weakremover(libwx_qtu_gl-suse8_0_0) weakremover(libwx_qtu_gl-suse9_0_0) weakremover(libwx_qtu_html-suse3_1_1) weakremover(libwx_qtu_html-suse3_1_2) weakremover(libwx_qtu_html-suse3_1_3) weakremover(libwx_qtu_html-suse4_0_0) weakremover(libwx_qtu_html-suse5_0_0) weakremover(libwx_qtu_html-suse8_0_0) weakremover(libwx_qtu_html-suse9_0_0) weakremover(libwx_qtu_media-suse3_1_1) weakremover(libwx_qtu_media-suse3_1_2) weakremover(libwx_qtu_media-suse3_1_3) weakremover(libwx_qtu_media-suse4_0_0) weakremover(libwx_qtu_media-suse5_0_0) weakremover(libwx_qtu_media-suse8_0_0) weakremover(libwx_qtu_media-suse9_0_0) weakremover(libwx_qtu_propgrid-suse3_1_1) weakremover(libwx_qtu_propgrid-suse3_1_2) weakremover(libwx_qtu_propgrid-suse3_1_3) weakremover(libwx_qtu_propgrid-suse4_0_0) weakremover(libwx_qtu_propgrid-suse5_0_0) weakremover(libwx_qtu_propgrid-suse8_0_0) weakremover(libwx_qtu_propgrid-suse9_0_0) weakremover(libwx_qtu_qa-suse3_1_1) weakremover(libwx_qtu_qa-suse3_1_2) weakremover(libwx_qtu_qa-suse3_1_3) weakremover(libwx_qtu_qa-suse4_0_0) weakremover(libwx_qtu_qa-suse5_0_0) weakremover(libwx_qtu_qa-suse8_0_0) weakremover(libwx_qtu_qa-suse9_0_0) weakremover(libwx_qtu_ribbon-suse3_1_1) weakremover(libwx_qtu_ribbon-suse3_1_2) weakremover(libwx_qtu_ribbon-suse3_1_3) weakremover(libwx_qtu_ribbon-suse4_0_0) weakremover(libwx_qtu_ribbon-suse5_0_0) weakremover(libwx_qtu_ribbon-suse8_0_0) weakremover(libwx_qtu_ribbon-suse9_0_0) weakremover(libwx_qtu_richtext-suse3_1_1) weakremover(libwx_qtu_richtext-suse3_1_2) weakremover(libwx_qtu_richtext-suse3_1_3) weakremover(libwx_qtu_richtext-suse4_0_0) weakremover(libwx_qtu_richtext-suse5_0_0) weakremover(libwx_qtu_richtext-suse8_0_0) weakremover(libwx_qtu_richtext-suse9_0_0) weakremover(libwx_qtu_stc-suse3_1_1) weakremover(libwx_qtu_stc-suse3_1_2) weakremover(libwx_qtu_stc-suse3_1_3) weakremover(libwx_qtu_stc-suse4_0_0) weakremover(libwx_qtu_stc-suse5_0_0) weakremover(libwx_qtu_stc-suse8_0_0) weakremover(libwx_qtu_stc-suse9_0_0) weakremover(libwx_qtu_xrc-suse3_1_1) weakremover(libwx_qtu_xrc-suse3_1_2) weakremover(libwx_qtu_xrc-suse3_1_3) weakremover(libwx_qtu_xrc-suse4_0_0) weakremover(libwx_qtu_xrc-suse5_0_0) weakremover(libwx_qtu_xrc-suse8_0_0) weakremover(libwx_qtu_xrc-suse9_0_0) weakremover(libwxcode_gtk2u_wxsqlite3-3_0-0) weakremover(libwxcode_gtk2u_wxsqlite3-3_1-0) weakremover(libwxcode_gtk2u_wxsqlite3-3_2-0) weakremover(libwxlua) weakremover(libwxlua-wx31-3_1_0_0) weakremover(libwxlua-wx32-3_1_0_0) weakremover(libwxlua_bind-wx31-3_1_0_0) weakremover(libwxlua_bind-wx32-3_1_0_0) weakremover(libwxlua_debug-wx31-3_1_0_0) weakremover(libwxlua_debug-wx32-3_1_0_0) weakremover(libwxlua_debugger-wx31-3_1_0_0) weakremover(libwxlua_debugger-wx32-3_1_0_0) weakremover(libwxstedit-wx30gtk2u-1_6_0) weakremover(libwxsvg-devel) weakremover(libwxsvg3) weakremover(libx86emu-devel) weakremover(libx86emu1) weakremover(libx86emu2) weakremover(libx86emu3) weakremover(libxalan-c-devel) weakremover(libxalan-c111) weakremover(libxalan-c112) weakremover(libxapian-devel) weakremover(libxapian22) weakremover(libxapian30) weakremover(libxapp-devel) weakremover(libxapp1) weakremover(libxar-devel) weakremover(libxar1) weakremover(libxatracker-devel) weakremover(libxatracker2) weakremover(libxbase64-1) weakremover(libxbrz-1_6) weakremover(libxbrz-1_7) weakremover(libxbrz-1_8) weakremover(libxbsql0) weakremover(libxc-devel) weakremover(libxc12) weakremover(libxc5) weakremover(libxcam-devel) weakremover(libxcam1) weakremover(libxcb-composite0) weakremover(libxcb-cursor0) weakremover(libxcb-damage0) weakremover(libxcb-devel) weakremover(libxcb-dpms0) weakremover(libxcb-dri2-0) weakremover(libxcb-dri3-0) weakremover(libxcb-errors0) weakremover(libxcb-ewmh2) weakremover(libxcb-glx0) weakremover(libxcb-icccm4) weakremover(libxcb-image0) weakremover(libxcb-imdkit1) weakremover(libxcb-keysyms1) weakremover(libxcb-present0) weakremover(libxcb-randr0) weakremover(libxcb-record0) weakremover(libxcb-render-util0) weakremover(libxcb-render0) weakremover(libxcb-res0) weakremover(libxcb-screensaver0) weakremover(libxcb-shape0) weakremover(libxcb-shm0) weakremover(libxcb-sync1) weakremover(libxcb-util1) weakremover(libxcb-xevie0) weakremover(libxcb-xf86dri0) weakremover(libxcb-xfixes0) weakremover(libxcb-xinerama0) weakremover(libxcb-xinput0) weakremover(libxcb-xkb1) weakremover(libxcb-xprint0) weakremover(libxcb-xrm0) weakremover(libxcb-xtest0) weakremover(libxcb-xv0) weakremover(libxcb-xvmc0) weakremover(libxcb1) weakremover(libxcfun2) weakremover(libxclass-0_9_2) weakremover(libxcrypt-devel) weakremover(libxcrypt-devel-static) weakremover(libxcvt) weakremover(libxcvt-devel) weakremover(libxcvt0) weakremover(libxdg-app0) weakremover(libxdg-basedir-devel) weakremover(libxdg-basedir1) weakremover(libxdot4) weakremover(libxerces-c-3_1) weakremover(libxerces-c-3_2) weakremover(libxerces-c-devel) weakremover(libxfce4kbd-private-3-0) weakremover(libxfce4panel-1_0-4) weakremover(libxfce4panel-2_0-4) weakremover(libxfce4ui-1-0) weakremover(libxfce4ui-2-0) weakremover(libxfce4ui-devel) weakremover(libxfce4ui-tools) weakremover(libxfce4util-devel) weakremover(libxfce4util-tools) weakremover(libxfce4util7) weakremover(libxfconf-0-2) weakremover(libxfconf-0-3) weakremover(libxfconf-devel) weakremover(libxfdashboard0) weakremover(libxfsm-4_6-0) weakremover(libxine-devel) weakremover(libxine2) weakremover(libxine2-gnome-vfs) weakremover(libxine2-jack) weakremover(libxine2-pulse) weakremover(libxine2-sdl) weakremover(libxkbcommon-devel) weakremover(libxkbcommon-tools) weakremover(libxkbcommon-x11-0) weakremover(libxkbcommon-x11-devel) weakremover(libxkbcommon0) weakremover(libxkbfile-devel) weakremover(libxkbfile1) weakremover(libxkbregistry-devel) weakremover(libxkbregistry0) weakremover(libxkbui-devel) weakremover(libxkbui1) weakremover(libxklavier-devel) weakremover(libxklavier-doc) weakremover(libxklavier16) weakremover(libxls-devel) weakremover(libxls-tools) weakremover(libxlsreader1) weakremover(libxlsreader8) weakremover(libxmi0) weakremover(libxml++-2_6-2) weakremover(libxml++-3_0-1) weakremover(libxml++-4_0-1) weakremover(libxml++-5_0-1) weakremover(libxml++-devel) weakremover(libxml++26-devel) weakremover(libxml++30-devel) weakremover(libxml++40-devel) weakremover(libxml-security-c-devel) weakremover(libxml-security-c17) weakremover(libxml-security-c20) weakremover(libxml2-2) weakremover(libxml2-devel) weakremover(libxml2-tools) weakremover(libxmlb-devel) weakremover(libxmlb1) weakremover(libxmlb2) weakremover(libxmlbird1) weakremover(libxmlrpc++8) weakremover(libxmlrpc3) weakremover(libxmlrpc_abyss++8) weakremover(libxmlrpc_abyss3) weakremover(libxmlrpc_client++8) weakremover(libxmlrpc_client3) weakremover(libxmlrpc_cpp8) weakremover(libxmlrpc_packetsocket8) weakremover(libxmlrpc_server++8) weakremover(libxmlrpc_server3) weakremover(libxmlrpc_server_abyss++8) weakremover(libxmlrpc_server_abyss3) weakremover(libxmlrpc_server_cgi++8) weakremover(libxmlrpc_server_cgi3) weakremover(libxmlrpc_server_pstream++8) weakremover(libxmlrpc_util++8) weakremover(libxmlrpc_util3) weakremover(libxmlrpc_util4) weakremover(libxmlsec1-1) weakremover(libxmlsec1-gcrypt1) weakremover(libxmlsec1-gnutls1) weakremover(libxmlsec1-nss1) weakremover(libxmlsec1-openssl1) weakremover(libxmltooling-devel) weakremover(libxmltooling-lite10) weakremover(libxmltooling-lite8) weakremover(libxmltooling-lite9) weakremover(libxmltooling10) weakremover(libxmltooling6) weakremover(libxmltooling7) weakremover(libxmltooling8) weakremover(libxmltooling9) weakremover(libxmmsclient++-glib1) weakremover(libxmmsclient++4) weakremover(libxmmsclient-glib1) weakremover(libxmmsclient6) weakremover(libxmp-devel) weakremover(libxmp4) weakremover(libxnoise-devel) weakremover(libxnoise0) weakremover(libxornstorage-devel) weakremover(libxornstorage0) weakremover(libxosd2) weakremover(libxplayer-plparser-mini18) weakremover(libxplayer-plparser18) weakremover(libxreaderdocument3) weakremover(libxreaderview3) weakremover(libxshmfence-devel) weakremover(libxshmfence1) weakremover(libxslt-devel) weakremover(libxslt-python) weakremover(libxslt-tools) weakremover(libxslt1) weakremover(libxspf-devel) weakremover(libxspf4) weakremover(libxtables-devel) weakremover(libxtables10) weakremover(libxtables11) weakremover(libxtables12) weakremover(libxtermcap1_0) weakremover(libxtrx-devel) weakremover(libxtrx0) weakremover(libxtrx_lms7002m0_0_0-SUSE) weakremover(libxtrxdsp-devel) weakremover(libxtrxdsp0) weakremover(libxtrxll-devel) weakremover(libxtrxll0) weakremover(libxxhash0) weakremover(libxy3) weakremover(libxy4) weakremover(libyajl-devel) weakremover(libyajl-devel-static) weakremover(libyajl2) weakremover(libyaml-0-2) weakremover(libyaml-cpp0_5) weakremover(libyaml-cpp0_6) weakremover(libyaml-cpp0_7) weakremover(libyaml-devel) weakremover(libyang-cpp-devel) weakremover(libyang-cpp0_16) weakremover(libyang-cpp1) weakremover(libyang-devel) weakremover(libyang-extentions) weakremover(libyang0_16) weakremover(libyang1) weakremover(libyang2) weakremover(libyara-devel) weakremover(libyara10) weakremover(libyara3) weakremover(libyara4) weakremover(libyara8) weakremover(libyara9) weakremover(libyascreen0) weakremover(libyate6) weakremover(libyate6_4_0) weakremover(libyaz-devel) weakremover(libyaz5) weakremover(libyder1_4) weakremover(libyelp0) weakremover(libykclient-devel) weakremover(libykclient3) weakremover(libykcs11-1) weakremover(libykcs11-2) weakremover(libykcs11-devel) weakremover(libykneomgr-devel) weakremover(libykneomgr-doc) weakremover(libykneomgr0) weakremover(libykpers-1-1) weakremover(libykpers-devel) weakremover(libykpiv-devel) weakremover(libykpiv1) weakremover(libykpiv2) weakremover(libyubikey-devel) weakremover(libyubikey-tools) weakremover(libyubikey0) weakremover(libyui-devel) weakremover(libyui-doc) weakremover(libyui-ncurses-devel) weakremover(libyui-ncurses-doc) weakremover(libyui-ncurses-pkg-devel) weakremover(libyui-ncurses-pkg-doc) weakremover(libyui-ncurses-pkg10) weakremover(libyui-ncurses-pkg11) weakremover(libyui-ncurses-pkg12) weakremover(libyui-ncurses-pkg13) weakremover(libyui-ncurses-pkg14) weakremover(libyui-ncurses-pkg15) weakremover(libyui-ncurses-pkg16) weakremover(libyui-ncurses-pkg7) weakremover(libyui-ncurses-pkg8) weakremover(libyui-ncurses-pkg9) weakremover(libyui-ncurses-rest-api-devel) weakremover(libyui-ncurses-rest-api10) weakremover(libyui-ncurses-rest-api11) weakremover(libyui-ncurses-rest-api12) weakremover(libyui-ncurses-rest-api13) weakremover(libyui-ncurses-rest-api14) weakremover(libyui-ncurses-rest-api15) weakremover(libyui-ncurses-rest-api16) weakremover(libyui-ncurses-tools) weakremover(libyui-ncurses10) weakremover(libyui-ncurses11) weakremover(libyui-ncurses12) weakremover(libyui-ncurses13) weakremover(libyui-ncurses14) weakremover(libyui-ncurses15) weakremover(libyui-ncurses16) weakremover(libyui-ncurses7) weakremover(libyui-ncurses8) weakremover(libyui-ncurses9) weakremover(libyui-qt-devel) weakremover(libyui-qt-doc) weakremover(libyui-qt-graph-devel) weakremover(libyui-qt-graph-doc) weakremover(libyui-qt-graph10) weakremover(libyui-qt-graph11) weakremover(libyui-qt-graph12) weakremover(libyui-qt-graph13) weakremover(libyui-qt-graph14) weakremover(libyui-qt-graph15) weakremover(libyui-qt-graph16) weakremover(libyui-qt-graph7) weakremover(libyui-qt-graph8) weakremover(libyui-qt-graph9) weakremover(libyui-qt-pkg-devel) weakremover(libyui-qt-pkg-doc) weakremover(libyui-qt-pkg10) weakremover(libyui-qt-pkg11) weakremover(libyui-qt-pkg12) weakremover(libyui-qt-pkg13) weakremover(libyui-qt-pkg14) weakremover(libyui-qt-pkg15) weakremover(libyui-qt-pkg16) weakremover(libyui-qt-pkg7) weakremover(libyui-qt-pkg8) weakremover(libyui-qt-pkg9) weakremover(libyui-qt-rest-api-devel) weakremover(libyui-qt-rest-api10) weakremover(libyui-qt-rest-api11) weakremover(libyui-qt-rest-api12) weakremover(libyui-qt-rest-api13) weakremover(libyui-qt-rest-api14) weakremover(libyui-qt-rest-api15) weakremover(libyui-qt-rest-api16) weakremover(libyui-qt10) weakremover(libyui-qt11) weakremover(libyui-qt12) weakremover(libyui-qt13) weakremover(libyui-qt14) weakremover(libyui-qt15) weakremover(libyui-qt16) weakremover(libyui-qt7) weakremover(libyui-qt8) weakremover(libyui-qt9) weakremover(libyui-rest-api-devel) weakremover(libyui-rest-api10) weakremover(libyui-rest-api11) weakremover(libyui-rest-api12) weakremover(libyui-rest-api13) weakremover(libyui-rest-api14) weakremover(libyui-rest-api15) weakremover(libyui-rest-api16) weakremover(libyui10) weakremover(libyui11) weakremover(libyui12) weakremover(libyui13) weakremover(libyui14) weakremover(libyui15) weakremover(libyui16) weakremover(libyui7) weakremover(libyui8) weakremover(libyui9) weakremover(libyuv-devel) weakremover(libyuv0) weakremover(libz-ng-compat1) weakremover(libz-ng2) weakremover(libz1) weakremover(libz3-4_10) weakremover(libz3-4_11) weakremover(libz3-4_12) weakremover(libz3-4_5) weakremover(libz3-4_6) weakremover(libz3-4_8) weakremover(libzapojit-0_0-0) weakremover(libzapojit-devel) weakremover(libzarchive0_1) weakremover(libzbar-devel) weakremover(libzbar0) weakremover(libzbargtk-devel) weakremover(libzbargtk0) weakremover(libzbarqt-devel) weakremover(libzbarqt0) weakremover(libzbc-5_10_0) weakremover(libzbc-5_5_0) weakremover(libzbc-5_7_1) weakremover(libzbc-5_8_0) weakremover(libzbc-5_8_2) weakremover(libzbc-5_8_3) weakremover(libzbc-5_8_4) weakremover(libzbc-5_8_5) weakremover(libzbc-5_9_0) weakremover(libzbc-devel) weakremover(libzbc-gui) weakremover(libzbc-tools) weakremover(libzbc2) weakremover(libzbc5) weakremover(libzck-devel) weakremover(libzck1) weakremover(libzebra1) weakremover(libzeitgeist-1_0-1) weakremover(libzeitgeist-2_0-0) weakremover(libzeitgeist-devel) weakremover(libzen-devel) weakremover(libzen0) weakremover(libzfp0) weakremover(libzfp1) weakremover(libzhuyin-1_1-data) weakremover(libzhuyin-1_1-devel) weakremover(libzhuyin-data) weakremover(libzhuyin-devel) weakremover(libzhuyin13) weakremover(libzhuyin15) weakremover(libzhuyin7) weakremover(libzimg2) weakremover(libzinnia0) weakremover(libzio-devel) weakremover(libzio1) weakremover(libzip) weakremover(libzip-devel) weakremover(libzip-tools) weakremover(libzip2) weakremover(libzip4) weakremover(libzip5) weakremover(libzipkin-cpp-opentracing0) weakremover(libzita-convolver4) weakremover(libzita-resampler1) weakremover(libzlui0_99) weakremover(libzmf-0_0-0) weakremover(libzmf-devel) weakremover(libzmf-tools) weakremover(libzmq5) weakremover(libzmusic1) weakremover(libzn_poly-0_9) weakremover(libzopfli-devel) weakremover(libzopfli1) weakremover(libzopflipng1) weakremover(libzrtpcpp-devel) weakremover(libzrtpcpp4) weakremover(libzscanner3) weakremover(libzscanner4) weakremover(libzsolve0) weakremover(libzstd-devel) weakremover(libzstd-devel-static) weakremover(libzstd1) weakremover(libzvbi-chains0) weakremover(libzvbi0) weakremover(libzypp) weakremover(libzypp-devel) weakremover(libzypp-devel-doc) weakremover(libzypp-testsuite-tools) weakremover(libzzip-0-13) weakremover(licq) weakremover(licq-devel) weakremover(licq-kde4-gui) weakremover(licq-lang) weakremover(licq-qt4-gui) weakremover(licq-qt4-gui-data) weakremover(lifelines) weakremover(liferea) weakremover(light-locker) weakremover(lightdm) weakremover(lightdm-deepin-greeter) weakremover(lightdm-gobject-devel) weakremover(lightdm-gtk-greeter) weakremover(lightdm-kde-greeter) weakremover(lightdm-kde-greeter-lang) weakremover(lightdm-qt-devel) weakremover(lightdm-qt5-devel) weakremover(lightdm-slick-greeter) weakremover(lightly) weakremover(lightly-decoration) weakremover(lightly-style) weakremover(lightmediascanner) weakremover(lightmediascanner-devel) weakremover(lightsoff) weakremover(lightstep-tracer-cpp-devel) weakremover(lightstep-tracer-cpp-source) weakremover(lighttpd) weakremover(lighttpd-mod_authn_gssapi) weakremover(lighttpd-mod_authn_ldap) weakremover(lighttpd-mod_authn_mysql) weakremover(lighttpd-mod_authn_pam) weakremover(lighttpd-mod_authn_sasl) weakremover(lighttpd-mod_cml) weakremover(lighttpd-mod_geoip) weakremover(lighttpd-mod_magnet) weakremover(lighttpd-mod_maxminddb) weakremover(lighttpd-mod_mysql_vhost) weakremover(lighttpd-mod_rrdtool) weakremover(lighttpd-mod_trigger_b4_dl) weakremover(lighttpd-mod_vhostdb_dbi) weakremover(lighttpd-mod_vhostdb_ldap) weakremover(lighttpd-mod_vhostdb_mysql) weakremover(lighttpd-mod_vhostdb_pgsql) weakremover(lighttpd-mod_webdav) weakremover(lilv) weakremover(lilypond) weakremover(lilypond-century-schoolbook-l-fonts) weakremover(lilypond-texgy-fonts) weakremover(lime-devel) weakremover(limesuite) weakremover(limesuite-devel) weakremover(linbox-devel) weakremover(link-grammar) weakremover(link-grammar-devel) weakremover(linkloop) weakremover(links) weakremover(linphone) weakremover(linphone-cli) weakremover(linphone-lang) weakremover(linssid) weakremover(linstor) weakremover(linstor-common) weakremover(linstor-controller) weakremover(linstor-satellite) weakremover(linux-atm) weakremover(linux-atm-devel) weakremover(linux-ftools) weakremover(linux-glibc-devel) weakremover(linux_logo) weakremover(linux_pcnfsd2) weakremover(linuxconsoletools) weakremover(linuxptp) weakremover(linuxrc) weakremover(linuxvnc) weakremover(lio-mibs) weakremover(lio-utils) weakremover(liquidhaskell) weakremover(lirc-core) weakremover(lirc-devel) weakremover(lirc-disable-kernel-rc) weakremover(lirc-drv-ftdi) weakremover(lirc-drv-portaudio) weakremover(lirc-tools-gui) weakremover(listres) weakremover(lit) weakremover(lite-xl) weakremover(litetran) weakremover(littleb-devel) weakremover(littleb-examples) weakremover(littlewizard) weakremover(littlewizard-devel) weakremover(live-add-yast-repos) weakremover(live-fat-stick) weakremover(live-net-installer) weakremover(live-usb-gui) weakremover(live555) weakremover(live555-devel) weakremover(livestreamer) weakremover(lksctp-tools) weakremover(lksctp-tools-devel) weakremover(llcbench) weakremover(lld) weakremover(lld10) weakremover(lld11) weakremover(lld12) weakremover(lld13) weakremover(lld14) weakremover(lld15) weakremover(lld16) weakremover(lld4) weakremover(lld5) weakremover(lld6) weakremover(lld7) weakremover(lld8) weakremover(lld9) weakremover(lldb) weakremover(lldb-devel) weakremover(lldb16) weakremover(lldb16-devel) weakremover(lldpd) weakremover(lldpd-devel) weakremover(llmnrd) weakremover(llvm) weakremover(llvm-LTO-devel) weakremover(llvm-clang) weakremover(llvm-clang-devel) weakremover(llvm-devel) weakremover(llvm-doc) weakremover(llvm-emacs-plugins) weakremover(llvm-gold) weakremover(llvm-polly) weakremover(llvm-polly-devel) weakremover(llvm10) weakremover(llvm10-LTO-devel) weakremover(llvm10-devel) weakremover(llvm10-doc) weakremover(llvm10-gold) weakremover(llvm10-polly) weakremover(llvm10-polly-devel) weakremover(llvm11) weakremover(llvm11-LTO-devel) weakremover(llvm11-devel) weakremover(llvm11-gold) weakremover(llvm11-polly) weakremover(llvm11-polly-devel) weakremover(llvm12) weakremover(llvm12-LTO-devel) weakremover(llvm12-devel) weakremover(llvm12-gold) weakremover(llvm12-polly) weakremover(llvm12-polly-devel) weakremover(llvm13) weakremover(llvm13-LTO-devel) weakremover(llvm13-devel) weakremover(llvm13-gold) weakremover(llvm13-libc++-devel) weakremover(llvm13-libc++1) weakremover(llvm13-libc++abi-devel) weakremover(llvm13-libc++abi1) weakremover(llvm13-libclang13) weakremover(llvm13-polly) weakremover(llvm13-polly-devel) weakremover(llvm14) weakremover(llvm14-devel) weakremover(llvm14-gold) weakremover(llvm14-libc++-devel) weakremover(llvm14-libc++1) weakremover(llvm14-libc++abi-devel) weakremover(llvm14-libc++abi1) weakremover(llvm14-libclang13) weakremover(llvm14-polly) weakremover(llvm14-polly-devel) weakremover(llvm15) weakremover(llvm15-devel) weakremover(llvm15-gold) weakremover(llvm15-libc++-devel) weakremover(llvm15-libc++1) weakremover(llvm15-libc++abi-devel) weakremover(llvm15-libc++abi1) weakremover(llvm15-libclang13) weakremover(llvm15-polly) weakremover(llvm15-polly-devel) weakremover(llvm16) weakremover(llvm16-devel) weakremover(llvm16-gold) weakremover(llvm16-polly) weakremover(llvm16-polly-devel) weakremover(llvm4) weakremover(llvm4-LTO-devel) weakremover(llvm4-devel) weakremover(llvm4-emacs-plugins) weakremover(llvm4-gold) weakremover(llvm4-vim-plugins) weakremover(llvm5) weakremover(llvm5-LTO-devel) weakremover(llvm5-devel) weakremover(llvm5-emacs-plugins) weakremover(llvm5-gold) weakremover(llvm5-opt-viewer) weakremover(llvm5-vim-plugins) weakremover(llvm6) weakremover(llvm6-LTO-devel) weakremover(llvm6-devel) weakremover(llvm6-emacs-plugins) weakremover(llvm6-gold) weakremover(llvm6-opt-viewer) weakremover(llvm6-polly) weakremover(llvm6-polly-devel) weakremover(llvm6-vim-plugins) weakremover(llvm7) weakremover(llvm7-LTO-devel) weakremover(llvm7-devel) weakremover(llvm7-emacs-plugins) weakremover(llvm7-gold) weakremover(llvm7-polly) weakremover(llvm7-polly-devel) weakremover(llvm8) weakremover(llvm8-LTO-devel) weakremover(llvm8-devel) weakremover(llvm8-emacs-plugins) weakremover(llvm8-gold) weakremover(llvm8-polly) weakremover(llvm8-polly-devel) weakremover(llvm9) weakremover(llvm9-LTO-devel) weakremover(llvm9-devel) weakremover(llvm9-doc) weakremover(llvm9-emacs-plugins) weakremover(llvm9-gold) weakremover(llvm9-polly) weakremover(llvm9-polly-devel) weakremover(lmarbles) weakremover(lmdb) weakremover(lmdb-devel) weakremover(lmicc-account) weakremover(lmicc-bin) weakremover(lmicc-hardware) weakremover(lmicc-libs) weakremover(lmicc-network) weakremover(lmicc-overview) weakremover(lmicc-service) weakremover(lmicc-software) weakremover(lmms) weakremover(lmms-devel) weakremover(lnav) weakremover(lndir) weakremover(lockdev) weakremover(lockdev-devel) weakremover(lockfile) weakremover(lodepng-devel) weakremover(log4cplus-devel) weakremover(log4cpp-devel) weakremover(logcli) weakremover(logdigest) weakremover(logfilegen) weakremover(logrotate) weakremover(logstalgia) weakremover(logtail) weakremover(logtop) weakremover(logwarn) weakremover(lokalize) weakremover(loki) weakremover(lollypop-portal) weakremover(lomoco) weakremover(lookbook) weakremover(lostfeathers) weakremover(loudmouth-devel) weakremover(loudmouth-doc) weakremover(lout) weakremover(love) weakremover(love-0_7_2) weakremover(low-memory-monitor) weakremover(low-memory-monitor-doc) weakremover(lowpan-tools) weakremover(lowpan-tools-devel) weakremover(lowpan-tools-tests) weakremover(lpairs) weakremover(lpe) weakremover(lprof) weakremover(lpsolve) weakremover(lpsolve-devel) weakremover(lrcShow-X) weakremover(lrcShow-X-lang) weakremover(lrslib) weakremover(lrslib-devel) weakremover(lrzip) weakremover(lsb) weakremover(lscsoft-glue-data) weakremover(lsd) weakremover(lsdvd) weakremover(lshw) weakremover(lshw-gui) weakremover(lskat) weakremover(lsof) weakremover(lsp-plugins) weakremover(lsp-plugins-common) weakremover(lsp-plugins-devel) weakremover(lsscsi) weakremover(lswm) weakremover(lswt) weakremover(lsyncd) weakremover(ltrace) weakremover(lttng-modules) weakremover(lttng-modules-kmp-64kb) weakremover(lttng-modules-kmp-default) weakremover(lttng-tools) weakremover(lttng-tools-devel) weakremover(lttng-ust) weakremover(lttng-ust-devel) weakremover(lttoolbox) weakremover(lttoolbox-devel) weakremover(ltxml) weakremover(ltxml-devel) weakremover(lua) weakremover(lua-Hamliblua) weakremover(lua-clingo) weakremover(lua-devel) weakremover(lua-doc) weakremover(lua-genders) weakremover(lua-language-server) weakremover(lua-lgi) weakremover(lua-lgi-doc) weakremover(lua-libguestfs) weakremover(lua-libprelude) weakremover(lua-lmod) weakremover(lua-lmod-man) weakremover(lua-luafilesystem) weakremover(lua-luaposix) weakremover(lua-luaposix-doc) weakremover(lua-luaterm) weakremover(lua-rrdtool) weakremover(lua51) weakremover(lua51-BitOp) weakremover(lua51-BitOp-doc) weakremover(lua51-LPeg) weakremover(lua51-LPeg-doc) weakremover(lua51-MessagePack) weakremover(lua51-bit32) weakremover(lua51-cjson) weakremover(lua51-compat-5.3) weakremover(lua51-cyrussasl) weakremover(lua51-devel) weakremover(lua51-ldbus) weakremover(lua51-lgi) weakremover(lua51-lgi-doc) weakremover(lua51-linenoise) weakremover(lua51-lpeg) weakremover(lua51-lua-dbus) weakremover(lua51-lua-ev) weakremover(lua51-lua-ev-devel) weakremover(lua51-lua-mpris) weakremover(lua51-luadbi) weakremover(lua51-luaevent) weakremover(lua51-luaexpat) weakremover(lua51-luafilesystem) weakremover(lua51-luajit) weakremover(lua51-luajit-devel) weakremover(lua51-lualdap) weakremover(lua51-luaposix) weakremover(lua51-luasec) weakremover(lua51-luasocket) weakremover(lua51-luasocket-devel) weakremover(lua51-luasql) weakremover(lua51-luasystem) weakremover(lua51-luaterm) weakremover(lua51-luaunbound) weakremover(lua51-luautf8) weakremover(lua51-luv) weakremover(lua51-luv-devel) weakremover(lua51-mpack) weakremover(lua51-penlight-doc) weakremover(lua51-readline) weakremover(lua51-zlib) weakremover(lua52) weakremover(lua52-devel) weakremover(lua52-doc) weakremover(lua53) weakremover(lua53-cjson) weakremover(lua53-compat-5.3) weakremover(lua53-cyrussasl) weakremover(lua53-devel) weakremover(lua53-editorconfig-core-lua) weakremover(lua53-ldbus) weakremover(lua53-lgi) weakremover(lua53-lgi-doc) weakremover(lua53-linenoise) weakremover(lua53-lpeg) weakremover(lua53-lua-dbus) weakremover(lua53-lua-ev) weakremover(lua53-lua-ev-devel) weakremover(lua53-lua-mpris) weakremover(lua53-luadbi) weakremover(lua53-luaevent) weakremover(lua53-luaexpat) weakremover(lua53-luafilesystem) weakremover(lua53-lualdap) weakremover(lua53-luaposix) weakremover(lua53-luasec) weakremover(lua53-luasocket) weakremover(lua53-luasocket-devel) weakremover(lua53-luasql) weakremover(lua53-luasystem) weakremover(lua53-luaterm) weakremover(lua53-luaunbound) weakremover(lua53-luautf8) weakremover(lua53-luv) weakremover(lua53-luv-devel) weakremover(lua53-mpack) weakremover(lua53-penlight-doc) weakremover(lua53-readline) weakremover(lua53-zlib) weakremover(lua54) weakremover(lua54-bit32) weakremover(lua54-cjson) weakremover(lua54-compat-5.3) weakremover(lua54-cyrussasl) weakremover(lua54-devel) weakremover(lua54-editorconfig-core-lua) weakremover(lua54-ldbus) weakremover(lua54-lgi) weakremover(lua54-lgi-doc) weakremover(lua54-linenoise) weakremover(lua54-lpeg) weakremover(lua54-lua-dbus) weakremover(lua54-lua-ev) weakremover(lua54-lua-ev-devel) weakremover(lua54-lua-mpris) weakremover(lua54-luadbi) weakremover(lua54-luaevent) weakremover(lua54-luaexpat) weakremover(lua54-luafilesystem) weakremover(lua54-lualdap) weakremover(lua54-luaposix) weakremover(lua54-luasec) weakremover(lua54-luasocket) weakremover(lua54-luasocket-devel) weakremover(lua54-luasql) weakremover(lua54-luasystem) weakremover(lua54-luaterm) weakremover(lua54-luaunbound) weakremover(lua54-luautf8) weakremover(lua54-luv) weakremover(lua54-luv-devel) weakremover(lua54-mpack) weakremover(lua54-penlight-doc) weakremover(lua54-readline) weakremover(lua54-zlib) weakremover(luabind-devel) weakremover(luajit) weakremover(luajit-devel) weakremover(luasocket) weakremover(lucene++-devel) weakremover(lucene-misc) weakremover(luckybackup) weakremover(lugaru) weakremover(luit) weakremover(luksmeta) weakremover(lunar-calendar) weakremover(lunar-calendar-devel) weakremover(lunar-calendar-gtk3-module) weakremover(lunar-date) weakremover(lunar-date-devel) weakremover(luvcview) weakremover(lv) weakremover(lv2) weakremover(lv2-airwindows) weakremover(lv2-devel) weakremover(lv2-examples) weakremover(lv2-guitarix) weakremover(lv2-lsp-plugins) weakremover(lv2-rnnoise) weakremover(lv2-swh-plugins) weakremover(lvm2) weakremover(lvm2-clvm) weakremover(lvm2-cmirrord) weakremover(lvm2-devel) weakremover(lvm2-lockd) weakremover(lvm2-testsuite) weakremover(lxappearance) weakremover(lxappearance-devel) weakremover(lxappearance-obconf) weakremover(lxc) weakremover(lxc-devel) weakremover(lxcc) weakremover(lxcfs) weakremover(lxd) weakremover(lxdm) weakremover(lximage-qt) weakremover(lxinput) weakremover(lxlauncher) weakremover(lxmusic) weakremover(lxmusic-lang) weakremover(lxpanel) weakremover(lxpanel-devel) weakremover(lxpanel-plugin-power-manager) weakremover(lxqt-about) weakremover(lxqt-admin-lang) weakremover(lxqt-archiver) weakremover(lxqt-common) weakremover(lxqt-config) weakremover(lxqt-globalkeys) weakremover(lxqt-globalkeys-devel) weakremover(lxqt-l10n) weakremover(lxqt-notificationd) weakremover(lxqt-openssh-askpass) weakremover(lxqt-panel) weakremover(lxqt-policykit) weakremover(lxqt-powermanagement) weakremover(lxqt-qtplugin) weakremover(lxqt-runner) weakremover(lxqt-session) weakremover(lxqt-sudo) weakremover(lxrandr) weakremover(lxsession) weakremover(lxshortcut) weakremover(lxtask) weakremover(lxterminal) weakremover(lynx) weakremover(lyx) weakremover(lz4) weakremover(lzfse) weakremover(lzfse-devel) weakremover(lzham_codec-devel) weakremover(lzham_codec-libs) weakremover(lzip) weakremover(lziprecover) weakremover(lzlib-devel) weakremover(lzma-sdk-devel) weakremover(lzo-devel) weakremover(lzo-devel-static) weakremover(lzop) weakremover(m17n-lib) weakremover(m17n-lib-devel) weakremover(m4) weakremover(mISDNuser) weakremover(mISDNuser-devel) weakremover(mac) weakremover(mac-robber) weakremover(macchanger) weakremover(macchina) weakremover(machinery) weakremover(machinery-doc) weakremover(madplay) weakremover(maelstrom) weakremover(maeparser-devel) weakremover(mage) weakremover(mailcommon) weakremover(mailcommon-devel) weakremover(maildir-utils) weakremover(mailimporter) weakremover(mailimporter-devel) weakremover(mailman) weakremover(mailnag) weakremover(mailnag-lang) weakremover(mailsync) weakremover(mailutils) weakremover(mailutils-delivery) weakremover(mailutils-devel) weakremover(mailutils-imap4d) weakremover(mailutils-mh) weakremover(mailutils-notify) weakremover(mailutils-pop3d) weakremover(mailx) weakremover(maim) weakremover(mairix) weakremover(make) weakremover(makedepend) weakremover(makedev) weakremover(makedumpfile) weakremover(makeinfo) weakremover(makeinfo4) weakremover(mako) weakremover(malaga) weakremover(malcontent) weakremover(malcontent-control) weakremover(malcontent-devel) weakremover(mame) weakremover(mame-arcade) weakremover(mame-mess) weakremover(mame-tools) weakremover(man) weakremover(man-pages-fr-extra) weakremover(manaplus) weakremover(mandoc) weakremover(mandoc-bin) weakremover(mandown) weakremover(mangler) weakremover(mango-doc) weakremover(mangoapp) weakremover(mangohud) weakremover(manpageeditor) weakremover(mapserver) weakremover(mapserver-devel) weakremover(marble) weakremover(marble-devel) weakremover(marble-kde) weakremover(marble-qt) weakremover(marco) weakremover(marco-devel) weakremover(mariadb) weakremover(mariadb-bench) weakremover(mariadb-client) weakremover(mariadb-connector-odbc) weakremover(mariadb-galera) weakremover(mariadb-java-client) weakremover(mariadb-rpm-macros) weakremover(mariadb-test) weakremover(mariadb-tools) weakremover(marisa) weakremover(marisa-devel) weakremover(markdown-unlit) weakremover(markdownpart) weakremover(markmywords) weakremover(mate-applet-appmenu) weakremover(mate-applet-dock) weakremover(mate-applet-indicator) weakremover(mate-applet-sensors) weakremover(mate-applet-sensors-devel) weakremover(mate-applet-softupd) weakremover(mate-applets) weakremover(mate-calc) weakremover(mate-control-center) weakremover(mate-control-center-devel) weakremover(mate-desktop) weakremover(mate-desktop-devel) weakremover(mate-desktop-gschemas) weakremover(mate-dictionary) weakremover(mate-disk-image-mounter) weakremover(mate-disk-usage-analyzer) weakremover(mate-eiciel) weakremover(mate-media) weakremover(mate-menus) weakremover(mate-menus-devel) weakremover(mate-netbook) weakremover(mate-netspeed) weakremover(mate-netspeed-lang) weakremover(mate-notification-daemon) weakremover(mate-panel) weakremover(mate-panel-devel) weakremover(mate-polkit) weakremover(mate-polkit-devel) weakremover(mate-power-manager) weakremover(mate-screensaver) weakremover(mate-screensaver-devel) weakremover(mate-screenshot) weakremover(mate-search-tool) weakremover(mate-session-manager) weakremover(mate-session-manager-gschemas) weakremover(mate-settings-daemon) weakremover(mate-settings-daemon-devel) weakremover(mate-system-log) weakremover(mate-system-monitor) weakremover(mate-terminal) weakremover(mate-user-share) weakremover(matekbd-common) weakremover(mathgl-cgi) weakremover(mathgl-devel) weakremover(mathgl-devel-static) weakremover(mathgl-examples) weakremover(mathgl-lua) weakremover(mathgl-tools) weakremover(mathmod) weakremover(mathomatic) weakremover(mathomatic-devel) weakremover(matio-tools) weakremover(matrix-quaternion) weakremover(matrix-synapse) weakremover(matthewlib-java) weakremover(matthewlib-java-javadoc) weakremover(mautrix-telegram-server) weakremover(maven) weakremover(maven-lib) weakremover(mawk) weakremover(maxima) weakremover(maxima-exec-clisp) weakremover(maxima-exec-sbcl) weakremover(maxima-xmaxima) weakremover(maya-calendar) weakremover(maya-calendar-devel) weakremover(maya-calendar-lang) weakremover(mayavi) weakremover(mayavi-doc) weakremover(mayavi-jupyter) weakremover(mbedtls-2-devel) weakremover(mbedtls-devel) weakremover(mbox-importer) weakremover(mbpoll) weakremover(mbuffer) weakremover(mc) weakremover(mcabber) weakremover(mcabber-devel) weakremover(mccs) weakremover(mcds) weakremover(mcfly) weakremover(mchange-commons-javadoc) weakremover(mcjoin) weakremover(mcpp) weakremover(mcpp-devel) weakremover(mcqd) weakremover(mcrypt) weakremover(mcstrans) weakremover(md_monitor) weakremover(mda-lv2) weakremover(mdadm) weakremover(mdbook) weakremover(mdbtools) weakremover(mdbtools-devel) weakremover(mdbtools-gui) weakremover(mdds-1_0-devel) weakremover(mdds-1_2-devel) weakremover(mdds-1_4-devel) weakremover(mdds-devel) weakremover(mdevctl) weakremover(mdtest) weakremover(meabo) weakremover(meanwhile-devel) weakremover(meanwhile-doc) weakremover(med-tools) weakremover(mediainfo) weakremover(mediainfo-gui) weakremover(mediastreamer2) weakremover(mediastreamer2-devel) weakremover(mediastreamer2-doc) weakremover(mediastreamer2-lang) weakremover(medit) weakremover(medit-lang) weakremover(mednafen) weakremover(mednafen-server) weakremover(meep) weakremover(meep-devel) weakremover(mega-sdist) weakremover(megaglest) weakremover(megatools) weakremover(melange) weakremover(melody) weakremover(melt) weakremover(melt6) weakremover(memcached) weakremover(memcached-devel) weakremover(memkind) weakremover(memkind-devel) weakremover(memleax) weakremover(memphis-devel) weakremover(menu-cache) weakremover(menu-cache-devel) weakremover(mercurial) weakremover(mercurial-tests) weakremover(meson-test) weakremover(meson-testsuite) weakremover(meson-tools) weakremover(messagelib) weakremover(messagelib-devel) weakremover(metacity) weakremover(metacity-devel) weakremover(metacity-theme-plata) weakremover(metacity-tools) weakremover(metaio-devel) weakremover(metaio-utils) weakremover(metallb-controller) weakremover(metallb-speaker) weakremover(metamail) weakremover(metamath) weakremover(metamath-book) weakremover(metamath-data) weakremover(metatheme-ambiant-mate-common) weakremover(metatheme-breeze-common) weakremover(metatheme-geeko-common) weakremover(metatheme-plata-common) weakremover(metatheme-radiant-mate-common) weakremover(meteo) weakremover(meterbridge) weakremover(metis) weakremover(metis-devel) weakremover(metis_5_1_0-gnu-hpc) weakremover(metis_5_1_0-gnu-hpc-devel) weakremover(metronome) weakremover(mfgtools) weakremover(mfoc) weakremover(mfsm) weakremover(mftrace) weakremover(mg) weakremover(mgdiff) weakremover(mgetty) weakremover(mgp) weakremover(mhash-devel) weakremover(mhtml-firefox) weakremover(mhvtl) weakremover(mhvtl-kmp-64kb) weakremover(mhvtl-kmp-default) weakremover(micro-editor) weakremover(microcom) weakremover(microdnf) weakremover(microformats2-parser) weakremover(microos-devel-tools) weakremover(microos-tools) weakremover(micropython) weakremover(microspdy2http) weakremover(midori) weakremover(midori-branding-openSUSE) weakremover(midori-branding-upstream) weakremover(midori-devel) weakremover(midori-lang) weakremover(miller) weakremover(milou5) weakremover(miltertest) weakremover(mimalloc-devel) weakremover(mimic) weakremover(mimic-devel) weakremover(minder) weakremover(mined) weakremover(minetest) weakremover(minetestserver) weakremover(mingetty) weakremover(mingw32-cpp) weakremover(mingw32-cross-binutils) weakremover(mingw32-cross-binutils-utils) weakremover(mingw32-cross-breakpad-tools) weakremover(mingw32-cross-cpp) weakremover(mingw32-cross-cpp-bootstrap) weakremover(mingw32-cross-gcc) weakremover(mingw32-cross-gcc-bootstrap) weakremover(mingw32-cross-gcc-c++) weakremover(mingw32-cross-gcc-fortran) weakremover(mingw32-cross-gcc-objc) weakremover(mingw32-cross-pkgconf) weakremover(mingw32-gcc) weakremover(mingw32-gcc-c++) weakremover(mingw32-gcc-fortran) weakremover(mingw32-gcc-objc) weakremover(mingw32-libatomic1) weakremover(mingw32-libgcc_s_sjlj1) weakremover(mingw32-libgfortran5) weakremover(mingw32-libgomp1) weakremover(mingw32-libobjc4) weakremover(mingw32-libquadmath0) weakremover(mingw32-libssp0) weakremover(mingw32-libstdc++-gdb-printer) weakremover(mingw32-libstdc++6) weakremover(mingw64-cpp) weakremover(mingw64-cross-binutils) weakremover(mingw64-cross-binutils-utils) weakremover(mingw64-cross-breakpad-tools) weakremover(mingw64-cross-cpp) weakremover(mingw64-cross-cpp-bootstrap) weakremover(mingw64-cross-gcc) weakremover(mingw64-cross-gcc-bootstrap) weakremover(mingw64-cross-gcc-c++) weakremover(mingw64-cross-gcc-fortran) weakremover(mingw64-cross-gcc-objc) weakremover(mingw64-cross-pkgconf) weakremover(mingw64-gcc) weakremover(mingw64-gcc-c++) weakremover(mingw64-gcc-fortran) weakremover(mingw64-gcc-objc) weakremover(mingw64-libatomic1) weakremover(mingw64-libgcc_s_seh1) weakremover(mingw64-libgfortran5) weakremover(mingw64-libgomp1) weakremover(mingw64-libobjc4) weakremover(mingw64-libquadmath0) weakremover(mingw64-libssp0) weakremover(mingw64-libstdc++-gdb-printer) weakremover(mingw64-libstdc++6) weakremover(minicom) weakremover(minicondor) weakremover(minidlna) weakremover(minikube) weakremover(minimodem) weakremover(mininet) weakremover(mininews) weakremover(minio-client) weakremover(minisat) weakremover(minisat-devel) weakremover(minitube) weakremover(miniupnpc) weakremover(minizinc) weakremover(minizip-devel) weakremover(minuet) weakremover(minuet-devel) weakremover(mipv6d) weakremover(miredo-client) weakremover(miredo-common) weakremover(miredo-devel) weakremover(miredo-server) weakremover(mirisdr) weakremover(mirisdr-udev) weakremover(mirror-registry) weakremover(mirrormagic) weakremover(mirrorsorcerer) weakremover(misfortune) weakremover(mjpegtools) weakremover(mjpg-streamer) weakremover(mkcomposecache) weakremover(mkelfImage) weakremover(mkfontdir) weakremover(mkfontscale) weakremover(mkisofs) weakremover(mkl-dnn-devel) weakremover(mkl-dnn-doc) weakremover(mksh) weakremover(mksusecd) weakremover(mktorrent) weakremover(mkvtoolnix) weakremover(mkvtoolnix-gui) weakremover(mkvtoolnix-tools) weakremover(mlmmj) weakremover(mlocate) weakremover(mlterm) weakremover(mlterm-canna) weakremover(mlterm-common) weakremover(mlterm-fcitx) weakremover(mlterm-ibus) weakremover(mlterm-m17n) weakremover(mlterm-scim) weakremover(mlterm-sdl2) weakremover(mlterm-uim) weakremover(mlterm-wnn) weakremover(mlxbf-bootctl) weakremover(mmc-utils) weakremover(mmdblookup) weakremover(mmv) weakremover(moarvm) weakremover(mobidict) weakremover(mobipocket) weakremover(mobipocket-devel) weakremover(moc) weakremover(mod_spatialite) weakremover(modem-manager-gui) weakremover(modglue-devel) weakremover(modify-fasta) weakremover(modsecurity) weakremover(modsecurity-devel) weakremover(modulemd-validator) weakremover(modulemd-validator-v1) weakremover(moe) weakremover(moinmoin-wiki) weakremover(mokutil) weakremover(mold) weakremover(molequeue) weakremover(molequeue-devel) weakremover(molequeue-libs0) weakremover(molsketch) weakremover(molsketch-devel) weakremover(monero-devel) weakremover(monero-devel-static) weakremover(monero-doc) weakremover(monero-gui) weakremover(monero-utils) weakremover(monerod) weakremover(mongodb) weakremover(mongodb-mongoperf) weakremover(mongodb-mongos) weakremover(mongodb-server) weakremover(mongodb-shell) weakremover(monit) weakremover(monit-doc) weakremover(monitor) weakremover(monitor-lang) weakremover(monitoring-plugins) weakremover(monitoring-plugins-all) weakremover(monitoring-plugins-breeze) weakremover(monitoring-plugins-by_ssh) weakremover(monitoring-plugins-cluster) weakremover(monitoring-plugins-common) weakremover(monitoring-plugins-cups) weakremover(monitoring-plugins-dbi) weakremover(monitoring-plugins-dbi-mysql) weakremover(monitoring-plugins-dbi-pgsql) weakremover(monitoring-plugins-dbi-sqlite3) weakremover(monitoring-plugins-dhcp) weakremover(monitoring-plugins-dig) weakremover(monitoring-plugins-disk) weakremover(monitoring-plugins-disk_smb) weakremover(monitoring-plugins-diskio) weakremover(monitoring-plugins-dns) weakremover(monitoring-plugins-dummy) weakremover(monitoring-plugins-extras) weakremover(monitoring-plugins-file_age) weakremover(monitoring-plugins-flexlm) weakremover(monitoring-plugins-fping) weakremover(monitoring-plugins-hpjd) weakremover(monitoring-plugins-http) weakremover(monitoring-plugins-icmp) weakremover(monitoring-plugins-ide_smart) weakremover(monitoring-plugins-ifoperstatus) weakremover(monitoring-plugins-ifstatus) weakremover(monitoring-plugins-ircd) weakremover(monitoring-plugins-ldap) weakremover(monitoring-plugins-load) weakremover(monitoring-plugins-log) weakremover(monitoring-plugins-mailq) weakremover(monitoring-plugins-mrtg) weakremover(monitoring-plugins-mrtgtraf) weakremover(monitoring-plugins-mysql) weakremover(monitoring-plugins-nagios) weakremover(monitoring-plugins-nrpe) weakremover(monitoring-plugins-nt) weakremover(monitoring-plugins-ntp_peer) weakremover(monitoring-plugins-ntp_time) weakremover(monitoring-plugins-nwstat) weakremover(monitoring-plugins-oracle) weakremover(monitoring-plugins-overcr) weakremover(monitoring-plugins-pgsql) weakremover(monitoring-plugins-ping) weakremover(monitoring-plugins-procs) weakremover(monitoring-plugins-radius) weakremover(monitoring-plugins-real) weakremover(monitoring-plugins-rpc) weakremover(monitoring-plugins-sensors) weakremover(monitoring-plugins-smtp) weakremover(monitoring-plugins-snmp) weakremover(monitoring-plugins-ssh) weakremover(monitoring-plugins-swap) weakremover(monitoring-plugins-tcp) weakremover(monitoring-plugins-time) weakremover(monitoring-plugins-ups) weakremover(monitoring-plugins-uptime) weakremover(monitoring-plugins-users) weakremover(monitoring-plugins-wave) weakremover(monitoring-tools) weakremover(mono-complete) weakremover(mono-core) weakremover(mono-data) weakremover(mono-data-oracle) weakremover(mono-data-sqlite) weakremover(mono-devel) weakremover(mono-extras) weakremover(mono-libkolabxml1) weakremover(mono-locale-extras) weakremover(mono-mvc) weakremover(mono-nat) weakremover(mono-nat-devel) weakremover(mono-nuget) weakremover(mono-nuget-devel) weakremover(mono-nunit) weakremover(mono-reactive) weakremover(mono-uia) weakremover(mono-uia-devel) weakremover(mono-upnp) weakremover(mono-upnp-devel) weakremover(mono-wcf) weakremover(mono-web) weakremover(mono-winforms) weakremover(mono-winfxcore) weakremover(monodoc-core) weakremover(monteverdi) weakremover(moodbar) weakremover(moodbar-devel) weakremover(moolticute) weakremover(moonjit) weakremover(moonjit-devel) weakremover(mopac7) weakremover(moreutils) weakremover(moreutils-parallel) weakremover(morituri) weakremover(morris) weakremover(mosh) weakremover(mosquitto) weakremover(mosquitto-clients) weakremover(mosquitto-devel) weakremover(most) weakremover(motif) weakremover(motif-devel) weakremover(motion) weakremover(motv) weakremover(mousepad) weakremover(mousepad-devel) weakremover(mousetweaks) weakremover(movit-devel) weakremover(mozaddon-bugmenot) weakremover(mozaddon-firebug) weakremover(mozc) weakremover(mozc-gui-tools) weakremover(mozilla-jss) weakremover(mozilla-jss-javadoc) weakremover(mozilla-kde4-integration) weakremover(mozilla-nspr) weakremover(mozilla-nspr-devel) weakremover(mozilla-nss) weakremover(mozilla-nss-certs) weakremover(mozilla-nss-devel) weakremover(mozilla-nss-sysinit) weakremover(mozilla-nss-tools) weakremover(mozjs102) weakremover(mozjs102-devel) weakremover(mozjs17) weakremover(mozjs17-devel) weakremover(mozjs24) weakremover(mozjs24-devel) weakremover(mozjs38) weakremover(mozjs38-devel) weakremover(mozjs52) weakremover(mozjs52-devel) weakremover(mozjs60) weakremover(mozjs60-devel) weakremover(mozjs68) weakremover(mozjs68-devel) weakremover(mozjs78) weakremover(mozjs78-devel) weakremover(mozjs91) weakremover(mozjs91-devel) weakremover(mozldap-devel) weakremover(mozldap-libs) weakremover(mozldap-tools) weakremover(mp) weakremover(mp-gtk3) weakremover(mp3_check) weakremover(mp3gain) weakremover(mpc-devel) weakremover(mpc-qt) weakremover(mpclient) weakremover(mpd) weakremover(mpdecimal-devel) weakremover(mpeg2dec) weakremover(mpfi-devel) weakremover(mpfpx-devel) weakremover(mpfr-devel) weakremover(mpfrcx-devel) weakremover(mpg123) weakremover(mpg123-devel) weakremover(mpg123-esound) weakremover(mpg123-jack) weakremover(mpg123-openal) weakremover(mpg123-portaudio) weakremover(mpg123-pulse) weakremover(mpg123-sdl) weakremover(mpiP_3_4_1-gnu-mpich-hpc) weakremover(mpiP_3_4_1-gnu-mpich-hpc-devel-static) weakremover(mpiP_3_4_1-gnu-mpich-hpc-doc) weakremover(mpiP_3_4_1-gnu-mvapich2-hpc) weakremover(mpiP_3_4_1-gnu-mvapich2-hpc-devel-static) weakremover(mpiP_3_4_1-gnu-mvapich2-hpc-doc) weakremover(mpiP_3_4_1-gnu-openmpi1-hpc) weakremover(mpiP_3_4_1-gnu-openmpi1-hpc-devel-static) weakremover(mpiP_3_4_1-gnu-openmpi1-hpc-doc) weakremover(mpiP_3_4_1-gnu-openmpi2-hpc) weakremover(mpiP_3_4_1-gnu-openmpi2-hpc-devel-static) weakremover(mpiP_3_4_1-gnu-openmpi2-hpc-doc) weakremover(mpiP_3_4_1-gnu-openmpi3-hpc) weakremover(mpiP_3_4_1-gnu-openmpi3-hpc-devel-static) weakremover(mpiP_3_4_1-gnu-openmpi3-hpc-doc) weakremover(mpiP_3_5-gnu-mpich-hpc) weakremover(mpiP_3_5-gnu-mpich-hpc-devel) weakremover(mpiP_3_5-gnu-mpich-hpc-devel-static) weakremover(mpiP_3_5-gnu-mpich-hpc-doc) weakremover(mpiP_3_5-gnu-mvapich2-hpc) weakremover(mpiP_3_5-gnu-mvapich2-hpc-devel) weakremover(mpiP_3_5-gnu-mvapich2-hpc-devel-static) weakremover(mpiP_3_5-gnu-mvapich2-hpc-doc) weakremover(mpiP_3_5-gnu-openmpi1-hpc) weakremover(mpiP_3_5-gnu-openmpi1-hpc-devel) weakremover(mpiP_3_5-gnu-openmpi1-hpc-devel-static) weakremover(mpiP_3_5-gnu-openmpi1-hpc-doc) weakremover(mpiP_3_5-gnu-openmpi2-hpc) weakremover(mpiP_3_5-gnu-openmpi2-hpc-devel) weakremover(mpiP_3_5-gnu-openmpi2-hpc-devel-static) weakremover(mpiP_3_5-gnu-openmpi2-hpc-doc) weakremover(mpiP_3_5-gnu-openmpi3-hpc) weakremover(mpiP_3_5-gnu-openmpi3-hpc-devel) weakremover(mpiP_3_5-gnu-openmpi3-hpc-devel-static) weakremover(mpiP_3_5-gnu-openmpi3-hpc-doc) weakremover(mpiP_3_5-gnu-openmpi4-hpc) weakremover(mpiP_3_5-gnu-openmpi4-hpc-devel) weakremover(mpiP_3_5-gnu-openmpi4-hpc-devel-static) weakremover(mpiP_3_5-gnu-openmpi4-hpc-doc) weakremover(mpibash) weakremover(mpibash-examples) weakremover(mpich) weakremover(mpich-devel) weakremover(mpich-gnu-hpc) weakremover(mpich-gnu-hpc-devel) weakremover(mpich-gnu-hpc-devel-static) weakremover(mpich-ofi) weakremover(mpich-ofi-devel) weakremover(mpich-ofi-gnu-hpc) weakremover(mpich-ofi-gnu-hpc-devel) weakremover(mpich-ofi-gnu-hpc-devel-static) weakremover(mpich-ofi_3_2_1-gnu-hpc) weakremover(mpich-ofi_3_2_1-gnu-hpc-devel) weakremover(mpich-ofi_3_2_1-gnu-hpc-devel-static) weakremover(mpich-ofi_3_2_1-gnu-hpc-macros-devel) weakremover(mpich-ofi_3_3-gnu-hpc) weakremover(mpich-ofi_3_3-gnu-hpc-devel) weakremover(mpich-ofi_3_3-gnu-hpc-devel-static) weakremover(mpich-ofi_3_3-gnu-hpc-macros-devel) weakremover(mpich-ofi_3_3_1-gnu-hpc) weakremover(mpich-ofi_3_3_1-gnu-hpc-devel) weakremover(mpich-ofi_3_3_1-gnu-hpc-devel-static) weakremover(mpich-ofi_3_3_1-gnu-hpc-macros-devel) weakremover(mpich-ofi_3_3_2-gnu-hpc) weakremover(mpich-ofi_3_3_2-gnu-hpc-devel) weakremover(mpich-ofi_3_3_2-gnu-hpc-devel-static) weakremover(mpich-ofi_3_3_2-gnu-hpc-macros-devel) weakremover(mpich-ofi_3_4_1-gnu-hpc) weakremover(mpich-ofi_3_4_1-gnu-hpc-devel) weakremover(mpich-ofi_3_4_1-gnu-hpc-devel-static) weakremover(mpich-ofi_3_4_1-gnu-hpc-macros-devel) weakremover(mpich-ofi_3_4_2-gnu-hpc) weakremover(mpich-ofi_3_4_2-gnu-hpc-devel) weakremover(mpich-ofi_3_4_2-gnu-hpc-devel-static) weakremover(mpich-ofi_3_4_2-gnu-hpc-macros-devel) weakremover(mpich-ofi_3_4_3-gnu-hpc) weakremover(mpich-ofi_3_4_3-gnu-hpc-devel) weakremover(mpich-ofi_3_4_3-gnu-hpc-devel-static) weakremover(mpich-ofi_3_4_3-gnu-hpc-macros-devel) weakremover(mpich-ofi_4_0_1-gnu-hpc) weakremover(mpich-ofi_4_0_1-gnu-hpc-devel) weakremover(mpich-ofi_4_0_1-gnu-hpc-devel-static) weakremover(mpich-ofi_4_0_1-gnu-hpc-macros-devel) weakremover(mpich-ofi_4_0_2-gnu-hpc) weakremover(mpich-ofi_4_0_2-gnu-hpc-devel) weakremover(mpich-ofi_4_0_2-gnu-hpc-devel-static) weakremover(mpich-ofi_4_0_2-gnu-hpc-macros-devel) weakremover(mpich_3_2_1-gnu-hpc) weakremover(mpich_3_2_1-gnu-hpc-devel) weakremover(mpich_3_2_1-gnu-hpc-devel-static) weakremover(mpich_3_2_1-gnu-hpc-macros-devel) weakremover(mpich_3_3-gnu-hpc) weakremover(mpich_3_3-gnu-hpc-devel) weakremover(mpich_3_3-gnu-hpc-devel-static) weakremover(mpich_3_3-gnu-hpc-macros-devel) weakremover(mpich_3_3_1-gnu-hpc) weakremover(mpich_3_3_1-gnu-hpc-devel) weakremover(mpich_3_3_1-gnu-hpc-devel-static) weakremover(mpich_3_3_1-gnu-hpc-macros-devel) weakremover(mpich_3_3_2-gnu-hpc) weakremover(mpich_3_3_2-gnu-hpc-devel) weakremover(mpich_3_3_2-gnu-hpc-devel-static) weakremover(mpich_3_3_2-gnu-hpc-macros-devel) weakremover(mpich_3_4_1-gnu-hpc) weakremover(mpich_3_4_1-gnu-hpc-devel) weakremover(mpich_3_4_1-gnu-hpc-devel-static) weakremover(mpich_3_4_1-gnu-hpc-macros-devel) weakremover(mpich_3_4_2-gnu-hpc) weakremover(mpich_3_4_2-gnu-hpc-devel) weakremover(mpich_3_4_2-gnu-hpc-devel-static) weakremover(mpich_3_4_2-gnu-hpc-macros-devel) weakremover(mpich_3_4_3-gnu-hpc) weakremover(mpich_3_4_3-gnu-hpc-devel) weakremover(mpich_3_4_3-gnu-hpc-devel-static) weakremover(mpich_3_4_3-gnu-hpc-macros-devel) weakremover(mpich_4_0_1-gnu-hpc) weakremover(mpich_4_0_1-gnu-hpc-devel) weakremover(mpich_4_0_1-gnu-hpc-devel-static) weakremover(mpich_4_0_1-gnu-hpc-macros-devel) weakremover(mpich_4_0_2-gnu-hpc) weakremover(mpich_4_0_2-gnu-hpc-devel) weakremover(mpich_4_0_2-gnu-hpc-devel-static) weakremover(mpich_4_0_2-gnu-hpc-macros-devel) weakremover(mpitests) weakremover(mpitests-mpich) weakremover(mpitests-mpich-gnu-hpc) weakremover(mpitests-mpich-ofi) weakremover(mpitests-mpich-ofi-gnu-hpc) weakremover(mpitests-mvapich2) weakremover(mpitests-mvapich2-gnu-hpc) weakremover(mpitests-openmpi) weakremover(mpitests-openmpi1) weakremover(mpitests-openmpi1-gnu-hpc) weakremover(mpitests-openmpi2) weakremover(mpitests-openmpi2-gnu-hpc) weakremover(mpitests-openmpi3) weakremover(mpitests-openmpi3-gnu-hpc) weakremover(mpitests-openmpi4) weakremover(mpitests-openmpi4-gnu-hpc) weakremover(mpop) weakremover(mpop-doc) weakremover(mpris-ctl) weakremover(mpt-status) weakremover(mpv) weakremover(mpv-devel) weakremover(mpv-mpris) weakremover(mpv-plugin-mpris) weakremover(mpvpaper) weakremover(mraa) weakremover(mraa-devel) weakremover(mraa-examples) weakremover(mrboom) weakremover(mrouted) weakremover(mrsh) weakremover(mrsh-rsh-compat) weakremover(mrsh-rsh-server-compat) weakremover(mrsh-server) weakremover(mrtg) weakremover(mrtg-doc) weakremover(mruby) weakremover(mruby-devel) weakremover(mscgen) weakremover(msgpack-c-devel) weakremover(msgpack-cxx-devel) weakremover(msgpack-devel) weakremover(msitools) weakremover(msitools-devel) weakremover(msmtp) weakremover(msmtp-mta) weakremover(msoak) weakremover(mspack-examples) weakremover(mspack-tools) weakremover(mstflint) weakremover(mt-st) weakremover(mt32emu) weakremover(mt32emu-qt) weakremover(mt_st) weakremover(mtail) weakremover(mtd-utils) weakremover(mtdev) weakremover(mtdev-devel) weakremover(mtools) weakremover(mtools-doc) weakremover(mtools-floppyd) weakremover(mtp-tools) weakremover(mtpaint) weakremover(mtr) weakremover(mtr-gtk) weakremover(mtree) weakremover(mtx) weakremover(muffin) weakremover(muffin-devel) weakremover(mujs) weakremover(mujs-devel) weakremover(multiload-ng-base) weakremover(multiload-ng-xfce4) weakremover(multimon-ng) weakremover(multipath-tools) weakremover(multipath-tools-devel) weakremover(multipath-tools-rbd) weakremover(multitail) weakremover(multus) weakremover(mumble) weakremover(mumble-server) weakremover(mumps-devel) weakremover(mumps-devel-static) weakremover(mumps-examples) weakremover(mumps-mvapich2-5-compat) weakremover(mumps-mvapich2-devel) weakremover(mumps-mvapich2-devel-static) weakremover(mumps-mvapich2-devel-static-compat) weakremover(mumps-mvapich2-examples) weakremover(mumps-openmpi-5-compat) weakremover(mumps-openmpi-devel) weakremover(mumps-openmpi-devel-static) weakremover(mumps-openmpi-devel-static-compat) weakremover(mumps-openmpi-examples) weakremover(mumps-openmpi1-5-compat) weakremover(mumps-openmpi1-devel) weakremover(mumps-openmpi1-devel-static) weakremover(mumps-openmpi1-devel-static-compat) weakremover(mumps-openmpi1-examples) weakremover(mumps-openmpi2-5-compat) weakremover(mumps-openmpi2-devel) weakremover(mumps-openmpi2-devel-static) weakremover(mumps-openmpi2-devel-static-compat) weakremover(mumps-openmpi2-examples) weakremover(mumps-openmpi3-5-compat) weakremover(mumps-openmpi3-devel) weakremover(mumps-openmpi3-devel-static) weakremover(mumps-openmpi3-devel-static-compat) weakremover(mumps-openmpi3-examples) weakremover(mumps-openmpi4-5-compat) weakremover(mumps-openmpi4-devel) weakremover(mumps-openmpi4-devel-static) weakremover(mumps-openmpi4-devel-static-compat) weakremover(mumps-openmpi4-examples) weakremover(mumps-ptscotch-openmpi-5-compat) weakremover(mumps-ptscotch-openmpi-devel) weakremover(mumps-ptscotch-openmpi-devel-static) weakremover(mumps-ptscotch-openmpi-devel-static-compat) weakremover(mumps-ptscotch-openmpi-examples) weakremover(mumps-ptscotch-openmpi1-5-compat) weakremover(mumps-ptscotch-openmpi1-devel) weakremover(mumps-ptscotch-openmpi1-devel-static) weakremover(mumps-ptscotch-openmpi1-devel-static-compat) weakremover(mumps-ptscotch-openmpi1-examples) weakremover(mumps-ptscotch-openmpi2-5-compat) weakremover(mumps-ptscotch-openmpi2-devel) weakremover(mumps-ptscotch-openmpi2-devel-static) weakremover(mumps-ptscotch-openmpi2-devel-static-compat) weakremover(mumps-ptscotch-openmpi2-examples) weakremover(mumps-ptscotch-openmpi3-devel) weakremover(mumps-ptscotch-openmpi3-devel-static) weakremover(mumps-ptscotch-openmpi3-devel-static-compat) weakremover(mumps-ptscotch-openmpi3-examples) weakremover(mumps-ptscotch-openmpi4-devel) weakremover(mumps-ptscotch-openmpi4-devel-static) weakremover(mumps-ptscotch-openmpi4-devel-static-compat) weakremover(mumps-ptscotch-openmpi4-examples) weakremover(mumps-scotch-devel) weakremover(mumps-scotch-devel-static) weakremover(mumps-scotch-examples) weakremover(mumps_5_1_2-gnu-mpich-hpc-devel) weakremover(mumps_5_1_2-gnu-mpich-hpc-devel-static) weakremover(mumps_5_1_2-gnu-mpich-hpc-doc) weakremover(mumps_5_1_2-gnu-mpich-hpc-examples) weakremover(mumps_5_1_2-gnu-mvapich2-hpc-devel) weakremover(mumps_5_1_2-gnu-mvapich2-hpc-devel-static) weakremover(mumps_5_1_2-gnu-mvapich2-hpc-doc) weakremover(mumps_5_1_2-gnu-mvapich2-hpc-examples) weakremover(mumps_5_1_2-gnu-openmpi1-hpc-devel) weakremover(mumps_5_1_2-gnu-openmpi1-hpc-devel-static) weakremover(mumps_5_1_2-gnu-openmpi1-hpc-doc) weakremover(mumps_5_1_2-gnu-openmpi1-hpc-examples) weakremover(mumps_5_1_2-gnu-openmpi2-hpc-devel) weakremover(mumps_5_1_2-gnu-openmpi2-hpc-devel-static) weakremover(mumps_5_1_2-gnu-openmpi2-hpc-doc) weakremover(mumps_5_1_2-gnu-openmpi2-hpc-examples) weakremover(mumps_5_1_2-gnu-openmpi3-hpc-devel) weakremover(mumps_5_1_2-gnu-openmpi3-hpc-devel-static) weakremover(mumps_5_1_2-gnu-openmpi3-hpc-doc) weakremover(mumps_5_1_2-gnu-openmpi3-hpc-examples) weakremover(mumps_5_2_1-gnu-mpich-hpc-devel) weakremover(mumps_5_2_1-gnu-mpich-hpc-devel-static) weakremover(mumps_5_2_1-gnu-mpich-hpc-doc) weakremover(mumps_5_2_1-gnu-mpich-hpc-examples) weakremover(mumps_5_2_1-gnu-mvapich2-hpc-devel) weakremover(mumps_5_2_1-gnu-mvapich2-hpc-devel-static) weakremover(mumps_5_2_1-gnu-mvapich2-hpc-doc) weakremover(mumps_5_2_1-gnu-mvapich2-hpc-examples) weakremover(mumps_5_2_1-gnu-openmpi1-hpc-devel) weakremover(mumps_5_2_1-gnu-openmpi1-hpc-devel-static) weakremover(mumps_5_2_1-gnu-openmpi1-hpc-doc) weakremover(mumps_5_2_1-gnu-openmpi1-hpc-examples) weakremover(mumps_5_2_1-gnu-openmpi2-hpc-devel) weakremover(mumps_5_2_1-gnu-openmpi2-hpc-devel-static) weakremover(mumps_5_2_1-gnu-openmpi2-hpc-doc) weakremover(mumps_5_2_1-gnu-openmpi2-hpc-examples) weakremover(mumps_5_2_1-gnu-openmpi3-hpc-devel) weakremover(mumps_5_2_1-gnu-openmpi3-hpc-devel-static) weakremover(mumps_5_2_1-gnu-openmpi3-hpc-doc) weakremover(mumps_5_2_1-gnu-openmpi3-hpc-examples) weakremover(mumps_5_2_1-gnu-openmpi4-hpc-devel) weakremover(mumps_5_2_1-gnu-openmpi4-hpc-devel-static) weakremover(mumps_5_2_1-gnu-openmpi4-hpc-doc) weakremover(mumps_5_2_1-gnu-openmpi4-hpc-examples) weakremover(mumps_5_3_5-gnu-mpich-hpc-devel) weakremover(mumps_5_3_5-gnu-mpich-hpc-devel-static) weakremover(mumps_5_3_5-gnu-mpich-hpc-examples) weakremover(mumps_5_3_5-gnu-mvapich2-hpc-devel) weakremover(mumps_5_3_5-gnu-mvapich2-hpc-devel-static) weakremover(mumps_5_3_5-gnu-mvapich2-hpc-examples) weakremover(mumps_5_3_5-gnu-openmpi1-hpc-devel) weakremover(mumps_5_3_5-gnu-openmpi1-hpc-devel-static) weakremover(mumps_5_3_5-gnu-openmpi1-hpc-examples) weakremover(mumps_5_3_5-gnu-openmpi2-hpc-devel) weakremover(mumps_5_3_5-gnu-openmpi2-hpc-devel-static) weakremover(mumps_5_3_5-gnu-openmpi2-hpc-examples) weakremover(mumps_5_3_5-gnu-openmpi3-hpc-devel) weakremover(mumps_5_3_5-gnu-openmpi3-hpc-devel-static) weakremover(mumps_5_3_5-gnu-openmpi3-hpc-examples) weakremover(mumps_5_3_5-gnu-openmpi4-hpc-devel) weakremover(mumps_5_3_5-gnu-openmpi4-hpc-devel-static) weakremover(mumps_5_3_5-gnu-openmpi4-hpc-examples) weakremover(munge) weakremover(munge-devel) weakremover(munit-devel) weakremover(muparser-devel) weakremover(muparserx-devel) weakremover(mupdf) weakremover(mupdf-devel-static) weakremover(mupen64plus-plugin-audio-sdl) weakremover(mupen64plus-plugin-input-sdl) weakremover(mupen64plus-plugin-rsp-hle) weakremover(mupen64plus-plugin-video-glide64mk2) weakremover(mupen64plus-plugin-video-rice) weakremover(mupen64plus-ui-console) weakremover(museic) weakremover(musepack) weakremover(musepack-devel) weakremover(musescore) weakremover(musescore-devel) weakremover(musique) weakremover(mustang-plug) weakremover(mutt) weakremover(mutter) weakremover(mutter-data) weakremover(mutter-devel) weakremover(mvapich2) weakremover(mvapich2-devel) weakremover(mvapich2-devel-static) weakremover(mvapich2-doc) weakremover(mvapich2-gnu-hpc) weakremover(mvapich2-gnu-hpc-devel) weakremover(mvapich2_2_2-gnu-hpc) weakremover(mvapich2_2_2-gnu-hpc-devel) weakremover(mvapich2_2_2-gnu-hpc-devel-static) weakremover(mvapich2_2_2-gnu-hpc-doc) weakremover(mvapich2_2_2-gnu-hpc-macros-devel) weakremover(mvapich2_2_3_1-gnu-hpc) weakremover(mvapich2_2_3_1-gnu-hpc-devel) weakremover(mvapich2_2_3_1-gnu-hpc-devel-static) weakremover(mvapich2_2_3_1-gnu-hpc-doc) weakremover(mvapich2_2_3_1-gnu-hpc-macros-devel) weakremover(mvapich2_2_3_2-gnu-hpc) weakremover(mvapich2_2_3_2-gnu-hpc-devel) weakremover(mvapich2_2_3_2-gnu-hpc-devel-static) weakremover(mvapich2_2_3_2-gnu-hpc-doc) weakremover(mvapich2_2_3_2-gnu-hpc-macros-devel) weakremover(mvapich2_2_3_3-gnu-hpc) weakremover(mvapich2_2_3_3-gnu-hpc-devel) weakremover(mvapich2_2_3_3-gnu-hpc-devel-static) weakremover(mvapich2_2_3_3-gnu-hpc-doc) weakremover(mvapich2_2_3_3-gnu-hpc-macros-devel) weakremover(mvapich2_2_3_4-gnu-hpc) weakremover(mvapich2_2_3_4-gnu-hpc-devel) weakremover(mvapich2_2_3_4-gnu-hpc-devel-static) weakremover(mvapich2_2_3_4-gnu-hpc-doc) weakremover(mvapich2_2_3_4-gnu-hpc-macros-devel) weakremover(mvapich2_2_3_5-gnu-hpc) weakremover(mvapich2_2_3_5-gnu-hpc-devel) weakremover(mvapich2_2_3_5-gnu-hpc-devel-static) weakremover(mvapich2_2_3_5-gnu-hpc-doc) weakremover(mvapich2_2_3_5-gnu-hpc-macros-devel) weakremover(mvapich2_2_3_6-gnu-hpc) weakremover(mvapich2_2_3_6-gnu-hpc-devel) weakremover(mvapich2_2_3_6-gnu-hpc-devel-static) weakremover(mvapich2_2_3_6-gnu-hpc-doc) weakremover(mvapich2_2_3_6-gnu-hpc-macros-devel) weakremover(mvapich2_2_3_7-gnu-hpc) weakremover(mvapich2_2_3_7-gnu-hpc-devel) weakremover(mvapich2_2_3_7-gnu-hpc-devel-static) weakremover(mvapich2_2_3_7-gnu-hpc-doc) weakremover(mvapich2_2_3_7-gnu-hpc-macros-devel) weakremover(mxml) weakremover(mxml-devel) weakremover(mygnuhealth) weakremover(myman) weakremover(mypaint) weakremover(myspell-dictionaries) weakremover(myspell-eo_EO) weakremover(myspell-lightproof-en) weakremover(myspell-lightproof-hu_HU) weakremover(myspell-lightproof-pt_BR) weakremover(myspell-lightproof-ru_RU) weakremover(myspell-pt_AO) weakremover(mysql-community-server) weakremover(mysql-community-server-bench) weakremover(mysql-community-server-client) weakremover(mysql-community-server-errormessages) weakremover(mysql-community-server-test) weakremover(mysql-community-server-tools) weakremover(mysql-workbench) weakremover(mysql-xml-to-csv) weakremover(mythes-devel) weakremover(myxer) weakremover(naev) weakremover(naev-data) weakremover(nagios) weakremover(nagios-contrib) weakremover(nagios-devel) weakremover(nagios-www) weakremover(nagios-www-dch) weakremover(nagstamon) weakremover(nagvis) weakremover(nagvis-demos) weakremover(namazu) weakremover(namazu-cgi) weakremover(namazu-devel) weakremover(nano) weakremover(nano-icinga2) weakremover(nano-plugin-conky) weakremover(nanomsg-devel) weakremover(nanopb-devel) weakremover(nasc) weakremover(nasm) weakremover(nasm-doc) weakremover(nast) weakremover(native-platform) weakremover(nautilus) weakremover(nautilus-actions) weakremover(nautilus-actions-devel) weakremover(nautilus-actions-lang) weakremover(nautilus-deja-dup) weakremover(nautilus-devel) weakremover(nautilus-eiciel) weakremover(nautilus-evince) weakremover(nautilus-extension-actions) weakremover(nautilus-extension-console) weakremover(nautilus-extension-dropbox) weakremover(nautilus-extension-nitroshare) weakremover(nautilus-extension-seahorse) weakremover(nautilus-extension-terminal) weakremover(nautilus-extension-tracker-tags) weakremover(nautilus-file-roller) weakremover(nautilus-font-manager) weakremover(nautilus-image-converter) weakremover(nautilus-plugin-easytag) weakremover(nautilus-search-tool) weakremover(nautilus-search-tool-lang) weakremover(nautilus-sendto) weakremover(nautilus-share) weakremover(nautilus-terminal) weakremover(nautilus-totem) weakremover(nauty) weakremover(nauty-devel) weakremover(nbd) weakremover(nbd-doc) weakremover(nbdfuse) weakremover(nbdkit) weakremover(nbdkit-basic-filters) weakremover(nbdkit-basic-plugins) weakremover(nbdkit-curl-plugin) weakremover(nbdkit-devel) weakremover(nbdkit-example-plugins) weakremover(nbdkit-gzip-filter) weakremover(nbdkit-linuxdisk-plugin) weakremover(nbdkit-nbd-plugin) weakremover(nbdkit-python-plugin) weakremover(nbdkit-server) weakremover(nbdkit-ssh-plugin) weakremover(nbdkit-tar-filter) weakremover(nbdkit-tmpdisk-plugin) weakremover(nbdkit-xz-filter) weakremover(nbsdgames) weakremover(ncat) weakremover(ncdu) weakremover(ncftp) weakremover(ncmpcpp) weakremover(nco) weakremover(ncompress) weakremover(ncspot) weakremover(ncurses-devel) weakremover(ncurses-devel-static) weakremover(ncurses-examples) weakremover(ncurses-tests) weakremover(ncurses-utils) weakremover(ncurses5-devel) weakremover(ncurses5-devel-static) weakremover(ndctl) weakremover(ndiff) weakremover(ndpi-common) weakremover(ndpi-tools) weakremover(ndpmon) weakremover(ndppd) weakremover(neard) weakremover(neard-devel) weakremover(neard-test) weakremover(neatvnc-devel) weakremover(nedit) weakremover(neix) weakremover(neko) weakremover(neko-devel) weakremover(neko-mysql) weakremover(nemesis) weakremover(nemiver) weakremover(nemiver-devel) weakremover(nemo) weakremover(nemo-devel) weakremover(nemo-extension-actions) weakremover(nemo-extension-dropbox) weakremover(nemo-extension-fileroller) weakremover(nemo-extension-gtkhash) weakremover(nemo-extension-image-converter) weakremover(nemo-extension-nitroshare) weakremover(nemo-extension-preview) weakremover(nemo-extension-rabbitvcs) weakremover(nemo-extension-repairer) weakremover(nemo-extension-seahorse) weakremover(nemo-extension-share) weakremover(nemo-extension-xreader) weakremover(nemo-font-manager) weakremover(neochat) weakremover(neomutt) weakremover(neovim) weakremover(neovim-gtk) weakremover(nerdctl) weakremover(nested) weakremover(nestopia) weakremover(net-snmp) weakremover(net-snmp-devel) weakremover(net-snmp-python) weakremover(net-tools) weakremover(net-tools-deprecated) weakremover(net6) weakremover(net6-devel) weakremover(netacct) weakremover(netatalk) weakremover(netatalk-devel) weakremover(netavark) weakremover(netcalc) weakremover(netcat-openbsd) weakremover(netcdf) weakremover(netcdf-cxx4-gnu-hpc-tools) weakremover(netcdf-cxx4-tools) weakremover(netcdf-cxx4_4_3_0-gnu-hpc-tools) weakremover(netcdf-cxx4_4_3_1-gnu-hpc-tools) weakremover(netcdf-devel) weakremover(netcdf-devel-data) weakremover(netcdf-devel-static) weakremover(netcdf-fortran-gnu-hpc) weakremover(netcdf-fortran-gnu-mpich-hpc) weakremover(netcdf-fortran-gnu-mvapich2-hpc) weakremover(netcdf-fortran-gnu-openmpi1-hpc) weakremover(netcdf-fortran-gnu-openmpi2-hpc) weakremover(netcdf-fortran-gnu-openmpi3-hpc) weakremover(netcdf-fortran-gnu-openmpi4-hpc) weakremover(netcdf-fortran_4_4_4-gnu-hpc) weakremover(netcdf-fortran_4_4_4-gnu-hpc-devel) weakremover(netcdf-fortran_4_4_4-gnu-hpc-devel-static) weakremover(netcdf-fortran_4_4_4-gnu-mpich-hpc) weakremover(netcdf-fortran_4_4_4-gnu-mpich-hpc-devel) weakremover(netcdf-fortran_4_4_4-gnu-mpich-hpc-devel-static) weakremover(netcdf-fortran_4_4_4-gnu-openmpi1-hpc) weakremover(netcdf-fortran_4_4_4-gnu-openmpi1-hpc-devel) weakremover(netcdf-fortran_4_4_4-gnu-openmpi1-hpc-devel-static) weakremover(netcdf-fortran_4_4_4-gnu-openmpi2-hpc) weakremover(netcdf-fortran_4_4_4-gnu-openmpi2-hpc-devel) weakremover(netcdf-fortran_4_4_4-gnu-openmpi2-hpc-devel-static) weakremover(netcdf-fortran_4_4_4-gnu-openmpi3-hpc) weakremover(netcdf-fortran_4_4_4-gnu-openmpi3-hpc-devel) weakremover(netcdf-fortran_4_4_4-gnu-openmpi3-hpc-devel-static) weakremover(netcdf-fortran_4_4_5-gnu-mpich-hpc) weakremover(netcdf-fortran_4_4_5-gnu-mpich-hpc-devel) weakremover(netcdf-fortran_4_4_5-gnu-mpich-hpc-devel-static) weakremover(netcdf-fortran_4_4_5-gnu-openmpi1-hpc) weakremover(netcdf-fortran_4_4_5-gnu-openmpi1-hpc-devel) weakremover(netcdf-fortran_4_4_5-gnu-openmpi1-hpc-devel-static) weakremover(netcdf-fortran_4_4_5-gnu-openmpi2-hpc) weakremover(netcdf-fortran_4_4_5-gnu-openmpi2-hpc-devel) weakremover(netcdf-fortran_4_4_5-gnu-openmpi2-hpc-devel-static) weakremover(netcdf-fortran_4_4_5-gnu-openmpi3-hpc) weakremover(netcdf-fortran_4_4_5-gnu-openmpi3-hpc-devel) weakremover(netcdf-fortran_4_4_5-gnu-openmpi3-hpc-devel-static) weakremover(netcdf-fortran_4_5_2-gnu-hpc) weakremover(netcdf-fortran_4_5_2-gnu-hpc-devel) weakremover(netcdf-fortran_4_5_2-gnu-hpc-devel-static) weakremover(netcdf-fortran_4_5_2-gnu-mpich-hpc) weakremover(netcdf-fortran_4_5_2-gnu-mpich-hpc-devel) weakremover(netcdf-fortran_4_5_2-gnu-mpich-hpc-devel-static) weakremover(netcdf-fortran_4_5_2-gnu-mvapich2-hpc) weakremover(netcdf-fortran_4_5_2-gnu-mvapich2-hpc-devel) weakremover(netcdf-fortran_4_5_2-gnu-mvapich2-hpc-devel-static) weakremover(netcdf-fortran_4_5_2-gnu-openmpi1-hpc) weakremover(netcdf-fortran_4_5_2-gnu-openmpi1-hpc-devel) weakremover(netcdf-fortran_4_5_2-gnu-openmpi1-hpc-devel-static) weakremover(netcdf-fortran_4_5_2-gnu-openmpi2-hpc) weakremover(netcdf-fortran_4_5_2-gnu-openmpi2-hpc-devel) weakremover(netcdf-fortran_4_5_2-gnu-openmpi2-hpc-devel-static) weakremover(netcdf-fortran_4_5_2-gnu-openmpi3-hpc) weakremover(netcdf-fortran_4_5_2-gnu-openmpi3-hpc-devel) weakremover(netcdf-fortran_4_5_2-gnu-openmpi3-hpc-devel-static) weakremover(netcdf-fortran_4_5_2-gnu-openmpi4-hpc) weakremover(netcdf-fortran_4_5_2-gnu-openmpi4-hpc-devel) weakremover(netcdf-fortran_4_5_2-gnu-openmpi4-hpc-devel-static) weakremover(netcdf-fortran_4_5_3-gnu-hpc) weakremover(netcdf-fortran_4_5_3-gnu-hpc-devel) weakremover(netcdf-fortran_4_5_3-gnu-mpich-hpc) weakremover(netcdf-fortran_4_5_3-gnu-mpich-hpc-devel) weakremover(netcdf-fortran_4_5_3-gnu-mvapich2-hpc) weakremover(netcdf-fortran_4_5_3-gnu-mvapich2-hpc-devel) weakremover(netcdf-fortran_4_5_3-gnu-openmpi1-hpc) weakremover(netcdf-fortran_4_5_3-gnu-openmpi1-hpc-devel) weakremover(netcdf-fortran_4_5_3-gnu-openmpi2-hpc) weakremover(netcdf-fortran_4_5_3-gnu-openmpi2-hpc-devel) weakremover(netcdf-fortran_4_5_3-gnu-openmpi3-hpc) weakremover(netcdf-fortran_4_5_3-gnu-openmpi3-hpc-devel) weakremover(netcdf-fortran_4_5_3-gnu-openmpi4-hpc) weakremover(netcdf-fortran_4_5_3-gnu-openmpi4-hpc-devel) weakremover(netcdf-openmpi) weakremover(netcdf-openmpi-devel) weakremover(netcdf-openmpi-devel-data) weakremover(netcdf-openmpi-devel-static) weakremover(netcdf-openmpi1) weakremover(netcdf-openmpi1-devel) weakremover(netcdf-openmpi1-devel-static) weakremover(netcdf-openmpi2) weakremover(netcdf-openmpi2-devel) weakremover(netcdf-openmpi2-devel-static) weakremover(netcdf-openmpi3) weakremover(netcdf-openmpi3-devel) weakremover(netcdf-openmpi3-devel-static) weakremover(netcdf-openmpi4) weakremover(netcdf-openmpi4-devel) weakremover(netcdf-openmpi4-devel-static) weakremover(netcdf_4_6_1-gnu-hpc) weakremover(netcdf_4_6_1-gnu-hpc-devel) weakremover(netcdf_4_6_1-gnu-hpc-devel-data) weakremover(netcdf_4_6_1-gnu-hpc-devel-static) weakremover(netcdf_4_6_1-gnu-mpich-hpc) weakremover(netcdf_4_6_1-gnu-mpich-hpc-devel) weakremover(netcdf_4_6_1-gnu-mpich-hpc-devel-static) weakremover(netcdf_4_6_1-gnu-mvapich2-hpc) weakremover(netcdf_4_6_1-gnu-mvapich2-hpc-devel) weakremover(netcdf_4_6_1-gnu-mvapich2-hpc-devel-static) weakremover(netcdf_4_6_1-gnu-openmpi1-hpc) weakremover(netcdf_4_6_1-gnu-openmpi1-hpc-devel) weakremover(netcdf_4_6_1-gnu-openmpi1-hpc-devel-static) weakremover(netcdf_4_6_1-gnu-openmpi2-hpc) weakremover(netcdf_4_6_1-gnu-openmpi2-hpc-devel) weakremover(netcdf_4_6_1-gnu-openmpi2-hpc-devel-static) weakremover(netcdf_4_6_1-gnu-openmpi3-hpc) weakremover(netcdf_4_6_1-gnu-openmpi3-hpc-devel) weakremover(netcdf_4_6_1-gnu-openmpi3-hpc-devel-static) weakremover(netcdf_4_7_0-gnu-hpc) weakremover(netcdf_4_7_0-gnu-hpc-devel) weakremover(netcdf_4_7_0-gnu-hpc-devel-data) weakremover(netcdf_4_7_0-gnu-hpc-devel-static) weakremover(netcdf_4_7_0-gnu-mpich-hpc) weakremover(netcdf_4_7_0-gnu-mpich-hpc-devel) weakremover(netcdf_4_7_0-gnu-mpich-hpc-devel-static) weakremover(netcdf_4_7_0-gnu-mvapich2-hpc) weakremover(netcdf_4_7_0-gnu-mvapich2-hpc-devel) weakremover(netcdf_4_7_0-gnu-mvapich2-hpc-devel-static) weakremover(netcdf_4_7_0-gnu-openmpi1-hpc) weakremover(netcdf_4_7_0-gnu-openmpi1-hpc-devel) weakremover(netcdf_4_7_0-gnu-openmpi1-hpc-devel-static) weakremover(netcdf_4_7_0-gnu-openmpi2-hpc) weakremover(netcdf_4_7_0-gnu-openmpi2-hpc-devel) weakremover(netcdf_4_7_0-gnu-openmpi2-hpc-devel-static) weakremover(netcdf_4_7_0-gnu-openmpi3-hpc) weakremover(netcdf_4_7_0-gnu-openmpi3-hpc-devel) weakremover(netcdf_4_7_0-gnu-openmpi3-hpc-devel-static) weakremover(netcdf_4_7_1-gnu-hpc) weakremover(netcdf_4_7_1-gnu-hpc-devel) weakremover(netcdf_4_7_1-gnu-hpc-devel-data) weakremover(netcdf_4_7_1-gnu-hpc-devel-static) weakremover(netcdf_4_7_1-gnu-mpich-hpc) weakremover(netcdf_4_7_1-gnu-mpich-hpc-devel) weakremover(netcdf_4_7_1-gnu-mpich-hpc-devel-static) weakremover(netcdf_4_7_1-gnu-mvapich2-hpc) weakremover(netcdf_4_7_1-gnu-mvapich2-hpc-devel) weakremover(netcdf_4_7_1-gnu-mvapich2-hpc-devel-static) weakremover(netcdf_4_7_1-gnu-openmpi1-hpc) weakremover(netcdf_4_7_1-gnu-openmpi1-hpc-devel) weakremover(netcdf_4_7_1-gnu-openmpi1-hpc-devel-static) weakremover(netcdf_4_7_1-gnu-openmpi2-hpc) weakremover(netcdf_4_7_1-gnu-openmpi2-hpc-devel) weakremover(netcdf_4_7_1-gnu-openmpi2-hpc-devel-static) weakremover(netcdf_4_7_1-gnu-openmpi3-hpc) weakremover(netcdf_4_7_1-gnu-openmpi3-hpc-devel) weakremover(netcdf_4_7_1-gnu-openmpi3-hpc-devel-static) weakremover(netcdf_4_7_3-gnu-hpc) weakremover(netcdf_4_7_3-gnu-hpc-devel) weakremover(netcdf_4_7_3-gnu-hpc-devel-data) weakremover(netcdf_4_7_3-gnu-hpc-devel-static) weakremover(netcdf_4_7_3-gnu-mpich-hpc) weakremover(netcdf_4_7_3-gnu-mpich-hpc-devel) weakremover(netcdf_4_7_3-gnu-mpich-hpc-devel-static) weakremover(netcdf_4_7_3-gnu-mvapich2-hpc) weakremover(netcdf_4_7_3-gnu-mvapich2-hpc-devel) weakremover(netcdf_4_7_3-gnu-mvapich2-hpc-devel-static) weakremover(netcdf_4_7_3-gnu-openmpi1-hpc) weakremover(netcdf_4_7_3-gnu-openmpi1-hpc-devel) weakremover(netcdf_4_7_3-gnu-openmpi1-hpc-devel-static) weakremover(netcdf_4_7_3-gnu-openmpi2-hpc) weakremover(netcdf_4_7_3-gnu-openmpi2-hpc-devel) weakremover(netcdf_4_7_3-gnu-openmpi2-hpc-devel-static) weakremover(netcdf_4_7_3-gnu-openmpi3-hpc) weakremover(netcdf_4_7_3-gnu-openmpi3-hpc-devel) weakremover(netcdf_4_7_3-gnu-openmpi3-hpc-devel-static) weakremover(netcdf_4_7_3-gnu-openmpi4-hpc) weakremover(netcdf_4_7_3-gnu-openmpi4-hpc-devel) weakremover(netcdf_4_7_3-gnu-openmpi4-hpc-devel-static) weakremover(netcdf_4_7_4-gnu-hpc) weakremover(netcdf_4_7_4-gnu-hpc-devel) weakremover(netcdf_4_7_4-gnu-hpc-devel-static) weakremover(netcdf_4_7_4-gnu-mpich-hpc) weakremover(netcdf_4_7_4-gnu-mpich-hpc-devel) weakremover(netcdf_4_7_4-gnu-mpich-hpc-devel-static) weakremover(netcdf_4_7_4-gnu-mvapich2-hpc) weakremover(netcdf_4_7_4-gnu-mvapich2-hpc-devel) weakremover(netcdf_4_7_4-gnu-mvapich2-hpc-devel-static) weakremover(netcdf_4_7_4-gnu-openmpi1-hpc) weakremover(netcdf_4_7_4-gnu-openmpi1-hpc-devel) weakremover(netcdf_4_7_4-gnu-openmpi1-hpc-devel-static) weakremover(netcdf_4_7_4-gnu-openmpi2-hpc) weakremover(netcdf_4_7_4-gnu-openmpi2-hpc-devel) weakremover(netcdf_4_7_4-gnu-openmpi2-hpc-devel-static) weakremover(netcdf_4_7_4-gnu-openmpi3-hpc) weakremover(netcdf_4_7_4-gnu-openmpi3-hpc-devel) weakremover(netcdf_4_7_4-gnu-openmpi3-hpc-devel-static) weakremover(netcdf_4_7_4-gnu-openmpi4-hpc) weakremover(netcdf_4_7_4-gnu-openmpi4-hpc-devel) weakremover(netcdf_4_7_4-gnu-openmpi4-hpc-devel-static) weakremover(netcdf_4_8_0-gnu-hpc) weakremover(netcdf_4_8_0-gnu-hpc-devel) weakremover(netcdf_4_8_0-gnu-hpc-devel-static) weakremover(netcdf_4_8_0-gnu-mpich-hpc) weakremover(netcdf_4_8_0-gnu-mpich-hpc-devel) weakremover(netcdf_4_8_0-gnu-mpich-hpc-devel-static) weakremover(netcdf_4_8_0-gnu-mvapich2-hpc) weakremover(netcdf_4_8_0-gnu-mvapich2-hpc-devel) weakremover(netcdf_4_8_0-gnu-mvapich2-hpc-devel-static) weakremover(netcdf_4_8_0-gnu-openmpi1-hpc) weakremover(netcdf_4_8_0-gnu-openmpi1-hpc-devel) weakremover(netcdf_4_8_0-gnu-openmpi1-hpc-devel-static) weakremover(netcdf_4_8_0-gnu-openmpi2-hpc) weakremover(netcdf_4_8_0-gnu-openmpi2-hpc-devel) weakremover(netcdf_4_8_0-gnu-openmpi2-hpc-devel-static) weakremover(netcdf_4_8_0-gnu-openmpi3-hpc) weakremover(netcdf_4_8_0-gnu-openmpi3-hpc-devel) weakremover(netcdf_4_8_0-gnu-openmpi3-hpc-devel-static) weakremover(netcdf_4_8_0-gnu-openmpi4-hpc) weakremover(netcdf_4_8_0-gnu-openmpi4-hpc-devel) weakremover(netcdf_4_8_0-gnu-openmpi4-hpc-devel-static) weakremover(netcdf_4_8_1-gnu-hpc) weakremover(netcdf_4_8_1-gnu-hpc-devel) weakremover(netcdf_4_8_1-gnu-hpc-devel-static) weakremover(netcdf_4_8_1-gnu-mpich-hpc) weakremover(netcdf_4_8_1-gnu-mpich-hpc-devel) weakremover(netcdf_4_8_1-gnu-mpich-hpc-devel-static) weakremover(netcdf_4_8_1-gnu-mvapich2-hpc) weakremover(netcdf_4_8_1-gnu-mvapich2-hpc-devel) weakremover(netcdf_4_8_1-gnu-mvapich2-hpc-devel-static) weakremover(netcdf_4_8_1-gnu-openmpi1-hpc) weakremover(netcdf_4_8_1-gnu-openmpi1-hpc-devel) weakremover(netcdf_4_8_1-gnu-openmpi1-hpc-devel-static) weakremover(netcdf_4_8_1-gnu-openmpi2-hpc) weakremover(netcdf_4_8_1-gnu-openmpi2-hpc-devel) weakremover(netcdf_4_8_1-gnu-openmpi2-hpc-devel-static) weakremover(netcdf_4_8_1-gnu-openmpi3-hpc) weakremover(netcdf_4_8_1-gnu-openmpi3-hpc-devel) weakremover(netcdf_4_8_1-gnu-openmpi3-hpc-devel-static) weakremover(netcdf_4_8_1-gnu-openmpi4-hpc) weakremover(netcdf_4_8_1-gnu-openmpi4-hpc-devel) weakremover(netcdf_4_8_1-gnu-openmpi4-hpc-devel-static) weakremover(netcdf_4_9_0-gnu-hpc) weakremover(netcdf_4_9_0-gnu-hpc-devel) weakremover(netcdf_4_9_0-gnu-hpc-devel-static) weakremover(netcdf_4_9_0-gnu-mpich-hpc) weakremover(netcdf_4_9_0-gnu-mpich-hpc-devel) weakremover(netcdf_4_9_0-gnu-mpich-hpc-devel-static) weakremover(netcdf_4_9_0-gnu-mvapich2-hpc) weakremover(netcdf_4_9_0-gnu-mvapich2-hpc-devel) weakremover(netcdf_4_9_0-gnu-mvapich2-hpc-devel-static) weakremover(netcdf_4_9_0-gnu-openmpi1-hpc) weakremover(netcdf_4_9_0-gnu-openmpi1-hpc-devel) weakremover(netcdf_4_9_0-gnu-openmpi1-hpc-devel-static) weakremover(netcdf_4_9_0-gnu-openmpi2-hpc) weakremover(netcdf_4_9_0-gnu-openmpi2-hpc-devel) weakremover(netcdf_4_9_0-gnu-openmpi2-hpc-devel-static) weakremover(netcdf_4_9_0-gnu-openmpi3-hpc) weakremover(netcdf_4_9_0-gnu-openmpi3-hpc-devel) weakremover(netcdf_4_9_0-gnu-openmpi3-hpc-devel-static) weakremover(netcdf_4_9_0-gnu-openmpi4-hpc) weakremover(netcdf_4_9_0-gnu-openmpi4-hpc-devel) weakremover(netcdf_4_9_0-gnu-openmpi4-hpc-devel-static) weakremover(netcdf_4_9_2-gnu-hpc) weakremover(netcdf_4_9_2-gnu-hpc-devel) weakremover(netcdf_4_9_2-gnu-hpc-devel-static) weakremover(netcdf_4_9_2-gnu-mpich-hpc) weakremover(netcdf_4_9_2-gnu-mpich-hpc-devel) weakremover(netcdf_4_9_2-gnu-mpich-hpc-devel-static) weakremover(netcdf_4_9_2-gnu-mvapich2-hpc) weakremover(netcdf_4_9_2-gnu-mvapich2-hpc-devel) weakremover(netcdf_4_9_2-gnu-mvapich2-hpc-devel-static) weakremover(netcdf_4_9_2-gnu-openmpi1-hpc) weakremover(netcdf_4_9_2-gnu-openmpi1-hpc-devel) weakremover(netcdf_4_9_2-gnu-openmpi1-hpc-devel-static) weakremover(netcdf_4_9_2-gnu-openmpi2-hpc) weakremover(netcdf_4_9_2-gnu-openmpi2-hpc-devel) weakremover(netcdf_4_9_2-gnu-openmpi2-hpc-devel-static) weakremover(netcdf_4_9_2-gnu-openmpi3-hpc) weakremover(netcdf_4_9_2-gnu-openmpi3-hpc-devel) weakremover(netcdf_4_9_2-gnu-openmpi3-hpc-devel-static) weakremover(netcdf_4_9_2-gnu-openmpi4-hpc) weakremover(netcdf_4_9_2-gnu-openmpi4-hpc-devel) weakremover(netcdf_4_9_2-gnu-openmpi4-hpc-devel-static) weakremover(netdata) weakremover(netdate) weakremover(netdiscover) weakremover(netease-cloud-music-gtk) weakremover(netgen) weakremover(netgen-devel) weakremover(netgen-gui-libs) weakremover(netgen-libs) weakremover(nethogs) weakremover(netlabel-tools) weakremover(netpbm) weakremover(netpbm-vulnerable) weakremover(netperfmeter) weakremover(netsniff-ng) weakremover(nettle) weakremover(netty) weakremover(netty-javadoc) weakremover(netty-jni-util) weakremover(netty-jni-util-sources) weakremover(netty-poms) weakremover(netty-tcnative) weakremover(netty-tcnative-javadoc) weakremover(neverball) weakremover(neverball-doc) weakremover(neverball-mapc) weakremover(neverball-neverputt) weakremover(newsbeuter) weakremover(newsbeuter-lang) weakremover(newsboat) weakremover(newt) weakremover(newt-devel) weakremover(newt-static) weakremover(nextcloud-client) weakremover(nextcloud-client-dolphin) weakremover(nextcloud-client-lang) weakremover(nextcloud-desktop) weakremover(nextcloud-desktop-dolphin) weakremover(nf3d) weakremover(nfacct) weakremover(nfc-eventd) weakremover(nfcutils) weakremover(nfdump) weakremover(nfdump-devel) weakremover(nfs-client) weakremover(nfs-client-provisioner) weakremover(nfs-client-provisioner-k8s-yaml) weakremover(nfs-doc) weakremover(nfs-ganesha) weakremover(nfs-ganesha-ceph) weakremover(nfs-ganesha-devel) weakremover(nfs-ganesha-mount-9P) weakremover(nfs-ganesha-nullfs) weakremover(nfs-ganesha-proxy) weakremover(nfs-ganesha-rados-grace) weakremover(nfs-ganesha-rados-urls) weakremover(nfs-ganesha-rgw) weakremover(nfs-ganesha-vfs) weakremover(nfs-ganesha-xfs) weakremover(nfs-kernel-server) weakremover(nfs4-acl-tools) weakremover(nfsidmap) weakremover(nfsidmap-devel) weakremover(nfswatch) weakremover(nftables) weakremover(nftables-devel) weakremover(nftlb) weakremover(nghttp2) weakremover(nghttp2-doc) weakremover(nginx) weakremover(nginx-geolite-asn) weakremover(nginx-geolite-city) weakremover(nginx-geolite-country) weakremover(nginx-ingress-controller) weakremover(nginx-module-brotli) weakremover(nginx-module-cookie-flag) weakremover(nginx-module-devel-kit) weakremover(nginx-module-devel-kit-source) weakremover(nginx-module-http-auth-digest) weakremover(nginx-module-http-substitutions-filter) weakremover(nginx-module-modsecurity) weakremover(nginx-module-set-misc) weakremover(nginx-module-sticky-ng) weakremover(nginx-module-vts) weakremover(nginx-module-zstd) weakremover(ngrep) weakremover(ngspice) weakremover(ngspice-scripts) weakremover(ngspice-xspice-cm) weakremover(ngspice-xspice-cm-devel) weakremover(nh2ps) weakremover(nilfs-utils) weakremover(nilfs-utils-devel) weakremover(nim) weakremover(ninja) weakremover(ninja-ide) weakremover(ninvaders) weakremover(nip2) weakremover(nitrogen) weakremover(nitroshare) weakremover(nitroshare-kde) weakremover(nkf) weakremover(nload) weakremover(nlohmann_json-devel) weakremover(nlopt-devel) weakremover(nm-tray) weakremover(nma-data) weakremover(nmap) weakremover(nmapsi4) weakremover(nmh) weakremover(nml) weakremover(nmon) weakremover(nmtree) weakremover(nng-devel) weakremover(nnn) weakremover(no-more-secrets) weakremover(nodejs-common) weakremover(nodejs-default) weakremover(nodejs-devel-default) weakremover(nodejs-electron) weakremover(nodejs-electron-devel) weakremover(nodejs-emojione) weakremover(nodejs-emojione-awesome) weakremover(nodejs-emojione-demo) weakremover(nodejs-emojione-meteor) weakremover(nodejs-emojione-python) weakremover(nodejs-emojione-swift) weakremover(nodejs-mraa) weakremover(nodejs-upm) weakremover(nodejs10) weakremover(nodejs10-devel) weakremover(nodejs10-docs) weakremover(nodejs12) weakremover(nodejs12-devel) weakremover(nodejs12-docs) weakremover(nodejs14) weakremover(nodejs14-devel) weakremover(nodejs14-docs) weakremover(nodejs15) weakremover(nodejs15-devel) weakremover(nodejs15-docs) weakremover(nodejs16) weakremover(nodejs16-devel) weakremover(nodejs16-docs) weakremover(nodejs17) weakremover(nodejs17-devel) weakremover(nodejs17-docs) weakremover(nodejs18) weakremover(nodejs18-devel) weakremover(nodejs19) weakremover(nodejs19-devel) weakremover(nodejs4) weakremover(nodejs4-devel) weakremover(nodejs4-docs) weakremover(nodejs6) weakremover(nodejs6-devel) weakremover(nodejs6-docs) weakremover(nodejs8) weakremover(nodejs8-devel) weakremover(nodejs8-docs) weakremover(noise) weakremover(noise-devel) weakremover(noise-lang) weakremover(noisetorch) weakremover(nomacs) weakremover(non-mixer) weakremover(non-ntk) weakremover(non-ntk-devel) weakremover(non-ntk-fluid) weakremover(non-sequencer) weakremover(non-session-manager) weakremover(non-timeline) weakremover(noping) weakremover(normaliz) weakremover(normaliz-devel) weakremover(noson-app) weakremover(noson-devel) weakremover(notary) weakremover(notcurses++-devel) weakremover(notcurses-core-devel) weakremover(notcurses-demos) weakremover(notcurses-devel) weakremover(notejot) weakremover(notepadqq) weakremover(notes-up) weakremover(notes-up-lang) weakremover(notification-daemon) weakremover(notify-osd) weakremover(notify-osd-config) weakremover(notmuch) weakremover(notmuch-devel) weakremover(notmuch-doc) weakremover(notmuch-emacs) weakremover(noto-coloremoji-fonts) weakremover(noto-sans-cjk-fonts) weakremover(noto-sans-hk-black-fonts) weakremover(noto-sans-hk-bold-fonts) weakremover(noto-sans-hk-demilight-fonts) weakremover(noto-sans-hk-fonts) weakremover(noto-sans-hk-fonts-full) weakremover(noto-sans-hk-light-fonts) weakremover(noto-sans-hk-medium-fonts) weakremover(noto-sans-hk-mono-fonts) weakremover(noto-sans-hk-regular-fonts) weakremover(noto-sans-hk-thin-fonts) weakremover(noto-sans-jp-black-fonts) weakremover(noto-sans-jp-bold-fonts) weakremover(noto-sans-jp-demilight-fonts) weakremover(noto-sans-jp-fonts) weakremover(noto-sans-jp-fonts-full) weakremover(noto-sans-jp-light-fonts) weakremover(noto-sans-jp-medium-fonts) weakremover(noto-sans-jp-mono-fonts) weakremover(noto-sans-jp-regular-fonts) weakremover(noto-sans-jp-thin-fonts) weakremover(noto-sans-kr-black-fonts) weakremover(noto-sans-kr-bold-fonts) weakremover(noto-sans-kr-demilight-fonts) weakremover(noto-sans-kr-fonts) weakremover(noto-sans-kr-fonts-full) weakremover(noto-sans-kr-light-fonts) weakremover(noto-sans-kr-medium-fonts) weakremover(noto-sans-kr-mono-fonts) weakremover(noto-sans-kr-regular-fonts) weakremover(noto-sans-kr-thin-fonts) weakremover(noto-sans-sc-black-fonts) weakremover(noto-sans-sc-bold-fonts) weakremover(noto-sans-sc-demilight-fonts) weakremover(noto-sans-sc-fonts) weakremover(noto-sans-sc-fonts-full) weakremover(noto-sans-sc-light-fonts) weakremover(noto-sans-sc-medium-fonts) weakremover(noto-sans-sc-mono-fonts) weakremover(noto-sans-sc-regular-fonts) weakremover(noto-sans-sc-thin-fonts) weakremover(noto-sans-tc-black-fonts) weakremover(noto-sans-tc-bold-fonts) weakremover(noto-sans-tc-demilight-fonts) weakremover(noto-sans-tc-fonts) weakremover(noto-sans-tc-fonts-full) weakremover(noto-sans-tc-light-fonts) weakremover(noto-sans-tc-medium-fonts) weakremover(noto-sans-tc-mono-fonts) weakremover(noto-sans-tc-regular-fonts) weakremover(noto-sans-tc-thin-fonts) weakremover(noto-serif-jp-black-fonts) weakremover(noto-serif-jp-bold-fonts) weakremover(noto-serif-jp-extralight-fonts) weakremover(noto-serif-jp-fonts) weakremover(noto-serif-jp-fonts-full) weakremover(noto-serif-jp-light-fonts) weakremover(noto-serif-jp-medium-fonts) weakremover(noto-serif-jp-regular-fonts) weakremover(noto-serif-jp-semibold-fonts) weakremover(noto-serif-kr-black-fonts) weakremover(noto-serif-kr-bold-fonts) weakremover(noto-serif-kr-extralight-fonts) weakremover(noto-serif-kr-fonts) weakremover(noto-serif-kr-fonts-full) weakremover(noto-serif-kr-light-fonts) weakremover(noto-serif-kr-medium-fonts) weakremover(noto-serif-kr-regular-fonts) weakremover(noto-serif-kr-semibold-fonts) weakremover(noto-serif-sc-black-fonts) weakremover(noto-serif-sc-bold-fonts) weakremover(noto-serif-sc-extralight-fonts) weakremover(noto-serif-sc-fonts) weakremover(noto-serif-sc-fonts-full) weakremover(noto-serif-sc-light-fonts) weakremover(noto-serif-sc-medium-fonts) weakremover(noto-serif-sc-regular-fonts) weakremover(noto-serif-sc-semibold-fonts) weakremover(noto-serif-tc-black-fonts) weakremover(noto-serif-tc-bold-fonts) weakremover(noto-serif-tc-extralight-fonts) weakremover(noto-serif-tc-fonts) weakremover(noto-serif-tc-fonts-full) weakremover(noto-serif-tc-light-fonts) weakremover(noto-serif-tc-medium-fonts) weakremover(noto-serif-tc-regular-fonts) weakremover(noto-serif-tc-semibold-fonts) weakremover(nova) weakremover(novell-ipsec-tools) weakremover(novell-ipsec-tools-devel) weakremover(novell-nortelplugins) weakremover(novell-sound-theme) weakremover(novprog) weakremover(npapi-sdk) weakremover(nping) weakremover(npm-default) weakremover(npm10) weakremover(npm12) weakremover(npm14) weakremover(npm15) weakremover(npm16) weakremover(npm17) weakremover(npm18) weakremover(npm19) weakremover(npm4) weakremover(npm6) weakremover(npm8) weakremover(npth-devel) weakremover(nqp) weakremover(nrpe) weakremover(nsca) weakremover(nsca-client) weakremover(nscd) weakremover(nsd) weakremover(nsnake) weakremover(nss-mdns) weakremover(nss-myhostname) weakremover(nss-mymachines) weakremover(nss-pam-ldapd) weakremover(nss-resolve) weakremover(nss-shared-helper-devel) weakremover(nss-systemd) weakremover(nss_ldap) weakremover(nss_synth) weakremover(nss_wrapper) weakremover(ntfs-3g) weakremover(ntfsprogs) weakremover(ntfsprogs-extra) weakremover(ntl-devel) weakremover(ntp) weakremover(ntp-dcf77-tools) weakremover(ntp-doc) weakremover(ntp2chrony) weakremover(ntpsec) weakremover(ntpsec-devel) weakremover(ntpsec-doc) weakremover(ntpsec-utils) weakremover(nudoku) weakremover(nulloy) weakremover(nulloy-gstreamer) weakremover(nulloy-phonon) weakremover(nulloy-taglib) weakremover(nulloy-vlc) weakremover(numactl) weakremover(numad) weakremover(numlockx) weakremover(nunit) weakremover(nunit-devel) weakremover(nuntius) weakremover(nuspell) weakremover(nuspell-devel) weakremover(nut) weakremover(nut-cgi) weakremover(nut-devel) weakremover(nut-devel-doc-pdf) weakremover(nut-doc-pdf) weakremover(nut-drivers-net) weakremover(nvdock) weakremover(nvidia-container-toolkit) weakremover(nvidia-open-driver-G06-signed-kmp-64kb) weakremover(nvidia-open-driver-G06-signed-kmp-default) weakremover(nvme-cli) weakremover(nvme-stas) weakremover(nvptx-tools) weakremover(nvtop) weakremover(nwg-launchers) weakremover(nxtvepg) weakremover(nyancat) weakremover(o2scl-devel) weakremover(o2scl-doc) weakremover(oaml-devel) weakremover(oath-toolkit) weakremover(obby) weakremover(obby-devel) weakremover(obconf) weakremover(obconf-qt) weakremover(obex-data-server) weakremover(obexd) weakremover(obexd-client) weakremover(obexd-server) weakremover(obexfs) weakremover(obexftp) weakremover(obexftp-devel) weakremover(obfs4) weakremover(obs-service-cargo_audit) weakremover(obs-service-cdi_containers_meta) weakremover(obs-service-kubevirt_containers_meta) weakremover(obs-service-rust2rpm) weakremover(ocaml) weakremover(ocaml-astring) weakremover(ocaml-astring-devel) weakremover(ocaml-augeas) weakremover(ocaml-augeas-devel) weakremover(ocaml-base) weakremover(ocaml-base-devel) weakremover(ocaml-base64) weakremover(ocaml-base64-devel) weakremover(ocaml-benchmark) weakremover(ocaml-benchmark-devel) weakremover(ocaml-bigarray-compat) weakremover(ocaml-bigarray-compat-devel) weakremover(ocaml-bin_prot) weakremover(ocaml-bin_prot-devel) weakremover(ocaml-bisect_ppx) weakremover(ocaml-bisect_ppx-devel) weakremover(ocaml-bos) weakremover(ocaml-bos-devel) weakremover(ocaml-brlapi) weakremover(ocaml-cairo) weakremover(ocaml-cairo-devel) weakremover(ocaml-calendar) weakremover(ocaml-calendar-devel) weakremover(ocaml-camlbz2) weakremover(ocaml-camlbz2-devel) weakremover(ocaml-camlp-streams) weakremover(ocaml-camlp-streams-devel) weakremover(ocaml-camlp4) weakremover(ocaml-camlp4-devel) weakremover(ocaml-camlp5) weakremover(ocaml-camlp5-devel) weakremover(ocaml-camlzip) weakremover(ocaml-camlzip-devel) weakremover(ocaml-camlzip-test) weakremover(ocaml-camomile) weakremover(ocaml-camomile-data) weakremover(ocaml-camomile-devel) weakremover(ocaml-cmdliner) weakremover(ocaml-cmdliner-devel) weakremover(ocaml-compiler-libs) weakremover(ocaml-compiler-libs-devel) weakremover(ocaml-cppo) weakremover(ocaml-cppo-devel) weakremover(ocaml-csexp) weakremover(ocaml-csexp-devel) weakremover(ocaml-csv) weakremover(ocaml-csv-devel) weakremover(ocaml-ctypes) weakremover(ocaml-ctypes-devel) weakremover(ocaml-cudf) weakremover(ocaml-cudf-devel) weakremover(ocaml-curses) weakremover(ocaml-curses-devel) weakremover(ocaml-docs) weakremover(ocaml-dose) weakremover(ocaml-dose-devel) weakremover(ocaml-dune) weakremover(ocaml-dune-configurator) weakremover(ocaml-dune-configurator-devel) weakremover(ocaml-dune-devel) weakremover(ocaml-easy-format) weakremover(ocaml-easy-format-devel) weakremover(ocaml-extlib) weakremover(ocaml-extlib-devel) weakremover(ocaml-facile) weakremover(ocaml-facile-devel) weakremover(ocaml-fieldslib) weakremover(ocaml-fieldslib-devel) weakremover(ocaml-fileutils) weakremover(ocaml-fileutils-devel) weakremover(ocaml-findlib) weakremover(ocaml-findlib-camlp4) weakremover(ocaml-findlib-devel) weakremover(ocaml-fmt) weakremover(ocaml-fmt-devel) weakremover(ocaml-fpath) weakremover(ocaml-fpath-devel) weakremover(ocaml-gen) weakremover(ocaml-gen-devel) weakremover(ocaml-gettext) weakremover(ocaml-gettext-camomile) weakremover(ocaml-gettext-camomile-devel) weakremover(ocaml-gettext-devel) weakremover(ocaml-gettext-stub) weakremover(ocaml-gettext-stub-devel) weakremover(ocaml-graphics) weakremover(ocaml-graphics-devel) weakremover(ocaml-hivex) weakremover(ocaml-hivex-devel) weakremover(ocaml-integers) weakremover(ocaml-integers-devel) weakremover(ocaml-jsonm) weakremover(ocaml-jsonm-devel) weakremover(ocaml-lablgl) weakremover(ocaml-lablgl-devel) weakremover(ocaml-lablgtk2) weakremover(ocaml-lablgtk2-devel) weakremover(ocaml-lablgtk3) weakremover(ocaml-lablgtk3-devel) weakremover(ocaml-labltk) weakremover(ocaml-labltk-devel) weakremover(ocaml-libguestfs) weakremover(ocaml-libguestfs-devel) weakremover(ocaml-libvirt) weakremover(ocaml-libvirt-devel) weakremover(ocaml-logs) weakremover(ocaml-logs-devel) weakremover(ocaml-luv) weakremover(ocaml-luv-devel) weakremover(ocaml-mccs) weakremover(ocaml-mccs-devel) weakremover(ocaml-menhir) weakremover(ocaml-menhir-devel) weakremover(ocaml-migrate-parsetree) weakremover(ocaml-migrate-parsetree-devel) weakremover(ocaml-minisat) weakremover(ocaml-minisat-devel) weakremover(ocaml-num) weakremover(ocaml-num-devel) weakremover(ocaml-oasis) weakremover(ocaml-oasis-devel) weakremover(ocaml-obuild) weakremover(ocaml-ocaml-compiler-libs) weakremover(ocaml-ocaml-compiler-libs-devel) weakremover(ocaml-ocamlbuild) weakremover(ocaml-ocamlbuild-devel) weakremover(ocaml-ocamldoc) weakremover(ocaml-ocamlgraph) weakremover(ocaml-ocamlgraph-devel) weakremover(ocaml-odn) weakremover(ocaml-odn-devel) weakremover(ocaml-ounit) weakremover(ocaml-ounit-devel) weakremover(ocaml-parmap) weakremover(ocaml-parmap-devel) weakremover(ocaml-pcre) weakremover(ocaml-pcre-devel) weakremover(ocaml-pp) weakremover(ocaml-pp-devel) weakremover(ocaml-ppx_bin_prot) weakremover(ocaml-ppx_bin_prot-devel) weakremover(ocaml-ppx_compare) weakremover(ocaml-ppx_compare-devel) weakremover(ocaml-ppx_custom_printf) weakremover(ocaml-ppx_custom_printf-devel) weakremover(ocaml-ppx_derivers) weakremover(ocaml-ppx_derivers-devel) weakremover(ocaml-ppx_deriving) weakremover(ocaml-ppx_deriving-devel) weakremover(ocaml-ppx_fields_conv) weakremover(ocaml-ppx_fields_conv-devel) weakremover(ocaml-ppx_here) weakremover(ocaml-ppx_here-devel) weakremover(ocaml-ppx_optcomp) weakremover(ocaml-ppx_optcomp-devel) weakremover(ocaml-ppx_sexp_conv) weakremover(ocaml-ppx_sexp_conv-devel) weakremover(ocaml-ppx_tools_versioned) weakremover(ocaml-ppx_tools_versioned-devel) weakremover(ocaml-ppx_variants_conv) weakremover(ocaml-ppx_variants_conv-devel) weakremover(ocaml-ppxlib) weakremover(ocaml-ppxlib-devel) weakremover(ocaml-ptmap) weakremover(ocaml-ptmap-devel) weakremover(ocaml-pyml) weakremover(ocaml-pyml-devel) weakremover(ocaml-qcheck) weakremover(ocaml-qcheck-devel) weakremover(ocaml-qtest) weakremover(ocaml-qtest-devel) weakremover(ocaml-re) weakremover(ocaml-re-devel) weakremover(ocaml-result) weakremover(ocaml-result-devel) weakremover(ocaml-rope) weakremover(ocaml-rope-devel) weakremover(ocaml-rpm-macros) weakremover(ocaml-rresult) weakremover(ocaml-rresult-devel) weakremover(ocaml-runtime) weakremover(ocaml-sedlex) weakremover(ocaml-sedlex-devel) weakremover(ocaml-sexplib0) weakremover(ocaml-sexplib0-devel) weakremover(ocaml-sha) weakremover(ocaml-sha-devel) weakremover(ocaml-source) weakremover(ocaml-stdcompat) weakremover(ocaml-stdcompat-devel) weakremover(ocaml-stdio) weakremover(ocaml-stdio-devel) weakremover(ocaml-stdlib-shims) weakremover(ocaml-stdlib-shims-devel) weakremover(ocaml-type-conv) weakremover(ocaml-type-conv-devel) weakremover(ocaml-uutf) weakremover(ocaml-uutf-devel) weakremover(ocaml-variantslib) weakremover(ocaml-variantslib-devel) weakremover(ocaml-x11) weakremover(ocaml-xml-light) weakremover(ocaml-xml-light-devel) weakremover(ocaml-zarith) weakremover(ocaml-zarith-devel) weakremover(ocamlify) weakremover(ocamlmod) weakremover(occt) weakremover(occt-DRAWEXE) weakremover(occt-devel) weakremover(oce) weakremover(oce-DRAWEXE) weakremover(oce-devel) weakremover(ocfs2-tools) weakremover(ocfs2-tools-devel) weakremover(ocfs2-tools-devel-static) weakremover(ocfs2-tools-o2cb) weakremover(ocfs2console) weakremover(oci-seccomp-bpf-hook) weakremover(ocl-icd-devel) weakremover(ocli) weakremover(oclock) weakremover(ocp) weakremover(ocr_1_0_1-gnu-hpc) weakremover(ocr_1_0_1-gnu-hpc-devel) weakremover(ocr_1_0_1-gnu-hpc-doc) weakremover(ocr_1_0_1-gnu-hpc-examples) weakremover(ocr_1_0_1-gnu-mpich-hpc) weakremover(ocr_1_0_1-gnu-mpich-hpc-devel) weakremover(ocr_1_0_1-gnu-mpich-hpc-doc) weakremover(ocr_1_0_1-gnu-mpich-hpc-examples) weakremover(ocr_1_0_1-gnu-mvapich2-hpc) weakremover(ocr_1_0_1-gnu-mvapich2-hpc-devel) weakremover(ocr_1_0_1-gnu-mvapich2-hpc-doc) weakremover(ocr_1_0_1-gnu-mvapich2-hpc-examples) weakremover(ocr_1_0_1-gnu-openmpi1-hpc) weakremover(ocr_1_0_1-gnu-openmpi1-hpc-devel) weakremover(ocr_1_0_1-gnu-openmpi1-hpc-doc) weakremover(ocr_1_0_1-gnu-openmpi1-hpc-examples) weakremover(ocr_1_0_1-gnu-openmpi2-hpc) weakremover(ocr_1_0_1-gnu-openmpi2-hpc-devel) weakremover(ocr_1_0_1-gnu-openmpi2-hpc-doc) weakremover(ocr_1_0_1-gnu-openmpi2-hpc-examples) weakremover(ocr_1_0_1-gnu-openmpi3-hpc) weakremover(ocr_1_0_1-gnu-openmpi3-hpc-devel) weakremover(ocr_1_0_1-gnu-openmpi3-hpc-doc) weakremover(ocr_1_0_1-gnu-openmpi3-hpc-examples) weakremover(ocr_1_0_1-gnu-openmpi4-hpc) weakremover(ocr_1_0_1-gnu-openmpi4-hpc-devel) weakremover(ocr_1_0_1-gnu-openmpi4-hpc-doc) weakremover(ocr_1_0_1-gnu-openmpi4-hpc-examples) weakremover(ocrad) weakremover(ocrad-devel) weakremover(ocserv) weakremover(octant) weakremover(octave) weakremover(octave-cli) weakremover(octave-devel) weakremover(octave-forge-communications) weakremover(octave-forge-control) weakremover(octave-forge-database) weakremover(octave-forge-econometrics) weakremover(octave-forge-fits) weakremover(octave-forge-fl-core) weakremover(octave-forge-general) weakremover(octave-forge-geometry) weakremover(octave-forge-gsl) weakremover(octave-forge-image) weakremover(octave-forge-image-acquisition) weakremover(octave-forge-instrument-control) weakremover(octave-forge-interval) weakremover(octave-forge-io) weakremover(octave-forge-lssa) weakremover(octave-forge-ltfat) weakremover(octave-forge-mapping) weakremover(octave-forge-mechanics) weakremover(octave-forge-miscellaneous) weakremover(octave-forge-nan) weakremover(octave-forge-netcdf) weakremover(octave-forge-nurbs) weakremover(octave-forge-ocs) weakremover(octave-forge-octclip) weakremover(octave-forge-octproj) weakremover(octave-forge-odepkg) weakremover(octave-forge-optim) weakremover(octave-forge-parallel) weakremover(octave-forge-quaternion) weakremover(octave-forge-secs2d) weakremover(octave-forge-signal) weakremover(octave-forge-sockets) weakremover(octave-forge-specfun) weakremover(octave-forge-statistics) weakremover(octave-forge-stk) weakremover(octave-forge-strings) weakremover(octave-forge-struct) weakremover(octave-forge-tisean) weakremover(octave-forge-video) weakremover(octave-forge-vrml) weakremover(octave-lal) weakremover(octave-lalburst) weakremover(octave-lalframe) weakremover(octave-lalinference) weakremover(octave-lalinspiral) weakremover(octave-lalmetaio) weakremover(octave-lalpulsar) weakremover(octave-lalsimulation) weakremover(octave-mathgl) weakremover(octave-nlopt_optimize) weakremover(octave-openEMS) weakremover(oddjob) weakremover(oddjob-gpupdate) weakremover(oddjob-mkhomedir) weakremover(ode-devel) weakremover(odp-devel) weakremover(odp-example) weakremover(odp-libs) weakremover(odp-thunderx-devel) weakremover(odp-thunderx-example) weakremover(odp-thunderx-libs) weakremover(odt2txt) weakremover(offlineimap) weakremover(offlineimap-htmldoc) weakremover(ofl) weakremover(ofono) weakremover(ofono-devel) weakremover(ofono-tests) weakremover(oggz-tools) weakremover(ogmtools) weakremover(ogre-demos) weakremover(ogre-demos-devel) weakremover(ogre-devel) weakremover(ogre-docs) weakremover(ogre-media) weakremover(ogre-mono) weakremover(ogre-python) weakremover(ogre-tools) weakremover(ohcount) weakremover(ohpc) weakremover(oidentd) weakremover(okteta) weakremover(okteta-devel) weakremover(okteta-part) weakremover(okteto) weakremover(okular) weakremover(okular-devel) weakremover(okular-mobile) weakremover(okular-spectre) weakremover(olm-devel) weakremover(omemo-utils) weakremover(omniORB) weakremover(omniORB-devel) weakremover(omniORBpy) weakremover(omniORBpy-devel) weakremover(omnispeak) weakremover(omping) weakremover(onboard) weakremover(onednn-devel) weakremover(onedrive) weakremover(onedrive-completion-bash) weakremover(onedrive-completion-fish) weakremover(onedrive-completion-zsh) weakremover(onefetch) weakremover(oneko) weakremover(oniguruma-devel) weakremover(onioncat) weakremover(onnx-backend-test) weakremover(onnx-devel) weakremover(ooRexx) weakremover(ooRexx-devel) weakremover(opal-firmware) weakremover(opam) weakremover(opam-devel) weakremover(opam-file-format) weakremover(opam-file-format-devel) weakremover(opam-installer) weakremover(open-iscsi) weakremover(open-iscsi-devel) weakremover(open-isns) weakremover(open-isns-devel) weakremover(open-lldp) weakremover(open-lldp-devel) weakremover(open-vm-tools) weakremover(open-vm-tools-containerinfo) weakremover(open-vm-tools-desktop) weakremover(open-vm-tools-sdmp) weakremover(openCOLLADA-devel) weakremover(openCOLLADA-utils) weakremover(openCryptoki) weakremover(openCryptoki-64bit) weakremover(openCryptoki-devel) weakremover(openEMS) weakremover(openEMS-devel) weakremover(openEMS-matlab) weakremover(openQA) weakremover(openQA-auto-update) weakremover(openQA-bootstrap) weakremover(openQA-client) weakremover(openQA-common) weakremover(openQA-continuous-update) weakremover(openQA-devel) weakremover(openQA-doc) weakremover(openQA-local-db) weakremover(openQA-python-scripts) weakremover(openQA-single-instance) weakremover(openQA-worker) weakremover(openSUSE-Addon-NonOss-release) weakremover(openSUSE-MicroOS-release) weakremover(openSUSE-MicroOS-release-appliance) weakremover(openSUSE-MicroOS-release-appliance-kubic) weakremover(openSUSE-MicroOS-release-dvd) weakremover(openSUSE-MicroOS-release-kubic-dvd) weakremover(openSUSE-Tumbleweed-Kubic-release) weakremover(openSUSE-Tumbleweed-Kubic-release-dvd) weakremover(openSUSE-appstream-process) weakremover(openSUSE-build-key) weakremover(openSUSE-release) weakremover(openSUSE-release-appliance-custom) weakremover(openSUSE-release-appliance-docker) weakremover(openSUSE-release-appliance-hyperv) weakremover(openSUSE-release-appliance-kvm) weakremover(openSUSE-release-appliance-openstack) weakremover(openSUSE-release-appliance-vagrant) weakremover(openSUSE-release-appliance-vmware) weakremover(openSUSE-release-appliance-wsl) weakremover(openSUSE-release-dvd) weakremover(openSUSE-release-ftp) weakremover(openSUSE-release-livecd-gnome) weakremover(openSUSE-release-livecd-kde) weakremover(openSUSE-release-livecd-x11) weakremover(openSUSE-release-mini) weakremover(openSUSE-release-usb-gnome) weakremover(openSUSE-release-usb-kde) weakremover(openSUSE-release-usb-x11) weakremover(openSUSE-repos-MicroOS) weakremover(openSUSE-repos-Tumbleweed) weakremover(openSUSE-signkey-cert) weakremover(openSUSE-software) weakremover(openafs) weakremover(openafs-authlibs) weakremover(openafs-authlibs-devel) weakremover(openafs-client) weakremover(openafs-devel) weakremover(openafs-fuse_client) weakremover(openafs-kmp-64kb) weakremover(openafs-kmp-default) weakremover(openafs-server) weakremover(openal-soft-devel) weakremover(openal-soft-makehrtf) weakremover(openal-soft-makemhr) weakremover(openal-soft-tools) weakremover(openam) weakremover(openamp-devel) weakremover(openamp-examples) weakremover(openarena) weakremover(openarena-data) weakremover(openbabel) weakremover(openbabel-devel) weakremover(openbabel-gui) weakremover(openblas-common-devel) weakremover(openblas-devel) weakremover(openblas-devel-headers) weakremover(openblas-devel-static) weakremover(openblas-pthreads_0_2_20-gnu-hpc-devel-static) weakremover(openblas-pthreads_0_3_10-gnu-hpc-devel-static) weakremover(openblas-pthreads_0_3_12-gnu-hpc-devel-static) weakremover(openblas-pthreads_0_3_13-gnu-hpc-devel-static) weakremover(openblas-pthreads_0_3_14-gnu-hpc-devel-static) weakremover(openblas-pthreads_0_3_16-gnu-hpc-devel-static) weakremover(openblas-pthreads_0_3_17-gnu-hpc-devel-static) weakremover(openblas-pthreads_0_3_20-gnu-hpc-devel-static) weakremover(openblas-pthreads_0_3_21-gnu-hpc-devel-static) weakremover(openblas-pthreads_0_3_4-gnu-hpc-devel-static) weakremover(openblas-pthreads_0_3_5-gnu-hpc-devel-static) weakremover(openblas-pthreads_0_3_6-gnu-hpc-devel-static) weakremover(openblas-pthreads_0_3_7-gnu-hpc-devel-static) weakremover(openblas-pthreads_0_3_8-gnu-hpc-devel-static) weakremover(openblas-pthreads_0_3_9-gnu-hpc-devel-static) weakremover(openblas_0_2_20-gnu-hpc-devel-static) weakremover(openblas_0_3_10-gnu-hpc-devel-static) weakremover(openblas_0_3_12-gnu-hpc-devel-static) weakremover(openblas_0_3_13-gnu-hpc-devel-static) weakremover(openblas_0_3_14-gnu-hpc-devel-static) weakremover(openblas_0_3_16-gnu-hpc-devel-static) weakremover(openblas_0_3_17-gnu-hpc-devel-static) weakremover(openblas_0_3_20-gnu-hpc-devel-static) weakremover(openblas_0_3_21-gnu-hpc-devel-static) weakremover(openblas_0_3_4-gnu-hpc-devel-static) weakremover(openblas_0_3_5-gnu-hpc-devel-static) weakremover(openblas_0_3_6-gnu-hpc-devel-static) weakremover(openblas_0_3_7-gnu-hpc-devel-static) weakremover(openblas_0_3_8-gnu-hpc-devel-static) weakremover(openblas_0_3_9-gnu-hpc-devel-static) weakremover(openblas_openmp-devel-static) weakremover(openblas_pthreads-devel-static) weakremover(openblas_serial-devel-static) weakremover(openbox) weakremover(openbox-devel) weakremover(openbox-gnome) weakremover(openbox-kde) weakremover(openbox-theme-plata) weakremover(openbsc) weakremover(openbsc-bs11-utils) weakremover(openbsc-bsc-sccplite) weakremover(opencc) weakremover(opencc-data) weakremover(opencc-devel) weakremover(opencensus-cpp-devel) weakremover(opencl-headers-1_2) weakremover(openclipart-png) weakremover(openclipart-svg) weakremover(openclonk) weakremover(openconnect) weakremover(openconnect-devel) weakremover(opencsg-devel) weakremover(openct) weakremover(openct-devel) weakremover(opencv) weakremover(opencv-devel) weakremover(opencv-qt5) weakremover(opencv-qt5-devel) weakremover(opencv3) weakremover(opencv3-devel) weakremover(opencv3-doc) weakremover(opendchub) weakremover(opendkim) weakremover(opendkim-devel) weakremover(openexr) weakremover(openexr-devel) weakremover(openexr-doc) weakremover(openfortivpn) weakremover(openfst) weakremover(openfst-devel) weakremover(opengreedy) weakremover(openh323) weakremover(openh323-devel) weakremover(openhantek) weakremover(openhpi) weakremover(openhpi-clients) weakremover(openhpi-daemon) weakremover(openhpi-devel) weakremover(openhpi-subagent) weakremover(openjade) weakremover(openjade-devel) weakremover(openjfx) weakremover(openjfx-devel) weakremover(openjfx-javadoc) weakremover(openjfx-jmods) weakremover(openjfx-src) weakremover(openjfx8) weakremover(openjfx8-devel) weakremover(openjfx8-src) weakremover(openjpeg) weakremover(openjpeg-devel) weakremover(openjpeg2) weakremover(openjpeg2-devel) weakremover(openjpeg2-devel-doc) weakremover(openkim-models) weakremover(openldap2) weakremover(openldap2-back-meta) weakremover(openldap2-back-perl) weakremover(openldap2-back-sock) weakremover(openldap2-back-sql) weakremover(openldap2-client) weakremover(openldap2-contrib) weakremover(openldap2-devel) weakremover(openldap2-devel-static) weakremover(openldap2-ppolicy-check-password) weakremover(openlibm-devel) weakremover(openlierox) weakremover(openlmi) weakremover(openlmi-account) weakremover(openlmi-fan) weakremover(openlmi-hardware) weakremover(openlmi-journald) weakremover(openlmi-locale) weakremover(openlmi-logicalfile) weakremover(openlmi-networking) weakremover(openlmi-pcp) weakremover(openlmi-pegasus-compat) weakremover(openlmi-powermanagement) weakremover(openlmi-providers) weakremover(openlmi-providers-devel) weakremover(openlmi-providers-doc) weakremover(openlmi-providers-libs) weakremover(openlmi-python-base) weakremover(openlmi-python-providers) weakremover(openlmi-python-test) weakremover(openlmi-service) weakremover(openlmi-software) weakremover(openlmi-sssd) weakremover(openlmi-tools) weakremover(openmcu) weakremover(openmcu-codecs) weakremover(openmpi) weakremover(openmpi-config) weakremover(openmpi-devel) weakremover(openmpi-devel-static) weakremover(openmpi-libs) weakremover(openmpi-testsuite) weakremover(openmpi1) weakremover(openmpi1-config) weakremover(openmpi1-devel) weakremover(openmpi1-docs) weakremover(openmpi1-gnu-hpc) weakremover(openmpi1-gnu-hpc-devel-static) weakremover(openmpi1-libs) weakremover(openmpi1-macros-devel) weakremover(openmpi2) weakremover(openmpi2-config) weakremover(openmpi2-devel) weakremover(openmpi2-docs) weakremover(openmpi2-gnu-hpc) weakremover(openmpi2-gnu-hpc-devel-static) weakremover(openmpi2-libs) weakremover(openmpi2-macros-devel) weakremover(openmpi3) weakremover(openmpi3-config) weakremover(openmpi3-devel) weakremover(openmpi3-docs) weakremover(openmpi3-gnu-hpc) weakremover(openmpi3-gnu-hpc-devel-static) weakremover(openmpi3-libs) weakremover(openmpi3-macros-devel) weakremover(openmpi4) weakremover(openmpi4-config) weakremover(openmpi4-devel) weakremover(openmpi4-docs) weakremover(openmpi4-gnu-hpc) weakremover(openmpi4-gnu-hpc-devel-static) weakremover(openmpi4-libs) weakremover(openmpi4-macros-devel) weakremover(openmpi5) weakremover(openmpi5-config) weakremover(openmpi5-devel) weakremover(openmpi5-docs) weakremover(openmpi5-gnu-hpc) weakremover(openmpi5-gnu-hpc-devel-static) weakremover(openmpi5-libs) weakremover(openmpi5-macros-devel) weakremover(openmpi_1_10_7-gnu-hpc) weakremover(openmpi_1_10_7-gnu-hpc-devel) weakremover(openmpi_1_10_7-gnu-hpc-devel-static) weakremover(openmpi_1_10_7-gnu-hpc-docs) weakremover(openmpi_1_10_7-gnu-hpc-macros-devel) weakremover(openmpi_2_1_3-gnu-hpc) weakremover(openmpi_2_1_3-gnu-hpc-devel) weakremover(openmpi_2_1_3-gnu-hpc-devel-static) weakremover(openmpi_2_1_3-gnu-hpc-docs) weakremover(openmpi_2_1_3-gnu-hpc-macros-devel) weakremover(openmpi_2_1_3-gnu-hpc-testsuite) weakremover(openmpi_2_1_5-gnu-hpc) weakremover(openmpi_2_1_5-gnu-hpc-devel) weakremover(openmpi_2_1_5-gnu-hpc-devel-static) weakremover(openmpi_2_1_5-gnu-hpc-docs) weakremover(openmpi_2_1_5-gnu-hpc-macros-devel) weakremover(openmpi_2_1_5-gnu-hpc-testsuite) weakremover(openmpi_2_1_6-gnu-hpc) weakremover(openmpi_2_1_6-gnu-hpc-devel) weakremover(openmpi_2_1_6-gnu-hpc-devel-static) weakremover(openmpi_2_1_6-gnu-hpc-docs) weakremover(openmpi_2_1_6-gnu-hpc-macros-devel) weakremover(openmpi_3_0_0-gnu-hpc) weakremover(openmpi_3_0_0-gnu-hpc-devel) weakremover(openmpi_3_0_0-gnu-hpc-devel-static) weakremover(openmpi_3_0_0-gnu-hpc-docs) weakremover(openmpi_3_0_0-gnu-hpc-macros-devel) weakremover(openmpi_3_0_0-gnu-hpc-testsuite) weakremover(openmpi_3_1_1-gnu-hpc) weakremover(openmpi_3_1_1-gnu-hpc-devel) weakremover(openmpi_3_1_1-gnu-hpc-devel-static) weakremover(openmpi_3_1_1-gnu-hpc-docs) weakremover(openmpi_3_1_1-gnu-hpc-macros-devel) weakremover(openmpi_3_1_1-gnu-hpc-testsuite) weakremover(openmpi_3_1_3-gnu-hpc) weakremover(openmpi_3_1_3-gnu-hpc-devel) weakremover(openmpi_3_1_3-gnu-hpc-devel-static) weakremover(openmpi_3_1_3-gnu-hpc-docs) weakremover(openmpi_3_1_3-gnu-hpc-macros-devel) weakremover(openmpi_3_1_3-gnu-hpc-testsuite) weakremover(openmpi_3_1_4-gnu-hpc) weakremover(openmpi_3_1_4-gnu-hpc-devel) weakremover(openmpi_3_1_4-gnu-hpc-devel-static) weakremover(openmpi_3_1_4-gnu-hpc-docs) weakremover(openmpi_3_1_4-gnu-hpc-macros-devel) weakremover(openmpi_3_1_4-gnu-hpc-testsuite) weakremover(openmpi_3_1_6-gnu-hpc) weakremover(openmpi_3_1_6-gnu-hpc-devel) weakremover(openmpi_3_1_6-gnu-hpc-devel-static) weakremover(openmpi_3_1_6-gnu-hpc-docs) weakremover(openmpi_3_1_6-gnu-hpc-macros-devel) weakremover(openmpi_4_0_2-gnu-hpc) weakremover(openmpi_4_0_2-gnu-hpc-devel) weakremover(openmpi_4_0_2-gnu-hpc-devel-static) weakremover(openmpi_4_0_2-gnu-hpc-docs) weakremover(openmpi_4_0_2-gnu-hpc-macros-devel) weakremover(openmpi_4_0_2-gnu-hpc-testsuite) weakremover(openmpi_4_0_3-gnu-hpc) weakremover(openmpi_4_0_3-gnu-hpc-devel) weakremover(openmpi_4_0_3-gnu-hpc-devel-static) weakremover(openmpi_4_0_3-gnu-hpc-docs) weakremover(openmpi_4_0_3-gnu-hpc-macros-devel) weakremover(openmpi_4_0_3-gnu-hpc-testsuite) weakremover(openmpi_4_0_4-gnu-hpc) weakremover(openmpi_4_0_4-gnu-hpc-devel) weakremover(openmpi_4_0_4-gnu-hpc-devel-static) weakremover(openmpi_4_0_4-gnu-hpc-docs) weakremover(openmpi_4_0_4-gnu-hpc-macros-devel) weakremover(openmpi_4_0_4-gnu-hpc-testsuite) weakremover(openmpi_4_0_5-gnu-hpc) weakremover(openmpi_4_0_5-gnu-hpc-devel) weakremover(openmpi_4_0_5-gnu-hpc-devel-static) weakremover(openmpi_4_0_5-gnu-hpc-docs) weakremover(openmpi_4_0_5-gnu-hpc-macros-devel) weakremover(openmpi_4_0_5-gnu-hpc-testsuite) weakremover(openmpi_4_1_0-gnu-hpc) weakremover(openmpi_4_1_0-gnu-hpc-devel) weakremover(openmpi_4_1_0-gnu-hpc-devel-static) weakremover(openmpi_4_1_0-gnu-hpc-docs) weakremover(openmpi_4_1_0-gnu-hpc-macros-devel) weakremover(openmpi_4_1_0-gnu-hpc-testsuite) weakremover(openmpi_4_1_1-gnu-hpc) weakremover(openmpi_4_1_1-gnu-hpc-devel) weakremover(openmpi_4_1_1-gnu-hpc-devel-static) weakremover(openmpi_4_1_1-gnu-hpc-docs) weakremover(openmpi_4_1_1-gnu-hpc-macros-devel) weakremover(openmpi_4_1_1-gnu-hpc-testsuite) weakremover(openmpi_4_1_4-gnu-hpc) weakremover(openmpi_4_1_4-gnu-hpc-devel) weakremover(openmpi_4_1_4-gnu-hpc-devel-static) weakremover(openmpi_4_1_4-gnu-hpc-docs) weakremover(openmpi_4_1_4-gnu-hpc-macros-devel) weakremover(openmpi_5_0_0-gnu-hpc) weakremover(openmpi_5_0_0-gnu-hpc-devel) weakremover(openmpi_5_0_0-gnu-hpc-devel-static) weakremover(openmpi_5_0_0-gnu-hpc-docs) weakremover(openmpi_5_0_0-gnu-hpc-macros-devel) weakremover(openmpt123) weakremover(openmw) weakremover(openobex-apps) weakremover(openobex-devel) weakremover(openocd) weakremover(openomf) weakremover(openparamon) weakremover(openpgl-devel) weakremover(openpgm-devel) weakremover(openqa-mon) weakremover(openrct2) weakremover(openrdate) weakremover(opensaml-bin) weakremover(opensaml-schemas) weakremover(opensc) weakremover(openscap) weakremover(openscap-content) weakremover(openscap-devel) weakremover(openscap-docker) weakremover(openscap-engine-sce) weakremover(openscap-extra-probes) weakremover(openscap-utils) weakremover(openslide-tools) weakremover(openslp) weakremover(openslp-devel) weakremover(openslp-server) weakremover(opensm) weakremover(opensm-devel) weakremover(opensm-libs3) weakremover(opensp) weakremover(opensp-devel) weakremover(openspecfun-devel) weakremover(openssh) weakremover(openssh-askpass) weakremover(openssh-askpass-gnome) weakremover(openssh-cavs) weakremover(openssh-clients) weakremover(openssh-common) weakremover(openssh-fips) weakremover(openssh-helpers) weakremover(openssh-server) weakremover(openssh-server-config-rootlogin) weakremover(openssl-1_0_0) weakremover(openssl-1_0_0-cavs) weakremover(openssl-1_1) weakremover(openssl-3) weakremover(openssl-cavs) weakremover(openssl-cbs-devel) weakremover(openssl-debuginfo) weakremover(openssl-engine-af_alg) weakremover(openssl-engine-libp11) weakremover(openssl-ibmpkcs11) weakremover(openssl_tpm2_engine) weakremover(openssl_tpm_engine) weakremover(openstack-suse-macros) weakremover(openstack-suse-sudo) weakremover(openstack-tempest) weakremover(openstack-tempest-doc) weakremover(openstack-utils) weakremover(opensurge) weakremover(opensuse-welcome) weakremover(opentracing-cpp-devel) weakremover(openttd) weakremover(openttd-dedicated) weakremover(opentyrian) weakremover(openucx-tools) weakremover(openvas-cli) weakremover(openvas-manager) weakremover(openvas-scanner) weakremover(openvas-scanner-doc) weakremover(openvas-smb) weakremover(openvdb-devel) weakremover(openvdb-tools) weakremover(openvpn) weakremover(openvpn-auth-pam-plugin) weakremover(openvpn-devel) weakremover(openvpn-down-root-plugin) weakremover(openvswitch) weakremover(openvswitch-devel) weakremover(openvswitch-dpdk) weakremover(openvswitch-dpdk-devel) weakremover(openvswitch-dpdk-ovn) weakremover(openvswitch-dpdk-pki) weakremover(openvswitch-dpdk-switch) weakremover(openvswitch-dpdk-test) weakremover(openvswitch-dpdk-vtep) weakremover(openvswitch-ipsec) weakremover(openvswitch-ovn) weakremover(openvswitch-ovn-central) weakremover(openvswitch-ovn-common) weakremover(openvswitch-ovn-docker) weakremover(openvswitch-ovn-host) weakremover(openvswitch-ovn-vtep) weakremover(openvswitch-pki) weakremover(openvswitch-switch) weakremover(openvswitch-test) weakremover(openvswitch-vtep) weakremover(openwsman-perl) weakremover(openwsman-python) weakremover(openwsman-ruby) weakremover(openwsman-server) weakremover(openwsman-server-plugin-ruby) weakremover(openxcom) weakremover(openxcom-doc) weakremover(opera-uget-integrator) weakremover(opie) weakremover(oping) weakremover(opmsg) weakremover(oprofile) weakremover(oprofile-devel) weakremover(opt_gnome-compat) weakremover(optee-client) weakremover(optee-client-devel) weakremover(optipng) weakremover(opus-tools) weakremover(opusfile-devel) weakremover(oqs-provider) weakremover(orage) weakremover(orage-doc) weakremover(orbit2) weakremover(orbit2-devel) weakremover(orbit2-doc) weakremover(orc) weakremover(orc-doc) weakremover(orcania-devel) weakremover(origami-icon-theme) weakremover(orion) weakremover(orthanc) weakremover(orthanc-devel) weakremover(orthanc-dicomweb) weakremover(orthanc-framework) weakremover(orthanc-framework-devel) weakremover(orthanc-framework-source) weakremover(orthanc-gdcm) weakremover(orthanc-indexer) weakremover(orthanc-mysql) weakremover(orthanc-neuro) weakremover(orthanc-postgresql) weakremover(orthanc-python) weakremover(orthanc-source) weakremover(orthanc-tcia) weakremover(orthanc-webviewer) weakremover(orthanc-wsi) weakremover(orthos2-client) weakremover(ortp) weakremover(ortp-devel) weakremover(os-autoinst) weakremover(os-autoinst-devel) weakremover(os-autoinst-openvswitch) weakremover(os-autoinst-s390-deps) weakremover(os-autoinst-swtpm) weakremover(os-prober) weakremover(osc-plugin-install) weakremover(osdkeys) weakremover(osdlyrics) weakremover(osinfo-db-tools) weakremover(osl.imageio1_10) weakremover(osl.imageio1_9) weakremover(osmo-bsc) weakremover(osmo-bsc-abisip-find) weakremover(osmo-bsc-bs11-utils) weakremover(osmo-bsc-ipaccess-utils) weakremover(osmo-bsc-meas-utils) weakremover(osmo-bts) weakremover(osmo-bts-omldummy) weakremover(osmo-bts-virtual) weakremover(osmo-e1d) weakremover(osmo-e1d-devel) weakremover(osmo-fl2k) weakremover(osmo-fl2k-devel) weakremover(osmo-fl2k-udev) weakremover(osmo-gbproxy) weakremover(osmo-ggsn) weakremover(osmo-gtphub) weakremover(osmo-hlr) weakremover(osmo-iuh) weakremover(osmo-mgw) weakremover(osmo-msc) weakremover(osmo-mslookup-client) weakremover(osmo-pcap) weakremover(osmo-pcu) weakremover(osmo-remsim-bankd) weakremover(osmo-remsim-client) weakremover(osmo-remsim-server) weakremover(osmo-sgsn) weakremover(osmo-sip-connector) weakremover(osmo-smlc) weakremover(osmo-stp) weakremover(osmo-trx) weakremover(osmo-trx-lms) weakremover(osmo-trx-uhd) weakremover(osmo-trx-usrp1) weakremover(osmosdr) weakremover(osmosdr-devel) weakremover(ossim) weakremover(ossim-devel) weakremover(ossim-sample-data) weakremover(osslsigncode) weakremover(ossp-uuid) weakremover(ostree) weakremover(ostree-devel) weakremover(ostree-grub2) weakremover(osv-scanner) weakremover(otb-bin) weakremover(otb-devel) weakremover(otb-qt) weakremover(oto) weakremover(otpclient) weakremover(otrs) weakremover(otrs-doc) weakremover(otrs-itsm) weakremover(otter-browser) weakremover(ouch) weakremover(ovirt-guest-agent-common) weakremover(ovmf) weakremover(ovmf-tools) weakremover(ovn) weakremover(ovn-central) weakremover(ovn-devel) weakremover(ovn-docker) weakremover(ovn-host) weakremover(ovn-vtep) weakremover(ovnkube) weakremover(ovnkube-cni) weakremover(owncloud-client) weakremover(owncloud-client-caja) weakremover(owncloud-client-doc) weakremover(owncloud-client-dolphin) weakremover(owncloud-client-l10n) weakremover(owncloud-client-nautilus) weakremover(owncloud-client-nemo) weakremover(owntone) weakremover(oxygen5) weakremover(oxygen5-decoration) weakremover(oxygen5-devel) weakremover(oxygen5-style) weakremover(oyranos) weakremover(oyranos-monitor) weakremover(oyranos-profile-graph) weakremover(oyranos-qcmsevents) weakremover(oyranos-qcmsevents-qt4) weakremover(oyranos-ui-fltk) weakremover(p0f) weakremover(p11-kit) weakremover(p11-kit-devel) weakremover(p11-kit-nss-trust) weakremover(p11-kit-server) weakremover(p11-kit-tools) weakremover(p7zip) weakremover(p7zip-doc) weakremover(p7zip-full) weakremover(p8-platform-devel) weakremover(pacemaker) weakremover(pacemaker-cli) weakremover(pacemaker-devel) weakremover(pacemaker-libs) weakremover(pacemaker-remote) weakremover(packETH) weakremover(package-update-indicator) weakremover(packagekitqt5-devel) weakremover(packagekitqt6-devel) weakremover(packit) weakremover(paexec) weakremover(pagein) weakremover(pagemon) weakremover(pagetools) weakremover(palapeli) weakremover(palapeli-devel) weakremover(palaura) weakremover(palette) weakremover(palm-db-tools) weakremover(pam) weakremover(pam-config) weakremover(pam-deprecated) weakremover(pam-devel) weakremover(pam-extra) weakremover(pam-fscrypt) weakremover(pam-modules) weakremover(pam-python) weakremover(pam-test) weakremover(pam-userdb) weakremover(pam_apparmor) weakremover(pam_cap) weakremover(pam_ccreds) weakremover(pam_cgfs) weakremover(pam_chroot) weakremover(pam_cifscreds) weakremover(pam_csync) weakremover(pam_dbus) weakremover(pam_krb5) weakremover(pam_kwallet) weakremover(pam_ldap) weakremover(pam_mktemp) weakremover(pam_mount) weakremover(pam_oath) weakremover(pam_p11) weakremover(pam_passwdqc) weakremover(pam_pkcs11) weakremover(pam_pkcs11-devel-doc) weakremover(pam_pwquality) weakremover(pam_radius) weakremover(pam_saslauthd) weakremover(pam_script) weakremover(pam_smb) weakremover(pam_snapper) weakremover(pam_ssh) weakremover(pam_ssh_agent_auth) weakremover(pam_u2f) weakremover(pam_unix) weakremover(pam_unix-nis) weakremover(pam_userpass) weakremover(pam_wrapper) weakremover(pam_yubico) weakremover(paman) weakremover(pamix) weakremover(pamixer) weakremover(pan) weakremover(pandoc) weakremover(pandoc-cli) weakremover(pandoc-pdf) weakremover(pango-devel) weakremover(pango-tools) weakremover(pangomm-devel) weakremover(pangomm1_4-devel) weakremover(pangomm1_4-doc) weakremover(pangox-compat) weakremover(pangox-devel) weakremover(pantheon-calculator) weakremover(pantheon-calculator-lang) weakremover(pantheon-files) weakremover(pantheon-files-lang) weakremover(pantheon-photos) weakremover(pantheon-photos-lang) weakremover(pantheon-terminal) weakremover(pantheon-terminal-lang) weakremover(paper) weakremover(paperjam) weakremover(paperkey) weakremover(paperwork) weakremover(papi) weakremover(papi-devel) weakremover(papi-devel-static) weakremover(papi-hpc-devel) weakremover(papi_5_5_1-hpc) weakremover(papi_5_5_1-hpc-devel) weakremover(papi_5_5_1-hpc-devel-static) weakremover(papi_5_6_0-hpc) weakremover(papi_5_6_0-hpc-devel) weakremover(papi_5_6_0-hpc-devel-static) weakremover(papi_5_7_0-hpc) weakremover(papi_5_7_0-hpc-devel) weakremover(papi_5_7_0-hpc-devel-static) weakremover(papi_6_0_0-hpc) weakremover(papi_6_0_0-hpc-devel) weakremover(papi_6_0_0-hpc-devel-static) weakremover(papi_6_0_0_1-hpc) weakremover(papi_6_0_0_1-hpc-devel) weakremover(papi_6_0_0_1-hpc-devel-static) weakremover(papi_7_0_0-hpc) weakremover(papi_7_0_0-hpc-devel) weakremover(papi_7_0_0-hpc-devel-static) weakremover(paprefs) weakremover(paps) weakremover(par) weakremover(par2cmdline) weakremover(par_text) weakremover(paradise) weakremover(parallel-netcdf-devel-data) weakremover(parallel-netcdf-mvapich2) weakremover(parallel-netcdf-mvapich2-devel) weakremover(parallel-netcdf-mvapich2-devel-static) weakremover(parallel-netcdf-openmpi) weakremover(parallel-netcdf-openmpi-devel) weakremover(parallel-netcdf-openmpi-devel-static) weakremover(parallel-netcdf-openmpi1) weakremover(parallel-netcdf-openmpi1-devel) weakremover(parallel-netcdf-openmpi1-devel-static) weakremover(parallel-netcdf-openmpi2) weakremover(parallel-netcdf-openmpi2-devel) weakremover(parallel-netcdf-openmpi2-devel-static) weakremover(parallel-netcdf-openmpi3) weakremover(parallel-netcdf-openmpi3-devel) weakremover(parallel-netcdf-openmpi3-devel-static) weakremover(paraview) weakremover(paraview-devel) weakremover(paraview-plugin-SciberQuestToolKit) weakremover(parcellite) weakremover(pari-devel) weakremover(pari-gp) weakremover(parkverbot) weakremover(parlatype) weakremover(parley) weakremover(parole) weakremover(parole-devel) weakremover(parpack-openmpi) weakremover(parpack-openmpi-devel) weakremover(parpack-openmpi1-devel) weakremover(parpack-openmpi2-devel) weakremover(parpack-openmpi3-devel) weakremover(parpack-openmpi4-devel) weakremover(parsec) weakremover(parsec-tool) weakremover(partclone) weakremover(parted) weakremover(parted-devel) weakremover(parti) weakremover(partio) weakremover(partio-devel) weakremover(partitionmanager) weakremover(parzip) weakremover(passwdqc) weakremover(passwdqc-devel) weakremover(pasystray) weakremover(patch) weakremover(patchelf) weakremover(patchutils) weakremover(patterns-base-32bit) weakremover(patterns-base-apparmor) weakremover(patterns-base-apparmor-32bit) weakremover(patterns-base-apparmor_opt) weakremover(patterns-base-base) weakremover(patterns-base-base-32bit) weakremover(patterns-base-basesystem) weakremover(patterns-base-basic_desktop) weakremover(patterns-base-bootloader) weakremover(patterns-base-console) weakremover(patterns-base-documentation) weakremover(patterns-base-enhanced_base) weakremover(patterns-base-enhanced_base-32bit) weakremover(patterns-base-enhanced_base_opt) weakremover(patterns-base-fips) weakremover(patterns-base-minimal_base) weakremover(patterns-base-minimal_base-32bit) weakremover(patterns-base-minimal_base_conflicts) weakremover(patterns-base-selinux) weakremover(patterns-base-sw_management) weakremover(patterns-base-sw_management-32bit) weakremover(patterns-base-transactional_base) weakremover(patterns-base-update_test) weakremover(patterns-base-x11) weakremover(patterns-base-x11-32bit) weakremover(patterns-base-x11_enhanced) weakremover(patterns-base-x11_enhanced-32bit) weakremover(patterns-base-x11_opt) weakremover(patterns-base-x11_raspberrypi) weakremover(patterns-budgie-budgie) weakremover(patterns-budgie-budgie_applets) weakremover(patterns-caasp-MicroOS) weakremover(patterns-caasp-MicroOS-defaults) weakremover(patterns-caasp-alt-container-runtime) weakremover(patterns-caasp-alt-onlyDVD) weakremover(patterns-caasp-apparmor) weakremover(patterns-caasp-cloud) weakremover(patterns-caasp-container-runtime) weakremover(patterns-caasp-container-runtime-config) weakremover(patterns-caasp-container-runtime-kubernetes) weakremover(patterns-caasp-hardware) weakremover(patterns-caasp-ima_evm) weakremover(patterns-caasp-kubeadm) weakremover(patterns-caasp-onlyDVD) weakremover(patterns-caasp-selinux) weakremover(patterns-caasp-sssd-ldap) weakremover(patterns-ceph-containers-ceph_base) weakremover(patterns-cinnamon-cinnamon) weakremover(patterns-cinnamon-cinnamon_basis) weakremover(patterns-containers-container_runtime) weakremover(patterns-containers-container_runtime_kubernetes) weakremover(patterns-containers-kubeadm) weakremover(patterns-containers-kubernetes_utilities) weakremover(patterns-containers-kubic_admin) weakremover(patterns-containers-kubic_loadbalancer) weakremover(patterns-containers-kubic_worker) weakremover(patterns-deepin-deepin) weakremover(patterns-deepin-deepin_admin) weakremover(patterns-deepin-deepin_basis) weakremover(patterns-deepin-deepin_internet) weakremover(patterns-deepin-deepin_multimedia) weakremover(patterns-deepin-deepin_office) weakremover(patterns-deepin-deepin_office_opt) weakremover(patterns-deepin-deepin_utilities) weakremover(patterns-desktop-books) weakremover(patterns-desktop-imaging) weakremover(patterns-desktop-imaging_opt) weakremover(patterns-desktop-laptop) weakremover(patterns-desktop-mobile) weakremover(patterns-desktop-multimedia) weakremover(patterns-desktop-multimedia_opt) weakremover(patterns-desktop-technical_writing) weakremover(patterns-devel-base-devel_basis) weakremover(patterns-devel-base-devel_basis-32bit) weakremover(patterns-devel-base-devel_kernel) weakremover(patterns-devel-base-devel_kernel-32bit) weakremover(patterns-devel-base-devel_rpm_build) weakremover(patterns-devel-base-devel_web) weakremover(patterns-devel-java-devel_java) weakremover(patterns-devel-mono-devel_mono) weakremover(patterns-devel-osc-devel_osc_build) weakremover(patterns-devel-perl-devel_perl) weakremover(patterns-devel-python-devel_python3) weakremover(patterns-devel-ruby-devel_ruby) weakremover(patterns-devel-tcl-devel_tcl) weakremover(patterns-devel-vulkan-devel_vulkan) weakremover(patterns-enlightenment-enlightenment) weakremover(patterns-fonts-fonts) weakremover(patterns-fonts-fonts_opt) weakremover(patterns-games-games) weakremover(patterns-gnome-devel_gnome) weakremover(patterns-gnome-gnome) weakremover(patterns-gnome-gnome_basic) weakremover(patterns-gnome-gnome_basis) weakremover(patterns-gnome-gnome_basis_opt) weakremover(patterns-gnome-gnome_games) weakremover(patterns-gnome-gnome_ide) weakremover(patterns-gnome-gnome_imaging) weakremover(patterns-gnome-gnome_internet) weakremover(patterns-gnome-gnome_multimedia) weakremover(patterns-gnome-gnome_office) weakremover(patterns-gnome-gnome_utilities) weakremover(patterns-gnome-gnome_x11) weakremover(patterns-gnome-gnome_yast) weakremover(patterns-gnome-sw_management_gnome) weakremover(patterns-haskell-haskell_platform) weakremover(patterns-hpc-compute_node) weakremover(patterns-hpc-development_node) weakremover(patterns-hpc-libraries) weakremover(patterns-hpc-workload_server) weakremover(patterns-kubernetes-container_runtime_kubernetes) weakremover(patterns-kubernetes-kubeadm) weakremover(patterns-kubernetes-kubernetes_utilities) weakremover(patterns-leechcraft-leechcraft) weakremover(patterns-leechcraft-leechcraft_browser) weakremover(patterns-leechcraft-leechcraft_media) weakremover(patterns-leechcraft-leechcraft_messenger) weakremover(patterns-leechcraft-leechcraft_netutils) weakremover(patterns-leechcraft-leechcraft_office) weakremover(patterns-leechcraft-leechcraft_utilities) weakremover(patterns-lxde-lxde) weakremover(patterns-lxde-lxde_laptop) weakremover(patterns-lxde-lxde_office) weakremover(patterns-lxqt-lxqt) weakremover(patterns-mate-mate) weakremover(patterns-mate-mate_admin) weakremover(patterns-mate-mate_basis) weakremover(patterns-mate-mate_internet) weakremover(patterns-mate-mate_laptop) weakremover(patterns-mate-mate_office) weakremover(patterns-mate-mate_office_opt) weakremover(patterns-mate-mate_utilities) weakremover(patterns-media-rest_cd_core) weakremover(patterns-media-rest_cd_gnome) weakremover(patterns-media-rest_cd_kde) weakremover(patterns-media-rest_cd_x11) weakremover(patterns-media-rest_core_dvd) weakremover(patterns-media-rest_dvd) weakremover(patterns-microos-alt_onlyDVD) weakremover(patterns-microos-apparmor) weakremover(patterns-microos-base) weakremover(patterns-microos-base-microdnf) weakremover(patterns-microos-base-packagekit) weakremover(patterns-microos-base-zypper) weakremover(patterns-microos-basesystem) weakremover(patterns-microos-cloud) weakremover(patterns-microos-cockpit) weakremover(patterns-microos-defaults) weakremover(patterns-microos-desktop-common) weakremover(patterns-microos-desktop-gnome) weakremover(patterns-microos-desktop-kde) weakremover(patterns-microos-hardware) weakremover(patterns-microos-ima_evm) weakremover(patterns-microos-onlyDVD) weakremover(patterns-microos-ra_agent) weakremover(patterns-microos-ra_verifier) weakremover(patterns-microos-selinux) weakremover(patterns-microos-sssd_ldap) weakremover(patterns-network-network_admin) weakremover(patterns-office-office) weakremover(patterns-openSUSE-32bit) weakremover(patterns-openSUSE-64bit) weakremover(patterns-openSUSE-apparmor) weakremover(patterns-openSUSE-apparmor_opt) weakremover(patterns-openSUSE-base) weakremover(patterns-openSUSE-books) weakremover(patterns-openSUSE-console) weakremover(patterns-openSUSE-devel_C_C++) weakremover(patterns-openSUSE-devel_basis) weakremover(patterns-openSUSE-devel_gnome) weakremover(patterns-openSUSE-devel_ide) weakremover(patterns-openSUSE-devel_java) weakremover(patterns-openSUSE-devel_kde_frameworks) weakremover(patterns-openSUSE-devel_kernel) weakremover(patterns-openSUSE-devel_mono) weakremover(patterns-openSUSE-devel_perl) weakremover(patterns-openSUSE-devel_python) weakremover(patterns-openSUSE-devel_python3) weakremover(patterns-openSUSE-devel_qt4) weakremover(patterns-openSUSE-devel_rpm_build) weakremover(patterns-openSUSE-devel_ruby) weakremover(patterns-openSUSE-devel_tcl) weakremover(patterns-openSUSE-devel_web) weakremover(patterns-openSUSE-devel_yast) weakremover(patterns-openSUSE-dhcp_dns_server) weakremover(patterns-openSUSE-directory_server) weakremover(patterns-openSUSE-enhanced_base) weakremover(patterns-openSUSE-enhanced_base_opt) weakremover(patterns-openSUSE-enlightenment) weakremover(patterns-openSUSE-file_server) weakremover(patterns-openSUSE-fonts) weakremover(patterns-openSUSE-fonts_opt) weakremover(patterns-openSUSE-games) weakremover(patterns-openSUSE-gateway_server) weakremover(patterns-openSUSE-generic_server) weakremover(patterns-openSUSE-gnome) weakremover(patterns-openSUSE-gnome_admin) weakremover(patterns-openSUSE-gnome_basis) weakremover(patterns-openSUSE-gnome_basis_opt) weakremover(patterns-openSUSE-gnome_games) weakremover(patterns-openSUSE-gnome_ide) weakremover(patterns-openSUSE-gnome_imaging) weakremover(patterns-openSUSE-gnome_imaging_opt) weakremover(patterns-openSUSE-gnome_internet) weakremover(patterns-openSUSE-gnome_laptop) weakremover(patterns-openSUSE-gnome_multimedia) weakremover(patterns-openSUSE-gnome_multimedia_opt) weakremover(patterns-openSUSE-gnome_office) weakremover(patterns-openSUSE-gnome_office_opt) weakremover(patterns-openSUSE-gnome_utilities) weakremover(patterns-openSUSE-gnome_yast) weakremover(patterns-openSUSE-haskell_platform) weakremover(patterns-openSUSE-imaging) weakremover(patterns-openSUSE-imaging_opt) weakremover(patterns-openSUSE-kde_telepathy) weakremover(patterns-openSUSE-kvm_server) weakremover(patterns-openSUSE-lamp_server) weakremover(patterns-openSUSE-laptop) weakremover(patterns-openSUSE-leechcraft) weakremover(patterns-openSUSE-leechcraft_browser) weakremover(patterns-openSUSE-leechcraft_media) weakremover(patterns-openSUSE-leechcraft_messenger) weakremover(patterns-openSUSE-leechcraft_netutils) weakremover(patterns-openSUSE-leechcraft_office) weakremover(patterns-openSUSE-leechcraft_utilities) weakremover(patterns-openSUSE-lxde) weakremover(patterns-openSUSE-lxde_laptop) weakremover(patterns-openSUSE-lxde_office) weakremover(patterns-openSUSE-lxqt) weakremover(patterns-openSUSE-mail_server) weakremover(patterns-openSUSE-mate) weakremover(patterns-openSUSE-mate_admin) weakremover(patterns-openSUSE-mate_basis) weakremover(patterns-openSUSE-mate_internet) weakremover(patterns-openSUSE-mate_laptop) weakremover(patterns-openSUSE-mate_office) weakremover(patterns-openSUSE-mate_office_opt) weakremover(patterns-openSUSE-mate_utilities) weakremover(patterns-openSUSE-minimal_base) weakremover(patterns-openSUSE-minimal_base-conflicts) weakremover(patterns-openSUSE-misc_server) weakremover(patterns-openSUSE-multimedia) weakremover(patterns-openSUSE-multimedia_opt) weakremover(patterns-openSUSE-network_admin) weakremover(patterns-openSUSE-non_oss) weakremover(patterns-openSUSE-non_oss_opt) weakremover(patterns-openSUSE-office) weakremover(patterns-openSUSE-office_opt) weakremover(patterns-openSUSE-print_server) weakremover(patterns-openSUSE-remote_desktop) weakremover(patterns-openSUSE-rest_cd_gnome) weakremover(patterns-openSUSE-rest_cd_kde) weakremover(patterns-openSUSE-rest_cd_x11) weakremover(patterns-openSUSE-rest_core_dvd) weakremover(patterns-openSUSE-rest_dvd) weakremover(patterns-openSUSE-rest_dvd9) weakremover(patterns-openSUSE-rest_promo_dvd) weakremover(patterns-openSUSE-sw_management) weakremover(patterns-openSUSE-sw_management_gnome) weakremover(patterns-openSUSE-tabletpc) weakremover(patterns-openSUSE-technical_writing) weakremover(patterns-openSUSE-update_test) weakremover(patterns-openSUSE-voip) weakremover(patterns-openSUSE-x11) weakremover(patterns-openSUSE-x11_opt) weakremover(patterns-openSUSE-x11_yast) weakremover(patterns-openSUSE-x86) weakremover(patterns-openSUSE-xen_server) weakremover(patterns-openSUSE-xfce) weakremover(patterns-openSUSE-xfce_basis) weakremover(patterns-openSUSE-xfce_laptop) weakremover(patterns-openSUSE-xfce_office) weakremover(patterns-openSUSE-yast2_basis) weakremover(patterns-openSUSE-yast2_install_wf) weakremover(patterns-server-dhcp_dns_server) weakremover(patterns-server-dhcp_dns_server-32bit) weakremover(patterns-server-directory_server) weakremover(patterns-server-directory_server-32bit) weakremover(patterns-server-file_server) weakremover(patterns-server-file_server-32bit) weakremover(patterns-server-gateway_server) weakremover(patterns-server-gateway_server-32bit) weakremover(patterns-server-kvm_server) weakremover(patterns-server-kvm_tools) weakremover(patterns-server-lamp_server) weakremover(patterns-server-lamp_server-32bit) weakremover(patterns-server-mail_server) weakremover(patterns-server-mail_server-32bit) weakremover(patterns-server-printing) weakremover(patterns-server-printing-32bit) weakremover(patterns-sway-sway) weakremover(patterns-xfce-xfce) weakremover(patterns-xfce-xfce_basis) weakremover(patterns-xfce-xfce_laptop) weakremover(patterns-xfce-xfce_office) weakremover(patterns-yast-devel_yast) weakremover(patterns-yast-x11_yast) weakremover(patterns-yast-yast2_basis) weakremover(patterns-yast-yast2_desktop) weakremover(patterns-yast-yast2_install_wf) weakremover(patterns-yast-yast2_server) weakremover(pavucontrol) weakremover(pavucontrol-qt) weakremover(pavuk) weakremover(pavumeter) weakremover(pax-utils) weakremover(pbm2l7k) weakremover(pbzip2) weakremover(pcapdump) weakremover(pcapinfo) weakremover(pcapplusplus-devel) weakremover(pcaudiolib-devel) weakremover(pcb) weakremover(pcfclock) weakremover(pcfclock-kmp-64kb) weakremover(pcfclock-kmp-default) weakremover(pciutils) weakremover(pciutils-devel) weakremover(pcmanfm) weakremover(pcmanfm-devel) weakremover(pcmanfm-qt) weakremover(pcmanx-gtk2) weakremover(pcmciautils) weakremover(pcp) weakremover(pcp-conf) weakremover(pcp-devel) weakremover(pcp-export-pcp2elasticsearch) weakremover(pcp-export-pcp2graphite) weakremover(pcp-export-pcp2influxdb) weakremover(pcp-export-pcp2json) weakremover(pcp-export-pcp2spark) weakremover(pcp-export-pcp2xml) weakremover(pcp-export-pcp2zabbix) weakremover(pcp-export-zabbix-agent) weakremover(pcp-gui) weakremover(pcp-import-collectl2pcp) weakremover(pcp-import-ganglia2pcp) weakremover(pcp-import-iostat2pcp) weakremover(pcp-import-mrtg2pcp) weakremover(pcp-import-sar2pcp) weakremover(pcp-import-sheet2pcp) weakremover(pcp-manager) weakremover(pcp-pmda-activemq) weakremover(pcp-pmda-apache) weakremover(pcp-pmda-bash) weakremover(pcp-pmda-bind2) weakremover(pcp-pmda-bonding) weakremover(pcp-pmda-cifs) weakremover(pcp-pmda-cisco) weakremover(pcp-pmda-dbping) weakremover(pcp-pmda-dm) weakremover(pcp-pmda-docker) weakremover(pcp-pmda-ds389) weakremover(pcp-pmda-ds389log) weakremover(pcp-pmda-elasticsearch) weakremover(pcp-pmda-gfs2) weakremover(pcp-pmda-gluster) weakremover(pcp-pmda-gpfs) weakremover(pcp-pmda-gpsd) weakremover(pcp-pmda-hacluster) weakremover(pcp-pmda-haproxy) weakremover(pcp-pmda-infiniband) weakremover(pcp-pmda-json) weakremover(pcp-pmda-kvm) weakremover(pcp-pmda-libvirt) weakremover(pcp-pmda-lio) weakremover(pcp-pmda-lmsensors) weakremover(pcp-pmda-logger) weakremover(pcp-pmda-lustre) weakremover(pcp-pmda-lustrecomm) weakremover(pcp-pmda-mailq) weakremover(pcp-pmda-memcache) weakremover(pcp-pmda-mic) weakremover(pcp-pmda-mounts) weakremover(pcp-pmda-mysql) weakremover(pcp-pmda-named) weakremover(pcp-pmda-netcheck) weakremover(pcp-pmda-netfilter) weakremover(pcp-pmda-news) weakremover(pcp-pmda-nfsclient) weakremover(pcp-pmda-nginx) weakremover(pcp-pmda-nutcracker) weakremover(pcp-pmda-nvidia-gpu) weakremover(pcp-pmda-openmetrics) weakremover(pcp-pmda-openvswitch) weakremover(pcp-pmda-oracle) weakremover(pcp-pmda-papi) weakremover(pcp-pmda-pdns) weakremover(pcp-pmda-perfevent) weakremover(pcp-pmda-postfix) weakremover(pcp-pmda-postgresql) weakremover(pcp-pmda-prometheus) weakremover(pcp-pmda-rabbitmq) weakremover(pcp-pmda-redis) weakremover(pcp-pmda-roomtemp) weakremover(pcp-pmda-rpm) weakremover(pcp-pmda-rsyslog) weakremover(pcp-pmda-samba) weakremover(pcp-pmda-sendmail) weakremover(pcp-pmda-shping) weakremover(pcp-pmda-slurm) weakremover(pcp-pmda-smart) weakremover(pcp-pmda-snmp) weakremover(pcp-pmda-sockets) weakremover(pcp-pmda-summary) weakremover(pcp-pmda-systemd) weakremover(pcp-pmda-trace) weakremover(pcp-pmda-unbound) weakremover(pcp-pmda-vmware) weakremover(pcp-pmda-weblog) weakremover(pcp-pmda-zimbra) weakremover(pcp-pmda-zswap) weakremover(pcp-system-tools) weakremover(pcp-testsuite) weakremover(pcp-webapi) weakremover(pcp-zeroconf) weakremover(pcre-devel) weakremover(pcre-devel-static) weakremover(pcre-testsuite) weakremover(pcre-tools) weakremover(pcre2-devel) weakremover(pcre2-devel-static) weakremover(pcre2-tools) weakremover(pcsc-acr38) weakremover(pcsc-acr38-devel) weakremover(pcsc-acsccid) weakremover(pcsc-asedriveiiie-serial) weakremover(pcsc-asedriveiiie-usb) weakremover(pcsc-asekey) weakremover(pcsc-ccid) weakremover(pcsc-cyberjack) weakremover(pcsc-eco5000) weakremover(pcsc-gempc) weakremover(pcsc-lite) weakremover(pcsc-lite-devel) weakremover(pcsc-openct) weakremover(pcsc-reflex60) weakremover(pcsc-tools) weakremover(pcsc-towitoko) weakremover(pcsc-towitoko-devel) weakremover(pdf2djvu) weakremover(pdf2svg) weakremover(pdfchain) weakremover(pdfcompare) weakremover(pdfgrep) weakremover(pdfmixtool) weakremover(pdfmod) weakremover(pdfmod-lang) weakremover(pdfquirk) weakremover(pdfshuffler) weakremover(pdfshuffler-lang) weakremover(pdns) weakremover(pdns-backend-geoip) weakremover(pdns-backend-godbc) weakremover(pdns-backend-ldap) weakremover(pdns-backend-lmdb) weakremover(pdns-backend-lua) weakremover(pdns-backend-mydns) weakremover(pdns-backend-mysql) weakremover(pdns-backend-postgresql) weakremover(pdns-backend-remote) weakremover(pdns-backend-sqlite3) weakremover(pdns-recursor) weakremover(pdnsd) weakremover(pdsh) weakremover(pdsh-dshgroup) weakremover(pdsh-genders) weakremover(pdsh-machines) weakremover(pdsh-netgroup) weakremover(pdsh-slurm) weakremover(peazip) weakremover(peek) weakremover(peerunity-qt) weakremover(peerunityd) weakremover(peg) weakremover(peksystray) weakremover(pen) weakremover(pencil) weakremover(pentobi) weakremover(pentobi-kde-thumbnailer) weakremover(pepper) weakremover(percona-toolkit) weakremover(perf) weakremover(perf-bash-completion) weakremover(perf-devel) weakremover(perf-gtk) weakremover(perf-rebuild) weakremover(perftest) weakremover(perl) weakremover(perl-Acme-Damn) weakremover(perl-Algorithm-Combinatorics) weakremover(perl-Alien-Build) weakremover(perl-Alien-Hunspell) weakremover(perl-Alien-Libxml2) weakremover(perl-Alien-SDL) weakremover(perl-Alien-wxWidgets) weakremover(perl-AnyEvent) weakremover(perl-Apache-Filter) weakremover(perl-Apache-SessionX) weakremover(perl-Authen-DecHpwd) weakremover(perl-Authen-SASL-Cyrus) weakremover(perl-B-COW) weakremover(perl-B-Hooks-OP-Annotation) weakremover(perl-B-Hooks-OP-Check) weakremover(perl-B-Hooks-OP-PPAddr) weakremover(perl-B-Utils) weakremover(perl-BIND-Conf_Parser) weakremover(perl-BSD-Resource) weakremover(perl-BerkeleyDB) weakremover(perl-Bit-Vector) weakremover(perl-Boost-Geometry-Utils) weakremover(perl-Bootloader) weakremover(perl-Bootloader-YAML) weakremover(perl-CPAN-Meta) weakremover(perl-CPAN-Meta-YAML) weakremover(perl-CSS-Minifier-XS) weakremover(perl-Cairo) weakremover(perl-Cairo-GObject) weakremover(perl-Class-Accessor-Chained) weakremover(perl-Class-C3-XS) weakremover(perl-Class-Date) weakremover(perl-Class-Load-XS) weakremover(perl-Class-MethodMaker) weakremover(perl-Class-WhiteHole) weakremover(perl-Class-XSAccessor) weakremover(perl-Clipboard) weakremover(perl-Clone) weakremover(perl-Code-DRY) weakremover(perl-CommonMark) weakremover(perl-Compress-Bzip2) weakremover(perl-Compress-Raw-Lzma) weakremover(perl-Config-General) weakremover(perl-Config-Simple) weakremover(perl-Convert-BER) weakremover(perl-Convert-UUlib) weakremover(perl-Cpanel-JSON-XS) weakremover(perl-Crypt-Blowfish) weakremover(perl-Crypt-DES) weakremover(perl-Crypt-DH-GMP) weakremover(perl-Crypt-Eksblowfish) weakremover(perl-Crypt-MySQL) weakremover(perl-Crypt-OpenSSL-Bignum) weakremover(perl-Crypt-OpenSSL-RSA) weakremover(perl-Crypt-OpenSSL-Random) weakremover(perl-Crypt-RC4) weakremover(perl-Crypt-Rijndael) weakremover(perl-Crypt-SSLeay) weakremover(perl-Crypt-UnixCrypt_XS) weakremover(perl-CryptX) weakremover(perl-Curses) weakremover(perl-Cyrus-IMAP) weakremover(perl-Cyrus-SIEVE-managesieve) weakremover(perl-DBD-MariaDB) weakremover(perl-DBD-ODBC) weakremover(perl-DBD-Pg) weakremover(perl-DBD-SQLite) weakremover(perl-DBD-mysql) weakremover(perl-DBI) weakremover(perl-DBIx-Transaction) weakremover(perl-DNS-LDNS) weakremover(perl-Data-AMF) weakremover(perl-Data-Clone) weakremover(perl-Data-Dump-Streamer) weakremover(perl-Data-Peek) weakremover(perl-Data-Structure-Util) weakremover(perl-Data-Util) weakremover(perl-Date-Simple) weakremover(perl-DateTime) weakremover(perl-DateTime-Calendar-Mayan) weakremover(perl-Devel-Caller) weakremover(perl-Devel-CheckLib) weakremover(perl-Devel-CoreStack) weakremover(perl-Devel-Cover) weakremover(perl-Devel-Declare) weakremover(perl-Devel-Leak) weakremover(perl-Devel-LexAlias) weakremover(perl-Devel-NYTProf) weakremover(perl-Devel-PPPort) weakremover(perl-Devel-PatchPerl) weakremover(perl-Device-SerialPort) weakremover(perl-Digest-CRC) weakremover(perl-Digest-JHash) weakremover(perl-Digest-MD4) weakremover(perl-Digest-MD5) weakremover(perl-Digest-SHA1) weakremover(perl-Digest-SHA3) weakremover(perl-Email-Address-XS) weakremover(perl-Encode) weakremover(perl-Encode-Detect) weakremover(perl-Encode-EUCJPASCII) weakremover(perl-Encode-HanExtra) weakremover(perl-Encode-JIS2K) weakremover(perl-Event) weakremover(perl-ExtUtils-CBuilder) weakremover(perl-ExtUtils-CppGuess) weakremover(perl-ExtUtils-MakeMaker-mini) weakremover(perl-ExtUtils-XSpp) weakremover(perl-FastCGI) weakremover(perl-File-Basename-Object) weakremover(perl-File-Comments) weakremover(perl-File-FcntlLock) weakremover(perl-File-LibMagic) weakremover(perl-File-Map) weakremover(perl-File-Next) weakremover(perl-File-Sync) weakremover(perl-File-Type) weakremover(perl-File-Unpack) weakremover(perl-Filesys-Df) weakremover(perl-Filesys-Statvfs) weakremover(perl-Font-FreeType) weakremover(perl-FreezeThaw) weakremover(perl-Fuse) weakremover(perl-GD) weakremover(perl-GD-Graph3d) weakremover(perl-GStreamer1) weakremover(perl-Getopt-ArgvFile) weakremover(perl-Git) weakremover(perl-Glib) weakremover(perl-Glib-Object-Introspection) weakremover(perl-Gnome2) weakremover(perl-Gnome2-Canvas) weakremover(perl-Gnome2-GConf) weakremover(perl-Gnome2-VFS) weakremover(perl-Gnome2-Wnck) weakremover(perl-Goo-Canvas) weakremover(perl-GraphicsMagick) weakremover(perl-Gtk2) weakremover(perl-Gtk2-AppIndicator) weakremover(perl-Gtk2-ImageView) weakremover(perl-Gtk2-Unique) weakremover(perl-Guard) weakremover(perl-HTML-Encoding) weakremover(perl-HTML-Parser) weakremover(perl-HTML-Tidy) weakremover(perl-HTTP-Parser-XS) weakremover(perl-HTTPS-Daemon) weakremover(perl-Hamlib) weakremover(perl-IO-Digest) weakremover(perl-IO-Interface) weakremover(perl-IO-Socket-IP) weakremover(perl-IO-Socket-Multicast) weakremover(perl-IO-String) weakremover(perl-IO-Tty) weakremover(perl-IPC-ShareLite) weakremover(perl-Image-Sane) weakremover(perl-Inline-Python) weakremover(perl-JSON-DWIW) weakremover(perl-JSON-Parse) weakremover(perl-JSON-XS) weakremover(perl-JavaScript-Minifier-XS) weakremover(perl-Lexical-SealRequireHints) weakremover(perl-Libssh-Session) weakremover(perl-Lingua-EN-Tagger) weakremover(perl-Lingua-Stem-Snowball) weakremover(perl-Linux-Inotify2) weakremover(perl-Linux-Pid) weakremover(perl-List-BinarySearch-XS) weakremover(perl-List-MoreUtils-XS) weakremover(perl-List-SomeUtils-XS) weakremover(perl-LockFile-Simple) weakremover(perl-MLDBM-Sync) weakremover(perl-Mail-SPF_XS) weakremover(perl-Mail-SpamAssassin-Plugin-dqs) weakremover(perl-Makefile-DOM) weakremover(perl-Math-BigInt-GMP) weakremover(perl-Math-Calc-Units) weakremover(perl-Math-Clipper) weakremover(perl-Math-ConvexHull-MonotoneChain) weakremover(perl-Math-Geometry-Voronoi) weakremover(perl-Math-Int64) weakremover(perl-Math-Libm) weakremover(perl-Math-PlanePath) weakremover(perl-Mcrypt) weakremover(perl-Module-Build-XSUtil) weakremover(perl-Module-ScanDeps) weakremover(perl-Mojolicious-Plugin-Bootstrap3) weakremover(perl-Moose) weakremover(perl-MooseX-Role-WithOverloading) weakremover(perl-MooseX-Types-Parameterizable) weakremover(perl-Mouse) weakremover(perl-Mozilla-LDAP) weakremover(perl-MusicBrainz-DiscID) weakremover(perl-NKF) weakremover(perl-Nagios-Plugin) weakremover(perl-Net-AMQP-RabbitMQ) weakremover(perl-Net-DBus) weakremover(perl-Net-IDN-Encode) weakremover(perl-Net-IPv4Addr) weakremover(perl-Net-Jabber) weakremover(perl-Net-LibIDN) weakremover(perl-Net-LibIDN2) weakremover(perl-Net-Libproxy) weakremover(perl-Net-Oping) weakremover(perl-Net-Patricia) weakremover(perl-Net-Pcap) weakremover(perl-Net-SSH2) weakremover(perl-Net-SSLeay) weakremover(perl-NetAddr-IP) weakremover(perl-NetxAP) weakremover(perl-OSSP-uuid) weakremover(perl-OpenGL) weakremover(perl-PAR-Packer) weakremover(perl-PCP-LogImport) weakremover(perl-PCP-LogSummary) weakremover(perl-PCP-MMV) weakremover(perl-PCP-PMDA) weakremover(perl-PDA-Pilot) weakremover(perl-Package-Stash-XS) weakremover(perl-PadWalker) weakremover(perl-Pango) weakremover(perl-Params-Classify) weakremover(perl-Params-Util) weakremover(perl-Params-Validate) weakremover(perl-Parse-CPAN-Meta) weakremover(perl-Parse-RecDescent) weakremover(perl-Passwd-Keyring-Gnome) weakremover(perl-PathTools) weakremover(perl-Perl-Critic-Pulp) weakremover(perl-PerlIO-Layers) weakremover(perl-PerlIO-eol) weakremover(perl-PerlIO-gzip) weakremover(perl-PerlIO-locale) weakremover(perl-PerlIO-utf8_strict) weakremover(perl-PerlMagick) weakremover(perl-PkgConfig) weakremover(perl-PlRPC) weakremover(perl-Pod-HtmlPsPdf) weakremover(perl-Prima) weakremover(perl-Proc-ProcessTable) weakremover(perl-RPM-Header-PurePerl) weakremover(perl-RPM2) weakremover(perl-Readonly-XS) weakremover(perl-Ref-Util-XS) weakremover(perl-Regexp-Shellish) weakremover(perl-SDL) weakremover(perl-SGML-Parser-OpenSP) weakremover(perl-SGMLS) weakremover(perl-SNMP) weakremover(perl-SVN-Simple) weakremover(perl-Scalar-List-Utils) weakremover(perl-Scalar-String) weakremover(perl-Scope-Upper) weakremover(perl-Search-Xapian) weakremover(perl-Selenium-Remote-Driver) weakremover(perl-Sereal-Decoder) weakremover(perl-Sereal-Encoder) weakremover(perl-Session-Token) weakremover(perl-Set-Crontab) weakremover(perl-Set-Object) weakremover(perl-Socket-MsgHdr) weakremover(perl-Socket6) weakremover(perl-Sort-Key) weakremover(perl-Spooky-Patterns-XS) weakremover(perl-Statistics-CaseResampling) weakremover(perl-String-Approx) weakremover(perl-String-CRC32) weakremover(perl-Sub-Identify) weakremover(perl-Sub-Name) weakremover(perl-Symbol-Table) weakremover(perl-Syntax-Keyword-Try) weakremover(perl-Sys-CPU) weakremover(perl-Sys-Guestfs) weakremover(perl-Sys-LoadAvg) weakremover(perl-Sys-MemInfo) weakremover(perl-Sys-Virt) weakremover(perl-SystemPerl) weakremover(perl-SystemPerl-devel) weakremover(perl-Template-Toolkit) weakremover(perl-Term-ReadKey) weakremover(perl-Term-ReadLine-Gnu) weakremover(perl-Term-ReadPassword) weakremover(perl-Term-Terminfo) weakremover(perl-TermReadLine-Gnu) weakremover(perl-Test-CChecker) weakremover(perl-Test-File) weakremover(perl-Test-Harness) weakremover(perl-Test-LeakTrace) weakremover(perl-Test-Taint) weakremover(perl-Test-Unit) weakremover(perl-Text-ASCIITable) weakremover(perl-Text-Aspell) weakremover(perl-Text-BibTeX) weakremover(perl-Text-BibTeX-devel) weakremover(perl-Text-CSV_XS) weakremover(perl-Text-ChaSen) weakremover(perl-Text-CharWidth) weakremover(perl-Text-DelimMatch) weakremover(perl-Text-Hunspell) weakremover(perl-Text-Iconv) weakremover(perl-Text-Kakasi) weakremover(perl-Text-Soundex) weakremover(perl-Time-Moment) weakremover(perl-Time-modules) weakremover(perl-Tk) weakremover(perl-Tk-TableMatrix) weakremover(perl-Tk-devel) weakremover(perl-TryCatch) weakremover(perl-UNIVERSAL-ref) weakremover(perl-UUID) weakremover(perl-Unicode-Collate) weakremover(perl-Unicode-LineBreak) weakremover(perl-Unicode-Map) weakremover(perl-Unicode-Map8) weakremover(perl-Unicode-Normalize) weakremover(perl-Unicode-String) weakremover(perl-Unix-Syslog) weakremover(perl-Variable-Magic) weakremover(perl-Verilog-Perl) weakremover(perl-WWW-Curl) weakremover(perl-WWW-Form-UrlEncoded) weakremover(perl-Want) weakremover(perl-WeakRef) weakremover(perl-Win-Hivex) weakremover(perl-Wx) weakremover(perl-X11-Protocol-Other) weakremover(perl-X500-DN) weakremover(perl-XML-Bare) weakremover(perl-XML-Dumper) weakremover(perl-XML-Entities) weakremover(perl-XML-LibXML) weakremover(perl-XML-LibXSLT) weakremover(perl-XML-NodeFilter) weakremover(perl-XML-Parser) weakremover(perl-XML-SAX-ExpatXS) weakremover(perl-XML-Structured) weakremover(perl-XML-Writer-String) weakremover(perl-XS-Parse-Keyword) weakremover(perl-XSLoader) weakremover(perl-XString) weakremover(perl-YAML-LibYAML) weakremover(perl-YAML-LibYAML-API) weakremover(perl-YAML-Perl) weakremover(perl-YAML-Syck) weakremover(perl-apparmor) weakremover(perl-autobox) weakremover(perl-autovivification) weakremover(perl-bareword-filehandles) weakremover(perl-base) weakremover(perl-camgm) weakremover(perl-checkbot) weakremover(perl-clinkgrammar) weakremover(perl-common-sense) weakremover(perl-forks) weakremover(perl-gdal) weakremover(perl-genders) weakremover(perl-getdata) weakremover(perl-gettext) weakremover(perl-indirect) weakremover(perl-libconfigfile) weakremover(perl-libintl-perl) weakremover(perl-libprelude) weakremover(perl-libxml-perl) weakremover(perl-mapscript) weakremover(perl-marisa) weakremover(perl-multidimensional) weakremover(perl-obexftp) weakremover(perl-pcsc) weakremover(perl-qpid) weakremover(perl-qpid-proton) weakremover(perl-qt4) weakremover(perl-qt4-devel) weakremover(perl-razor-agents) weakremover(perl-rrdtool) weakremover(perl-slurm) weakremover(perl-solv) weakremover(perl-thrift) weakremover(perl-version) weakremover(perl-xfconf) weakremover(perl-xrood-client-admin) weakremover(perl-yui) weakremover(perl-zypp) weakremover(permissions) weakremover(perseus-sdr-tools) weakremover(pesign) weakremover(pesign-obs-integration) weakremover(petsc-devel) weakremover(petsc-doc) weakremover(petsc-gnu-mpich-hpc-devel) weakremover(petsc-gnu-mvapich2-hpc-devel) weakremover(petsc-gnu-openmpi1-hpc-devel) weakremover(petsc-gnu-openmpi2-hpc-devel) weakremover(petsc-gnu-openmpi3-hpc-devel) weakremover(petsc-gnu-openmpi4-hpc-devel) weakremover(petsc-openmpi-devel) weakremover(petsc-openmpi1-devel) weakremover(petsc-openmpi2-devel) weakremover(petsc-openmpi3-devel) weakremover(petsc-openmpi4-devel) weakremover(petsc_3_11_3-gnu-mpich-hpc-devel) weakremover(petsc_3_11_3-gnu-mpich-hpc-saws) weakremover(petsc_3_11_3-gnu-mvapich2-hpc-devel) weakremover(petsc_3_11_3-gnu-mvapich2-hpc-saws) weakremover(petsc_3_11_3-gnu-openmpi1-hpc-devel) weakremover(petsc_3_11_3-gnu-openmpi1-hpc-saws) weakremover(petsc_3_11_3-gnu-openmpi2-hpc-devel) weakremover(petsc_3_11_3-gnu-openmpi2-hpc-saws) weakremover(petsc_3_11_3-gnu-openmpi3-hpc-devel) weakremover(petsc_3_11_3-gnu-openmpi3-hpc-saws) weakremover(petsc_3_12_2-gnu-mpich-hpc-devel) weakremover(petsc_3_12_2-gnu-mpich-hpc-saws) weakremover(petsc_3_12_2-gnu-mvapich2-hpc-devel) weakremover(petsc_3_12_2-gnu-mvapich2-hpc-saws) weakremover(petsc_3_12_2-gnu-openmpi1-hpc-devel) weakremover(petsc_3_12_2-gnu-openmpi1-hpc-saws) weakremover(petsc_3_12_2-gnu-openmpi2-hpc-devel) weakremover(petsc_3_12_2-gnu-openmpi2-hpc-saws) weakremover(petsc_3_12_2-gnu-openmpi3-hpc-devel) weakremover(petsc_3_12_2-gnu-openmpi3-hpc-saws) weakremover(petsc_3_14_1-gnu-mpich-hpc-devel) weakremover(petsc_3_14_1-gnu-mpich-hpc-saws) weakremover(petsc_3_14_1-gnu-mvapich2-hpc-devel) weakremover(petsc_3_14_1-gnu-mvapich2-hpc-saws) weakremover(petsc_3_14_1-gnu-openmpi1-hpc-devel) weakremover(petsc_3_14_1-gnu-openmpi1-hpc-saws) weakremover(petsc_3_14_1-gnu-openmpi2-hpc-devel) weakremover(petsc_3_14_1-gnu-openmpi2-hpc-saws) weakremover(petsc_3_14_1-gnu-openmpi3-hpc-devel) weakremover(petsc_3_14_1-gnu-openmpi3-hpc-saws) weakremover(petsc_3_14_1-gnu-openmpi4-hpc-devel) weakremover(petsc_3_14_1-gnu-openmpi4-hpc-saws) weakremover(petsc_3_14_4-gnu-mpich-hpc-devel) weakremover(petsc_3_14_4-gnu-mpich-hpc-saws) weakremover(petsc_3_14_4-gnu-mvapich2-hpc-devel) weakremover(petsc_3_14_4-gnu-mvapich2-hpc-saws) weakremover(petsc_3_14_4-gnu-openmpi1-hpc-devel) weakremover(petsc_3_14_4-gnu-openmpi1-hpc-saws) weakremover(petsc_3_14_4-gnu-openmpi2-hpc-devel) weakremover(petsc_3_14_4-gnu-openmpi2-hpc-saws) weakremover(petsc_3_14_4-gnu-openmpi3-hpc-devel) weakremover(petsc_3_14_4-gnu-openmpi3-hpc-saws) weakremover(petsc_3_14_4-gnu-openmpi4-hpc-devel) weakremover(petsc_3_14_4-gnu-openmpi4-hpc-saws) weakremover(petsc_3_14_5-gnu-mpich-hpc-devel) weakremover(petsc_3_14_5-gnu-mpich-hpc-saws) weakremover(petsc_3_14_5-gnu-mvapich2-hpc-devel) weakremover(petsc_3_14_5-gnu-mvapich2-hpc-saws) weakremover(petsc_3_14_5-gnu-openmpi1-hpc-devel) weakremover(petsc_3_14_5-gnu-openmpi1-hpc-saws) weakremover(petsc_3_14_5-gnu-openmpi2-hpc-devel) weakremover(petsc_3_14_5-gnu-openmpi2-hpc-saws) weakremover(petsc_3_14_5-gnu-openmpi3-hpc-devel) weakremover(petsc_3_14_5-gnu-openmpi3-hpc-saws) weakremover(petsc_3_14_5-gnu-openmpi4-hpc-devel) weakremover(petsc_3_14_5-gnu-openmpi4-hpc-saws) weakremover(petsc_3_18_4-gnu-mpich-hpc-devel) weakremover(petsc_3_18_4-gnu-mpich-hpc-saws) weakremover(petsc_3_18_4-gnu-mvapich2-hpc-devel) weakremover(petsc_3_18_4-gnu-mvapich2-hpc-saws) weakremover(petsc_3_18_4-gnu-openmpi1-hpc-devel) weakremover(petsc_3_18_4-gnu-openmpi1-hpc-saws) weakremover(petsc_3_18_4-gnu-openmpi2-hpc-devel) weakremover(petsc_3_18_4-gnu-openmpi2-hpc-saws) weakremover(petsc_3_18_4-gnu-openmpi3-hpc-devel) weakremover(petsc_3_18_4-gnu-openmpi3-hpc-saws) weakremover(petsc_3_18_4-gnu-openmpi4-hpc-devel) weakremover(petsc_3_18_4-gnu-openmpi4-hpc-saws) weakremover(petsc_3_18_5-gnu-mpich-hpc-devel) weakremover(petsc_3_18_5-gnu-mpich-hpc-saws) weakremover(petsc_3_18_5-gnu-mvapich2-hpc-devel) weakremover(petsc_3_18_5-gnu-mvapich2-hpc-saws) weakremover(petsc_3_18_5-gnu-openmpi1-hpc-devel) weakremover(petsc_3_18_5-gnu-openmpi1-hpc-saws) weakremover(petsc_3_18_5-gnu-openmpi2-hpc-devel) weakremover(petsc_3_18_5-gnu-openmpi2-hpc-saws) weakremover(petsc_3_18_5-gnu-openmpi3-hpc-devel) weakremover(petsc_3_18_5-gnu-openmpi3-hpc-saws) weakremover(petsc_3_18_5-gnu-openmpi4-hpc-devel) weakremover(petsc_3_18_5-gnu-openmpi4-hpc-saws) weakremover(petsc_3_8_3-gnu-mpich-hpc-devel) weakremover(petsc_3_8_3-gnu-mpich-hpc-saws) weakremover(petsc_3_8_3-gnu-mvapich2-hpc-devel) weakremover(petsc_3_8_3-gnu-mvapich2-hpc-saws) weakremover(petsc_3_8_3-gnu-openmpi1-hpc-devel) weakremover(petsc_3_8_3-gnu-openmpi1-hpc-saws) weakremover(petsc_3_8_3-gnu-openmpi2-hpc-devel) weakremover(petsc_3_8_3-gnu-openmpi2-hpc-saws) weakremover(petsc_3_8_3-gnu-openmpi3-hpc-devel) weakremover(petsc_3_8_3-gnu-openmpi3-hpc-saws) weakremover(pfsalign) weakremover(pfscalibration) weakremover(pfscalign) weakremover(pfsglview) weakremover(pfstmo) weakremover(pfstools) weakremover(pfstools-devel) weakremover(pfstools-exr) weakremover(pfstools-imgmagick) weakremover(pfstools-octave) weakremover(pfsview) weakremover(pg_comparator) weakremover(pgadmin3) weakremover(pgadmin3-lang) weakremover(pgadmin4) weakremover(pgbackrest) weakremover(pgloader) weakremover(pgn-extract) weakremover(phalanx) weakremover(phantomjs) weakremover(phd2) weakremover(phd2-lang) weakremover(phodav-devel) weakremover(phonon-backend-gstreamer) weakremover(phonon-backend-vlc) weakremover(phonon-devel) weakremover(phonon4qt5-backend-gstreamer) weakremover(phonon4qt5-backend-vlc) weakremover(phonon4qt5-devel) weakremover(phononsettings) weakremover(photoqt) weakremover(photorec) weakremover(php-doc) weakremover(php-libkolab0) weakremover(php-libkolab1) weakremover(php-libkolabxml1) weakremover(php-mapi) weakremover(php-mapscript) weakremover(php-mapscriptng) weakremover(php-xapian) weakremover(php5) weakremover(php5-bcmath) weakremover(php5-bz2) weakremover(php5-calendar) weakremover(php5-ctype) weakremover(php5-curl) weakremover(php5-dba) weakremover(php5-devel) weakremover(php5-dom) weakremover(php5-enchant) weakremover(php5-exif) weakremover(php5-fastcgi) weakremover(php5-fileinfo) weakremover(php5-firebird) weakremover(php5-fpm) weakremover(php5-ftp) weakremover(php5-gd) weakremover(php5-gettext) weakremover(php5-gmp) weakremover(php5-ice) weakremover(php5-iconv) weakremover(php5-imap) weakremover(php5-intl) weakremover(php5-json) weakremover(php5-ldap) weakremover(php5-mbstring) weakremover(php5-mcrypt) weakremover(php5-mssql) weakremover(php5-mysql) weakremover(php5-odbc) weakremover(php5-opcache) weakremover(php5-openssl) weakremover(php5-pcntl) weakremover(php5-pdo) weakremover(php5-pear) weakremover(php5-pear-Crypt_Blowfish) weakremover(php5-pear-DB) weakremover(php5-pear-DB_DataObject) weakremover(php5-pear-DB_DataObject_FormBuilder) weakremover(php5-pear-Date) weakremover(php5-pear-Date_Holidays) weakremover(php5-pear-Date_Holidays_Austria) weakremover(php5-pear-Date_Holidays_Brazil) weakremover(php5-pear-Date_Holidays_Croatia) weakremover(php5-pear-Date_Holidays_Denmark) weakremover(php5-pear-Date_Holidays_EnglandWales) weakremover(php5-pear-Date_Holidays_Finland) weakremover(php5-pear-Date_Holidays_Germany) weakremover(php5-pear-Date_Holidays_Iceland) weakremover(php5-pear-Date_Holidays_Ireland) weakremover(php5-pear-Date_Holidays_Italy) weakremover(php5-pear-Date_Holidays_Japan) weakremover(php5-pear-Date_Holidays_Netherlands) weakremover(php5-pear-Date_Holidays_Norway) weakremover(php5-pear-Date_Holidays_Portugal) weakremover(php5-pear-Date_Holidays_Romania) weakremover(php5-pear-Date_Holidays_Spain) weakremover(php5-pear-Date_Holidays_Sweden) weakremover(php5-pear-File) weakremover(php5-pear-File_IMC) weakremover(php5-pear-HTML_Common) weakremover(php5-pear-HTML_QuickForm) weakremover(php5-pear-HTTP_Request) weakremover(php5-pear-HTTP_Request2) weakremover(php5-pear-HTTP_WebDAV_Server) weakremover(php5-pear-Log) weakremover(php5-pear-MDB2) weakremover(php5-pear-MDB2_Driver_mysql) weakremover(php5-pear-MDB2_Driver_mysqli) weakremover(php5-pear-MDB2_Driver_pgsql) weakremover(php5-pear-Mail) weakremover(php5-pear-Mail_mimeDecode) weakremover(php5-pear-Net_DIME) weakremover(php5-pear-Net_IMAP) weakremover(php5-pear-Net_LDAP) weakremover(php5-pear-Net_URL) weakremover(php5-pear-Net_URL2) weakremover(php5-pear-SOAP) weakremover(php5-pear-Services_Weather) weakremover(php5-pear-Text_CAPTCHA) weakremover(php5-pear-Text_Figlet) weakremover(php5-pear-Text_Password) weakremover(php5-pear-Text_Wiki) weakremover(php5-pear-XML_SVG) weakremover(php5-pear-XML_Serializer) weakremover(php5-pear-cache_lite) weakremover(php5-pear-channel-ezno) weakremover(php5-pear-channel-horde) weakremover(php5-pear-channel-phpunit) weakremover(php5-pear-channel-symfony) weakremover(php5-pear-channel-symfony2) weakremover(php5-pear-ezc-Base) weakremover(php5-pear-ezc-ConsoleTools) weakremover(php5-pear-ezc-Graph) weakremover(php5-pear-phpunit-DbUnit) weakremover(php5-pear-phpunit-File_Iterator) weakremover(php5-pear-phpunit-Object_Freezer) weakremover(php5-pear-phpunit-PHPUnit_MockObject) weakremover(php5-pear-phpunit-PHP_CodeBrowser) weakremover(php5-pear-phpunit-PHP_CodeCoverage) weakremover(php5-pear-phpunit-PHP_Timer) weakremover(php5-pear-phpunit-PHP_TokenStream) weakremover(php5-pear-phpunit-Text_Template) weakremover(php5-pear-phpunit-bytekit) weakremover(php5-pear-symfony-YAML) weakremover(php5-pear-symfony2-Console) weakremover(php5-pear-symfony2-Finder) weakremover(php5-pear-symfony2-Yaml) weakremover(php5-pgsql) weakremover(php5-phalcon) weakremover(php5-phar) weakremover(php5-posix) weakremover(php5-pspell) weakremover(php5-readline) weakremover(php5-redland) weakremover(php5-shmop) weakremover(php5-smarty3) weakremover(php5-smarty3-doc) weakremover(php5-snmp) weakremover(php5-soap) weakremover(php5-sockets) weakremover(php5-sqlite) weakremover(php5-suhosin) weakremover(php5-sysvmsg) weakremover(php5-sysvsem) weakremover(php5-sysvshm) weakremover(php5-tidy) weakremover(php5-tn3270) weakremover(php5-tokenizer) weakremover(php5-wddx) weakremover(php5-xmlreader) weakremover(php5-xmlrpc) weakremover(php5-xmlwriter) weakremover(php5-xsl) weakremover(php5-zip) weakremover(php5-zlib) weakremover(php7) weakremover(php7-APCu) weakremover(php7-bcmath) weakremover(php7-bz2) weakremover(php7-calendar) weakremover(php7-cli) weakremover(php7-ctype) weakremover(php7-curl) weakremover(php7-dba) weakremover(php7-devel) weakremover(php7-dom) weakremover(php7-embed) weakremover(php7-enchant) weakremover(php7-exif) weakremover(php7-fastcgi) weakremover(php7-fileinfo) weakremover(php7-firebird) weakremover(php7-fpm) weakremover(php7-ftp) weakremover(php7-gd) weakremover(php7-geoip) weakremover(php7-gettext) weakremover(php7-gmagick) weakremover(php7-gmp) weakremover(php7-ice) weakremover(php7-iconv) weakremover(php7-imagick) weakremover(php7-imap) weakremover(php7-intl) weakremover(php7-json) weakremover(php7-ldap) weakremover(php7-lzf) weakremover(php7-maxminddb) weakremover(php7-mbstring) weakremover(php7-mcrypt) weakremover(php7-memcache) weakremover(php7-memcached) weakremover(php7-mysql) weakremover(php7-odbc) weakremover(php7-opcache) weakremover(php7-openssl) weakremover(php7-pcntl) weakremover(php7-pdo) weakremover(php7-pear) weakremover(php7-pear-Archive_Tar) weakremover(php7-pear-Auth_SASL) weakremover(php7-pear-MDB2) weakremover(php7-pear-MDB2_Driver_mysqli) weakremover(php7-pear-Net_IDNA2) weakremover(php7-pear-Net_LDAP2) weakremover(php7-pear-Net_Socket) weakremover(php7-pecl) weakremover(php7-pgsql) weakremover(php7-phalcon) weakremover(php7-phar) weakremover(php7-posix) weakremover(php7-pspell) weakremover(php7-psr) weakremover(php7-readline) weakremover(php7-redis) weakremover(php7-shmop) weakremover(php7-smbclient) weakremover(php7-snmp) weakremover(php7-soap) weakremover(php7-sockets) weakremover(php7-sodium) weakremover(php7-sqlite) weakremover(php7-sysvmsg) weakremover(php7-sysvsem) weakremover(php7-sysvshm) weakremover(php7-test) weakremover(php7-testresults) weakremover(php7-tidy) weakremover(php7-tokenizer) weakremover(php7-uuid) weakremover(php7-wddx) weakremover(php7-xdebug) weakremover(php7-xmlreader) weakremover(php7-xmlrpc) weakremover(php7-xmlwriter) weakremover(php7-xsl) weakremover(php7-zip) weakremover(php7-zlib) weakremover(php8) weakremover(php8-APCu) weakremover(php8-bcmath) weakremover(php8-bz2) weakremover(php8-calendar) weakremover(php8-cli) weakremover(php8-ctype) weakremover(php8-curl) weakremover(php8-dba) weakremover(php8-devel) weakremover(php8-dom) weakremover(php8-embed) weakremover(php8-enchant) weakremover(php8-exif) weakremover(php8-fastcgi) weakremover(php8-ffi) weakremover(php8-fileinfo) weakremover(php8-fpm) weakremover(php8-ftp) weakremover(php8-gd) weakremover(php8-gettext) weakremover(php8-gmagick) weakremover(php8-gmp) weakremover(php8-ice) weakremover(php8-iconv) weakremover(php8-imagick) weakremover(php8-intl) weakremover(php8-ldap) weakremover(php8-lzf) weakremover(php8-maxminddb) weakremover(php8-mbstring) weakremover(php8-memcache) weakremover(php8-memcached) weakremover(php8-mysql) weakremover(php8-odbc) weakremover(php8-opcache) weakremover(php8-openssl) weakremover(php8-pcntl) weakremover(php8-pdo) weakremover(php8-pgsql) weakremover(php8-phalcon) weakremover(php8-phar) weakremover(php8-posix) weakremover(php8-psr) weakremover(php8-readline) weakremover(php8-redis) weakremover(php8-shmop) weakremover(php8-smbclient) weakremover(php8-snmp) weakremover(php8-soap) weakremover(php8-sockets) weakremover(php8-sodium) weakremover(php8-sqlite) weakremover(php8-ssh2) weakremover(php8-sysvmsg) weakremover(php8-sysvsem) weakremover(php8-sysvshm) weakremover(php8-test) weakremover(php8-tidy) weakremover(php8-tokenizer) weakremover(php8-uuid) weakremover(php8-xdebug) weakremover(php8-xmlreader) weakremover(php8-xmlwriter) weakremover(php8-xsl) weakremover(php8-zip) weakremover(php8-zlib) weakremover(physlock) weakremover(pia) weakremover(pianobar) weakremover(picard) weakremover(picmi) weakremover(pico) weakremover(picocom) weakremover(picojson-devel) weakremover(picom) weakremover(picotool) weakremover(picplanner) weakremover(pidentd) weakremover(pidgin) weakremover(pidgin-advanced-sound-notification-lang) weakremover(pidgin-birthday-reminder-lang) weakremover(pidgin-devel) weakremover(pidgin-guifications-lang) weakremover(pidgin-indicator) weakremover(pidgin-indicator-lang) weakremover(pidgin-openfetion) weakremover(pidgin-otr) weakremover(pidgin-plugin-advanced-sound-notification) weakremover(pidgin-plugin-birthday-reminder) weakremover(pidgin-plugin-embeddedvideo) weakremover(pidgin-plugin-guifications) weakremover(pidgin-plugin-indicator) weakremover(pidgin-plugin-libnotify) weakremover(pidgin-plugin-mrim) weakremover(pidgin-plugin-openfetion) weakremover(pidgin-plugin-otr) weakremover(pidgin-plugin-pack) weakremover(pidgin-plugin-pack-extras) weakremover(pidgin-plugin-privacy-please) weakremover(pidgin-plugin-prpltwtr) weakremover(pidgin-plugin-skype) weakremover(pidgin-plugin-skypeweb) weakremover(pidgin-plugin-xmpp-receipts) weakremover(piglit) weakremover(pigz) weakremover(pihwm) weakremover(pihwm-devel) weakremover(pijul) weakremover(pijul-bash-completion) weakremover(pijul-fish-completion) weakremover(pijul-zsh-completion) weakremover(pilot) weakremover(pilot-link) weakremover(pim-data-exporter) weakremover(pim-sieve-editor) weakremover(pimcommon) weakremover(pimcommon-devel) weakremover(pinentry) weakremover(pinentry-efl) weakremover(pinentry-emacs) weakremover(pinentry-fltk) weakremover(pinentry-gnome3) weakremover(pinentry-gtk2) weakremover(pinentry-qt4) weakremover(pinentry-qt5) weakremover(pinfo) weakremover(pingtunnel) weakremover(pingus) weakremover(pink-pony) weakremover(pinpoint) weakremover(pipenightdreams) weakremover(pipewire) weakremover(pipewire-alsa) weakremover(pipewire-devel) weakremover(pipewire-doc) weakremover(pipewire-libjack-0_3) weakremover(pipewire-libjack-0_3-devel) weakremover(pipewire-libpulse-0_3) weakremover(pipewire-media-session) weakremover(pipewire-media-session-lang) weakremover(pipewire-module-x11-0_3) weakremover(pipewire-modules) weakremover(pipewire-modules-0_3) weakremover(pipewire-pulseaudio) weakremover(pipewire-spa-plugins) weakremover(pipewire-spa-plugins-0_2) weakremover(pipewire-spa-tools) weakremover(pipewire-tools) weakremover(pipewire0_2-compat) weakremover(pitivi) weakremover(pix) weakremover(pix-devel) weakremover(pixd) weakremover(pixmap) weakremover(pixz) weakremover(pk-update-icon) weakremover(pk-update-icon-lang) weakremover(pkTriggerCord) weakremover(pkcs11-helper) weakremover(pkcs11-helper-devel) weakremover(pkexec) weakremover(pkg-config) weakremover(pkgconf) weakremover(pkgconf-pkg-config) weakremover(pkipplib) weakremover(plank) weakremover(plank-devel) weakremover(plank-docklets) weakremover(plank-theme-plata) weakremover(planner) weakremover(planner-devel) weakremover(planner-lang) weakremover(plantri) weakremover(plasma-applet-weather-widget) weakremover(plasma-browser-integration) weakremover(plasma-framework) weakremover(plasma-framework-components) weakremover(plasma-framework-devel) weakremover(plasma-framework-private) weakremover(plasma-mycroft) weakremover(plasma-nm5) weakremover(plasma-nm5-fortisslvpn) weakremover(plasma-nm5-iodine) weakremover(plasma-nm5-l2tp) weakremover(plasma-nm5-libreswan) weakremover(plasma-nm5-mobile) weakremover(plasma-nm5-openconnect) weakremover(plasma-nm5-openswan) weakremover(plasma-nm5-openvpn) weakremover(plasma-nm5-pptp) weakremover(plasma-nm5-ssh) weakremover(plasma-nm5-sstp) weakremover(plasma-nm5-strongswan) weakremover(plasma-nm5-vpnc) weakremover(plasma-nm5-wireguard) weakremover(plasma-pass) weakremover(plasma-theme-oxygen) weakremover(plasma-vault) weakremover(plasma-vault-backend-cryfs) weakremover(plasma-vault-backend-encfs) weakremover(plasma-wayland-protocols) weakremover(plasma5-addons) weakremover(plasma5-addons-devel) weakremover(plasma5-bigscreen) weakremover(plasma5-desktop) weakremover(plasma5-desktop-emojier) weakremover(plasma5-disks) weakremover(plasma5-firewall) weakremover(plasma5-integration-devel) weakremover(plasma5-integration-plugin) weakremover(plasma5-mediacenter) weakremover(plasma5-mobile) weakremover(plasma5-nano) weakremover(plasma5-openSUSE) weakremover(plasma5-pa) weakremover(plasma5-phone-components) weakremover(plasma5-phone-components-lang) weakremover(plasma5-pk-updates) weakremover(plasma5-sdk) weakremover(plasma5-session-wayland) weakremover(plasma5-systemmonitor) weakremover(plasma5-thunderbolt) weakremover(plasma5-welcome) weakremover(plasma5-workspace) weakremover(plasma5-workspace-devel) weakremover(plasma5-workspace-libs) weakremover(plasmaengineexplorer5) weakremover(plasmatube) weakremover(plasmoid-active-window-control) weakremover(playerctl) weakremover(playerctl-devel) weakremover(pleaser) weakremover(plee-the-bear) weakremover(plexus-containers-component-javadoc) weakremover(plib-devel) weakremover(plistutil) weakremover(plotutils) weakremover(plotutils-devel) weakremover(plplay) weakremover(plplot-common) weakremover(plplot-devel) weakremover(plplot-doc) weakremover(plplot-driver-cairo) weakremover(plplot-driver-ntk) weakremover(plplot-driver-ps) weakremover(plplot-driver-psttf) weakremover(plplot-driver-svg) weakremover(plplot-driver-xfig) weakremover(plplot-driver-xwin) weakremover(plplot-java) weakremover(plplot-lua) weakremover(plplot-octave) weakremover(plplot-python3-qt) weakremover(plplot-tcltk-devel) weakremover(plplot-tcltk-libs) weakremover(plplot-wxwidgets) weakremover(plplotada-devel) weakremover(plplotcxx-devel) weakremover(plplotfortran-devel) weakremover(plplotqt-devel) weakremover(plplotwxwidgets-devel) weakremover(pluma) weakremover(pluma-devel) weakremover(pluto) weakremover(plymouth) weakremover(plymouth-devel) weakremover(plymouth-plugin-fade-throbber) weakremover(plymouth-plugin-label) weakremover(plymouth-plugin-label-ft) weakremover(plymouth-plugin-script) weakremover(plymouth-plugin-space-flares) weakremover(plymouth-plugin-throbgress) weakremover(plymouth-plugin-tribar) weakremover(plymouth-plugin-two-step) weakremover(plymouth-theme-breeze) weakremover(plymouth-theme-breeze-plugin-breeze) weakremover(plymouth-x11-renderer) weakremover(plzip) weakremover(pmacct) weakremover(pmccabe) weakremover(pmdk) weakremover(pmdk-devel-doc) weakremover(pmdk-tools) weakremover(pmemkv-devel) weakremover(pmemkv-python) weakremover(pmidi) weakremover(pmix) weakremover(pmix-devel) weakremover(pmix-plugin-munge) weakremover(pmix-pluginlib) weakremover(pmix-plugins) weakremover(pmix-test) weakremover(pnetcdf-mpich) weakremover(pnetcdf-mpich-devel) weakremover(pnetcdf-mpich-devel-static) weakremover(pnetcdf-mvapich2) weakremover(pnetcdf-mvapich2-devel) weakremover(pnetcdf-mvapich2-devel-static) weakremover(pnetcdf-openmpi1) weakremover(pnetcdf-openmpi1-devel) weakremover(pnetcdf-openmpi1-devel-static) weakremover(pnetcdf-openmpi2) weakremover(pnetcdf-openmpi2-devel) weakremover(pnetcdf-openmpi2-devel-static) weakremover(pnetcdf-openmpi3) weakremover(pnetcdf-openmpi3-devel) weakremover(pnetcdf-openmpi3-devel-static) weakremover(pnetcdf-openmpi4) weakremover(pnetcdf-openmpi4-devel) weakremover(pnetcdf-openmpi4-devel-static) weakremover(pnetcdf_1_12_1-gnu-mpich-hpc) weakremover(pnetcdf_1_12_1-gnu-mpich-hpc-devel) weakremover(pnetcdf_1_12_1-gnu-mpich-hpc-devel-static) weakremover(pnetcdf_1_12_1-gnu-mvapich2-hpc) weakremover(pnetcdf_1_12_1-gnu-mvapich2-hpc-devel) weakremover(pnetcdf_1_12_1-gnu-mvapich2-hpc-devel-static) weakremover(pnetcdf_1_12_1-gnu-openmpi2-hpc) weakremover(pnetcdf_1_12_1-gnu-openmpi2-hpc-devel) weakremover(pnetcdf_1_12_1-gnu-openmpi2-hpc-devel-static) weakremover(pnetcdf_1_12_1-gnu-openmpi3-hpc) weakremover(pnetcdf_1_12_1-gnu-openmpi3-hpc-devel) weakremover(pnetcdf_1_12_1-gnu-openmpi3-hpc-devel-static) weakremover(pnetcdf_1_12_1-gnu-openmpi4-hpc) weakremover(pnetcdf_1_12_1-gnu-openmpi4-hpc-devel) weakremover(pnetcdf_1_12_1-gnu-openmpi4-hpc-devel-static) weakremover(pnetcdf_1_12_1-hpc-doc) weakremover(pnetcdf_1_12_2-gnu-mpich-hpc) weakremover(pnetcdf_1_12_2-gnu-mpich-hpc-devel) weakremover(pnetcdf_1_12_2-gnu-mpich-hpc-devel-static) weakremover(pnetcdf_1_12_2-gnu-mvapich2-hpc) weakremover(pnetcdf_1_12_2-gnu-mvapich2-hpc-devel) weakremover(pnetcdf_1_12_2-gnu-mvapich2-hpc-devel-static) weakremover(pnetcdf_1_12_2-gnu-openmpi2-hpc) weakremover(pnetcdf_1_12_2-gnu-openmpi2-hpc-devel) weakremover(pnetcdf_1_12_2-gnu-openmpi2-hpc-devel-static) weakremover(pnetcdf_1_12_2-gnu-openmpi3-hpc) weakremover(pnetcdf_1_12_2-gnu-openmpi3-hpc-devel) weakremover(pnetcdf_1_12_2-gnu-openmpi3-hpc-devel-static) weakremover(pnetcdf_1_12_2-gnu-openmpi4-hpc) weakremover(pnetcdf_1_12_2-gnu-openmpi4-hpc-devel) weakremover(pnetcdf_1_12_2-gnu-openmpi4-hpc-devel-static) weakremover(pnetcdf_1_12_2-hpc-doc) weakremover(pnetcdf_1_12_3-gnu-mpich-hpc) weakremover(pnetcdf_1_12_3-gnu-mpich-hpc-devel) weakremover(pnetcdf_1_12_3-gnu-mpich-hpc-devel-static) weakremover(pnetcdf_1_12_3-gnu-mvapich2-hpc) weakremover(pnetcdf_1_12_3-gnu-mvapich2-hpc-devel) weakremover(pnetcdf_1_12_3-gnu-mvapich2-hpc-devel-static) weakremover(pnetcdf_1_12_3-gnu-openmpi2-hpc) weakremover(pnetcdf_1_12_3-gnu-openmpi2-hpc-devel) weakremover(pnetcdf_1_12_3-gnu-openmpi2-hpc-devel-static) weakremover(pnetcdf_1_12_3-gnu-openmpi3-hpc) weakremover(pnetcdf_1_12_3-gnu-openmpi3-hpc-devel) weakremover(pnetcdf_1_12_3-gnu-openmpi3-hpc-devel-static) weakremover(pnetcdf_1_12_3-gnu-openmpi4-hpc) weakremover(pnetcdf_1_12_3-gnu-openmpi4-hpc-devel) weakremover(pnetcdf_1_12_3-gnu-openmpi4-hpc-devel-static) weakremover(pngcheck) weakremover(pngcrush) weakremover(pnglite-devel) weakremover(pngquant) weakremover(pngtoico) weakremover(pnm2ppa) weakremover(po-utils) weakremover(pocketsphinx) weakremover(pocketsphinx-devel) weakremover(pocketsphinx5) weakremover(pocketsphinx5-devel) weakremover(pocl) weakremover(pocl-devel) weakremover(poco-cpspc) weakremover(poco-devel) weakremover(podman) weakremover(podman-remote) weakremover(podofo) weakremover(poedit) weakremover(poezio) weakremover(pointfree) weakremover(pointful) weakremover(poke) weakremover(poke-devel) weakremover(polari) weakremover(polaris) weakremover(policycoreutils) weakremover(policycoreutils-devel) weakremover(policycoreutils-gui) weakremover(policycoreutils-newrole) weakremover(policycoreutils-sandbox) weakremover(polkit) weakremover(polkit-devel) weakremover(polkit-gnome) weakremover(polkit-kde-agent-1) weakremover(polkit-kde-agent-5) weakremover(polkit-whitelisting) weakremover(pology) weakremover(pology-lang) weakremover(polybar) weakremover(polylib) weakremover(polylib-devel) weakremover(polymake) weakremover(polymake-devel) weakremover(pongix) weakremover(ponysay) weakremover(popeye) weakremover(poppler-tools) weakremover(popt-devel) weakremover(portaudio-devel) weakremover(portmidi) weakremover(portmidi-devel) weakremover(portmidi-java) weakremover(posix_cc) weakremover(posixovl) weakremover(poster) weakremover(postfish) weakremover(postfix) weakremover(postfix-bdb) weakremover(postfix-bdb-lmdb) weakremover(postfix-ldap) weakremover(postfix-lmdb) weakremover(postfix-mysql) weakremover(postfix-postgresql) weakremover(postgresql10) weakremover(postgresql10-contrib) weakremover(postgresql10-devel) weakremover(postgresql10-docs) weakremover(postgresql10-llvmjit-devel) weakremover(postgresql10-pg_cron) weakremover(postgresql10-pgagent) weakremover(postgresql10-pgaudit) weakremover(postgresql10-pgsql-ogr-fdw) weakremover(postgresql10-plperl) weakremover(postgresql10-plpython) weakremover(postgresql10-plr) weakremover(postgresql10-plr-doc) weakremover(postgresql10-pltcl) weakremover(postgresql10-postgis) weakremover(postgresql10-postgis-utils) weakremover(postgresql10-server) weakremover(postgresql10-test) weakremover(postgresql10-timescaledb) weakremover(postgresql11) weakremover(postgresql11-contrib) weakremover(postgresql11-devel) weakremover(postgresql11-llvmjit) weakremover(postgresql11-llvmjit-devel) weakremover(postgresql11-orafce) weakremover(postgresql11-pg_cron) weakremover(postgresql11-pg_cron-llvmjit) weakremover(postgresql11-pgagent) weakremover(postgresql11-pgaudit) weakremover(postgresql11-pgaudit-llvmjit) weakremover(postgresql11-pgsql-ogr-fdw) weakremover(postgresql11-pgsql-ogr-fdw-llvmjit) weakremover(postgresql11-plperl) weakremover(postgresql11-plpython) weakremover(postgresql11-plr) weakremover(postgresql11-plr-doc) weakremover(postgresql11-pltcl) weakremover(postgresql11-postgis) weakremover(postgresql11-server) weakremover(postgresql11-server-devel) weakremover(postgresql11-test) weakremover(postgresql11-timescaledb) weakremover(postgresql12) weakremover(postgresql12-contrib) weakremover(postgresql12-devel) weakremover(postgresql12-devel-mini) weakremover(postgresql12-llvmjit) weakremover(postgresql12-llvmjit-devel) weakremover(postgresql12-orafce) weakremover(postgresql12-pg_cron) weakremover(postgresql12-pg_cron-llvmjit) weakremover(postgresql12-pgagent) weakremover(postgresql12-pgaudit) weakremover(postgresql12-pgaudit-llvmjit) weakremover(postgresql12-pgsql-ogr-fdw) weakremover(postgresql12-pgsql-ogr-fdw-llvmjit) weakremover(postgresql12-plperl) weakremover(postgresql12-plpython) weakremover(postgresql12-plr) weakremover(postgresql12-plr-doc) weakremover(postgresql12-pltcl) weakremover(postgresql12-postgis) weakremover(postgresql12-server) weakremover(postgresql12-server-devel) weakremover(postgresql12-test) weakremover(postgresql12-timescaledb) weakremover(postgresql13) weakremover(postgresql13-contrib) weakremover(postgresql13-devel) weakremover(postgresql13-devel-mini) weakremover(postgresql13-llvmjit) weakremover(postgresql13-llvmjit-devel) weakremover(postgresql13-orafce) weakremover(postgresql13-pg_cron) weakremover(postgresql13-pg_cron-llvmjit) weakremover(postgresql13-pgagent) weakremover(postgresql13-pgaudit) weakremover(postgresql13-pgaudit-llvmjit) weakremover(postgresql13-plperl) weakremover(postgresql13-plpython) weakremover(postgresql13-plr) weakremover(postgresql13-plr-doc) weakremover(postgresql13-pltcl) weakremover(postgresql13-postgis) weakremover(postgresql13-server) weakremover(postgresql13-server-devel) weakremover(postgresql13-test) weakremover(postgresql13-timescaledb) weakremover(postgresql14) weakremover(postgresql14-contrib) weakremover(postgresql14-devel) weakremover(postgresql14-devel-mini) weakremover(postgresql14-llvmjit) weakremover(postgresql14-llvmjit-devel) weakremover(postgresql14-orafce) weakremover(postgresql14-pg_cron) weakremover(postgresql14-pgagent) weakremover(postgresql14-pgaudit) weakremover(postgresql14-plperl) weakremover(postgresql14-plpython) weakremover(postgresql14-plr) weakremover(postgresql14-plr-doc) weakremover(postgresql14-pltcl) weakremover(postgresql14-postgis) weakremover(postgresql14-server) weakremover(postgresql14-server-devel) weakremover(postgresql14-test) weakremover(postgresql14-timescaledb) weakremover(postgresql15) weakremover(postgresql15-contrib) weakremover(postgresql15-devel) weakremover(postgresql15-devel-mini) weakremover(postgresql15-llvmjit) weakremover(postgresql15-llvmjit-devel) weakremover(postgresql15-orafce) weakremover(postgresql15-pg_cron) weakremover(postgresql15-pgagent) weakremover(postgresql15-pgaudit) weakremover(postgresql15-plperl) weakremover(postgresql15-plpython) weakremover(postgresql15-plr) weakremover(postgresql15-plr-doc) weakremover(postgresql15-pltcl) weakremover(postgresql15-postgis) weakremover(postgresql15-server) weakremover(postgresql15-server-devel) weakremover(postgresql15-test) weakremover(postgresql15-timescaledb) weakremover(postgresql93) weakremover(postgresql93-contrib) weakremover(postgresql93-devel) weakremover(postgresql93-docs) weakremover(postgresql93-pgagent) weakremover(postgresql93-plperl) weakremover(postgresql93-plpython) weakremover(postgresql93-plr) weakremover(postgresql93-plr-doc) weakremover(postgresql93-pltcl) weakremover(postgresql93-server) weakremover(postgresql93-test) weakremover(postgresql94) weakremover(postgresql94-contrib) weakremover(postgresql94-devel) weakremover(postgresql94-docs) weakremover(postgresql94-pgagent) weakremover(postgresql94-plperl) weakremover(postgresql94-plpython) weakremover(postgresql94-plr) weakremover(postgresql94-plr-doc) weakremover(postgresql94-pltcl) weakremover(postgresql94-server) weakremover(postgresql94-test) weakremover(postgresql95) weakremover(postgresql95-contrib) weakremover(postgresql95-devel) weakremover(postgresql95-docs) weakremover(postgresql95-pg_cron) weakremover(postgresql95-pgagent) weakremover(postgresql95-pgaudit) weakremover(postgresql95-pgsql-ogr-fdw) weakremover(postgresql95-plperl) weakremover(postgresql95-plpython) weakremover(postgresql95-plr) weakremover(postgresql95-plr-doc) weakremover(postgresql95-pltcl) weakremover(postgresql95-server) weakremover(postgresql95-test) weakremover(postgresql96) weakremover(postgresql96-contrib) weakremover(postgresql96-devel) weakremover(postgresql96-docs) weakremover(postgresql96-pg_cron) weakremover(postgresql96-pgagent) weakremover(postgresql96-pgaudit) weakremover(postgresql96-pgsql-ogr-fdw) weakremover(postgresql96-plperl) weakremover(postgresql96-plpython) weakremover(postgresql96-plr) weakremover(postgresql96-plr-doc) weakremover(postgresql96-pltcl) weakremover(postgresql96-server) weakremover(postgresql96-test) weakremover(postgresql96-timescaledb) weakremover(postsrsd) weakremover(potrace) weakremover(potrace-devel) weakremover(pound) weakremover(pound-doc) weakremover(povray) weakremover(powdertoy) weakremover(power-profiles-daemon) weakremover(powercap) weakremover(powercap-devel) weakremover(powerd) weakremover(powerdevil5) weakremover(powerline) weakremover(powerline-go) weakremover(powerman) weakremover(powerman-devel) weakremover(powermanga) weakremover(powerstat) weakremover(powertop) weakremover(ppl) weakremover(ppl-devel) weakremover(pplite-devel) weakremover(ppp) weakremover(ppp-devel) weakremover(ppp-userpass) weakremover(ppplay) weakremover(pprof) weakremover(pps-tools) weakremover(pps-tools-devel) weakremover(pps-udev) weakremover(pptp) weakremover(pptpd) weakremover(pqiv) weakremover(pqiv-ffmpeg) weakremover(pqiv-gdkpixbuf) weakremover(pqiv-libarchive) weakremover(pqiv-poppler) weakremover(pqiv-spectre) weakremover(pqiv-wand) weakremover(pqiv-webp) weakremover(praat) weakremover(pragha) weakremover(pragha-plugins) weakremover(pragha-plugins-devel) weakremover(prboom-plus) weakremover(prctl) weakremover(prelude-lml) weakremover(prelude-lml-devel) weakremover(prelude-manager) weakremover(prelude-manager-db-plugin) weakremover(prelude-manager-devel) weakremover(prelude-manager-smtp-plugin) weakremover(prelude-manager-snmp-plugin) weakremover(prelude-manager-xml-plugin) weakremover(prelude-tools) weakremover(preludedb-tools) weakremover(premake4) weakremover(presage) weakremover(presage-data) weakremover(primecount) weakremover(primesieve) weakremover(primus) weakremover(printer-driver-brlaser) weakremover(printproto-devel) weakremover(prison-qt5-devel) weakremover(prison-qt5-imports) weakremover(priv_wrapper) weakremover(privoxy) weakremover(procdump) weakremover(procenv) weakremover(procinfo) weakremover(procmail) weakremover(procmeter) weakremover(procmeter-devel) weakremover(procmon) weakremover(procps) weakremover(procps-devel) weakremover(procps4) weakremover(procps4-devel) weakremover(procs) weakremover(product-builder) weakremover(product-builder-plugin-openSUSE) weakremover(profanity) weakremover(profanity-mini) weakremover(profanity-standard) weakremover(profiteur) weakremover(proftpd) weakremover(proftpd-devel) weakremover(proftpd-doc) weakremover(proftpd-ldap) weakremover(proftpd-mysql) weakremover(proftpd-pgsql) weakremover(proftpd-radius) weakremover(proftpd-sqlite) weakremover(progress) weakremover(proj) weakremover(proj-devel) weakremover(projectM) weakremover(projectM-data) weakremover(projectM-devel) weakremover(prom2json) weakremover(prometheus-blackbox_exporter) weakremover(prometheus-cpp-devel) weakremover(prometheus-ha_cluster_exporter) weakremover(prometheus-hanadb_exporter) weakremover(prometheus-postgres_exporter) weakremover(prometheus-sap_host_exporter) weakremover(prometheus-saptune_exporter) weakremover(promtail) weakremover(prosody) weakremover(prosody-community-modules) weakremover(protobuf-c) weakremover(protobuf-devel) weakremover(protobuf-java) weakremover(protoc-gen-go) weakremover(protoc-gen-go-source) weakremover(protoc-gen-gogo) weakremover(protoc-gen-gogo-source) weakremover(protoc-gen-validate) weakremover(protoc-gen-validate-source) weakremover(providers) weakremover(proxychains-ng) weakremover(proxymngr) weakremover(prozgui) weakremover(psgplay) weakremover(psi+) weakremover(psi+-plugins-attentionplugin) weakremover(psi+-plugins-autoreplyplugin) weakremover(psi+-plugins-birthdayreminderplugin) weakremover(psi+-plugins-captchaformsplugin) weakremover(psi+-plugins-chessplugin) weakremover(psi+-plugins-cleanerplugin) weakremover(psi+-plugins-clientswitcherplugin) weakremover(psi+-plugins-conferenceloggerplugin) weakremover(psi+-plugins-contentdownloaderplugin) weakremover(psi+-plugins-devel) weakremover(psi+-plugins-enummessagesplugin) weakremover(psi+-plugins-extendedmenuplugin) weakremover(psi+-plugins-extendedoptionsplugin) weakremover(psi+-plugins-gmailserviceplugin) weakremover(psi+-plugins-gnome3supportplugin) weakremover(psi+-plugins-gnupgplugin) weakremover(psi+-plugins-gomokugameplugin) weakremover(psi+-plugins-historykeeperplugin) weakremover(psi+-plugins-httpuploadplugin) weakremover(psi+-plugins-icqdieplugin) weakremover(psi+-plugins-imageplugin) weakremover(psi+-plugins-imagepreviewplugin) weakremover(psi+-plugins-jabberdiskplugin) weakremover(psi+-plugins-juickplugin) weakremover(psi+-plugins-messagefilterplugin) weakremover(psi+-plugins-omemoplugin) weakremover(psi+-plugins-openpgpplugin) weakremover(psi+-plugins-otrplugin) weakremover(psi+-plugins-pepchangenotifyplug