remover(unar) weakremover(unbound) weakremover(unbound-anchor) weakremover(unbound-devel) weakremover(unbound-python) weakremover(unclutter) weakremover(uncrustify) weakremover(unetbootin) weakremover(unibilium-devel) weakremover(unifdef) weakremover(unionfs-fuse) weakremover(unique-factory-devel) weakremover(unison) weakremover(unison-text) weakremover(units) weakremover(unittest-cpp-devel) weakremover(unity-gtk-module-common) weakremover(unity-gtk2-module) weakremover(unity-gtk3-module) weakremover(universal-ctags) weakremover(unixODBC) weakremover(unixODBC-devel) weakremover(unixbench) weakremover(unmass) weakremover(unpaper) weakremover(unsermake) weakremover(unshield) weakremover(unshield-devel) weakremover(unzip) weakremover(unzip-rcc) weakremover(unzix) weakremover(upb-devel) weakremover(upb-source) weakremover(update-alternatives) weakremover(update-checker) weakremover(update-test-32bit-pkg) weakremover(update-test-affects-package-manager) weakremover(update-test-broken) weakremover(update-test-feature) weakremover(update-test-interactive) weakremover(update-test-optional) weakremover(update-test-reboot-needed) weakremover(update-test-relogin-suggested) weakremover(update-test-retracted) weakremover(update-test-security) weakremover(update-test-trival) weakremover(update-test-trivial) weakremover(uperf) weakremover(upm-devel) weakremover(upmpdcli) weakremover(upnp-inspector) weakremover(upower) weakremover(upplay) weakremover(upsm) weakremover(upx) weakremover(uranium-firmware-lulzbot) weakremover(uranium-lulzbot) weakremover(urcu-docs) weakremover(urfkill) weakremover(urh) weakremover(uriparse) weakremover(uriparser) weakremover(uriparser-devel) weakremover(uriparser-doc) weakremover(urlview) weakremover(urxvt-font-size) weakremover(urxvt-perls) weakremover(us428control) weakremover(usb_modeswitch) weakremover(usbauth) weakremover(usbauth-notifier) weakremover(usbguard) weakremover(usbguard-applet-qt) weakremover(usbguard-devel) weakremover(usbguard-tools) weakremover(usbip) weakremover(usbip-devel) weakremover(usbmuxd) weakremover(usbprog) weakremover(usbprog-devel) weakremover(usbprog-gui) weakremover(usbredir) weakremover(usbredir-devel) weakremover(usbsdmux-udev) weakremover(usbtop) weakremover(usbutils) weakremover(usbview) weakremover(ushare) weakremover(usnic_udp_pingpong) weakremover(usrp-tools) weakremover(usrsctp-devel) weakremover(usx2yloader) weakremover(utempter-devel) weakremover(utf8proc-devel) weakremover(utfcpp-devel) weakremover(util-linux) weakremover(util-linux-systemd) weakremover(util-linux-tty-tools) weakremover(util-macros-devel) weakremover(utils-libnfs) weakremover(utmp-cli) weakremover(utox) weakremover(utsushi) weakremover(uucp) weakremover(uucp-xinetd) weakremover(uudeview) weakremover(uuid-devel) weakremover(uuidd) weakremover(uvcdynctrl) weakremover(uwac0-0-devel) weakremover(uwsc) weakremover(uwsgi) weakremover(uwsgi-emperor_pg) weakremover(uwsgi-emperor_zeromq) weakremover(uwsgi-geoip) weakremover(uwsgi-gevent) weakremover(uwsgi-glusterfs) weakremover(uwsgi-greenlet) weakremover(uwsgi-jvm) weakremover(uwsgi-ldap) weakremover(uwsgi-libffi) weakremover(uwsgi-logzmq) weakremover(uwsgi-lua) weakremover(uwsgi-pam) weakremover(uwsgi-php7) weakremover(uwsgi-php8) weakremover(uwsgi-psgi) weakremover(uwsgi-pypy) weakremover(uwsgi-python) weakremover(uwsgi-python3) weakremover(uwsgi-sqlite3) weakremover(uwsgi-xslt) weakremover(v2ray-core) weakremover(v4l-conf) weakremover(v4l-tools) weakremover(v4l-utils) weakremover(v4l-utils-devel-tools) weakremover(v4l2loopback-kmp-64kb) weakremover(v4l2loopback-kmp-default) weakremover(vaapi-dummy-driver) weakremover(vaapi-tools) weakremover(vaapi-wayland-tools) weakremover(vacation) weakremover(vacuum-im) weakremover(vacuum-im-devel) weakremover(vacuum-im-plugins-dbusnotifications) weakremover(vacuum-im-plugins-gmailnotify) weakremover(vacuum-im-plugins-kinotifications) weakremover(vacuum-im-plugins-spellchecker) weakremover(vacuum-im-plugins-statistics) weakremover(vacuum-im-plugins-usermood) weakremover(vacuum-im-plugins-usertune) weakremover(vagrant) weakremover(vagrant-libvirt) weakremover(vagrant-libvirt-doc) weakremover(vagrant-sshfs) weakremover(vagrant-sshfs-testsuite) weakremover(vala) weakremover(vala-cmake-modules) weakremover(vala-panel) weakremover(vala-panel-devel) weakremover(vala-panel-extras-battery) weakremover(vala-panel-extras-gtop) weakremover(vala-panel-extras-lang) weakremover(vala-panel-extras-volume) weakremover(vala-panel-extras-weather) weakremover(vala-panel-extras-xkb) weakremover(vala-panel-extras-xkb-flags) weakremover(vala-panel-plugin-appmenu) weakremover(vala-panel-plugin-sntray) weakremover(vala-panel-plugin-sntray-lang) weakremover(vala-panel-plugins-base) weakremover(vala-panel-plugins-wnck) weakremover(vala-panel-runner) weakremover(valadoc) weakremover(valadoc-doclet-devhelp) weakremover(valadoc-doclet-gtkdoc) weakremover(valadoc-doclet-html) weakremover(vale) weakremover(valgrind) weakremover(valgrind-devel) weakremover(vamp-plugin-sdk) weakremover(vamp-plugin-sdk-devel) weakremover(vapoursynth-devel) weakremover(vapoursynth-plugin-eedi3) weakremover(vapoursynth-plugin-imwri) weakremover(vapoursynth-plugin-miscfilters) weakremover(vapoursynth-plugin-morpho) weakremover(vapoursynth-plugin-ocr) weakremover(vapoursynth-plugin-removegrain) weakremover(vapoursynth-plugin-subtext) weakremover(vapoursynth-plugin-vinverse) weakremover(vapoursynth-plugin-vivtc) weakremover(vapoursynth-tools) weakremover(varnish) weakremover(varnish-devel) weakremover(vboot) weakremover(vbrfix) weakremover(vcdimager) weakremover(vcdimager-devel) weakremover(vcontrold) weakremover(vde2) weakremover(vde2-cryptcab) weakremover(vde2-slirp) weakremover(vdr) weakremover(vdr-devel) weakremover(vdr-devel-doc) weakremover(vdr-lang) weakremover(vdr-plugin-epgsearch) weakremover(vdr-plugin-femon) weakremover(vdr-plugin-remote) weakremover(vdr-plugin-satip) weakremover(vdr-plugin-streamdev-client) weakremover(vdr-plugin-streamdev-server) weakremover(vdr-plugin-xineliboutput) weakremover(vdr-xineliboutput-client) weakremover(vectorscan-devel) weakremover(vectorscan-examples) weakremover(ved) weakremover(vegastrike) weakremover(vegastrike-data) weakremover(vegastrike-extra) weakremover(vegastrike-music) weakremover(vegastrike-speech) weakremover(velero) weakremover(velero-plugin-for-aws) weakremover(velero-plugin-for-csi) weakremover(velero-plugin-for-gcp) weakremover(velero-plugin-for-microsoft-azure) weakremover(velociraptor) weakremover(velociraptor-client) weakremover(velociraptor-kafka-humio-gateway) weakremover(velum) weakremover(velum-branding) weakremover(verdict-devel) weakremover(verilator) weakremover(verilator-doc) weakremover(verilator-doc-pdf) weakremover(veyon) weakremover(vfontas) weakremover(vgrabbj) weakremover(vgrep) weakremover(vhba-kmp-64kb) weakremover(vhba-kmp-default) weakremover(vhostmd) weakremover(vidcutter) weakremover(vido) weakremover(viewnior) weakremover(viewprof) weakremover(viewres) weakremover(vifm) weakremover(vigra-devel) weakremover(vilistextum) weakremover(vim) weakremover(vim-bootstrap) weakremover(vim-completion-golang) weakremover(vim-icinga2) weakremover(vim-plugin-conky) weakremover(vim-plugin-devhelp) weakremover(vim-small) weakremover(vimb) weakremover(vinagre) weakremover(vino) weakremover(vips-modules-8.12) weakremover(vips-modules-8.13) weakremover(vips-tools) weakremover(virglrenderer-devel) weakremover(virglrenderer-test-server) weakremover(virt-p2v) weakremover(virt-sandbox) weakremover(virt-top) weakremover(virt-v2v) weakremover(virt-viewer) weakremover(virt-what) weakremover(virtaal) weakremover(virtaal-lang) weakremover(virtuoso-drivers) weakremover(virtuoso-server) weakremover(viruskiller) weakremover(visio2svg-conv) weakremover(visualjackm) weakremover(vitetris) weakremover(vkbasalt) weakremover(vkd3d-devel) weakremover(vkeybd) weakremover(vkmark) weakremover(vkquake) weakremover(vlan) weakremover(vlc) weakremover(vlc-codec-gstreamer) weakremover(vlc-devel) weakremover(vlc-jack) weakremover(vlc-noX) weakremover(vlc-opencv) weakremover(vlc-qt) weakremover(vlc-vdpau) weakremover(vlock) weakremover(vm-dump-metrics) weakremover(vm-dump-metrics-devel) weakremover(vm-install) weakremover(vmaf-data) weakremover(vmaf-devel) weakremover(vms-empire) weakremover(vmtouch) weakremover(vncmanager) weakremover(vncmanager-controller) weakremover(vncmanager-controller-gnome) weakremover(vncmanager-greeter) weakremover(vnote) weakremover(vnstat) weakremover(vnstat-cgi) weakremover(vocal) weakremover(vodovod) weakremover(voikkospell) weakremover(vokoscreen) weakremover(vokoscreenNG) weakremover(volk) weakremover(volk-devel) weakremover(volk_modtool) weakremover(voms-clients) weakremover(voms-devel) weakremover(vorbis-tools) weakremover(vorbisgain) weakremover(voro++) weakremover(voro++-devel) weakremover(votca) weakremover(votca-csg) weakremover(votca-csg-apps) weakremover(votca-csg-devel) weakremover(votca-csg-doc) weakremover(votca-csgapps) weakremover(votca-ctp) weakremover(votca-ctp-common) weakremover(votca-ctp-devel) weakremover(votca-ctp-doc) weakremover(votca-devel) weakremover(votca-tools) weakremover(votca-tools-devel) weakremover(votca-xtp) weakremover(votca-xtp-devel) weakremover(votca-xtp-doc) weakremover(voxelands) weakremover(vpcs) weakremover(vpnc) weakremover(vpx-tools) weakremover(vsftpd) weakremover(vsqlite++-devel) weakremover(vsqlite++-doc) weakremover(vst-lsp-plugins) weakremover(vst-rnnoise) weakremover(vst3-rnnoise) weakremover(vtable-dumper) weakremover(vte-devel) weakremover(vte-tools) weakremover(vte-tools-gtk4) weakremover(vte016-sharp) weakremover(vte2-devel) weakremover(vte2-lang) weakremover(vte2-tools) weakremover(vtk) weakremover(vtk-devel) weakremover(vtk-devel-doc) weakremover(vtk-examples) weakremover(vtk-java) weakremover(vtk-java-devel) weakremover(vtk-m-devel) weakremover(vtk-m-mpich-devel) weakremover(vtk-m-openmpi3-devel) weakremover(vtk-m-openmpi4-devel) weakremover(vtk-openmpi-devel) weakremover(vtk-openmpi-devel-doc) weakremover(vtk-openmpi-java) weakremover(vtk-openmpi-qt) weakremover(vtk-openmpi-tcl) weakremover(vtk-openmpi1-devel) weakremover(vtk-openmpi1-devel-doc) weakremover(vtk-openmpi1-java) weakremover(vtk-openmpi1-qt) weakremover(vtk-openmpi2-devel) weakremover(vtk-openmpi2-devel-doc) weakremover(vtk-openmpi2-java) weakremover(vtk-openmpi2-java-devel) weakremover(vtk-openmpi2-qt) weakremover(vtk-openmpi2-tcl) weakremover(vtk-openmpi3-devel) weakremover(vtk-openmpi3-devel-doc) weakremover(vtk-openmpi3-java) weakremover(vtk-openmpi3-java-devel) weakremover(vtk-openmpi3-qt) weakremover(vtk-openmpi4-devel) weakremover(vtk-openmpi4-java) weakremover(vtk-openmpi4-java-devel) weakremover(vtk-openmpi4-qt) weakremover(vtk-qt) weakremover(vtk-tcl) weakremover(vulkan) weakremover(vulkan-devel) weakremover(vulkan-doc) weakremover(vulkan-tools) weakremover(vulkan-validationlayers) weakremover(vulkan-validationlayers-devel) weakremover(vusb-analyzer) weakremover(vym) weakremover(w3m) weakremover(w3m-inline-image) weakremover(w_scan) weakremover(wadptr) weakremover(waffle) weakremover(waffle-devel) weakremover(waltham-devel) weakremover(wammu) weakremover(wammu-lang) weakremover(wannier90) weakremover(wannier90-devel) weakremover(wannier90-openmpi1) weakremover(wannier90-openmpi1-devel) weakremover(wannier90-openmpi2) weakremover(wannier90-openmpi2-devel) weakremover(wannier90-openmpi3) weakremover(wannier90-openmpi3-devel) weakremover(wannier90-openmpi4) weakremover(wannier90-openmpi4-devel) weakremover(wannier90-openmpi5) weakremover(wannier90-openmpi5-devel) weakremover(warewulf4) weakremover(warewulf4-api) weakremover(warewulf4-overlay) weakremover(warewulf4-slurm) weakremover(warzone2100) weakremover(wasm-pack) weakremover(watchexec) weakremover(watchman) weakremover(watchman-python) weakremover(wavemon) weakremover(wavpack) weakremover(wavpack-devel) weakremover(wavpack-doc) weakremover(waybar) weakremover(wayland-devel) weakremover(wayland-utils) weakremover(waylandpp) weakremover(waylandpp-devel) weakremover(waylock) weakremover(wayshot) weakremover(wayvnc) weakremover(wbg) weakremover(wbxml2-tools) weakremover(wcd) weakremover(wcslib-devel) weakremover(wcslib-tools) weakremover(wdfs) weakremover(wdiff) weakremover(wdm) weakremover(weather-wallpaper) weakremover(weather-wallpaper-lang) weakremover(weave-kube) weakremover(weave-npc) weakremover(webalizer) weakremover(webcamoid) weakremover(webcamoid-devel) weakremover(webenginepart) weakremover(webkit-jsc-1) weakremover(webkit-jsc-3) weakremover(webkit-jsc-4) weakremover(webkit-jsc-4.1) weakremover(webkit-jsc-5.0) weakremover(webkit-jsc-6.0) weakremover(webkit2gtk-4_0-injected-bundles) weakremover(webkit2gtk-4_1-injected-bundles) weakremover(webkit2gtk-5_0-injected-bundles) weakremover(webkit2gtk3-devel) weakremover(webkit2gtk3-minibrowser) weakremover(webkit2gtk3-plugin-process-gtk2) weakremover(webkit2gtk3-soup2-devel) weakremover(webkit2gtk3-soup2-minibrowser) weakremover(webkit2gtk4-devel) weakremover(webkit2gtk4-minibrowser) weakremover(webkitgtk-6_0-injected-bundles) weakremover(weblug) weakremover(webp-pixbuf-loader) weakremover(weechat) weakremover(weechat-aspell) weakremover(weechat-devel) weakremover(weechat-doc) weakremover(weechat-guile) weakremover(weechat-lua) weakremover(weechat-perl) weakremover(weechat-python) weakremover(weechat-ruby) weakremover(weechat-spell) weakremover(weechat-tcl) weakremover(weggli) weakremover(wesnoth) weakremover(wesnoth-campaign-server) weakremover(wesnoth-server) weakremover(wesnoth-tools) weakremover(weston) weakremover(weston-devel) weakremover(wev) weakremover(wezterm) weakremover(wezterm-mux-server) weakremover(wf-recorder) weakremover(wget) weakremover(wget2) weakremover(whatsapp-for-linux) weakremover(when-command) weakremover(when-command-lang) weakremover(which) weakremover(whipper) weakremover(whois) weakremover(whois-bash-completion) weakremover(wicked) weakremover(wicked-nbft) weakremover(wicked-service) weakremover(widelands) weakremover(widelands-debug) weakremover(wiggle) weakremover(wiiuse-devel) weakremover(wildmidi) weakremover(wildmidi-devel) weakremover(wimlib-devel) weakremover(wimtools) weakremover(wine) weakremover(wine-devel) weakremover(wine-nine) weakremover(wine-nine-devel) weakremover(wine-staging) weakremover(wine-staging-devel) weakremover(wine-staging-nine) weakremover(wine-staging-nine-devel) weakremover(winetricks) weakremover(winpr-devel) weakremover(winpr2-devel) weakremover(wipe) weakremover(wire) weakremover(wireguard) weakremover(wireguard-kmp-64kb) weakremover(wireguard-kmp-default) weakremover(wireguard-tools) weakremover(wireless-tools) weakremover(wireplumber) weakremover(wireplumber-devel) weakremover(wireshark) weakremover(wireshark-devel) weakremover(wireshark-gtk) weakremover(wireshark-plugin-libvirt) weakremover(wireshark-ui-gtk) weakremover(wireshark-ui-qt) weakremover(wizznic) weakremover(wkhtmltopdf) weakremover(wkhtmltopdf-devel) weakremover(wl-clipboard) weakremover(wl-clipboard-rs) weakremover(wlc-devel) weakremover(wlgreet) weakremover(wlopm) weakremover(wlr-randr) weakremover(wlr-sunclock) weakremover(wlroots-devel) weakremover(wlroots10-devel) weakremover(wlsunset) weakremover(wmakerconf) weakremover(wmctrl) weakremover(wmgui) weakremover(wminput) weakremover(wmutils) weakremover(wnck-sharp) weakremover(wob) weakremover(wodim) weakremover(woff2) weakremover(woff2-devel) weakremover(wofi) weakremover(wofi-devel) weakremover(wok) weakremover(wok-devel) weakremover(wok-plugins-ginger) weakremover(wok-plugins-gingerbase) weakremover(wok-plugins-kimchi) weakremover(wol) weakremover(wordcut) weakremover(wordcut-devel) weakremover(wordnet) weakremover(wordnet-devel) weakremover(workrave) weakremover(workrave-devel) weakremover(wpa_supplicant) weakremover(wpa_supplicant-gui) weakremover(wpan-tools) weakremover(wpebackend-fdo-devel) weakremover(wrapsix) weakremover(writerperfect) weakremover(wsl-appx) weakremover(wslay) weakremover(wslay-devel) weakremover(wsmancli) weakremover(wt) weakremover(wt-dbo) weakremover(wt-devel) weakremover(wt-doc) weakremover(wtmpdb) weakremover(wtmpdb-devel) weakremover(wtype) weakremover(wumpus) weakremover(wv) weakremover(wv-devel) weakremover(wv2-devel) weakremover(wvdial) weakremover(wvstreams) weakremover(wvstreams-devel) weakremover(wwwoffle) weakremover(wxEDID) weakremover(wxEphe) weakremover(wxGTK3-3_2-devel) weakremover(wxMaxima) weakremover(wxQt-3_2-devel) weakremover(wxWidgets-3_0-devel) weakremover(wxWidgets-3_0-nostl-devel) weakremover(wxWidgets-3_0-plugin-sound_sdlu-3_0) weakremover(wxWidgets-3_2-devel) weakremover(wxWidgets-3_2-nostl-devel) weakremover(wxWidgets-3_2-plugin-sound_sdlu-3_2) weakremover(wxWidgets-ansi-compat-lib-config) weakremover(wxWidgets-ansi-devel) weakremover(wxWidgets-ansi-plugin-sound_sdl-2_8-wxcontainer) weakremover(wxWidgets-compat-lib-config) weakremover(wxWidgets-devel) weakremover(wxWidgets-docs) weakremover(wxWidgets-fedora-compat-lib-config) weakremover(wxWidgets-plugin-sound_sdlu-2_8-stl) weakremover(wxWidgets-wxcontainer-compat-lib-config) weakremover(wxWidgets-wxcontainer-devel) weakremover(wxWidgets-wxcontainer-plugin-sound_sdlu-2_8-wxcontainer) weakremover(wxWidgets-wxcontainer24c-compat-lib-config) weakremover(wxWidgets-wxcontainer24c-devel) weakremover(wxWidgets-wxcontainer24c-plugin-sound_sdlu-2_8-wxcontainer24c) weakremover(wxhexeditor) weakremover(wxlua) weakremover(wxlua-devel) weakremover(wxmp3gain) weakremover(wxsqlite3-devel) weakremover(wxstedit) weakremover(wxstedit-devel) weakremover(wxsvg) weakremover(wyrd) weakremover(wyrmgus) weakremover(wyrmgus-devel) weakremover(x-tile) weakremover(x-tile-lang) weakremover(x11perf) weakremover(x11vnc) weakremover(x11vnc-frontend) weakremover(x2x) weakremover(x3270) weakremover(xa) weakremover(xalan-c) weakremover(xaos) weakremover(xaos-lang) weakremover(xapian-core) weakremover(xapian-core-doc) weakremover(xapian-core-examples) weakremover(xapps-mate) weakremover(xar) weakremover(xauth) weakremover(xautolock) weakremover(xautomation) weakremover(xaw3dd) weakremover(xawtv) weakremover(xbacklight) weakremover(xbanish) weakremover(xbase) weakremover(xbase-devel) weakremover(xbase-doc) weakremover(xbench) weakremover(xbiff) weakremover(xbindkeys) weakremover(xbomb) weakremover(xboxdrv) weakremover(xbrlapi) weakremover(xbrz-devel) weakremover(xbsql) weakremover(xbsql-devel) weakremover(xca) weakremover(xcalc) weakremover(xcalib) weakremover(xcalib-profiles) weakremover(xcape) weakremover(xcas) weakremover(xcb) weakremover(xcb-imdkit-devel) weakremover(xcb-proto-devel) weakremover(xcb-util-cursor-devel) weakremover(xcb-util-devel) weakremover(xcb-util-errors-devel) weakremover(xcb-util-image-devel) weakremover(xcb-util-keysyms-devel) weakremover(xcb-util-renderutil-devel) weakremover(xcb-util-wm-devel) weakremover(xcb-util-xrm-devel) weakremover(xcfun-devel) weakremover(xchm) weakremover(xclass) weakremover(xclass-devel) weakremover(xclip) weakremover(xclipboard) weakremover(xclock) weakremover(xcm) weakremover(xcmsdb) weakremover(xcolors) weakremover(xcompmgr) weakremover(xconsole) weakremover(xcoral) weakremover(xcowsay) weakremover(xcursorgen) weakremover(xcwd) weakremover(xdbedizzy) weakremover(xdelta) weakremover(xdelta-devel) weakremover(xdelta3) weakremover(xdg-app) weakremover(xdg-app-devel) weakremover(xdg-dbus-proxy) weakremover(xdg-desktop-portal) weakremover(xdg-desktop-portal-devel) weakremover(xdg-desktop-portal-gnome) weakremover(xdg-desktop-portal-gtk) weakremover(xdg-desktop-portal-kde) weakremover(xdg-desktop-portal-lxqt) weakremover(xdg-desktop-portal-wlr) weakremover(xdg-user-dirs) weakremover(xdg-user-dirs-gtk) weakremover(xdg-utils-cxx-devel) weakremover(xdiskusage) weakremover(xditview) weakremover(xdm) weakremover(xdm-xsession) weakremover(xdmbgrd) weakremover(xdo) weakremover(xdotool) weakremover(xdotool-devel) weakremover(xdpyinfo) weakremover(xdriinfo) weakremover(xed) weakremover(xed-devel) weakremover(xedit) weakremover(xemacs) weakremover(xembedsniproxy) weakremover(xen) weakremover(xen-devel) weakremover(xen-doc-html) weakremover(xen-libs) weakremover(xen-tools) weakremover(xen-tools-domU) weakremover(xengine) weakremover(xerces-c) weakremover(xerces-c-doc) weakremover(xev) weakremover(xeyes) weakremover(xf86-input-evdev) weakremover(xf86-input-evdev-devel) weakremover(xf86-input-joystick) weakremover(xf86-input-joystick-devel) weakremover(xf86-input-keyboard) weakremover(xf86-input-libinput) weakremover(xf86-input-libinput-devel) weakremover(xf86-input-mouse) weakremover(xf86-input-mouse-devel) weakremover(xf86-input-synaptics) weakremover(xf86-input-synaptics-devel) weakremover(xf86-input-void) weakremover(xf86-input-wacom) weakremover(xf86-input-wacom-devel) weakremover(xf86-video-amdgpu) weakremover(xf86-video-ark) weakremover(xf86-video-ast) weakremover(xf86-video-ati) weakremover(xf86-video-chips) weakremover(xf86-video-cirrus) weakremover(xf86-video-dummy) weakremover(xf86-video-fbdev) weakremover(xf86-video-fbturbo) weakremover(xf86-video-fbturbo-live) weakremover(xf86-video-glint) weakremover(xf86-video-i128) weakremover(xf86-video-mach64) weakremover(xf86-video-mga) weakremover(xf86-video-neomagic) weakremover(xf86-video-nouveau) weakremover(xf86-video-nv) weakremover(xf86-video-qxl) weakremover(xf86-video-r128) weakremover(xf86-video-savage) weakremover(xf86-video-sis) weakremover(xf86-video-sisusb) weakremover(xf86-video-tdfx) weakremover(xf86-video-tga) weakremover(xf86-video-trident) weakremover(xf86-video-v4l) weakremover(xf86-video-vesa) weakremover(xf86-video-voodoo) weakremover(xf86dga) weakremover(xf86rushproto-devel) weakremover(xfburn) weakremover(xfce4-appfinder) weakremover(xfce4-battery-plugin) weakremover(xfce4-calculator-plugin) weakremover(xfce4-clipman-plugin) weakremover(xfce4-cpufreq-plugin) weakremover(xfce4-cpugraph-plugin) weakremover(xfce4-datetime-plugin) weakremover(xfce4-dev-tools) weakremover(xfce4-dict) weakremover(xfce4-diskperf-plugin) weakremover(xfce4-docklike-plugin) weakremover(xfce4-eyes-plugin) weakremover(xfce4-fsguard-plugin) weakremover(xfce4-genmon-plugin) weakremover(xfce4-icon-theme) weakremover(xfce4-kbdleds-plugin) weakremover(xfce4-mailwatch-plugin) weakremover(xfce4-mixer) weakremover(xfce4-mixer-lang) weakremover(xfce4-mixer-plugin) weakremover(xfce4-mount-plugin) weakremover(xfce4-mpc-plugin) weakremover(xfce4-multiload-nandhp-plugin) weakremover(xfce4-netload-plugin) weakremover(xfce4-netspeed-plugin) weakremover(xfce4-notes-plugin) weakremover(xfce4-notifyd) weakremover(xfce4-notifyd-theme-plata) weakremover(xfce4-panel) weakremover(xfce4-panel-devel) weakremover(xfce4-panel-plugin-appmenu) weakremover(xfce4-panel-plugin-battery) weakremover(xfce4-panel-plugin-calculator) weakremover(xfce4-panel-plugin-clipman) weakremover(xfce4-panel-plugin-cpufreq) weakremover(xfce4-panel-plugin-cpugraph) weakremover(xfce4-panel-plugin-datetime) weakremover(xfce4-panel-plugin-dict) weakremover(xfce4-panel-plugin-diskperf) weakremover(xfce4-panel-plugin-eyes) weakremover(xfce4-panel-plugin-fsguard) weakremover(xfce4-panel-plugin-genmon) weakremover(xfce4-panel-plugin-indicator) weakremover(xfce4-panel-plugin-mailwatch) weakremover(xfce4-panel-plugin-mixer) weakremover(xfce4-panel-plugin-mount) weakremover(xfce4-panel-plugin-mpc) weakremover(xfce4-panel-plugin-multiload-nandhp) weakremover(xfce4-panel-plugin-netload) weakremover(xfce4-panel-plugin-netspeed) weakremover(xfce4-panel-plugin-notes) weakremover(xfce4-panel-plugin-places) weakremover(xfce4-panel-plugin-power-manager) weakremover(xfce4-panel-plugin-pulseaudio) weakremover(xfce4-panel-plugin-screenshooter) weakremover(xfce4-panel-plugin-sensors) weakremover(xfce4-panel-plugin-sensors-devel) weakremover(xfce4-panel-plugin-smartbookmark) weakremover(xfce4-panel-plugin-sntray) weakremover(xfce4-panel-plugin-statusnotifier) weakremover(xfce4-panel-plugin-statusnotifier-lang) weakremover(xfce4-panel-plugin-systemload) weakremover(xfce4-panel-plugin-timeout) weakremover(xfce4-panel-plugin-timer) weakremover(xfce4-panel-plugin-verve) weakremover(xfce4-panel-plugin-wavelan) weakremover(xfce4-panel-plugin-weather) weakremover(xfce4-panel-plugin-whiskermenu) weakremover(xfce4-panel-plugin-xkb) weakremover(xfce4-panel-restore-defaults) weakremover(xfce4-places-plugin) weakremover(xfce4-power-manager) weakremover(xfce4-power-manager-plugin) weakremover(xfce4-pulseaudio-plugin) weakremover(xfce4-screensaver) weakremover(xfce4-screenshooter) weakremover(xfce4-screenshooter-plugin) weakremover(xfce4-sensors-plugin) weakremover(xfce4-sensors-plugin-devel) weakremover(xfce4-session) weakremover(xfce4-session-devel) weakremover(xfce4-settings) weakremover(xfce4-settings-color) weakremover(xfce4-smartbookmark-plugin) weakremover(xfce4-splash-branding-openSUSE) weakremover(xfce4-statusnotifier-plugin) weakremover(xfce4-statusnotifier-plugin-lang) weakremover(xfce4-stopwatch-plugin) weakremover(xfce4-systemload-plugin) weakremover(xfce4-taskmanager) weakremover(xfce4-terminal) weakremover(xfce4-time-out-plugin) weakremover(xfce4-timer-plugin) weakremover(xfce4-verve-plugin) weakremover(xfce4-volumed) weakremover(xfce4-volumed-pulse) weakremover(xfce4-wavelan-plugin) weakremover(xfce4-weather-plugin) weakremover(xfce4-whiskermenu-plugin) weakremover(xfce4-xkb-plugin) weakremover(xfconf) weakremover(xfd) weakremover(xfdashboard) weakremover(xfdashboard-devel) weakremover(xfdesktop) weakremover(xfig) weakremover(xfindproxy) weakremover(xfishtank) weakremover(xflr5) weakremover(xfmpc) weakremover(xfontsel) weakremover(xfs) weakremover(xfsdump) weakremover(xfsinfo) weakremover(xfsprogs) weakremover(xfsprogs-devel) weakremover(xfsprogs-scrub) weakremover(xfstests) weakremover(xfwm4) weakremover(xfwm4-theme-plata) weakremover(xfwm4-themes) weakremover(xfwp) weakremover(xgalaga++) weakremover(xgalaga-sdl) weakremover(xgamma) weakremover(xgboost) weakremover(xgc) weakremover(xgnokii) weakremover(xgrabsc) weakremover(xhfsutil) weakremover(xhost) weakremover(xiccd) weakremover(xindy) weakremover(xine-ui) weakremover(xinetd) weakremover(xinit) weakremover(xinput) weakremover(xiphos) weakremover(xiterm) weakremover(xjadeo) weakremover(xkb-switch) weakremover(xkbcomp) weakremover(xkbcomp-devel) weakremover(xkbevd) weakremover(xkbprint) weakremover(xkbutils) weakremover(xkeycaps) weakremover(xkill) weakremover(xl2tpd) weakremover(xl2tpd-doc) weakremover(xlatencytop) weakremover(xless) weakremover(xli) weakremover(xload) weakremover(xlockmore) weakremover(xlogo) weakremover(xlsatoms) weakremover(xlsclients) weakremover(xlsfonts) weakremover(xmag) weakremover(xmahjongg) weakremover(xman) weakremover(xmessage) weakremover(xmgrace) weakremover(xmgrace-devel) weakremover(xmh) weakremover(xmined) weakremover(xml-commons-jaxp-1.1-apis-manual) weakremover(xml-commons-jaxp-1.2-apis-manual) weakremover(xml-commons-jaxp-1.3-apis-manual) weakremover(xml-commons-jaxp-1.4-apis-manual) weakremover(xml-commons-which10) weakremover(xml-commons-which11) weakremover(xml-group-manager) weakremover(xml-security-c-bin) weakremover(xmlb-tool) weakremover(xmlbird-devel) weakremover(xmlrpc-c-devel) weakremover(xmlsec1) weakremover(xmlsec1-devel) weakremover(xmlsec1-gcrypt-devel) weakremover(xmlsec1-gnutls-devel) weakremover(xmlsec1-nss-devel) weakremover(xmlsec1-openssl-devel) weakremover(xmlstarlet) weakremover(xmlto) weakremover(xmms2) weakremover(xmms2-devel) weakremover(xmms2-docs) weakremover(xmms2-perl) weakremover(xmms2-plugin-airplay) weakremover(xmms2-plugin-ao) weakremover(xmms2-plugin-apefile) weakremover(xmms2-plugin-asf) weakremover(xmms2-plugin-asx) weakremover(xmms2-plugin-base) weakremover(xmms2-plugin-cdda) weakremover(xmms2-plugin-cue) weakremover(xmms2-plugin-curl) weakremover(xmms2-plugin-daap) weakremover(xmms2-plugin-flac) weakremover(xmms2-plugin-flv) weakremover(xmms2-plugin-gme) weakremover(xmms2-plugin-gvfs) weakremover(xmms2-plugin-html) weakremover(xmms2-plugin-ices) weakremover(xmms2-plugin-icymetaint) weakremover(xmms2-plugin-id3v2) weakremover(xmms2-plugin-jack) weakremover(xmms2-plugin-karaoke) weakremover(xmms2-plugin-m3u) weakremover(xmms2-plugin-modplug) weakremover(xmms2-plugin-mp4) weakremover(xmms2-plugin-musepack) weakremover(xmms2-plugin-normalize) weakremover(xmms2-plugin-ofa) weakremover(xmms2-plugin-pulse) weakremover(xmms2-plugin-samba) weakremover(xmms2-plugin-sndfile) weakremover(xmms2-plugin-speex) weakremover(xmms2-plugin-tta) weakremover(xmms2-plugin-vocoder) weakremover(xmms2-plugin-wave) weakremover(xmms2-plugin-wavpack) weakremover(xmms2-ruby) weakremover(xmobar) weakremover(xmodmap) weakremover(xmonad) weakremover(xmoontool) weakremover(xmore) weakremover(xmorph) weakremover(xmorph-devel) weakremover(xmoto) weakremover(xmp) weakremover(xmpp-dns) weakremover(xmppc) weakremover(xmrig) weakremover(xmvn) weakremover(xmvn-bisect) weakremover(xmvn-connector-aether-javadoc) weakremover(xmvn-connector-gradle) weakremover(xmvn-connector-gradle-javadoc) weakremover(xmvn-minimal) weakremover(xnoise) weakremover(xnoise-lang) weakremover(xob) weakremover(xonotic) weakremover(xonotic-server) weakremover(xorg-x11-Xvnc) weakremover(xorg-x11-Xvnc-module) weakremover(xorg-x11-driver-video) weakremover(xorg-x11-libX11-ccache) weakremover(xorg-x11-server) weakremover(xorg-x11-server-Xvfb) weakremover(xorg-x11-server-extra) weakremover(xorg-x11-server-sdk) weakremover(xorg-x11-server-source) weakremover(xorg-x11-server-wayland) weakremover(xorg-x11-server-wrapper) weakremover(xorgxrdp) weakremover(xorriso) weakremover(xorriso-tcltk) weakremover(xosd) weakremover(xosd-devel) weakremover(xosview) weakremover(xournal) weakremover(xournalpp) weakremover(xpenguins) weakremover(xpinguin) weakremover(xplanet) weakremover(xplayer) weakremover(xplayer-browser-plugin) weakremover(xplayer-browser-plugin-gmp) weakremover(xplayer-browser-plugin-vegas) weakremover(xplayer-devel) weakremover(xplayer-plparser) weakremover(xplayer-plparser-devel) weakremover(xplayer-plugin-zeitgeist) weakremover(xplayer-plugins) weakremover(xplr) weakremover(xplsprinters) weakremover(xpr) weakremover(xpra) weakremover(xprehashprinterlist) weakremover(xprintidle) weakremover(xprompt) weakremover(xprop) weakremover(xquarto) weakremover(xrandr) weakremover(xrdb) weakremover(xrdp) weakremover(xrdp-devel) weakremover(xreader) weakremover(xreader-backends) weakremover(xreader-devel) weakremover(xreader-plugin-comicsdocument) weakremover(xreader-plugin-djvudocument) weakremover(xreader-plugin-dvidocument) weakremover(xreader-plugin-epubdocument) weakremover(xreader-plugin-pdfdocument) weakremover(xreader-plugin-pixbufdocument) weakremover(xreader-plugin-psdocument) weakremover(xreader-plugin-tiffdocument) weakremover(xreader-plugin-xpsdocument) weakremover(xrefresh) weakremover(xrestop) weakremover(xroach) weakremover(xroachng) weakremover(xrootd-cl) weakremover(xrootd-cl-devel) weakremover(xrootd-client) weakremover(xrootd-client-devel) weakremover(xrootd-client-libs) weakremover(xrootd-fuse) weakremover(xrootd-libs) weakremover(xrootd-libs-devel) weakremover(xrootd-private-devel) weakremover(xrootd-server) weakremover(xrootd-server-devel) weakremover(xrootd-server-libs) weakremover(xrx) weakremover(xsane) weakremover(xscope) weakremover(xscreensaver) weakremover(xscreensaver-data) weakremover(xscreensaver-data-extra) weakremover(xsd) weakremover(xsd-doc) weakremover(xsel) weakremover(xselection) weakremover(xsession) weakremover(xset) weakremover(xsetmode) weakremover(xsetpointer) weakremover(xsetroot) weakremover(xsettingsd) weakremover(xsimd-devel) weakremover(xsimd-doc) weakremover(xsm) weakremover(xsnow) weakremover(xsp) weakremover(xstdcmap) weakremover(xstereograph) weakremover(xstroke) weakremover(xsv) weakremover(xsynth-dssi) weakremover(xtables-addons) weakremover(xtables-addons-kmp-64kb) weakremover(xtables-addons-kmp-default) weakremover(xtables-plugins) weakremover(xteddy) weakremover(xterm) weakremover(xterm-bin) weakremover(xterm-resize) weakremover(xtermset) weakremover(xtexit) weakremover(xtrabackup) weakremover(xtrabackup-test) weakremover(xtrap) weakremover(xtrx-tools) weakremover(xtrx_lms7002m-devel) weakremover(xtrxdsp-tests) weakremover(xtrxll-tools) weakremover(xvidtune) weakremover(xviewer) weakremover(xviewer-devel) weakremover(xviewer-plugin-exif-display) weakremover(xviewer-plugin-export-to-folder) weakremover(xviewer-plugin-fit-to-width) weakremover(xviewer-plugin-fullscreenbg) weakremover(xviewer-plugin-hide-titlebar) weakremover(xviewer-plugin-light-theme) weakremover(xviewer-plugin-map) weakremover(xviewer-plugin-postasa) weakremover(xviewer-plugin-pythonconsole) weakremover(xviewer-plugin-send-by-mail) weakremover(xviewer-plugin-slideshowshuffle) weakremover(xviewer-plugins) weakremover(xvinfo) weakremover(xvkbd) weakremover(xwallpaper) weakremover(xwayland) weakremover(xwayland-devel) weakremover(xwd) weakremover(xwininfo) weakremover(xwmfs) weakremover(xwud) weakremover(xxd) weakremover(xxhash) weakremover(xxhash-devel) weakremover(xxkb) weakremover(xyconv) weakremover(xyconvert) weakremover(xylib-devel) weakremover(xyscan) weakremover(xz) weakremover(xz-devel) weakremover(xz-devel-static) weakremover(xz-static-devel) weakremover(xzgv) weakremover(yackage) weakremover(yacreader) weakremover(yafc) weakremover(yafray) weakremover(yaics) weakremover(yajl) weakremover(yakuake) weakremover(yamagi-quake2) weakremover(yamagi-quake2-ctf) weakremover(yambar) weakremover(yaml-cpp-devel) weakremover(yang-tools) weakremover(yank) weakremover(yara) weakremover(yascreen-devel) weakremover(yasm) weakremover(yasm-devel) weakremover(yast2) weakremover(yast2-add-on-creator) weakremover(yast2-alternatives) weakremover(yast2-bootloader) weakremover(yast2-branding-openSUSE-Oxygen) weakremover(yast2-ca-management) weakremover(yast2-control-center) weakremover(yast2-control-center-gnome) weakremover(yast2-control-center-qt) weakremover(yast2-core) weakremover(yast2-core-debugger) weakremover(yast2-core-devel) weakremover(yast2-country) weakremover(yast2-country-data) weakremover(yast2-dbus-server) weakremover(yast2-dhcp-server) weakremover(yast2-dns-server) weakremover(yast2-drbd) weakremover(yast2-fonts) weakremover(yast2-hardware-detection) weakremover(yast2-http-server) weakremover(yast2-inetd) weakremover(yast2-inetd-doc) weakremover(yast2-kdump) weakremover(yast2-ldap) weakremover(yast2-live-installer) weakremover(yast2-logs) weakremover(yast2-migration) weakremover(yast2-nis-client) weakremover(yast2-nis-server) weakremover(yast2-packager) weakremover(yast2-perl-bindings) weakremover(yast2-pkg-bindings) weakremover(yast2-printer) weakremover(yast2-product-creator) weakremover(yast2-python-bindings) weakremover(yast2-python3-bindings) weakremover(yast2-rear) weakremover(yast2-reipl) weakremover(yast2-rmt) weakremover(yast2-ruby-bindings) weakremover(yast2-scanner) weakremover(yast2-schema) weakremover(yast2-schema-default) weakremover(yast2-schema-micro) weakremover(yast2-slp) weakremover(yast2-smt) weakremover(yast2-snapper) weakremover(yast2-sound) weakremover(yast2-squid) weakremover(yast2-storage) weakremover(yast2-storage-devel) weakremover(yast2-storage-ng) weakremover(yast2-trans-pot) weakremover(yast2-transfer) weakremover(yast2-tune) weakremover(yast2-update) weakremover(yast2-update-FACTORY) weakremover(yast2-users) weakremover(yast2-vm) weakremover(yast2-x11) weakremover(yast2-xml) weakremover(yast2-ycp-ui-bindings) weakremover(yast2-ycp-ui-bindings-devel) weakremover(yate) weakremover(yate-bts) weakremover(yate-devel) weakremover(yate-qt4) weakremover(yate-scripts) weakremover(yaz) weakremover(yder-devel) weakremover(yelp) weakremover(yelp-devel) weakremover(yesod-bin) weakremover(yishu) weakremover(ykclient) weakremover(ykneomgr) weakremover(ykpers) weakremover(yodl) weakremover(youtube-dl-gui) weakremover(youtube-dl-gui-lang) weakremover(yp-tools) weakremover(ypbind) weakremover(ypserv) weakremover(yq) weakremover(ytalk) weakremover(ytree) weakremover(yubico-piv-tool) weakremover(yubikey-manager-qt) weakremover(yubikey-neo-manager) weakremover(yubikey-personalization-gui) weakremover(yubikey-piv-manager) weakremover(yubioath-desktop) weakremover(yudit) weakremover(yum-filter-data) weakremover(yum-lang) weakremover(yum-list-data) weakremover(yum-metadata-parser) weakremover(yum-tmprepo) weakremover(yum-updatesd) weakremover(yum-upgrade-helper) weakremover(yum-verify) weakremover(z3) weakremover(z3-devel) weakremover(zabbix-agent) weakremover(zabbix-bash-completion) weakremover(zabbix-java-gateway) weakremover(zabbix-phpfrontend) weakremover(zabbix-proxy) weakremover(zabbix-proxy-mysql) weakremover(zabbix-proxy-postgresql) weakremover(zabbix-proxy-sqlite) weakremover(zabbix-server) weakremover(zabbix-server-mysql) weakremover(zabbix-server-postgresql) weakremover(zabbix-server-sqlite) weakremover(zabbix-ui) weakremover(zanshin) weakremover(zathura) weakremover(zathura-bash-completion) weakremover(zathura-devel) weakremover(zathura-fish-completion) weakremover(zathura-plugin-cb) weakremover(zathura-plugin-djvu) weakremover(zathura-plugin-pdf-mupdf) weakremover(zathura-plugin-pdf-poppler) weakremover(zathura-plugin-ps) weakremover(zathura-zsh-completion) weakremover(zaz) weakremover(zbar) weakremover(zchunk) weakremover(zdbsp) weakremover(zeal) weakremover(zeitgeist) weakremover(zeitgeist-devel) weakremover(zellij) weakremover(zenity) weakremover(zenmap) weakremover(zerofree) weakremover(zeroinstall-injector) weakremover(zeromq-devel) weakremover(zeromq-tools) weakremover(zfp) weakremover(zfp-devel) weakremover(zhu3d) weakremover(zig) weakremover(zile) weakremover(zile-doc) weakremover(zimg) weakremover(zimg-devel) weakremover(zinnia) weakremover(zinnia-devel) weakremover(zip) weakremover(zipkin-cpp-opentracing-devel) weakremover(zipkin-cpp-opentracing-devel-static) weakremover(ziptool) weakremover(zisofs-tools) weakremover(zita-convolver-devel) weakremover(zita-resampler-devel) weakremover(zita-resampler-tools) weakremover(zk) weakremover(zlib-devel) weakremover(zlib-devel-static) weakremover(zlib-ng-compat-devel) weakremover(zlib-ng-devel) weakremover(zlib-testsuite) weakremover(zlibrary) weakremover(zlibrary-devel) weakremover(zlibrary-ui-gtk) weakremover(zlibrary-ui-qt) weakremover(zlibrary0_99) weakremover(zmusic-devel) weakremover(zn_poly-devel) weakremover(znc) weakremover(znc-devel) weakremover(znc-perl) weakremover(znc-python3) weakremover(znc-tcl) weakremover(zola) weakremover(zonefs-tools) weakremover(zoo) weakremover(zopfli) weakremover(zot) weakremover(zoxide) weakremover(zpaq) weakremover(zps) weakremover(zram-generator) weakremover(zramcfg) weakremover(zsh) weakremover(zsh-htmldoc) weakremover(zstd) weakremover(zstd-gzip) weakremover(zsync) weakremover(zsync-devel) weakremover(ztail) weakremover(zutils) weakremover(zutty) weakremover(zvbi) weakremover(zvbi-devel) weakremover(zxing-cpp-devel) weakremover(zynaddsubfx) weakremover(zynaddsubfx-bash-completion) weakremover(zynaddsubfx-dssi) weakremover(zynaddsubfx-lv2) weakremover(zynaddsubfx-vst) weakremover(zypp-gui) weakremover(zypp-plugin-python) weakremover(zypper) weakremover(zypper-docker) weakremover(zypper-migration-plugin) weakremover(zziplib-devel)"
RDEPENDS:${PN} += "/bin/sh coreutils glibc product_flavor(MicroOS)"

inherit rpm
