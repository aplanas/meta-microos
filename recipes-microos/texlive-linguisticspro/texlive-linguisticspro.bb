SUMMARY = "LinguisticsPro fonts with LaTeX support"
DESCRIPTION = "The package provides LaTeX, pdfLaTeX, XeLaTeX and LuaLaTeX \
support for the LinguisticsPro family of fonts. This family is \
derived from the Utopia Nova font family, by Andreas Nolda."
LICENSE = "LPPL-1.0"

PV = "2023.201.svn64858"

RPM_NAME = "texlive-linguisticspro-2023.201.svn64858-54.1.noarch.rpm"
RPM_HASH = "daea8a8ca7cff447bc6cd5fdd7dc8276e04a476f473a2b578b5be19d60f4ad96cb93f0c2b3a824a615d57ff04b72bea9ce8a940c7363bee4b79e708fdbdeebd0"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex(LGRLinguisticsPro-LF.fd) tex(LGRLinguisticsPro-OsF.fd) tex(LY1LinguisticsPro-LF.fd) tex(LY1LinguisticsPro-OsF.fd) tex(LinguisticsPro-Bold-lf-lgr.tfm) tex(LinguisticsPro-Bold-lf-ly1.tfm) tex(LinguisticsPro-Bold-lf-ot1.tfm) tex(LinguisticsPro-Bold-lf-t1--base.tfm) tex(LinguisticsPro-Bold-lf-t1.tfm) tex(LinguisticsPro-Bold-lf-t1.vf) tex(LinguisticsPro-Bold-lf-t2a.tfm) tex(LinguisticsPro-Bold-lf-t2b.tfm) tex(LinguisticsPro-Bold-lf-t2c.tfm) tex(LinguisticsPro-Bold-lf-t3--base.tfm) tex(LinguisticsPro-Bold-lf-t3.tfm) tex(LinguisticsPro-Bold-lf-t3.vf) tex(LinguisticsPro-Bold-lf-ts1--base.tfm) tex(LinguisticsPro-Bold-lf-ts1.tfm) tex(LinguisticsPro-Bold-lf-ts1.vf) tex(LinguisticsPro-Bold-lf-ts3.tfm) tex(LinguisticsPro-Bold-osf-lgr.tfm) tex(LinguisticsPro-Bold-osf-ly1.tfm) tex(LinguisticsPro-Bold-osf-ot1.tfm) tex(LinguisticsPro-Bold-osf-t1--base.tfm) tex(LinguisticsPro-Bold-osf-t1.tfm) tex(LinguisticsPro-Bold-osf-t1.vf) tex(LinguisticsPro-Bold-osf-t2a.tfm) tex(LinguisticsPro-Bold-osf-t2b.tfm) tex(LinguisticsPro-Bold-osf-t2c.tfm) tex(LinguisticsPro-Bold-osf-t3--base.tfm) tex(LinguisticsPro-Bold-osf-t3.tfm) tex(LinguisticsPro-Bold-osf-t3.vf) tex(LinguisticsPro-Bold-osf-ts1--base.tfm) tex(LinguisticsPro-Bold-osf-ts1.tfm) tex(LinguisticsPro-Bold-osf-ts1.vf) tex(LinguisticsPro-Bold-osf-ts3.tfm) tex(LinguisticsPro-BoldItalic-lf-lgr.tfm) tex(LinguisticsPro-BoldItalic-lf-ly1.tfm) tex(LinguisticsPro-BoldItalic-lf-ot1.tfm) tex(LinguisticsPro-BoldItalic-lf-t1--base.tfm) tex(LinguisticsPro-BoldItalic-lf-t1.tfm) tex(LinguisticsPro-BoldItalic-lf-t1.vf) tex(LinguisticsPro-BoldItalic-lf-t2a.tfm) tex(LinguisticsPro-BoldItalic-lf-t2b.tfm) tex(LinguisticsPro-BoldItalic-lf-t2c.tfm) tex(LinguisticsPro-BoldItalic-lf-t3--base.tfm) tex(LinguisticsPro-BoldItalic-lf-t3.tfm) tex(LinguisticsPro-BoldItalic-lf-t3.vf) tex(LinguisticsPro-BoldItalic-lf-ts1--base.tfm) tex(LinguisticsPro-BoldItalic-lf-ts1.tfm) tex(LinguisticsPro-BoldItalic-lf-ts1.vf) tex(LinguisticsPro-BoldItalic-lf-ts3.tfm) tex(LinguisticsPro-BoldItalic-osf-lgr.tfm) tex(LinguisticsPro-BoldItalic-osf-ly1.tfm) tex(LinguisticsPro-BoldItalic-osf-ot1.tfm) tex(LinguisticsPro-BoldItalic-osf-t1--base.tfm) tex(LinguisticsPro-BoldItalic-osf-t1.tfm) tex(LinguisticsPro-BoldItalic-osf-t1.vf) tex(LinguisticsPro-BoldItalic-osf-t2a.tfm) tex(LinguisticsPro-BoldItalic-osf-t2b.tfm) tex(LinguisticsPro-BoldItalic-osf-t2c.tfm) tex(LinguisticsPro-BoldItalic-osf-t3--base.tfm) tex(LinguisticsPro-BoldItalic-osf-t3.tfm) tex(LinguisticsPro-BoldItalic-osf-t3.vf) tex(LinguisticsPro-BoldItalic-osf-ts1--base.tfm) tex(LinguisticsPro-BoldItalic-osf-ts1.tfm) tex(LinguisticsPro-BoldItalic-osf-ts1.vf) tex(LinguisticsPro-BoldItalic-osf-ts3.tfm) tex(LinguisticsPro-Italic-lf-lgr.tfm) tex(LinguisticsPro-Italic-lf-ly1.tfm) tex(LinguisticsPro-Italic-lf-ot1.tfm) tex(LinguisticsPro-Italic-lf-t1--base.tfm) tex(LinguisticsPro-Italic-lf-t1.tfm) tex(LinguisticsPro-Italic-lf-t1.vf) tex(LinguisticsPro-Italic-lf-t2a.tfm) tex(LinguisticsPro-Italic-lf-t2b.tfm) tex(LinguisticsPro-Italic-lf-t2c.tfm) tex(LinguisticsPro-Italic-lf-t3--base.tfm) tex(LinguisticsPro-Italic-lf-t3.tfm) tex(LinguisticsPro-Italic-lf-t3.vf) tex(LinguisticsPro-Italic-lf-ts1--base.tfm) tex(LinguisticsPro-Italic-lf-ts1.tfm) tex(LinguisticsPro-Italic-lf-ts1.vf) tex(LinguisticsPro-Italic-lf-ts3.tfm) tex(LinguisticsPro-Italic-osf-lgr.tfm) tex(LinguisticsPro-Italic-osf-ly1.tfm) tex(LinguisticsPro-Italic-osf-ot1.tfm) tex(LinguisticsPro-Italic-osf-t1--base.tfm) tex(LinguisticsPro-Italic-osf-t1.tfm) tex(LinguisticsPro-Italic-osf-t1.vf) tex(LinguisticsPro-Italic-osf-t2a.tfm) tex(LinguisticsPro-Italic-osf-t2b.tfm) tex(LinguisticsPro-Italic-osf-t2c.tfm) tex(LinguisticsPro-Italic-osf-t3--base.tfm) tex(LinguisticsPro-Italic-osf-t3.tfm) tex(LinguisticsPro-Italic-osf-t3.vf) tex(LinguisticsPro-Italic-osf-ts1--base.tfm) tex(LinguisticsPro-Italic-osf-ts1.tfm) tex(LinguisticsPro-Italic-osf-ts1.vf) tex(LinguisticsPro-Italic-osf-ts3.tfm) tex(LinguisticsPro-Regular-lf-lgr.tfm) tex(LinguisticsPro-Regular-lf-ly1.tfm) tex(LinguisticsPro-Regular-lf-ot1.tfm) tex(LinguisticsPro-Regular-lf-sc-lgr.tfm) tex(LinguisticsPro-Regular-lf-sc-ly1--base.tfm) tex(LinguisticsPro-Regular-lf-sc-ly1.tfm) tex(LinguisticsPro-Regular-lf-sc-ly1.vf) tex(LinguisticsPro-Regular-lf-sc-ot1--base.tfm) tex(LinguisticsPro-Regular-lf-sc-ot1.tfm) tex(LinguisticsPro-Regular-lf-sc-ot1.vf) tex(LinguisticsPro-Regular-lf-sc-t1--base.tfm) tex(LinguisticsPro-Regular-lf-sc-t1.tfm) tex(LinguisticsPro-Regular-lf-sc-t1.vf) tex(LinguisticsPro-Regular-lf-sc-t2a.tfm) tex(LinguisticsPro-Regular-lf-sc-t2b.tfm) tex(LinguisticsPro-Regular-lf-sc-t2c.tfm) tex(LinguisticsPro-Regular-lf-sc-t3--base.tfm) tex(LinguisticsPro-Regular-lf-sc-t3.tfm) tex(LinguisticsPro-Regular-lf-sc-t3.vf) tex(LinguisticsPro-Regular-lf-sc-ts3.tfm) tex(LinguisticsPro-Regular-lf-t1--base.tfm) tex(LinguisticsPro-Regular-lf-t1.tfm) tex(LinguisticsPro-Regular-lf-t1.vf) tex(LinguisticsPro-Regular-lf-t2a.tfm) tex(LinguisticsPro-Regular-lf-t2b.tfm) tex(LinguisticsPro-Regular-lf-t2c.tfm) tex(LinguisticsPro-Regular-lf-t3--base.tfm) tex(LinguisticsPro-Regular-lf-t3.tfm) tex(LinguisticsPro-Regular-lf-t3.vf) tex(LinguisticsPro-Regular-lf-ts1--base.tfm) tex(LinguisticsPro-Regular-lf-ts1.tfm) tex(LinguisticsPro-Regular-lf-ts1.vf) tex(LinguisticsPro-Regular-lf-ts3.tfm) tex(LinguisticsPro-Regular-osf-lgr.tfm) tex(LinguisticsPro-Regular-osf-ly1.tfm) tex(LinguisticsPro-Regular-osf-ot1.tfm) tex(LinguisticsPro-Regular-osf-sc-lgr.tfm) tex(LinguisticsPro-Regular-osf-sc-ly1--base.tfm) tex(LinguisticsPro-Regular-osf-sc-ly1.tfm) tex(LinguisticsPro-Regular-osf-sc-ly1.vf) tex(LinguisticsPro-Regular-osf-sc-ot1--base.tfm) tex(LinguisticsPro-Regular-osf-sc-ot1.tfm) tex(LinguisticsPro-Regular-osf-sc-ot1.vf) tex(LinguisticsPro-Regular-osf-sc-t1--base.tfm) tex(LinguisticsPro-Regular-osf-sc-t1.tfm) tex(LinguisticsPro-Regular-osf-sc-t1.vf) tex(LinguisticsPro-Regular-osf-sc-t2a.tfm) tex(LinguisticsPro-Regular-osf-sc-t2b.tfm) tex(LinguisticsPro-Regular-osf-sc-t2c.tfm) tex(LinguisticsPro-Regular-osf-sc-t3--base.tfm) tex(LinguisticsPro-Regular-osf-sc-t3.tfm) tex(LinguisticsPro-Regular-osf-sc-t3.vf) tex(LinguisticsPro-Regular-osf-sc-ts3.tfm) tex(LinguisticsPro-Regular-osf-t1--base.tfm) tex(LinguisticsPro-Regular-osf-t1.tfm) tex(LinguisticsPro-Regular-osf-t1.vf) tex(LinguisticsPro-Regular-osf-t2a.tfm) tex(LinguisticsPro-Regular-osf-t2b.tfm) tex(LinguisticsPro-Regular-osf-t2c.tfm) tex(LinguisticsPro-Regular-osf-t3--base.tfm) tex(LinguisticsPro-Regular-osf-t3.tfm) tex(LinguisticsPro-Regular-osf-t3.vf) tex(LinguisticsPro-Regular-osf-ts1--base.tfm) tex(LinguisticsPro-Regular-osf-ts1.tfm) tex(LinguisticsPro-Regular-osf-ts1.vf) tex(LinguisticsPro-Regular-osf-ts3.tfm) tex(LinguisticsPro.map) tex(OT1LinguisticsPro-LF.fd) tex(OT1LinguisticsPro-OsF.fd) tex(T1LinguisticsPro-LF.fd) tex(T1LinguisticsPro-OsF.fd) tex(T2ALinguisticsPro-LF.fd) tex(T2ALinguisticsPro-OsF.fd) tex(T2BLinguisticsPro-LF.fd) tex(T2BLinguisticsPro-OsF.fd) tex(T2CLinguisticsPro-LF.fd) tex(T2CLinguisticsPro-OsF.fd) tex(T3LinguisticsPro-LF.fd) tex(T3LinguisticsPro-OsF.fd) tex(TS1LinguisticsPro-LF.fd) tex(TS1LinguisticsPro-OsF.fd) tex(TS3LinguisticsPro-LF.fd) tex(TS3LinguisticsPro-OsF.fd) tex(linguisticspro.sty) tex(lnpr_2dchsz.enc) tex(lnpr_2io6ub.enc) tex(lnpr_2mzpfv.enc) tex(lnpr_2sam6o.enc) tex(lnpr_3ifnsw.enc) tex(lnpr_4slpb2.enc) tex(lnpr_5g7sdz.enc) tex(lnpr_6eapwe.enc) tex(lnpr_6ezgzr.enc) tex(lnpr_7s35zn.enc) tex(lnpr_bylpnz.enc) tex(lnpr_c3wdkv.enc) tex(lnpr_c5y55d.enc) tex(lnpr_clyilc.enc) tex(lnpr_ctp5bu.enc) tex(lnpr_d5qjpp.enc) tex(lnpr_ehss4d.enc) tex(lnpr_elz76p.enc) tex(lnpr_fxbwbp.enc) tex(lnpr_i7qe4r.enc) tex(lnpr_jlizdj.enc) tex(lnpr_jvdtnb.enc) tex(lnpr_klqkbd.enc) tex(lnpr_mptstw.enc) tex(lnpr_n5uv5s.enc) tex(lnpr_n7rfoz.enc) tex(lnpr_niynhd.enc) tex(lnpr_o6z2fv.enc) tex(lnpr_olwjlf.enc) tex(lnpr_p6qnqd.enc) tex(lnpr_pcxklf.enc) tex(lnpr_pq5q4e.enc) tex(lnpr_q4n4m4.enc) tex(lnpr_qzkx3x.enc) tex(lnpr_rozyzo.enc) tex(lnpr_rqjpbq.enc) tex(lnpr_rr27g2.enc) tex(lnpr_rwq5kg.enc) tex(lnpr_syddkj.enc) tex(lnpr_t2hwm2.enc) tex(lnpr_tdl523.enc) tex(lnpr_usrmsl.enc) tex(lnpr_vfi6fz.enc) tex(lnpr_vycqam.enc) tex(lnpr_waxsla.enc) tex(lnpr_whgjeg.enc) tex(lnpr_whn5dx.enc) tex(lnpr_wo5mze.enc) tex(lnpr_wsrlge.enc) tex(lnpr_wsw7yh.enc) tex(lnpr_xexdze.enc) tex(lnpr_xr332d.enc) tex(lnpr_xv6zbl.enc) tex(lnpr_y6ghoo.enc) tex(lnpr_ydj4q2.enc) texlive-linguisticspro"
RDEPENDS:${PN} += "/bin/sh coreutils ed findutils grep sed tex(fontaxes.sty) tex(fontenc.sty) tex(fontspec.sty) tex(ifluatex.sty) tex(ifxetex.sty) tex(mweights.sty) tex(textcomp.sty) tex(updmap.cfg) tex(xkeyval.sty) texlive texlive-filesystem texlive-kpathsea texlive-kpathsea-bin texlive-linguisticspro-fonts texlive-scripts texlive-scripts-bin"

inherit rpm
