SUMMARY = "The Garamond Libre font face"
DESCRIPTION = "Garamond Libre is a free and open-source old-style font family. \
It is a 'true Garamond,' i.e., it is based off the designs of \
16th-century French engraver Claude Garamond (also spelled \
Garamont). The Roman design is Garamond's; the italics are from \
a design by Robert Granjon. The upright Greek font is after a \
design by Firmin Didot; the 'italic' Greek font is after a \
design by Alexander Wilson. The font family includes support \
for Latin, Greek (monotonic and polytonic) and Cyrillic \
scripts, as well as small capitals, old-style figures, superior \
and inferior figures, historical ligatures, Byzantine musical \
symbols, the IPA and swash capitals."
LICENSE = "LPPL-1.0"

PV = "2023.201.1.4svn64412"

RPM_NAME = "texlive-garamond-libre-2023.201.1.4svn64412-52.1.noarch.rpm"
RPM_HASH = "f1d95113a65418a0b6a44829e9ce8abbf2e48535a88ea3a164c3a9b1918bc12ffcd2bf9181bc0cc4af843de92cc3ef35643c1f7d512302bc00d38b80b78c3b85"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex(GaramondLibre-Bold-inf-lgr.tfm) tex(GaramondLibre-Bold-inf-ly1.tfm) tex(GaramondLibre-Bold-inf-ot1.tfm) tex(GaramondLibre-Bold-inf-t1--base.tfm) tex(GaramondLibre-Bold-inf-t1.tfm) tex(GaramondLibre-Bold-inf-t1.vf) tex(GaramondLibre-Bold-inf-t2a.tfm) tex(GaramondLibre-Bold-inf-t2b.tfm) tex(GaramondLibre-Bold-inf-t2c.tfm) tex(GaramondLibre-Bold-lf-lgr.tfm) tex(GaramondLibre-Bold-lf-ly1.tfm) tex(GaramondLibre-Bold-lf-ot1.tfm) tex(GaramondLibre-Bold-lf-sc-lgr.tfm) tex(GaramondLibre-Bold-lf-sc-ly1--base.tfm) tex(GaramondLibre-Bold-lf-sc-ly1.tfm) tex(GaramondLibre-Bold-lf-sc-ly1.vf) tex(GaramondLibre-Bold-lf-sc-ot1--base.tfm) tex(GaramondLibre-Bold-lf-sc-ot1.tfm) tex(GaramondLibre-Bold-lf-sc-ot1.vf) tex(GaramondLibre-Bold-lf-sc-t1--base.tfm) tex(GaramondLibre-Bold-lf-sc-t1.tfm) tex(GaramondLibre-Bold-lf-sc-t1.vf) tex(GaramondLibre-Bold-lf-sc-t2a.tfm) tex(GaramondLibre-Bold-lf-sc-t2b.tfm) tex(GaramondLibre-Bold-lf-sc-t2c.tfm) tex(GaramondLibre-Bold-lf-swash-lgr--base.tfm) tex(GaramondLibre-Bold-lf-swash-lgr.tfm) tex(GaramondLibre-Bold-lf-swash-lgr.vf) tex(GaramondLibre-Bold-lf-swash-ly1.tfm) tex(GaramondLibre-Bold-lf-swash-ot1--base.tfm) tex(GaramondLibre-Bold-lf-swash-ot1.tfm) tex(GaramondLibre-Bold-lf-swash-ot1.vf) tex(GaramondLibre-Bold-lf-swash-t1--base.tfm) tex(GaramondLibre-Bold-lf-swash-t1.tfm) tex(GaramondLibre-Bold-lf-swash-t1.vf) tex(GaramondLibre-Bold-lf-swash-t2a--base.tfm) tex(GaramondLibre-Bold-lf-swash-t2a.tfm) tex(GaramondLibre-Bold-lf-swash-t2a.vf) tex(GaramondLibre-Bold-lf-swash-t2b--base.tfm) tex(GaramondLibre-Bold-lf-swash-t2b.tfm) tex(GaramondLibre-Bold-lf-swash-t2b.vf) tex(GaramondLibre-Bold-lf-swash-t2c--base.tfm) tex(GaramondLibre-Bold-lf-swash-t2c.tfm) tex(GaramondLibre-Bold-lf-swash-t2c.vf) tex(GaramondLibre-Bold-lf-t1--base.tfm) tex(GaramondLibre-Bold-lf-t1.tfm) tex(GaramondLibre-Bold-lf-t1.vf) tex(GaramondLibre-Bold-lf-t2a.tfm) tex(GaramondLibre-Bold-lf-t2b.tfm) tex(GaramondLibre-Bold-lf-t2c.tfm) tex(GaramondLibre-Bold-lf-ts1--base.tfm) tex(GaramondLibre-Bold-lf-ts1.tfm) tex(GaramondLibre-Bold-lf-ts1.vf) tex(GaramondLibre-Bold-orn-u.tfm) tex(GaramondLibre-Bold-osf-lgr.tfm) tex(GaramondLibre-Bold-osf-ly1.tfm) tex(GaramondLibre-Bold-osf-ot1.tfm) tex(GaramondLibre-Bold-osf-sc-lgr.tfm) tex(GaramondLibre-Bold-osf-sc-ly1--base.tfm) tex(GaramondLibre-Bold-osf-sc-ly1.tfm) tex(GaramondLibre-Bold-osf-sc-ly1.vf) tex(GaramondLibre-Bold-osf-sc-ot1--base.tfm) tex(GaramondLibre-Bold-osf-sc-ot1.tfm) tex(GaramondLibre-Bold-osf-sc-ot1.vf) tex(GaramondLibre-Bold-osf-sc-t1--base.tfm) tex(GaramondLibre-Bold-osf-sc-t1.tfm) tex(GaramondLibre-Bold-osf-sc-t1.vf) tex(GaramondLibre-Bold-osf-sc-t2a.tfm) tex(GaramondLibre-Bold-osf-sc-t2b.tfm) tex(GaramondLibre-Bold-osf-sc-t2c.tfm) tex(GaramondLibre-Bold-osf-swash-lgr--base.tfm) tex(GaramondLibre-Bold-osf-swash-lgr.tfm) tex(GaramondLibre-Bold-osf-swash-lgr.vf) tex(GaramondLibre-Bold-osf-swash-ly1.tfm) tex(GaramondLibre-Bold-osf-swash-ot1--base.tfm) tex(GaramondLibre-Bold-osf-swash-ot1.tfm) tex(GaramondLibre-Bold-osf-swash-ot1.vf) tex(GaramondLibre-Bold-osf-swash-t1--base.tfm) tex(GaramondLibre-Bold-osf-swash-t1.tfm) tex(GaramondLibre-Bold-osf-swash-t1.vf) tex(GaramondLibre-Bold-osf-swash-t2a--base.tfm) tex(GaramondLibre-Bold-osf-swash-t2a.tfm) tex(GaramondLibre-Bold-osf-swash-t2a.vf) tex(GaramondLibre-Bold-osf-swash-t2b--base.tfm) tex(GaramondLibre-Bold-osf-swash-t2b.tfm) tex(GaramondLibre-Bold-osf-swash-t2b.vf) tex(GaramondLibre-Bold-osf-swash-t2c--base.tfm) tex(GaramondLibre-Bold-osf-swash-t2c.tfm) tex(GaramondLibre-Bold-osf-swash-t2c.vf) tex(GaramondLibre-Bold-osf-t1--base.tfm) tex(GaramondLibre-Bold-osf-t1.tfm) tex(GaramondLibre-Bold-osf-t1.vf) tex(GaramondLibre-Bold-osf-t2a.tfm) tex(GaramondLibre-Bold-osf-t2b.tfm) tex(GaramondLibre-Bold-osf-t2c.tfm) tex(GaramondLibre-Bold-osf-ts1--base.tfm) tex(GaramondLibre-Bold-osf-ts1.tfm) tex(GaramondLibre-Bold-osf-ts1.vf) tex(GaramondLibre-Bold-sup-lgr.tfm) tex(GaramondLibre-Bold-sup-ly1.tfm) tex(GaramondLibre-Bold-sup-ot1.tfm) tex(GaramondLibre-Bold-sup-t1--base.tfm) tex(GaramondLibre-Bold-sup-t1.tfm) tex(GaramondLibre-Bold-sup-t1.vf) tex(GaramondLibre-Bold-sup-t2a.tfm) tex(GaramondLibre-Bold-sup-t2b.tfm) tex(GaramondLibre-Bold-sup-t2c.tfm) tex(GaramondLibre-BoldItalic-inf-lgr.tfm) tex(GaramondLibre-BoldItalic-inf-ly1.tfm) tex(GaramondLibre-BoldItalic-inf-ot1.tfm) tex(GaramondLibre-BoldItalic-inf-t1--base.tfm) tex(GaramondLibre-BoldItalic-inf-t1.tfm) tex(GaramondLibre-BoldItalic-inf-t1.vf) tex(GaramondLibre-BoldItalic-inf-t2a.tfm) tex(GaramondLibre-BoldItalic-inf-t2b.tfm) tex(GaramondLibre-BoldItalic-inf-t2c.tfm) tex(GaramondLibre-BoldItalic-lf-lgr.tfm) tex(GaramondLibre-BoldItalic-lf-ly1.tfm) tex(GaramondLibre-BoldItalic-lf-ot1.tfm) tex(GaramondLibre-BoldItalic-lf-sc-lgr.tfm) tex(GaramondLibre-BoldItalic-lf-sc-ly1--base.tfm) tex(GaramondLibre-BoldItalic-lf-sc-ly1.tfm) tex(GaramondLibre-BoldItalic-lf-sc-ly1.vf) tex(GaramondLibre-BoldItalic-lf-sc-ot1--base.tfm) tex(GaramondLibre-BoldItalic-lf-sc-ot1.tfm) tex(GaramondLibre-BoldItalic-lf-sc-ot1.vf) tex(GaramondLibre-BoldItalic-lf-sc-t1--base.tfm) tex(GaramondLibre-BoldItalic-lf-sc-t1.tfm) tex(GaramondLibre-BoldItalic-lf-sc-t1.vf) tex(GaramondLibre-BoldItalic-lf-sc-t2a.tfm) tex(GaramondLibre-BoldItalic-lf-sc-t2b.tfm) tex(GaramondLibre-BoldItalic-lf-sc-t2c.tfm) tex(GaramondLibre-BoldItalic-lf-swash-lgr--base.tfm) tex(GaramondLibre-BoldItalic-lf-swash-lgr.tfm) tex(GaramondLibre-BoldItalic-lf-swash-lgr.vf) tex(GaramondLibre-BoldItalic-lf-swash-ly1.tfm) tex(GaramondLibre-BoldItalic-lf-swash-ot1--base.tfm) tex(GaramondLibre-BoldItalic-lf-swash-ot1.tfm) tex(GaramondLibre-BoldItalic-lf-swash-ot1.vf) tex(GaramondLibre-BoldItalic-lf-swash-t1--base.tfm) tex(GaramondLibre-BoldItalic-lf-swash-t1.tfm) tex(GaramondLibre-BoldItalic-lf-swash-t1.vf) tex(GaramondLibre-BoldItalic-lf-swash-t2a--base.tfm) tex(GaramondLibre-BoldItalic-lf-swash-t2a.tfm) tex(GaramondLibre-BoldItalic-lf-swash-t2a.vf) tex(GaramondLibre-BoldItalic-lf-swash-t2b--base.tfm) tex(GaramondLibre-BoldItalic-lf-swash-t2b.tfm) tex(GaramondLibre-BoldItalic-lf-swash-t2b.vf) tex(GaramondLibre-BoldItalic-lf-swash-t2c--base.tfm) tex(GaramondLibre-BoldItalic-lf-swash-t2c.tfm) tex(GaramondLibre-BoldItalic-lf-swash-t2c.vf) tex(GaramondLibre-BoldItalic-lf-t1--base.tfm) tex(GaramondLibre-BoldItalic-lf-t1.tfm) tex(GaramondLibre-BoldItalic-lf-t1.vf) tex(GaramondLibre-BoldItalic-lf-t2a.tfm) tex(GaramondLibre-BoldItalic-lf-t2b.tfm) tex(GaramondLibre-BoldItalic-lf-t2c.tfm) tex(GaramondLibre-BoldItalic-lf-ts1--base.tfm) tex(GaramondLibre-BoldItalic-lf-ts1.tfm) tex(GaramondLibre-BoldItalic-lf-ts1.vf) tex(GaramondLibre-BoldItalic-orn-u.tfm) tex(GaramondLibre-BoldItalic-osf-lgr.tfm) tex(GaramondLibre-BoldItalic-osf-ly1.tfm) tex(GaramondLibre-BoldItalic-osf-ot1.tfm) tex(GaramondLibre-BoldItalic-osf-sc-lgr.tfm) tex(GaramondLibre-BoldItalic-osf-sc-ly1--base.tfm) tex(GaramondLibre-BoldItalic-osf-sc-ly1.tfm) tex(GaramondLibre-BoldItalic-osf-sc-ly1.vf) tex(GaramondLibre-BoldItalic-osf-sc-ot1--base.tfm) tex(GaramondLibre-BoldItalic-osf-sc-ot1.tfm) tex(GaramondLibre-BoldItalic-osf-sc-ot1.vf) tex(GaramondLibre-BoldItalic-osf-sc-t1--base.tfm) tex(GaramondLibre-BoldItalic-osf-sc-t1.tfm) tex(GaramondLibre-BoldItalic-osf-sc-t1.vf) tex(GaramondLibre-BoldItalic-osf-sc-t2a.tfm) tex(GaramondLibre-BoldItalic-osf-sc-t2b.tfm) tex(GaramondLibre-BoldItalic-osf-sc-t2c.tfm) tex(GaramondLibre-BoldItalic-osf-swash-lgr--base.tfm) tex(GaramondLibre-BoldItalic-osf-swash-lgr.tfm) tex(GaramondLibre-BoldItalic-osf-swash-lgr.vf) tex(GaramondLibre-BoldItalic-osf-swash-ly1.tfm) tex(GaramondLibre-BoldItalic-osf-swash-ot1--base.tfm) tex(GaramondLibre-BoldItalic-osf-swash-ot1.tfm) tex(GaramondLibre-BoldItalic-osf-swash-ot1.vf) tex(GaramondLibre-BoldItalic-osf-swash-t1--base.tfm) tex(GaramondLibre-BoldItalic-osf-swash-t1.tfm) tex(GaramondLibre-BoldItalic-osf-swash-t1.vf) tex(GaramondLibre-BoldItalic-osf-swash-t2a--base.tfm) tex(GaramondLibre-BoldItalic-osf-swash-t2a.tfm) tex(GaramondLibre-BoldItalic-osf-swash-t2a.vf) tex(GaramondLibre-BoldItalic-osf-swash-t2b--base.tfm) tex(GaramondLibre-BoldItalic-osf-swash-t2b.tfm) tex(GaramondLibre-BoldItalic-osf-swash-t2b.vf) tex(GaramondLibre-BoldItalic-osf-swash-t2c--base.tfm) tex(GaramondLibre-BoldItalic-osf-swash-t2c.tfm) tex(GaramondLibre-BoldItalic-osf-swash-t2c.vf) tex(GaramondLibre-BoldItalic-osf-t1--base.tfm) tex(GaramondLibre-BoldItalic-osf-t1.tfm) tex(GaramondLibre-BoldItalic-osf-t1.vf) tex(GaramondLibre-BoldItalic-osf-t2a.tfm) tex(GaramondLibre-BoldItalic-osf-t2b.tfm) tex(GaramondLibre-BoldItalic-osf-t2c.tfm) tex(GaramondLibre-BoldItalic-osf-ts1--base.tfm) tex(GaramondLibre-BoldItalic-osf-ts1.tfm) tex(GaramondLibre-BoldItalic-osf-ts1.vf) tex(GaramondLibre-BoldItalic-sup-lgr.tfm) tex(GaramondLibre-BoldItalic-sup-ly1.tfm) tex(GaramondLibre-BoldItalic-sup-ot1.tfm) tex(GaramondLibre-BoldItalic-sup-t1--base.tfm) tex(GaramondLibre-BoldItalic-sup-t1.tfm) tex(GaramondLibre-BoldItalic-sup-t1.vf) tex(GaramondLibre-BoldItalic-sup-t2a.tfm) tex(GaramondLibre-BoldItalic-sup-t2b.tfm) tex(GaramondLibre-BoldItalic-sup-t2c.tfm) tex(GaramondLibre-Italic-inf-lgr.tfm) tex(GaramondLibre-Italic-inf-ly1.tfm) tex(GaramondLibre-Italic-inf-ot1.tfm) tex(GaramondLibre-Italic-inf-t1--base.tfm) tex(GaramondLibre-Italic-inf-t1.tfm) tex(GaramondLibre-Italic-inf-t1.vf) tex(GaramondLibre-Italic-inf-t2a.tfm) tex(GaramondLibre-Italic-inf-t2b.tfm) tex(GaramondLibre-Italic-inf-t2c.tfm) tex(GaramondLibre-Italic-lf-lgr.tfm) tex(GaramondLibre-Italic-lf-ly1.tfm) tex(GaramondLibre-Italic-lf-ot1.tfm) tex(GaramondLibre-Italic-lf-sc-lgr.tfm) tex(GaramondLibre-Italic-lf-sc-ly1--base.tfm) tex(GaramondLibre-Italic-lf-sc-ly1.tfm) tex(GaramondLibre-Italic-lf-sc-ly1.vf) tex(GaramondLibre-Italic-lf-sc-ot1--base.tfm) tex(GaramondLibre-Italic-lf-sc-ot1.tfm) tex(GaramondLibre-Italic-lf-sc-ot1.vf) tex(GaramondLibre-Italic-lf-sc-t1--base.tfm) tex(GaramondLibre-Italic-lf-sc-t1.tfm) tex(GaramondLibre-Italic-lf-sc-t1.vf) tex(GaramondLibre-Italic-lf-sc-t2a.tfm) tex(GaramondLibre-Italic-lf-sc-t2b.tfm) tex(GaramondLibre-Italic-lf-sc-t2c.tfm) tex(GaramondLibre-Italic-lf-swash-lgr--base.tfm) tex(GaramondLibre-Italic-lf-swash-lgr.tfm) tex(GaramondLibre-Italic-lf-swash-lgr.vf) tex(GaramondLibre-Italic-lf-swash-ly1.tfm) tex(GaramondLibre-Italic-lf-swash-ot1--base.tfm) tex(GaramondLibre-Italic-lf-swash-ot1.tfm) tex(GaramondLibre-Italic-lf-swash-ot1.vf) tex(GaramondLibre-Italic-lf-swash-t1--base.tfm) tex(GaramondLibre-Italic-lf-swash-t1.tfm) tex(GaramondLibre-Italic-lf-swash-t1.vf) tex(GaramondLibre-Italic-lf-swash-t2a--base.tfm) tex(GaramondLibre-Italic-lf-swash-t2a.tfm) tex(GaramondLibre-Italic-lf-swash-t2a.vf) tex(GaramondLibre-Italic-lf-swash-t2b--base.tfm) tex(GaramondLibre-Italic-lf-swash-t2b.tfm) tex(GaramondLibre-Italic-lf-swash-t2b.vf) tex(GaramondLibre-Italic-lf-swash-t2c--base.tfm) tex(GaramondLibre-Italic-lf-swash-t2c.tfm) tex(GaramondLibre-Italic-lf-swash-t2c.vf) tex(GaramondLibre-Italic-lf-t1--base.tfm) tex(GaramondLibre-Italic-lf-t1.tfm) tex(GaramondLibre-Italic-lf-t1.vf) tex(GaramondLibre-Italic-lf-t2a.tfm) tex(GaramondLibre-Italic-lf-t2b.tfm) tex(GaramondLibre-Italic-lf-t2c.tfm) tex(GaramondLibre-Italic-lf-ts1--base.tfm) tex(GaramondLibre-Italic-lf-ts1.tfm) tex(GaramondLibre-Italic-lf-ts1.vf) tex(GaramondLibre-Italic-orn-u.tfm) tex(GaramondLibre-Italic-osf-lgr.tfm) tex(GaramondLibre-Italic-osf-ly1.tfm) tex(GaramondLibre-Italic-osf-ot1.tfm) tex(GaramondLibre-Italic-osf-sc-lgr.tfm) tex(GaramondLibre-Italic-osf-sc-ly1--base.tfm) tex(GaramondLibre-Italic-osf-sc-ly1.tfm) tex(GaramondLibre-Italic-osf-sc-ly1.vf) tex(GaramondLibre-Italic-osf-sc-ot1--base.tfm) tex(GaramondLibre-Italic-osf-sc-ot1.tfm) tex(GaramondLibre-Italic-osf-sc-ot1.vf) tex(GaramondLibre-Italic-osf-sc-t1--base.tfm) tex(GaramondLibre-Italic-osf-sc-t1.tfm) tex(GaramondLibre-Italic-osf-sc-t1.vf) tex(GaramondLibre-Italic-osf-sc-t2a.tfm) tex(GaramondLibre-Italic-osf-sc-t2b.tfm) tex(GaramondLibre-Italic-osf-sc-t2c.tfm) tex(GaramondLibre-Italic-osf-swash-lgr--base.tfm) tex(GaramondLibre-Italic-osf-swash-lgr.tfm) tex(GaramondLibre-Italic-osf-swash-lgr.vf) tex(GaramondLibre-Italic-osf-swash-ly1.tfm) tex(GaramondLibre-Italic-osf-swash-ot1--base.tfm) tex(GaramondLibre-Italic-osf-swash-ot1.tfm) tex(GaramondLibre-Italic-osf-swash-ot1.vf) tex(GaramondLibre-Italic-osf-swash-t1--base.tfm) tex(GaramondLibre-Italic-osf-swash-t1.tfm) tex(GaramondLibre-Italic-osf-swash-t1.vf) tex(GaramondLibre-Italic-osf-swash-t2a--base.tfm) tex(GaramondLibre-Italic-osf-swash-t2a.tfm) tex(GaramondLibre-Italic-osf-swash-t2a.vf) tex(GaramondLibre-Italic-osf-swash-t2b--base.tfm) tex(GaramondLibre-Italic-osf-swash-t2b.tfm) tex(GaramondLibre-Italic-osf-swash-t2b.vf) tex(GaramondLibre-Italic-osf-swash-t2c--base.tfm) tex(GaramondLibre-Italic-osf-swash-t2c.tfm) tex(GaramondLibre-Italic-osf-swash-t2c.vf) tex(GaramondLibre-Italic-osf-t1--base.tfm) tex(GaramondLibre-Italic-osf-t1.tfm) tex(GaramondLibre-Italic-osf-t1.vf) tex(GaramondLibre-Italic-osf-t2a.tfm) tex(GaramondLibre-Italic-osf-t2b.tfm) tex(GaramondLibre-Italic-osf-t2c.tfm) tex(GaramondLibre-Italic-osf-ts1--base.tfm) tex(GaramondLibre-Italic-osf-ts1.tfm) tex(GaramondLibre-Italic-osf-ts1.vf) tex(GaramondLibre-Italic-sup-lgr.tfm) tex(GaramondLibre-Italic-sup-ly1.tfm) tex(GaramondLibre-Italic-sup-ot1.tfm) tex(GaramondLibre-Italic-sup-t1--base.tfm) tex(GaramondLibre-Italic-sup-t1.tfm) tex(GaramondLibre-Italic-sup-t1.vf) tex(GaramondLibre-Italic-sup-t2a.tfm) tex(GaramondLibre-Italic-sup-t2b.tfm) tex(GaramondLibre-Italic-sup-t2c.tfm) tex(GaramondLibre-Regular-inf-lgr.tfm) tex(GaramondLibre-Regular-inf-ly1.tfm) tex(GaramondLibre-Regular-inf-ot1.tfm) tex(GaramondLibre-Regular-inf-t1--base.tfm) tex(GaramondLibre-Regular-inf-t1.tfm) tex(GaramondLibre-Regular-inf-t1.vf) tex(GaramondLibre-Regular-inf-t2a.tfm) tex(GaramondLibre-Regular-inf-t2b.tfm) tex(GaramondLibre-Regular-inf-t2c.tfm) tex(GaramondLibre-Regular-lf-lgr.tfm) tex(GaramondLibre-Regular-lf-ly1.tfm) tex(GaramondLibre-Regular-lf-ot1.tfm) tex(GaramondLibre-Regular-lf-sc-lgr.tfm) tex(GaramondLibre-Regular-lf-sc-ly1--base.tfm) tex(GaramondLibre-Regular-lf-sc-ly1.tfm) tex(GaramondLibre-Regular-lf-sc-ly1.vf) tex(GaramondLibre-Regular-lf-sc-ot1--base.tfm) tex(GaramondLibre-Regular-lf-sc-ot1.tfm) tex(GaramondLibre-Regular-lf-sc-ot1.vf) tex(GaramondLibre-Regular-lf-sc-t1--base.tfm) tex(GaramondLibre-Regular-lf-sc-t1.tfm) tex(GaramondLibre-Regular-lf-sc-t1.vf) tex(GaramondLibre-Regular-lf-sc-t2a.tfm) tex(GaramondLibre-Regular-lf-sc-t2b.tfm) tex(GaramondLibre-Regular-lf-sc-t2c.tfm) tex(GaramondLibre-Regular-lf-swash-lgr--base.tfm) tex(GaramondLibre-Regular-lf-swash-lgr.tfm) tex(GaramondLibre-Regular-lf-swash-lgr.vf) tex(GaramondLibre-Regular-lf-swash-ly1.tfm) tex(GaramondLibre-Regular-lf-swash-ot1--base.tfm) tex(GaramondLibre-Regular-lf-swash-ot1.tfm) tex(GaramondLibre-Regular-lf-swash-ot1.vf) tex(GaramondLibre-Regular-lf-swash-t1--base.tfm) tex(GaramondLibre-Regular-lf-swash-t1.tfm) tex(GaramondLibre-Regular-lf-swash-t1.vf) tex(GaramondLibre-Regular-lf-swash-t2a--base.tfm) tex(GaramondLibre-Regular-lf-swash-t2a.tfm) tex(GaramondLibre-Regular-lf-swash-t2a.vf) tex(GaramondLibre-Regular-lf-swash-t2b--base.tfm) tex(GaramondLibre-Regular-lf-swash-t2b.tfm) tex(GaramondLibre-Regular-lf-swash-t2b.vf) tex(GaramondLibre-Regular-lf-swash-t2c--base.tfm) tex(GaramondLibre-Regular-lf-swash-t2c.tfm) tex(GaramondLibre-Regular-lf-swash-t2c.vf) tex(GaramondLibre-Regular-lf-t1--base.tfm) tex(GaramondLibre-Regular-lf-t1.tfm) tex(GaramondLibre-Regular-lf-t1.vf) tex(GaramondLibre-Regular-lf-t2a.tfm) tex(GaramondLibre-Regular-lf-t2b.tfm) tex(GaramondLibre-Regular-lf-t2c.tfm) tex(GaramondLibre-Regular-lf-ts1--base.tfm) tex(GaramondLibre-Regular-lf-ts1.tfm) tex(GaramondLibre-Regular-lf-ts1.vf) tex(GaramondLibre-Regular-orn-u.tfm) tex(GaramondLibre-Regular-osf-lgr.tfm) tex(GaramondLibre-Regular-osf-ly1.tfm) tex(GaramondLibre-Regular-osf-ot1.tfm) tex(GaramondLibre-Regular-osf-sc-lgr.tfm) tex(GaramondLibre-Regular-osf-sc-ly1--base.tfm) tex(GaramondLibre-Regular-osf-sc-ly1.tfm) tex(GaramondLibre-Regular-osf-sc-ly1.vf) tex(GaramondLibre-Regular-osf-sc-ot1--base.tfm) tex(GaramondLibre-Regular-osf-sc-ot1.tfm) tex(GaramondLibre-Regular-osf-sc-ot1.vf) tex(GaramondLibre-Regular-osf-sc-t1--base.tfm) tex(GaramondLibre-Regular-osf-sc-t1.tfm) tex(GaramondLibre-Regular-osf-sc-t1.vf) tex(GaramondLibre-Regular-osf-sc-t2a.tfm) tex(GaramondLibre-Regular-osf-sc-t2b.tfm) tex(GaramondLibre-Regular-osf-sc-t2c.tfm) tex(GaramondLibre-Regular-osf-swash-lgr--base.tfm) tex(GaramondLibre-Regular-osf-swash-lgr.tfm) tex(GaramondLibre-Regular-osf-swash-lgr.vf) tex(GaramondLibre-Regular-osf-swash-ly1.tfm) tex(GaramondLibre-Regular-osf-swash-ot1--base.tfm) tex(GaramondLibre-Regular-osf-swash-ot1.tfm) tex(GaramondLibre-Regular-osf-swash-ot1.vf) tex(GaramondLibre-Regular-osf-swash-t1--base.tfm) tex(GaramondLibre-Regular-osf-swash-t1.tfm) tex(GaramondLibre-Regular-osf-swash-t1.vf) tex(GaramondLibre-Regular-osf-swash-t2a--base.tfm) tex(GaramondLibre-Regular-osf-swash-t2a.tfm) tex(GaramondLibre-Regular-osf-swash-t2a.vf) tex(GaramondLibre-Regular-osf-swash-t2b--base.tfm) tex(GaramondLibre-Regular-osf-swash-t2b.tfm) tex(GaramondLibre-Regular-osf-swash-t2b.vf) tex(GaramondLibre-Regular-osf-swash-t2c--base.tfm) tex(GaramondLibre-Regular-osf-swash-t2c.tfm) tex(GaramondLibre-Regular-osf-swash-t2c.vf) tex(GaramondLibre-Regular-osf-t1--base.tfm) tex(GaramondLibre-Regular-osf-t1.tfm) tex(GaramondLibre-Regular-osf-t1.vf) tex(GaramondLibre-Regular-osf-t2a.tfm) tex(GaramondLibre-Regular-osf-t2b.tfm) tex(GaramondLibre-Regular-osf-t2c.tfm) tex(GaramondLibre-Regular-osf-ts1--base.tfm) tex(GaramondLibre-Regular-osf-ts1.tfm) tex(GaramondLibre-Regular-osf-ts1.vf) tex(GaramondLibre-Regular-sup-lgr.tfm) tex(GaramondLibre-Regular-sup-ly1.tfm) tex(GaramondLibre-Regular-sup-ot1.tfm) tex(GaramondLibre-Regular-sup-t1--base.tfm) tex(GaramondLibre-Regular-sup-t1.tfm) tex(GaramondLibre-Regular-sup-t1.vf) tex(GaramondLibre-Regular-sup-t2a.tfm) tex(GaramondLibre-Regular-sup-t2b.tfm) tex(GaramondLibre-Regular-sup-t2c.tfm) tex(GaramondLibre.map) tex(LGRGaramondLibre-Inf.fd) tex(LGRGaramondLibre-LF.fd) tex(LGRGaramondLibre-OsF.fd) tex(LGRGaramondLibre-Sup.fd) tex(LY1GaramondLibre-Inf.fd) tex(LY1GaramondLibre-LF.fd) tex(LY1GaramondLibre-OsF.fd) tex(LY1GaramondLibre-Sup.fd) tex(OT1GaramondLibre-Inf.fd) tex(OT1GaramondLibre-LF.fd) tex(OT1GaramondLibre-OsF.fd) tex(OT1GaramondLibre-Sup.fd) tex(T1GaramondLibre-Inf.fd) tex(T1GaramondLibre-LF.fd) tex(T1GaramondLibre-OsF.fd) tex(T1GaramondLibre-Sup.fd) tex(T2AGaramondLibre-Inf.fd) tex(T2AGaramondLibre-LF.fd) tex(T2AGaramondLibre-OsF.fd) tex(T2AGaramondLibre-Sup.fd) tex(T2BGaramondLibre-Inf.fd) tex(T2BGaramondLibre-LF.fd) tex(T2BGaramondLibre-OsF.fd) tex(T2BGaramondLibre-Sup.fd) tex(T2CGaramondLibre-Inf.fd) tex(T2CGaramondLibre-LF.fd) tex(T2CGaramondLibre-OsF.fd) tex(T2CGaramondLibre-Sup.fd) tex(TS1GaramondLibre-LF.fd) tex(TS1GaramondLibre-OsF.fd) tex(UGaramondLibre-Orn.fd) tex(garamondlibre.sty) tex(grmlbr_26qpf7.enc) tex(grmlbr_2ituzd.enc) tex(grmlbr_3mt3an.enc) tex(grmlbr_3w7ozp.enc) tex(grmlbr_4b5hhp.enc) tex(grmlbr_6l5pxo.enc) tex(grmlbr_af3fmk.enc) tex(grmlbr_c7o3pq.enc) tex(grmlbr_crzyr4.enc) tex(grmlbr_cwdpfu.enc) tex(grmlbr_d5jenc.enc) tex(grmlbr_ddg2jn.enc) tex(grmlbr_ddnxa5.enc) tex(grmlbr_fb533q.enc) tex(grmlbr_ft27f3.enc) tex(grmlbr_fukic5.enc) tex(grmlbr_h5igdn.enc) tex(grmlbr_hbrvqa.enc) tex(grmlbr_hejid2.enc) tex(grmlbr_huatgi.enc) tex(grmlbr_ikpupx.enc) tex(grmlbr_iqbnqe.enc) tex(grmlbr_jwpqsx.enc) tex(grmlbr_kk2l3t.enc) tex(grmlbr_kyvbob.enc) tex(grmlbr_l5k5jt.enc) tex(grmlbr_ljc3nf.enc) tex(grmlbr_m5zyzk.enc) tex(grmlbr_madlva.enc) tex(grmlbr_nhixbh.enc) tex(grmlbr_nnzq7g.enc) tex(grmlbr_o3pzn3.enc) tex(grmlbr_oo4va4.enc) tex(grmlbr_p5a7xq.enc) tex(grmlbr_pcz4ad.enc) tex(grmlbr_pmempd.enc) tex(grmlbr_qgzksw.enc) tex(grmlbr_ql6cag.enc) tex(grmlbr_qnkmaf.enc) tex(grmlbr_qyly2w.enc) tex(grmlbr_rxhqtw.enc) tex(grmlbr_sbgl2v.enc) tex(grmlbr_srtteg.enc) tex(grmlbr_syncrn.enc) tex(grmlbr_tx4wra.enc) tex(grmlbr_u674gk.enc) tex(grmlbr_u7zlyy.enc) tex(grmlbr_ujl4dj.enc) tex(grmlbr_vzduxe.enc) tex(grmlbr_wgjy5a.enc) tex(grmlbr_wkdlc7.enc) tex(grmlbr_wt2iav.enc) tex(grmlbr_xqilo4.enc) tex(grmlbr_y75trc.enc) tex(grmlbr_yeyti3.enc) tex(grmlbr_yonrxo.enc) tex(grmlbr_zoesgh.enc) tex(grmlbr_zslxeq.enc) tex(grmlbr_zy2up7.enc) texlive-garamond-libre"
RDEPENDS:${PN} += "/bin/sh coreutils ed findutils grep sed tex(fontaxes.sty) tex(fontenc.sty) tex(fontspec.sty) tex(ifluatex.sty) tex(ifxetex.sty) tex(mweights.sty) tex(textcomp.sty) tex(updmap.cfg) tex(xkeyval.sty) texlive texlive-filesystem texlive-garamond-libre-fonts texlive-kpathsea texlive-kpathsea-bin texlive-scripts texlive-scripts-bin"

inherit rpm
