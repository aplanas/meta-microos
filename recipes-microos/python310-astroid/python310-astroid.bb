SUMMARY = "Representation of Python source as an AST for pylint"
DESCRIPTION = "This module provides a common base representation of Python source code for \
projects such as pychecker, pyreverse, pylint. The development of this library \
is governed by pylint's needs. \
 \
It provides a compatible representation which comes from the _ast \
module. It rebuilds the tree generated by the builtin _ast module by \
recursively walking down the AST and building an extended ast. The new \
node classes have additional methods and attributes for different \
usages. They include some support for static inference and local name \
scopes. Furthermore, astroid builds partial trees by inspecting living \
objects."
LICENSE = "LGPL-2.1-or-later"

PV = "2.15.4"

RPM_NAME = "python310-astroid-2.15.4-2.1.noarch.rpm"
RPM_HASH = "838c3eefa3761e444fddbf4d844bb56e27d7f6e0918ba9860dba87a540d9ba8bcac3ecdf9c68035237c4d4274341d0b73fc430216df7de957630ba559978d28f"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "python3-astroid python3.10dist(astroid) python310-astroid python3dist(astroid)"
RDEPENDS:${PN} += "python(abi) python310-lazy-object-proxy python310-typing-extensions python310-wrapt"

inherit rpm
