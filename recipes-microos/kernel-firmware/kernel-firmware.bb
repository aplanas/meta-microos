SUMMARY = "Linux kernel firmware files"
DESCRIPTION = "This package contains the raw uncompressed firmware files for Linux kernel \
drivers.  This package is provided only for compatibility with older kernels \
that do not support the compressed format."
LICENSE = "GPL-2.0-only & SUSE-Firmware & GPL-2.0-or-later & MIT"

PV = "20230427"

RPM_NAME = "kernel-firmware-20230427-1.1.noarch.rpm"
RPM_HASH = "2dc7704959ff9e7a91474ce9153e7866d276a2c220944cfdb98bc53ab1356f6af462f49175cbf2948f3a94b9379452b7e1af154225b317759bc9d9a25b3fdc88"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "3-model-a-plus.txt) 3-model-b-plus.txt) 3-model-b.txt) 4 4-model-b.txt) 4.txt) B.txt) C0 COMPUTER Compute Corp.-VALLEYVIEW Corporation-CHERRYVIEW D1 Foundation-Raspberry INC.-TF103CE.txt) Inc-Mipad2.txt) Model Module PLATFORM.txt) PLUS.txt) Pi Z83-4.txt) am5729-beagleboneai.txt) ath3k-firmware aura.txt) bananapro.txt) bcm43xx-firmware:/lib/firmware/brcm/brcmfmac43430-sdio.bin beaglev-starlight-jh7100-a1.txt) beaglev-starlight-jh7100-r0.txt) bpi-m2-plus.txt) bpi-m2-ultra.txt) bpi-m2-zero.txt) bpi-m3.txt) compat-wireless-firmware cubietruck.txt) cxgb3-firmware firefly-rk3399.txt) firmware(3com/typhoon.bin) firmware(RTL8192E/boot.img) firmware(RTL8192E/data.img) firmware(RTL8192E/main.img) firmware(a300_pfp.fw) firmware(a300_pm4.fw) firmware(acenic/tg1.bin) firmware(acenic/tg2.bin) firmware(adaptec/starfire_rx.bin) firmware(adaptec/starfire_tx.bin) firmware(advansys/3550.bin) firmware(advansys/38C0800.bin) firmware(advansys/38C1600.bin) firmware(advansys/mcode.bin) firmware(agere_ap_fw.bin) firmware(agere_sta_fw.bin) firmware(amd/amd_sev_fam17h_model0xh.sbin) firmware(amd/amd_sev_fam17h_model3xh.sbin) firmware(amd/amd_sev_fam19h_model0xh.sbin) firmware(amdgpu/aldebaran_mec.bin) firmware(amdgpu/aldebaran_mec2.bin) firmware(amdgpu/aldebaran_rlc.bin) firmware(amdgpu/aldebaran_sdma.bin) firmware(amdgpu/aldebaran_sjt_mec.bin) firmware(amdgpu/aldebaran_sjt_mec2.bin) firmware(amdgpu/aldebaran_smc.bin) firmware(amdgpu/aldebaran_sos.bin) firmware(amdgpu/aldebaran_ta.bin) firmware(amdgpu/aldebaran_vcn.bin) firmware(amdgpu/arcturus_asd.bin) firmware(amdgpu/arcturus_gpu_info.bin) firmware(amdgpu/arcturus_mec.bin) firmware(amdgpu/arcturus_mec2.bin) firmware(amdgpu/arcturus_rlc.bin) firmware(amdgpu/arcturus_sdma.bin) firmware(amdgpu/arcturus_smc.bin) firmware(amdgpu/arcturus_sos.bin) firmware(amdgpu/arcturus_ta.bin) firmware(amdgpu/arcturus_vcn.bin) firmware(amdgpu/banks_k_2_smc.bin) firmware(amdgpu/beige_goby_ce.bin) firmware(amdgpu/beige_goby_dmcub.bin) firmware(amdgpu/beige_goby_me.bin) firmware(amdgpu/beige_goby_mec.bin) firmware(amdgpu/beige_goby_mec2.bin) firmware(amdgpu/beige_goby_pfp.bin) firmware(amdgpu/beige_goby_rlc.bin) firmware(amdgpu/beige_goby_sdma.bin) firmware(amdgpu/beige_goby_smc.bin) firmware(amdgpu/beige_goby_sos.bin) firmware(amdgpu/beige_goby_ta.bin) firmware(amdgpu/beige_goby_vcn.bin) firmware(amdgpu/bonaire_ce.bin) firmware(amdgpu/bonaire_k_smc.bin) firmware(amdgpu/bonaire_mc.bin) firmware(amdgpu/bonaire_me.bin) firmware(amdgpu/bonaire_mec.bin) firmware(amdgpu/bonaire_pfp.bin) firmware(amdgpu/bonaire_rlc.bin) firmware(amdgpu/bonaire_sdma.bin) firmware(amdgpu/bonaire_sdma1.bin) firmware(amdgpu/bonaire_smc.bin) firmware(amdgpu/bonaire_uvd.bin) firmware(amdgpu/bonaire_vce.bin) firmware(amdgpu/carrizo_ce.bin) firmware(amdgpu/carrizo_me.bin) firmware(amdgpu/carrizo_mec.bin) firmware(amdgpu/carrizo_mec2.bin) firmware(amdgpu/carrizo_pfp.bin) firmware(amdgpu/carrizo_rlc.bin) firmware(amdgpu/carrizo_sdma.bin) firmware(amdgpu/carrizo_sdma1.bin) firmware(amdgpu/carrizo_uvd.bin) firmware(amdgpu/carrizo_vce.bin) firmware(amdgpu/cyan_skillfish2_ce.bin) firmware(amdgpu/cyan_skillfish2_me.bin) firmware(amdgpu/cyan_skillfish2_mec.bin) firmware(amdgpu/cyan_skillfish2_mec2.bin) firmware(amdgpu/cyan_skillfish2_pfp.bin) firmware(amdgpu/cyan_skillfish2_rlc.bin) firmware(amdgpu/cyan_skillfish2_sdma.bin) firmware(amdgpu/cyan_skillfish2_sdma1.bin) firmware(amdgpu/dcn_3_1_4_dmcub.bin) firmware(amdgpu/dcn_3_1_5_dmcub.bin) firmware(amdgpu/dcn_3_1_6_dmcub.bin) firmware(amdgpu/dcn_3_2_0_dmcub.bin) firmware(amdgpu/dcn_3_2_1_dmcub.bin) firmware(amdgpu/dimgrey_cavefish_ce.bin) firmware(amdgpu/dimgrey_cavefish_dmcub.bin) firmware(amdgpu/dimgrey_cavefish_me.bin) firmware(amdgpu/dimgrey_cavefish_mec.bin) firmware(amdgpu/dimgrey_cavefish_mec2.bin) firmware(amdgpu/dimgrey_cavefish_pfp.bin) firmware(amdgpu/dimgrey_cavefish_rlc.bin) firmware(amdgpu/dimgrey_cavefish_sdma.bin) firmware(amdgpu/dimgrey_cavefish_smc.bin) firmware(amdgpu/dimgrey_cavefish_sos.bin) firmware(amdgpu/dimgrey_cavefish_ta.bin) firmware(amdgpu/dimgrey_cavefish_vcn.bin) firmware(amdgpu/fiji_ce.bin) firmware(amdgpu/fiji_mc.bin) firmware(amdgpu/fiji_me.bin) firmware(amdgpu/fiji_mec.bin) firmware(amdgpu/fiji_mec2.bin) firmware(amdgpu/fiji_pfp.bin) firmware(amdgpu/fiji_rlc.bin) firmware(amdgpu/fiji_sdma.bin) firmware(amdgpu/fiji_sdma1.bin) firmware(amdgpu/fiji_smc.bin) firmware(amdgpu/fiji_uvd.bin) firmware(amdgpu/fiji_vce.bin) firmware(amdgpu/gc_10_3_6_ce.bin) firmware(amdgpu/gc_10_3_6_me.bin) firmware(amdgpu/gc_10_3_6_mec.bin) firmware(amdgpu/gc_10_3_6_mec2.bin) firmware(amdgpu/gc_10_3_6_pfp.bin) firmware(amdgpu/gc_10_3_6_rlc.bin) firmware(amdgpu/gc_10_3_7_ce.bin) firmware(amdgpu/gc_10_3_7_me.bin) firmware(amdgpu/gc_10_3_7_mec.bin) firmware(amdgpu/gc_10_3_7_mec2.bin) firmware(amdgpu/gc_10_3_7_pfp.bin) firmware(amdgpu/gc_10_3_7_rlc.bin) firmware(amdgpu/gc_11_0_0_imu.bin) firmware(amdgpu/gc_11_0_0_me.bin) firmware(amdgpu/gc_11_0_0_mec.bin) firmware(amdgpu/gc_11_0_0_mes.bin) firmware(amdgpu/gc_11_0_0_mes1.bin) firmware(amdgpu/gc_11_0_0_pfp.bin) firmware(amdgpu/gc_11_0_0_rlc.bin) firmware(amdgpu/gc_11_0_1_imu.bin) firmware(amdgpu/gc_11_0_1_me.bin) firmware(amdgpu/gc_11_0_1_mec.bin) firmware(amdgpu/gc_11_0_1_mes.bin) firmware(amdgpu/gc_11_0_1_mes1.bin) firmware(amdgpu/gc_11_0_1_pfp.bin) firmware(amdgpu/gc_11_0_1_rlc.bin) firmware(amdgpu/gc_11_0_2_imu.bin) firmware(amdgpu/gc_11_0_2_me.bin) firmware(amdgpu/gc_11_0_2_mec.bin) firmware(amdgpu/gc_11_0_2_mes.bin) firmware(amdgpu/gc_11_0_2_mes1.bin) firmware(amdgpu/gc_11_0_2_pfp.bin) firmware(amdgpu/gc_11_0_2_rlc.bin) firmware(amdgpu/gc_11_0_4_imu.bin) firmware(amdgpu/gc_11_0_4_me.bin) firmware(amdgpu/gc_11_0_4_mec.bin) firmware(amdgpu/gc_11_0_4_mes.bin) firmware(amdgpu/gc_11_0_4_mes1.bin) firmware(amdgpu/gc_11_0_4_pfp.bin) firmware(amdgpu/gc_11_0_4_rlc.bin) firmware(amdgpu/green_sardine_asd.bin) firmware(amdgpu/green_sardine_ce.bin) firmware(amdgpu/green_sardine_dmcub.bin) firmware(amdgpu/green_sardine_me.bin) firmware(amdgpu/green_sardine_mec.bin) firmware(amdgpu/green_sardine_mec2.bin) firmware(amdgpu/green_sardine_pfp.bin) firmware(amdgpu/green_sardine_rlc.bin) firmware(amdgpu/green_sardine_sdma.bin) firmware(amdgpu/green_sardine_ta.bin) firmware(amdgpu/green_sardine_vcn.bin) firmware(amdgpu/hainan_ce.bin) firmware(amdgpu/hainan_k_smc.bin) firmware(amdgpu/hainan_mc.bin) firmware(amdgpu/hainan_me.bin) firmware(amdgpu/hainan_pfp.bin) firmware(amdgpu/hainan_rlc.bin) firmware(amdgpu/hainan_smc.bin) firmware(amdgpu/hawaii_ce.bin) firmware(amdgpu/hawaii_k_smc.bin) firmware(amdgpu/hawaii_mc.bin) firmware(amdgpu/hawaii_me.bin) firmware(amdgpu/hawaii_mec.bin) firmware(amdgpu/hawaii_pfp.bin) firmware(amdgpu/hawaii_rlc.bin) firmware(amdgpu/hawaii_sdma.bin) firmware(amdgpu/hawaii_sdma1.bin) firmware(amdgpu/hawaii_smc.bin) firmware(amdgpu/hawaii_uvd.bin) firmware(amdgpu/hawaii_vce.bin) firmware(amdgpu/kabini_ce.bin) firmware(amdgpu/kabini_me.bin) firmware(amdgpu/kabini_mec.bin) firmware(amdgpu/kabini_pfp.bin) firmware(amdgpu/kabini_rlc.bin) firmware(amdgpu/kabini_sdma.bin) firmware(amdgpu/kabini_sdma1.bin) firmware(amdgpu/kabini_uvd.bin) firmware(amdgpu/kabini_vce.bin) firmware(amdgpu/kaveri_ce.bin) firmware(amdgpu/kaveri_me.bin) firmware(amdgpu/kaveri_mec.bin) firmware(amdgpu/kaveri_mec2.bin) firmware(amdgpu/kaveri_pfp.bin) firmware(amdgpu/kaveri_rlc.bin) firmware(amdgpu/kaveri_sdma.bin) firmware(amdgpu/kaveri_sdma1.bin) firmware(amdgpu/kaveri_uvd.bin) firmware(amdgpu/kaveri_vce.bin) firmware(amdgpu/mullins_ce.bin) firmware(amdgpu/mullins_me.bin) firmware(amdgpu/mullins_mec.bin) firmware(amdgpu/mullins_pfp.bin) firmware(amdgpu/mullins_rlc.bin) firmware(amdgpu/mullins_sdma.bin) firmware(amdgpu/mullins_sdma1.bin) firmware(amdgpu/mullins_uvd.bin) firmware(amdgpu/mullins_vce.bin) firmware(amdgpu/navi10_asd.bin) firmware(amdgpu/navi10_ce.bin) firmware(amdgpu/navi10_gpu_info.bin) firmware(amdgpu/navi10_me.bin) firmware(amdgpu/navi10_mec.bin) firmware(amdgpu/navi10_mec2.bin) firmware(amdgpu/navi10_pfp.bin) firmware(amdgpu/navi10_rlc.bin) firmware(amdgpu/navi10_sdma.bin) firmware(amdgpu/navi10_sdma1.bin) firmware(amdgpu/navi10_smc.bin) firmware(amdgpu/navi10_sos.bin) firmware(amdgpu/navi10_ta.bin) firmware(amdgpu/navi10_vcn.bin) firmware(amdgpu/navi12_asd.bin) firmware(amdgpu/navi12_ce.bin) firmware(amdgpu/navi12_dmcu.bin) firmware(amdgpu/navi12_gpu_info.bin) firmware(amdgpu/navi12_me.bin) firmware(amdgpu/navi12_mec.bin) firmware(amdgpu/navi12_mec2.bin) firmware(amdgpu/navi12_pfp.bin) firmware(amdgpu/navi12_rlc.bin) firmware(amdgpu/navi12_sdma.bin) firmware(amdgpu/navi12_sdma1.bin) firmware(amdgpu/navi12_smc.bin) firmware(amdgpu/navi12_sos.bin) firmware(amdgpu/navi12_ta.bin) firmware(amdgpu/navi12_vcn.bin) firmware(amdgpu/navi14_asd.bin) firmware(amdgpu/navi14_ce.bin) firmware(amdgpu/navi14_ce_wks.bin) firmware(amdgpu/navi14_gpu_info.bin) firmware(amdgpu/navi14_me.bin) firmware(amdgpu/navi14_me_wks.bin) firmware(amdgpu/navi14_mec.bin) firmware(amdgpu/navi14_mec2.bin) firmware(amdgpu/navi14_mec2_wks.bin) firmware(amdgpu/navi14_mec_wks.bin) firmware(amdgpu/navi14_pfp.bin) firmware(amdgpu/navi14_pfp_wks.bin) firmware(amdgpu/navi14_rlc.bin) firmware(amdgpu/navi14_sdma.bin) firmware(amdgpu/navi14_sdma1.bin) firmware(amdgpu/navi14_smc.bin) firmware(amdgpu/navi14_sos.bin) firmware(amdgpu/navi14_ta.bin) firmware(amdgpu/navi14_vcn.bin) firmware(amdgpu/navy_flounder_ce.bin) firmware(amdgpu/navy_flounder_dmcub.bin) firmware(amdgpu/navy_flounder_me.bin) firmware(amdgpu/navy_flounder_mec.bin) firmware(amdgpu/navy_flounder_mec2.bin) firmware(amdgpu/navy_flounder_pfp.bin) firmware(amdgpu/navy_flounder_rlc.bin) firmware(amdgpu/navy_flounder_sdma.bin) firmware(amdgpu/navy_flounder_smc.bin) firmware(amdgpu/navy_flounder_sos.bin) firmware(amdgpu/navy_flounder_ta.bin) firmware(amdgpu/navy_flounder_vcn.bin) firmware(amdgpu/oland_ce.bin) firmware(amdgpu/oland_k_smc.bin) firmware(amdgpu/oland_mc.bin) firmware(amdgpu/oland_me.bin) firmware(amdgpu/oland_pfp.bin) firmware(amdgpu/oland_rlc.bin) firmware(amdgpu/oland_smc.bin) firmware(amdgpu/oland_uvd.bin) firmware(amdgpu/picasso_asd.bin) firmware(amdgpu/picasso_ce.bin) firmware(amdgpu/picasso_gpu_info.bin) firmware(amdgpu/picasso_me.bin) firmware(amdgpu/picasso_mec.bin) firmware(amdgpu/picasso_mec2.bin) firmware(amdgpu/picasso_pfp.bin) firmware(amdgpu/picasso_rlc.bin) firmware(amdgpu/picasso_rlc_am4.bin) firmware(amdgpu/picasso_sdma.bin) firmware(amdgpu/picasso_ta.bin) firmware(amdgpu/picasso_vcn.bin) firmware(amdgpu/pitcairn_ce.bin) firmware(amdgpu/pitcairn_k_smc.bin) firmware(amdgpu/pitcairn_mc.bin) firmware(amdgpu/pitcairn_me.bin) firmware(amdgpu/pitcairn_pfp.bin) firmware(amdgpu/pitcairn_rlc.bin) firmware(amdgpu/pitcairn_smc.bin) firmware(amdgpu/pitcairn_uvd.bin) firmware(amdgpu/polaris10_ce.bin) firmware(amdgpu/polaris10_ce_2.bin) firmware(amdgpu/polaris10_k2_smc.bin) firmware(amdgpu/polaris10_k_mc.bin) firmware(amdgpu/polaris10_k_smc.bin) firmware(amdgpu/polaris10_mc.bin) firmware(amdgpu/polaris10_me.bin) firmware(amdgpu/polaris10_me_2.bin) firmware(amdgpu/polaris10_mec.bin) firmware(amdgpu/polaris10_mec2.bin) firmware(amdgpu/polaris10_mec2_2.bin) firmware(amdgpu/polaris10_mec_2.bin) firmware(amdgpu/polaris10_pfp.bin) firmware(amdgpu/polaris10_pfp_2.bin) firmware(amdgpu/polaris10_rlc.bin) firmware(amdgpu/polaris10_sdma.bin) firmware(amdgpu/polaris10_sdma1.bin) firmware(amdgpu/polaris10_smc.bin) firmware(amdgpu/polaris10_smc_sk.bin) firmware(amdgpu/polaris10_uvd.bin) firmware(amdgpu/polaris10_vce.bin) firmware(amdgpu/polaris11_ce.bin) firmware(amdgpu/polaris11_ce_2.bin) firmware(amdgpu/polaris11_k2_smc.bin) firmware(amdgpu/polaris11_k_mc.bin) firmware(amdgpu/polaris11_k_smc.bin) firmware(amdgpu/polaris11_mc.bin) firmware(amdgpu/polaris11_me.bin) firmware(amdgpu/polaris11_me_2.bin) firmware(amdgpu/polaris11_mec.bin) firmware(amdgpu/polaris11_mec2.bin) firmware(amdgpu/polaris11_mec2_2.bin) firmware(amdgpu/polaris11_mec_2.bin) firmware(amdgpu/polaris11_pfp.bin) firmware(amdgpu/polaris11_pfp_2.bin) firmware(amdgpu/polaris11_rlc.bin) firmware(amdgpu/polaris11_sdma.bin) firmware(amdgpu/polaris11_sdma1.bin) firmware(amdgpu/polaris11_smc.bin) firmware(amdgpu/polaris11_smc_sk.bin) firmware(amdgpu/polaris11_uvd.bin) firmware(amdgpu/polaris11_vce.bin) firmware(amdgpu/polaris12_32_mc.bin) firmware(amdgpu/polaris12_ce.bin) firmware(amdgpu/polaris12_ce_2.bin) firmware(amdgpu/polaris12_k_mc.bin) firmware(amdgpu/polaris12_k_smc.bin) firmware(amdgpu/polaris12_mc.bin) firmware(amdgpu/polaris12_me.bin) firmware(amdgpu/polaris12_me_2.bin) firmware(amdgpu/polaris12_mec.bin) firmware(amdgpu/polaris12_mec2.bin) firmware(amdgpu/polaris12_mec2_2.bin) firmware(amdgpu/polaris12_mec_2.bin) firmware(amdgpu/polaris12_pfp.bin) firmware(amdgpu/polaris12_pfp_2.bin) firmware(amdgpu/polaris12_rlc.bin) firmware(amdgpu/polaris12_sdma.bin) firmware(amdgpu/polaris12_sdma1.bin) firmware(amdgpu/polaris12_smc.bin) firmware(amdgpu/polaris12_uvd.bin) firmware(amdgpu/polaris12_vce.bin) firmware(amdgpu/psp_13_0_0_sos.bin) firmware(amdgpu/psp_13_0_0_ta.bin) firmware(amdgpu/psp_13_0_11_ta.bin) firmware(amdgpu/psp_13_0_11_toc.bin) firmware(amdgpu/psp_13_0_4_ta.bin) firmware(amdgpu/psp_13_0_4_toc.bin) firmware(amdgpu/psp_13_0_5_asd.bin) firmware(amdgpu/psp_13_0_5_ta.bin) firmware(amdgpu/psp_13_0_5_toc.bin) firmware(amdgpu/psp_13_0_7_sos.bin) firmware(amdgpu/psp_13_0_7_ta.bin) firmware(amdgpu/psp_13_0_8_asd.bin) firmware(amdgpu/psp_13_0_8_ta.bin) firmware(amdgpu/psp_13_0_8_toc.bin) firmware(amdgpu/raven2_asd.bin) firmware(amdgpu/raven2_ce.bin) firmware(amdgpu/raven2_gpu_info.bin) firmware(amdgpu/raven2_me.bin) firmware(amdgpu/raven2_mec.bin) firmware(amdgpu/raven2_mec2.bin) firmware(amdgpu/raven2_pfp.bin) firmware(amdgpu/raven2_rlc.bin) firmware(amdgpu/raven2_sdma.bin) firmware(amdgpu/raven2_ta.bin) firmware(amdgpu/raven2_vcn.bin) firmware(amdgpu/raven_asd.bin) firmware(amdgpu/raven_ce.bin) firmware(amdgpu/raven_dmcu.bin) firmware(amdgpu/raven_gpu_info.bin) firmware(amdgpu/raven_kicker_rlc.bin) firmware(amdgpu/raven_me.bin) firmware(amdgpu/raven_mec.bin) firmware(amdgpu/raven_mec2.bin) firmware(amdgpu/raven_pfp.bin) firmware(amdgpu/raven_rlc.bin) firmware(amdgpu/raven_sdma.bin) firmware(amdgpu/raven_ta.bin) firmware(amdgpu/raven_vcn.bin) firmware(amdgpu/renoir_asd.bin) firmware(amdgpu/renoir_ce.bin) firmware(amdgpu/renoir_dmcub.bin) firmware(amdgpu/renoir_gpu_info.bin) firmware(amdgpu/renoir_me.bin) firmware(amdgpu/renoir_mec.bin) firmware(amdgpu/renoir_mec2.bin) firmware(amdgpu/renoir_pfp.bin) firmware(amdgpu/renoir_rlc.bin) firmware(amdgpu/renoir_sdma.bin) firmware(amdgpu/renoir_ta.bin) firmware(amdgpu/renoir_vcn.bin) firmware(amdgpu/sdma_5_2_6.bin) firmware(amdgpu/sdma_5_2_7.bin) firmware(amdgpu/sdma_6_0_0.bin) firmware(amdgpu/sdma_6_0_1.bin) firmware(amdgpu/sdma_6_0_2.bin) firmware(amdgpu/si58_mc.bin) firmware(amdgpu/sienna_cichlid_ce.bin) firmware(amdgpu/sienna_cichlid_dmcub.bin) firmware(amdgpu/sienna_cichlid_me.bin) firmware(amdgpu/sienna_cichlid_mec.bin) firmware(amdgpu/sienna_cichlid_mec2.bin) firmware(amdgpu/sienna_cichlid_pfp.bin) firmware(amdgpu/sienna_cichlid_rlc.bin) firmware(amdgpu/sienna_cichlid_sdma.bin) firmware(amdgpu/sienna_cichlid_smc.bin) firmware(amdgpu/sienna_cichlid_sos.bin) firmware(amdgpu/sienna_cichlid_ta.bin) firmware(amdgpu/sienna_cichlid_vcn.bin) firmware(amdgpu/smu_13_0_0.bin) firmware(amdgpu/smu_13_0_7.bin) firmware(amdgpu/stoney_ce.bin) firmware(amdgpu/stoney_me.bin) firmware(amdgpu/stoney_mec.bin) firmware(amdgpu/stoney_pfp.bin) firmware(amdgpu/stoney_rlc.bin) firmware(amdgpu/stoney_sdma.bin) firmware(amdgpu/stoney_uvd.bin) firmware(amdgpu/stoney_vce.bin) firmware(amdgpu/tahiti_ce.bin) firmware(amdgpu/tahiti_k_smc.bin) firmware(amdgpu/tahiti_mc.bin) firmware(amdgpu/tahiti_me.bin) firmware(amdgpu/tahiti_pfp.bin) firmware(amdgpu/tahiti_rlc.bin) firmware(amdgpu/tahiti_smc.bin) firmware(amdgpu/tahiti_uvd.bin) firmware(amdgpu/tonga_ce.bin) firmware(amdgpu/tonga_k_smc.bin) firmware(amdgpu/tonga_mc.bin) firmware(amdgpu/tonga_me.bin) firmware(amdgpu/tonga_mec.bin) firmware(amdgpu/tonga_mec2.bin) firmware(amdgpu/tonga_pfp.bin) firmware(amdgpu/tonga_rlc.bin) firmware(amdgpu/tonga_sdma.bin) firmware(amdgpu/tonga_sdma1.bin) firmware(amdgpu/tonga_smc.bin) firmware(amdgpu/tonga_uvd.bin) firmware(amdgpu/tonga_vce.bin) firmware(amdgpu/topaz_ce.bin) firmware(amdgpu/topaz_k_smc.bin) firmware(amdgpu/topaz_mc.bin) firmware(amdgpu/topaz_me.bin) firmware(amdgpu/topaz_mec.bin) firmware(amdgpu/topaz_mec2.bin) firmware(amdgpu/topaz_pfp.bin) firmware(amdgpu/topaz_rlc.bin) firmware(amdgpu/topaz_sdma.bin) firmware(amdgpu/topaz_sdma1.bin) firmware(amdgpu/topaz_smc.bin) firmware(amdgpu/vangogh_asd.bin) firmware(amdgpu/vangogh_ce.bin) firmware(amdgpu/vangogh_dmcub.bin) firmware(amdgpu/vangogh_me.bin) firmware(amdgpu/vangogh_mec.bin) firmware(amdgpu/vangogh_mec2.bin) firmware(amdgpu/vangogh_pfp.bin) firmware(amdgpu/vangogh_rlc.bin) firmware(amdgpu/vangogh_sdma.bin) firmware(amdgpu/vangogh_toc.bin) firmware(amdgpu/vangogh_vcn.bin) firmware(amdgpu/vcn_3_1_2.bin) firmware(amdgpu/vcn_4_0_0.bin) firmware(amdgpu/vcn_4_0_2.bin) firmware(amdgpu/vcn_4_0_4.bin) firmware(amdgpu/vega10_acg_smc.bin) firmware(amdgpu/vega10_asd.bin) firmware(amdgpu/vega10_ce.bin) firmware(amdgpu/vega10_gpu_info.bin) firmware(amdgpu/vega10_me.bin) firmware(amdgpu/vega10_mec.bin) firmware(amdgpu/vega10_mec2.bin) firmware(amdgpu/vega10_pfp.bin) firmware(amdgpu/vega10_rlc.bin) firmware(amdgpu/vega10_sdma.bin) firmware(amdgpu/vega10_sdma1.bin) firmware(amdgpu/vega10_smc.bin) firmware(amdgpu/vega10_sos.bin) firmware(amdgpu/vega10_uvd.bin) firmware(amdgpu/vega10_vce.bin) firmware(amdgpu/vega12_asd.bin) firmware(amdgpu/vega12_ce.bin) firmware(amdgpu/vega12_gpu_info.bin) firmware(amdgpu/vega12_me.bin) firmware(amdgpu/vega12_mec.bin) firmware(amdgpu/vega12_mec2.bin) firmware(amdgpu/vega12_pfp.bin) firmware(amdgpu/vega12_rlc.bin) firmware(amdgpu/vega12_sdma.bin) firmware(amdgpu/vega12_sdma1.bin) firmware(amdgpu/vega12_smc.bin) firmware(amdgpu/vega12_sos.bin) firmware(amdgpu/vega12_uvd.bin) firmware(amdgpu/vega12_vce.bin) firmware(amdgpu/vega20_asd.bin) firmware(amdgpu/vega20_ce.bin) firmware(amdgpu/vega20_me.bin) firmware(amdgpu/vega20_mec.bin) firmware(amdgpu/vega20_mec2.bin) firmware(amdgpu/vega20_pfp.bin) firmware(amdgpu/vega20_rlc.bin) firmware(amdgpu/vega20_sdma.bin) firmware(amdgpu/vega20_sdma1.bin) firmware(amdgpu/vega20_smc.bin) firmware(amdgpu/vega20_sos.bin) firmware(amdgpu/vega20_ta.bin) firmware(amdgpu/vega20_uvd.bin) firmware(amdgpu/vega20_vce.bin) firmware(amdgpu/vegam_ce.bin) firmware(amdgpu/vegam_me.bin) firmware(amdgpu/vegam_mec.bin) firmware(amdgpu/vegam_mec2.bin) firmware(amdgpu/vegam_pfp.bin) firmware(amdgpu/vegam_rlc.bin) firmware(amdgpu/vegam_sdma.bin) firmware(amdgpu/vegam_sdma1.bin) firmware(amdgpu/vegam_smc.bin) firmware(amdgpu/vegam_uvd.bin) firmware(amdgpu/vegam_vce.bin) firmware(amdgpu/verde_ce.bin) firmware(amdgpu/verde_k_smc.bin) firmware(amdgpu/verde_mc.bin) firmware(amdgpu/verde_me.bin) firmware(amdgpu/verde_pfp.bin) firmware(amdgpu/verde_rlc.bin) firmware(amdgpu/verde_smc.bin) firmware(amdgpu/verde_uvd.bin) firmware(amdgpu/yellow_carp_asd.bin) firmware(amdgpu/yellow_carp_ce.bin) firmware(amdgpu/yellow_carp_dmcub.bin) firmware(amdgpu/yellow_carp_me.bin) firmware(amdgpu/yellow_carp_mec.bin) firmware(amdgpu/yellow_carp_mec2.bin) firmware(amdgpu/yellow_carp_pfp.bin) firmware(amdgpu/yellow_carp_rlc.bin) firmware(amdgpu/yellow_carp_sdma.bin) firmware(amdgpu/yellow_carp_ta.bin) firmware(amdgpu/yellow_carp_toc.bin) firmware(amdgpu/yellow_carp_vcn.bin) firmware(amphion/vpu/vpu_fw_imx8_dec.bin) firmware(amphion/vpu/vpu_fw_imx8_enc.bin) firmware(ar3k/1020200/PS_ASIC.pst) firmware(ar3k/1020200/RamPatch.txt) firmware(ar3k/1020200/ar3kbdaddr.pst) firmware(ar3k/1020201/PS_ASIC.pst) firmware(ar3k/1020201/RamPatch.txt) firmware(ar3k/1020201coex/ramps_0x01020201_26_HighPriority.dfu) firmware(ar3k/30000/PS_ASIC.pst) firmware(ar3k/30000/RamPatch.txt) firmware(ar3k/30000/ar3kbdaddr.pst) firmware(ar3k/30101/PS_ASIC.pst) firmware(ar3k/30101/RamPatch.txt) firmware(ar3k/30101/ar3kbdaddr.pst) firmware(ar3k/30101coex/PS_ASIC.pst) firmware(ar3k/30101coex/PS_ASIC_aclHighPri.pst) firmware(ar3k/30101coex/PS_ASIC_aclLowPri.pst) firmware(ar3k/30101coex/RamPatch.txt) firmware(ar3k/30101coex/ar3kbdaddr.pst) firmware(ar3k/AthrBT_0x01020001.dfu) firmware(ar3k/AthrBT_0x01020200.dfu) firmware(ar3k/AthrBT_0x01020201.dfu) firmware(ar3k/AthrBT_0x11020000.dfu) firmware(ar3k/AthrBT_0x11020100.dfu) firmware(ar3k/AthrBT_0x31010000.dfu) firmware(ar3k/AthrBT_0x31010100.dfu) firmware(ar3k/AthrBT_0x41020000.dfu) firmware(ar3k/ramps_0x01020001_26.dfu) firmware(ar3k/ramps_0x01020200_26.dfu) firmware(ar3k/ramps_0x01020200_40.dfu) firmware(ar3k/ramps_0x01020201_26.dfu) firmware(ar3k/ramps_0x01020201_40.dfu) firmware(ar3k/ramps_0x11020000_40.dfu) firmware(ar3k/ramps_0x11020100_40.dfu) firmware(ar3k/ramps_0x31010000_40.dfu) firmware(ar3k/ramps_0x31010100_40.dfu) firmware(ar3k/ramps_0x41020000_40.dfu) firmware(ar5523.bin) firmware(ar7010.fw) firmware(ar7010_1_1.fw) firmware(ar9170-1.fw) firmware(ar9170-2.fw) firmware(ar9271.fw) firmware(as102_data1_st.hex) firmware(as102_data2_st.hex) firmware(ast_dp501_fw.bin) firmware(ath10k/QCA4019/hw1.0/board-2.bin) firmware(ath10k/QCA4019/hw1.0/firmware-5.bin) firmware(ath10k/QCA4019/hw1.0/notice_ath10k_firmware-5.txt) firmware(ath10k/QCA6174/hw2.1/board-2.bin) firmware(ath10k/QCA6174/hw2.1/board.bin) firmware(ath10k/QCA6174/hw2.1/firmware-5.bin) firmware(ath10k/QCA6174/hw2.1/notice_ath10k_firmware-5.txt) firmware(ath10k/QCA6174/hw3.0/board-2.bin) firmware(ath10k/QCA6174/hw3.0/board.bin) firmware(ath10k/QCA6174/hw3.0/firmware-4.bin) firmware(ath10k/QCA6174/hw3.0/firmware-6.bin) firmware(ath10k/QCA6174/hw3.0/firmware-sdio-6.bin) firmware(ath10k/QCA6174/hw3.0/notice_ath10k_firmware-4.txt) firmware(ath10k/QCA6174/hw3.0/notice_ath10k_firmware-6.txt) firmware(ath10k/QCA6174/hw3.0/notice_ath10k_firmware-sdio-6.txt) firmware(ath10k/QCA9377/hw1.0/board-2.bin) firmware(ath10k/QCA9377/hw1.0/board.bin) firmware(ath10k/QCA9377/hw1.0/firmware-5.bin) firmware(ath10k/QCA9377/hw1.0/firmware-6.bin) firmware(ath10k/QCA9377/hw1.0/firmware-sdio-5.bin) firmware(ath10k/QCA9377/hw1.0/notice_ath10k_firmware-5.txt) firmware(ath10k/QCA9377/hw1.0/notice_ath10k_firmware-6.txt) firmware(ath10k/QCA9377/hw1.0/notice_ath10k_firmware-sdio-5.txt) firmware(ath10k/QCA9887/hw1.0/board.bin) firmware(ath10k/QCA9887/hw1.0/firmware-5.bin) firmware(ath10k/QCA9887/hw1.0/notice_ath10k_firmware-5.txt) firmware(ath10k/QCA9888/hw2.0/board-2.bin) firmware(ath10k/QCA9888/hw2.0/firmware-5.bin) firmware(ath10k/QCA9888/hw2.0/notice_ath10k_firmware-5.txt) firmware(ath10k/QCA988X/hw2.0/board.bin) firmware(ath10k/QCA988X/hw2.0/firmware-4.bin) firmware(ath10k/QCA988X/hw2.0/firmware-5.bin) firmware(ath10k/QCA988X/hw2.0/notice_ath10k_firmware-4.txt) firmware(ath10k/QCA988X/hw2.0/notice_ath10k_firmware-5.txt) firmware(ath10k/QCA9984/hw1.0/board-2.bin) firmware(ath10k/QCA9984/hw1.0/firmware-5.bin) firmware(ath10k/QCA9984/hw1.0/notice_ath10k_firmware-5.txt) firmware(ath10k/QCA99X0/hw2.0/board-2.bin) firmware(ath10k/QCA99X0/hw2.0/firmware-5.bin) firmware(ath10k/QCA99X0/hw2.0/notice_ath10k_firmware-5.txt) firmware(ath10k/WCN3990/hw1.0/board-2.bin) firmware(ath10k/WCN3990/hw1.0/firmware-5.bin) firmware(ath10k/WCN3990/hw1.0/notice.txt_wlanmdsp) firmware(ath10k/WCN3990/hw1.0/wlanmdsp.mbn) firmware(ath11k/IPQ5018/hw1.0/Notice.txt) firmware(ath11k/IPQ5018/hw1.0/board-2.bin) firmware(ath11k/IPQ5018/hw1.0/m3_fw.b00) firmware(ath11k/IPQ5018/hw1.0/m3_fw.b01) firmware(ath11k/IPQ5018/hw1.0/m3_fw.b02) firmware(ath11k/IPQ5018/hw1.0/m3_fw.flist) firmware(ath11k/IPQ5018/hw1.0/m3_fw.mdt) firmware(ath11k/IPQ5018/hw1.0/q6_fw.b00) firmware(ath11k/IPQ5018/hw1.0/q6_fw.b01) firmware(ath11k/IPQ5018/hw1.0/q6_fw.b02) firmware(ath11k/IPQ5018/hw1.0/q6_fw.b03) firmware(ath11k/IPQ5018/hw1.0/q6_fw.b04) firmware(ath11k/IPQ5018/hw1.0/q6_fw.b05) firmware(ath11k/IPQ5018/hw1.0/q6_fw.b07) firmware(ath11k/IPQ5018/hw1.0/q6_fw.b08) firmware(ath11k/IPQ5018/hw1.0/q6_fw.b09) firmware(ath11k/IPQ5018/hw1.0/q6_fw.b10) firmware(ath11k/IPQ5018/hw1.0/q6_fw.b11) firmware(ath11k/IPQ5018/hw1.0/q6_fw.b13) firmware(ath11k/IPQ5018/hw1.0/q6_fw.b14) firmware(ath11k/IPQ5018/hw1.0/q6_fw.flist) firmware(ath11k/IPQ5018/hw1.0/q6_fw.mdt) firmware(ath11k/IPQ6018/hw1.0/Notice.txt) firmware(ath11k/IPQ6018/hw1.0/board-2.bin) firmware(ath11k/IPQ6018/hw1.0/m3_fw.b00) firmware(ath11k/IPQ6018/hw1.0/m3_fw.b01) firmware(ath11k/IPQ6018/hw1.0/m3_fw.b02) firmware(ath11k/IPQ6018/hw1.0/m3_fw.flist) firmware(ath11k/IPQ6018/hw1.0/m3_fw.mdt) firmware(ath11k/IPQ6018/hw1.0/q6_fw.b00) firmware(ath11k/IPQ6018/hw1.0/q6_fw.b01) firmware(ath11k/IPQ6018/hw1.0/q6_fw.b02) firmware(ath11k/IPQ6018/hw1.0/q6_fw.b03) firmware(ath11k/IPQ6018/hw1.0/q6_fw.b04) firmware(ath11k/IPQ6018/hw1.0/q6_fw.b05) firmware(ath11k/IPQ6018/hw1.0/q6_fw.b07) firmware(ath11k/IPQ6018/hw1.0/q6_fw.b08) firmware(ath11k/IPQ6018/hw1.0/q6_fw.flist) firmware(ath11k/IPQ6018/hw1.0/q6_fw.mdt) firmware(ath11k/IPQ8074/hw2.0/Notice.txt) firmware(ath11k/IPQ8074/hw2.0/board-2.bin) firmware(ath11k/IPQ8074/hw2.0/m3_fw.b00) firmware(ath11k/IPQ8074/hw2.0/m3_fw.b01) firmware(ath11k/IPQ8074/hw2.0/m3_fw.b02) firmware(ath11k/IPQ8074/hw2.0/m3_fw.flist) firmware(ath11k/IPQ8074/hw2.0/m3_fw.mdt) firmware(ath11k/IPQ8074/hw2.0/q6_fw.b00) firmware(ath11k/IPQ8074/hw2.0/q6_fw.b01) firmware(ath11k/IPQ8074/hw2.0/q6_fw.b02) firmware(ath11k/IPQ8074/hw2.0/q6_fw.b03) firmware(ath11k/IPQ8074/hw2.0/q6_fw.b04) firmware(ath11k/IPQ8074/hw2.0/q6_fw.b05) firmware(ath11k/IPQ8074/hw2.0/q6_fw.b07) firmware(ath11k/IPQ8074/hw2.0/q6_fw.b08) firmware(ath11k/IPQ8074/hw2.0/q6_fw.flist) firmware(ath11k/IPQ8074/hw2.0/q6_fw.mdt) firmware(ath11k/QCA6390/hw2.0/Notice.txt) firmware(ath11k/QCA6390/hw2.0/amss.bin) firmware(ath11k/QCA6390/hw2.0/board-2.bin) firmware(ath11k/QCA6390/hw2.0/m3.bin) firmware(ath11k/QCN9074/hw1.0/Notice.txt) firmware(ath11k/QCN9074/hw1.0/amss.bin) firmware(ath11k/QCN9074/hw1.0/board-2.bin) firmware(ath11k/QCN9074/hw1.0/m3.bin) firmware(ath11k/WCN6750/hw1.0/Notice.txt) firmware(ath11k/WCN6750/hw1.0/board-2.bin) firmware(ath11k/WCN6750/hw1.0/wpss.b00) firmware(ath11k/WCN6750/hw1.0/wpss.b01) firmware(ath11k/WCN6750/hw1.0/wpss.b02) firmware(ath11k/WCN6750/hw1.0/wpss.b03) firmware(ath11k/WCN6750/hw1.0/wpss.b04) firmware(ath11k/WCN6750/hw1.0/wpss.b05) firmware(ath11k/WCN6750/hw1.0/wpss.b06) firmware(ath11k/WCN6750/hw1.0/wpss.b07) firmware(ath11k/WCN6750/hw1.0/wpss.b08) firmware(ath11k/WCN6750/hw1.0/wpss.mdt) firmware(ath11k/WCN6855/hw2.0/Notice.txt) firmware(ath11k/WCN6855/hw2.0/amss.bin) firmware(ath11k/WCN6855/hw2.0/board-2.bin) firmware(ath11k/WCN6855/hw2.0/m3.bin) firmware(ath11k/WCN6855/hw2.0/regdb.bin) firmware(ath11k/WCN6855/hw2.1/amss.bin) firmware(ath11k/WCN6855/hw2.1/board-2.bin) firmware(ath11k/WCN6855/hw2.1/m3.bin) firmware(ath11k/WCN6855/hw2.1/regdb.bin) firmware(ath3k-1.fw) firmware(ath6k/AR6002/athwlan.bin.z77) firmware(ath6k/AR6002/data.patch.hw2_0.bin) firmware(ath6k/AR6002/eeprom.bin) firmware(ath6k/AR6002/eeprom.data) firmware(ath6k/AR6003.1/hw2.1.1/athwlan.bin) firmware(ath6k/AR6003.1/hw2.1.1/bdata.SD31.bin) firmware(ath6k/AR6003.1/hw2.1.1/bdata.SD32.bin) firmware(ath6k/AR6003.1/hw2.1.1/bdata.WB31.bin) firmware(ath6k/AR6003.1/hw2.1.1/data.patch.bin) firmware(ath6k/AR6003.1/hw2.1.1/endpointping.bin) firmware(ath6k/AR6003.1/hw2.1.1/otp.bin) firmware(ath6k/AR6003/hw1.0/athwlan.bin.z77) firmware(ath6k/AR6003/hw1.0/bdata.SD31.bin) firmware(ath6k/AR6003/hw1.0/bdata.SD32.bin) firmware(ath6k/AR6003/hw1.0/bdata.WB31.bin) firmware(ath6k/AR6003/hw1.0/data.patch.bin) firmware(ath6k/AR6003/hw1.0/otp.bin.z77) firmware(ath6k/AR6003/hw2.0/athwlan.bin.z77) firmware(ath6k/AR6003/hw2.0/bdata.SD31.bin) firmware(ath6k/AR6003/hw2.0/bdata.SD32.bin) firmware(ath6k/AR6003/hw2.0/bdata.WB31.bin) firmware(ath6k/AR6003/hw2.0/data.patch.bin) firmware(ath6k/AR6003/hw2.0/otp.bin.z77) firmware(ath6k/AR6003/hw2.1.1/athwlan.bin) firmware(ath6k/AR6003/hw2.1.1/bdata.SD31.bin) firmware(ath6k/AR6003/hw2.1.1/bdata.SD32.bin) firmware(ath6k/AR6003/hw2.1.1/bdata.WB31.bin) firmware(ath6k/AR6003/hw2.1.1/data.patch.bin) firmware(ath6k/AR6003/hw2.1.1/endpointping.bin) firmware(ath6k/AR6003/hw2.1.1/fw-2.bin) firmware(ath6k/AR6003/hw2.1.1/fw-3.bin) firmware(ath6k/AR6003/hw2.1.1/otp.bin) firmware(ath6k/AR6004/hw1.2/bdata.bin) firmware(ath6k/AR6004/hw1.2/fw-2.bin) firmware(ath6k/AR6004/hw1.3/bdata.bin) firmware(ath6k/AR6004/hw1.3/fw-3.bin) firmware(ath9k_htc/htc_7010-1.4.0.fw) firmware(ath9k_htc/htc_9271-1.4.0.fw) firmware(atmel/wilc1000_ap_fw.bin) firmware(atmel/wilc1000_fw.bin) firmware(atmel/wilc1000_p2p_fw.bin) firmware(atmel/wilc1000_wifi_firmware-1.bin) firmware(atmel/wilc1000_wifi_firmware.bin) firmware(atusb/atusb-0.2.dfu) firmware(atusb/atusb-0.3.dfu) firmware(atusb/rzusb-0.3.bin) firmware(av7110/bootcode.bin) firmware(bnx2/bnx2-mips-06-6.2.3.fw) firmware(bnx2/bnx2-mips-09-6.2.1b.fw) firmware(bnx2/bnx2-rv2p-06-6.0.15.fw) firmware(bnx2/bnx2-rv2p-09-6.0.17.fw) firmware(bnx2/bnx2-rv2p-09ax-6.0.17.fw) firmware(bnx2x/bnx2x-e1-7.13.1.0.fw) firmware(bnx2x/bnx2x-e1-7.13.11.0.fw) firmware(bnx2x/bnx2x-e1-7.13.15.0.fw) firmware(bnx2x/bnx2x-e1-7.13.21.0.fw) firmware(bnx2x/bnx2x-e1h-7.13.1.0.fw) firmware(bnx2x/bnx2x-e1h-7.13.11.0.fw) firmware(bnx2x/bnx2x-e1h-7.13.15.0.fw) firmware(bnx2x/bnx2x-e1h-7.13.21.0.fw) firmware(bnx2x/bnx2x-e2-7.13.1.0.fw) firmware(bnx2x/bnx2x-e2-7.13.11.0.fw) firmware(bnx2x/bnx2x-e2-7.13.15.0.fw) firmware(bnx2x/bnx2x-e2-7.13.21.0.fw) firmware(brcm/BCM-0a5c-6410.hcd) firmware(brcm/BCM-0bb4-0306.hcd) firmware(brcm/bcm4329-fullmac-4.bin) firmware(brcm/bcm43xx-0.fw) firmware(brcm/bcm43xx_hdr-0.fw) firmware(brcm/brcmfmac43012-sdio.bin) firmware(brcm/brcmfmac43012-sdio.clm_blob) firmware(brcm/brcmfmac43143-sdio.bin) firmware(brcm/brcmfmac43143.bin) firmware(brcm/brcmfmac43236b.bin) firmware(brcm/brcmfmac43241b0-sdio.bin) firmware(brcm/brcmfmac43241b4-sdio.Advantech-MICA-071.txt) firmware(brcm/brcmfmac43241b4-sdio.Intel firmware(brcm/brcmfmac43241b4-sdio.bin) firmware(brcm/brcmfmac43241b5-sdio.bin) firmware(brcm/brcmfmac43242a.bin) firmware(brcm/brcmfmac4329-sdio.bin) firmware(brcm/brcmfmac4330-sdio.Prowise-PT301.txt) firmware(brcm/brcmfmac4330-sdio.bin) firmware(brcm/brcmfmac4334-sdio.bin) firmware(brcm/brcmfmac43340-sdio.ASUSTeK firmware(brcm/brcmfmac43340-sdio.bin) firmware(brcm/brcmfmac43340-sdio.meegopad-t08.txt) firmware(brcm/brcmfmac43340-sdio.pov-tab-p1006w-data.txt) firmware(brcm/brcmfmac43340-sdio.predia-basic.txt) firmware(brcm/brcmfmac4335-sdio.bin) firmware(brcm/brcmfmac43362-sdio.WC121.txt) firmware(brcm/brcmfmac43362-sdio.bin) firmware(brcm/brcmfmac43362-sdio.cubietech firmware(brcm/brcmfmac43362-sdio.kobo firmware(brcm/brcmfmac43362-sdio.lemaker firmware(brcm/brcmfmac4339-sdio.bin) firmware(brcm/brcmfmac43430-sdio.AP6212.txt) firmware(brcm/brcmfmac43430-sdio.Hampoo-D2D3_Vi8A1.txt) firmware(brcm/brcmfmac43430-sdio.MUR1DX.txt) firmware(brcm/brcmfmac43430-sdio.beagle firmware(brcm/brcmfmac43430-sdio.bin) firmware(brcm/brcmfmac43430-sdio.clm_blob) firmware(brcm/brcmfmac43430-sdio.friendlyarm firmware(brcm/brcmfmac43430-sdio.raspberrypi firmware(brcm/brcmfmac43430-sdio.sinovoip firmware(brcm/brcmfmac43430-sdio.starfive firmware(brcm/brcmfmac43430a0-sdio.ONDA-V80 firmware(brcm/brcmfmac43430a0-sdio.bin) firmware(brcm/brcmfmac43430a0-sdio.ilife-S806.txt) firmware(brcm/brcmfmac43430a0-sdio.jumper-ezpad-mini3.txt) firmware(brcm/brcmfmac43455-sdio.AW-CM256SM.txt) firmware(brcm/brcmfmac43455-sdio.MINIX-NEO firmware(brcm/brcmfmac43455-sdio.Raspberry firmware(brcm/brcmfmac43455-sdio.acepc-t8.txt) firmware(brcm/brcmfmac43455-sdio.beagle firmware(brcm/brcmfmac43455-sdio.bin) firmware(brcm/brcmfmac43455-sdio.clm_blob) firmware(brcm/brcmfmac43455-sdio.pine64 firmware(brcm/brcmfmac43455-sdio.raspberrypi firmware(brcm/brcmfmac4350-pcie.bin) firmware(brcm/brcmfmac4350c2-pcie.bin) firmware(brcm/brcmfmac4354-sdio.bin) firmware(brcm/brcmfmac4354-sdio.clm_blob) firmware(brcm/brcmfmac4356-pcie.Intel firmware(brcm/brcmfmac4356-pcie.Xiaomi firmware(brcm/brcmfmac4356-pcie.bin) firmware(brcm/brcmfmac4356-pcie.clm_blob) firmware(brcm/brcmfmac4356-pcie.gpd-win-pocket.txt) firmware(brcm/brcmfmac4356-sdio.AP6356S.txt) firmware(brcm/brcmfmac4356-sdio.bin) firmware(brcm/brcmfmac4356-sdio.clm_blob) firmware(brcm/brcmfmac4356-sdio.firefly firmware(brcm/brcmfmac4356-sdio.khadas firmware(brcm/brcmfmac4356-sdio.vamrs firmware(brcm/brcmfmac43569.bin) firmware(brcm/brcmfmac43570-pcie.bin) firmware(brcm/brcmfmac43570-pcie.clm_blob) firmware(brcm/brcmfmac4358-pcie.bin) firmware(brcm/brcmfmac43602-pcie.ap.bin) firmware(brcm/brcmfmac43602-pcie.bin) firmware(brcm/brcmfmac4366b-pcie.bin) firmware(brcm/brcmfmac4366c-pcie.bin) firmware(brcm/brcmfmac4371-pcie.bin) firmware(brcm/brcmfmac4373-sdio.bin) firmware(brcm/brcmfmac4373-sdio.clm_blob) firmware(brcm/brcmfmac4373.bin) firmware(brcm/brcmfmac54591-pcie.bin) firmware(brcm/brcmfmac54591-pcie.clm_blob) firmware(cadence/mhdp8546.bin) firmware(carl9170-1.fw) firmware(cavium/cnn55xx_ae.fw) firmware(cavium/cnn55xx_se.fw) firmware(cbfw-3.2.5.1.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-103c896e-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-103c896e-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-103c896e.wmfw) firmware(cirrus/cs35l41-dsp1-spk-cali-103c8971.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-103c8971.wmfw) firmware(cirrus/cs35l41-dsp1-spk-cali-103c8972.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-103c8972.wmfw) firmware(cirrus/cs35l41-dsp1-spk-cali-103c8973.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-103c8973.wmfw) firmware(cirrus/cs35l41-dsp1-spk-cali-103c8974.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-103c8974.wmfw) firmware(cirrus/cs35l41-dsp1-spk-cali-103c8975-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-103c8975-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-103c8975.wmfw) firmware(cirrus/cs35l41-dsp1-spk-cali-103c8981-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-103c8981-l1.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-103c8981-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-103c8981-r1.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-103c8981.wmfw) firmware(cirrus/cs35l41-dsp1-spk-cali-103c898e.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-103c898e.wmfw) firmware(cirrus/cs35l41-dsp1-spk-cali-103c898f.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-103c898f.wmfw) firmware(cirrus/cs35l41-dsp1-spk-cali-103c8991.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-103c8991.wmfw) firmware(cirrus/cs35l41-dsp1-spk-cali-103c8992.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-103c8992.wmfw) firmware(cirrus/cs35l41-dsp1-spk-cali-103c8994.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-103c8994.wmfw) firmware(cirrus/cs35l41-dsp1-spk-cali-103c8995.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-103c8995.wmfw) firmware(cirrus/cs35l41-dsp1-spk-cali-103c89c3-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-103c89c3-l1.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-103c89c3-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-103c89c3-r1.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-103c89c3.wmfw) firmware(cirrus/cs35l41-dsp1-spk-cali-103c89c6-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-103c89c6-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-103c89c6.wmfw) firmware(cirrus/cs35l41-dsp1-spk-cali-104312af-spkid0-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-104312af-spkid0-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-104312af-spkid1-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-104312af-spkid1-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-104312af.wmfw) firmware(cirrus/cs35l41-dsp1-spk-cali-10431a8f-spkid0-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-10431a8f-spkid0-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-10431a8f-spkid1-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-10431a8f-spkid1-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-10431a8f.wmfw) firmware(cirrus/cs35l41-dsp1-spk-cali-10431e02-spkid0-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-10431e02-spkid0-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-10431e02-spkid1-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-10431e02-spkid1-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-10431e02.wmfw) firmware(cirrus/cs35l41-dsp1-spk-cali-10431e12-spkid0-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-10431e12-spkid0-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-10431e12-spkid1-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-10431e12-spkid1-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-10431e12.wmfw) firmware(cirrus/cs35l41-dsp1-spk-cali-10431f12-spkid0-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-10431f12-spkid0-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-10431f12-spkid1-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-10431f12-spkid1-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-10431f12.wmfw) firmware(cirrus/cs35l41-dsp1-spk-cali-17aa22f1-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-17aa22f1-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-17aa22f1.wmfw) firmware(cirrus/cs35l41-dsp1-spk-cali-17aa22f2-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-17aa22f2-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-17aa22f2.wmfw) firmware(cirrus/cs35l41-dsp1-spk-cali-17aa22f3-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-17aa22f3-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-17aa22f3.wmfw) firmware(cirrus/cs35l41-dsp1-spk-cali-17aa2318-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-17aa2318-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-17aa2318.wmfw) firmware(cirrus/cs35l41-dsp1-spk-cali-17aa2319-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-17aa2319-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-17aa2319.wmfw) firmware(cirrus/cs35l41-dsp1-spk-cali-17aa231a-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-17aa231a-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-17aa231a.wmfw) firmware(cirrus/cs35l41-dsp1-spk-cali-17aa3847-spkid0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-17aa3847-spkid1.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-17aa3847.wmfw) firmware(cirrus/cs35l41-dsp1-spk-cali-17aa3855-spkid0.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-17aa3855-spkid1.bin) firmware(cirrus/cs35l41-dsp1-spk-cali-17aa3855.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-103c896e-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-103c896e-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-103c896e.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-103c8971.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-103c8971.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-103c8972.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-103c8972.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-103c8973.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-103c8973.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-103c8974.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-103c8974.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-103c8975-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-103c8975-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-103c8975.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-103c8981-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-103c8981-l1.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-103c8981-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-103c8981-r1.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-103c8981.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-103c898e.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-103c898e.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-103c898f.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-103c898f.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-103c8991.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-103c8991.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-103c8992.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-103c8992.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-103c8994.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-103c8994.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-103c8995.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-103c8995.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-103c89c3-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-103c89c3-l1.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-103c89c3-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-103c89c3-r1.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-103c89c3.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-103c89c6-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-103c89c6-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-103c89c6.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-104312af-spkid0-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-104312af-spkid0-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-104312af-spkid1-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-104312af-spkid1-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-104312af.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-10431a8f-spkid0-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-10431a8f-spkid0-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-10431a8f-spkid1-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-10431a8f-spkid1-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-10431a8f.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-10431e02-spkid0-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-10431e02-spkid0-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-10431e02-spkid1-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-10431e02-spkid1-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-10431e02.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-10431e12-spkid0-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-10431e12-spkid0-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-10431e12-spkid1-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-10431e12-spkid1-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-10431e12.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-10431f12-spkid0-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-10431f12-spkid0-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-10431f12-spkid1-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-10431f12-spkid1-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-10431f12.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa22f1-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa22f1-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa22f1.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa22f2-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa22f2-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa22f2.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa22f3-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa22f3-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa22f3.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa2318-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa2318-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa2318.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa2319-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa2319-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa2319.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa231a-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa231a-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa231a.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa3847-spkid0-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa3847-spkid0-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa3847-spkid1-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa3847-spkid1-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa3847.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa3855-spkid0-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa3855-spkid0-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa3855-spkid1-l0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa3855-spkid1-r0.bin) firmware(cirrus/cs35l41-dsp1-spk-prot-17aa3855.wmfw) firmware(cirrus/cs35l41-dsp1-spk-prot.bin) firmware(cirrus/cs35l41-dsp1-spk-prot.wmfw) firmware(cirrus/cs35l41/v6.39.0/halo_cspl_RAM_revB2_29.41.0.wmfw) firmware(cirrus/cs35l41/v6.47.0/halo_cspl_RAM_revB2_29.49.0.wmfw) firmware(cirrus/cs35l41/v6.61.1/halo_cspl_RAM_revB2_29.63.1.wmfw) firmware(cirrus/cs35l41/v6.63.0/halo_cspl_RAM_revB2_29.65.0.wmfw) firmware(cis/3CCFEM556.cis) firmware(cis/3CXEM556.cis) firmware(cis/COMpad2.cis) firmware(cis/COMpad4.cis) firmware(cis/DP83903.cis) firmware(cis/LA-PCM.cis) firmware(cis/MT5634ZLX.cis) firmware(cis/NE2K.cis) firmware(cis/PCMLM28.cis) firmware(cis/PE-200.cis) firmware(cis/PE520.cis) firmware(cis/RS-COM-2P.cis) firmware(cis/SW_555_SER.cis) firmware(cis/SW_7xx_SER.cis) firmware(cis/SW_8xx_SER.cis) firmware(cis/tamarack.cis) firmware(cmmb_vega_12mhz.inp) firmware(cmmb_venice_12mhz.inp) firmware(cnm/wave521c_k3_codec_fw.bin) firmware(cpia2/stv0672_vp4.bin) firmware(ct2fw-3.2.5.1.bin) firmware(ctefx.bin) firmware(ctfw-3.2.5.1.bin) firmware(ctspeq.bin) firmware(cxgb3/ael2005_opt_edc.bin) firmware(cxgb3/ael2005_twx_edc.bin) firmware(cxgb3/ael2020_twx_edc.bin) firmware(cxgb3/t3b_psram-1.1.0.bin) firmware(cxgb3/t3c_psram-1.1.0.bin) firmware(cxgb3/t3fw-7.0.0.bin) firmware(cxgb3/t3fw-7.1.0.bin) firmware(cxgb3/t3fw-7.10.0.bin) firmware(cxgb3/t3fw-7.12.0.bin) firmware(cxgb3/t3fw-7.4.0.bin) firmware(cxgb4/aq1202_fw.cld) firmware(cxgb4/bcm8483.bin) firmware(cxgb4/configs/t4-config-default.txt) firmware(cxgb4/configs/t5-config-default.txt) firmware(cxgb4/configs/t5-config-hashfilter.txt) firmware(cxgb4/configs/t6-config-default.txt) firmware(cxgb4/configs/t6-config-hashfilter.txt) firmware(cxgb4/t4-config.txt) firmware(cxgb4/t4fw-1.14.4.0.bin) firmware(cxgb4/t4fw-1.15.37.0.bin) firmware(cxgb4/t4fw-1.27.1.0.bin) firmware(cxgb4/t4fw.bin) firmware(cxgb4/t5-config.txt) firmware(cxgb4/t5fw-1.14.4.0.bin) firmware(cxgb4/t5fw-1.15.37.0.bin) firmware(cxgb4/t5fw-1.27.1.0.bin) firmware(cxgb4/t5fw.bin) firmware(cxgb4/t6-config.txt) firmware(cxgb4/t6fw-1.27.1.0.bin) firmware(cxgb4/t6fw.bin) firmware(cypress/cyfmac43012-sdio.bin) firmware(cypress/cyfmac43012-sdio.clm_blob) firmware(cypress/cyfmac43340-sdio.bin) firmware(cypress/cyfmac43362-sdio.bin) firmware(cypress/cyfmac4339-sdio.bin) firmware(cypress/cyfmac43430-sdio.bin) firmware(cypress/cyfmac43430-sdio.clm_blob) firmware(cypress/cyfmac43455-sdio.bin) firmware(cypress/cyfmac43455-sdio.clm_blob) firmware(cypress/cyfmac4354-sdio.bin) firmware(cypress/cyfmac4354-sdio.clm_blob) firmware(cypress/cyfmac4356-pcie.bin) firmware(cypress/cyfmac4356-pcie.clm_blob) firmware(cypress/cyfmac4356-sdio.bin) firmware(cypress/cyfmac4356-sdio.clm_blob) firmware(cypress/cyfmac43570-pcie.bin) firmware(cypress/cyfmac43570-pcie.clm_blob) firmware(cypress/cyfmac4373-sdio.bin) firmware(cypress/cyfmac4373-sdio.clm_blob) firmware(cypress/cyfmac54591-pcie.bin) firmware(cypress/cyfmac54591-pcie.clm_blob) firmware(dabusb/bitstream.bin) firmware(dabusb/firmware.fw) firmware(dpaa2/mc/mc_10.10.0_ls1088a.itb) firmware(dpaa2/mc/mc_10.10.0_ls2088a.itb) firmware(dpaa2/mc/mc_10.10.0_lx2160a.itb) firmware(dpaa2/mc/mc_10.14.3_ls1088a.itb) firmware(dpaa2/mc/mc_10.14.3_ls2088a.itb) firmware(dpaa2/mc/mc_10.14.3_lx2160a.itb) firmware(dpaa2/mc/mc_10.16.2_ls1088a.itb) firmware(dpaa2/mc/mc_10.16.2_ls2088a.itb) firmware(dpaa2/mc/mc_10.16.2_lx2160a.itb) firmware(dpaa2/mc/mc_10.18.0_ls1088a.itb) firmware(dpaa2/mc/mc_10.18.0_ls2088a.itb) firmware(dpaa2/mc/mc_10.18.0_lx2160a.itb) firmware(dpaa2/mc/mc_10.28.1_ls1088a.itb) firmware(dpaa2/mc/mc_10.28.1_ls2088a.itb) firmware(dpaa2/mc/mc_10.28.1_lx2160a.itb) firmware(dsp56k/bootstrap.bin) firmware(dvb-fe-xc4000-1.4.1.fw) firmware(dvb-fe-xc5000-1.6.114.fw) firmware(dvb-fe-xc5000c-4.1.30.7.fw) firmware(dvb-usb-dib0700-1.20.fw) firmware(dvb-usb-it9135-01.fw) firmware(dvb-usb-it9135-02.fw) firmware(dvb-usb-terratec-h5-drxk.fw) firmware(dvb_nova_12mhz.inp) firmware(dvb_nova_12mhz_b0.inp) firmware(e100/d101m_ucode.bin) firmware(e100/d101s_ucode.bin) firmware(e100/d102e_ucode.bin) firmware(edgeport/boot.fw) firmware(edgeport/boot2.fw) firmware(edgeport/down.fw) firmware(edgeport/down2.fw) firmware(edgeport/down3.bin) firmware(emi26/bitstream.fw) firmware(emi26/firmware.fw) firmware(emi26/loader.fw) firmware(emi62/bitstream.fw) firmware(emi62/loader.fw) firmware(emi62/midi.fw) firmware(emi62/spdif.fw) firmware(ene-ub6250/ms_init.bin) firmware(ene-ub6250/ms_rdwr.bin) firmware(ene-ub6250/msp_rdwr.bin) firmware(ene-ub6250/sd_init1.bin) firmware(ene-ub6250/sd_init2.bin) firmware(ene-ub6250/sd_rdwr.bin) firmware(ess/maestro3_assp_kernel.fw) firmware(ess/maestro3_assp_minisrc.fw) firmware(f2255usb.bin) firmware(go7007/go7007fw.bin) firmware(go7007/go7007tv.bin) firmware(go7007/lr192.fw) firmware(go7007/px-m402u.fw) firmware(go7007/px-tv402u.fw) firmware(go7007/s2250-1.fw) firmware(go7007/s2250-2.fw) firmware(go7007/wis-startrek.fw) firmware(hfi1_dc8051.fw) firmware(hfi1_fabric.fw) firmware(hfi1_pcie.fw) firmware(hfi1_sbus.fw) firmware(htc_7010.fw) firmware(htc_9271.fw) firmware(i915/adlp_dmc.bin) firmware(i915/adlp_dmc_ver2_09.bin) firmware(i915/adlp_dmc_ver2_10.bin) firmware(i915/adlp_dmc_ver2_12.bin) firmware(i915/adlp_dmc_ver2_14.bin) firmware(i915/adlp_dmc_ver2_16.bin) firmware(i915/adlp_guc_62.0.3.bin) firmware(i915/adlp_guc_69.0.3.bin) firmware(i915/adlp_guc_70.1.1.bin) firmware(i915/adlp_guc_70.bin) firmware(i915/adls_dmc_ver2_01.bin) firmware(i915/bxt_dmc_ver1.bin) firmware(i915/bxt_dmc_ver1_07.bin) firmware(i915/bxt_guc_32.0.3.bin) firmware(i915/bxt_guc_33.0.0.bin) firmware(i915/bxt_guc_49.0.1.bin) firmware(i915/bxt_guc_62.0.0.bin) firmware(i915/bxt_guc_69.0.3.bin) firmware(i915/bxt_guc_70.1.1.bin) firmware(i915/bxt_guc_ver8_7.bin) firmware(i915/bxt_guc_ver9_29.bin) firmware(i915/bxt_huc_2.0.0.bin) firmware(i915/bxt_huc_ver01_07_1398.bin) firmware(i915/bxt_huc_ver01_8_2893.bin) firmware(i915/cml_guc_33.0.0.bin) firmware(i915/cml_guc_49.0.1.bin) firmware(i915/cml_guc_62.0.0.bin) firmware(i915/cml_guc_69.0.3.bin) firmware(i915/cml_guc_70.1.1.bin) firmware(i915/cml_huc_4.0.0.bin) firmware(i915/cnl_dmc_ver1_06.bin) firmware(i915/cnl_dmc_ver1_07.bin) firmware(i915/dg1_dmc_ver2_02.bin) firmware(i915/dg1_guc_49.0.1.bin) firmware(i915/dg1_guc_62.0.0.bin) firmware(i915/dg1_guc_69.0.3.bin) firmware(i915/dg1_guc_70.1.1.bin) firmware(i915/dg1_guc_70.bin) firmware(i915/dg1_huc.bin) firmware(i915/dg1_huc_7.7.1.bin) firmware(i915/dg1_huc_7.9.3.bin) firmware(i915/dg2_dmc_ver2_06.bin) firmware(i915/dg2_dmc_ver2_07.bin) firmware(i915/dg2_dmc_ver2_08.bin) firmware(i915/dg2_guc_70.1.2.bin) firmware(i915/dg2_guc_70.4.1.bin) firmware(i915/dg2_guc_70.bin) firmware(i915/dg2_huc_gsc.bin) firmware(i915/ehl_guc_33.0.4.bin) firmware(i915/ehl_guc_49.0.1.bin) firmware(i915/ehl_guc_62.0.0.bin) firmware(i915/ehl_guc_69.0.3.bin) firmware(i915/ehl_guc_70.1.1.bin) firmware(i915/ehl_huc_9.0.0.bin) firmware(i915/glk_dmc_ver1_04.bin) firmware(i915/glk_guc_32.0.3.bin) firmware(i915/glk_guc_33.0.0.bin) firmware(i915/glk_guc_49.0.1.bin) firmware(i915/glk_guc_62.0.0.bin) firmware(i915/glk_guc_69.0.3.bin) firmware(i915/glk_guc_70.1.1.bin) firmware(i915/glk_huc_4.0.0.bin) firmware(i915/glk_huc_ver03_01_2893.bin) firmware(i915/icl_dmc_ver1_07.bin) firmware(i915/icl_dmc_ver1_09.bin) firmware(i915/icl_guc_32.0.3.bin) firmware(i915/icl_guc_33.0.0.bin) firmware(i915/icl_guc_49.0.1.bin) firmware(i915/icl_guc_62.0.0.bin) firmware(i915/icl_guc_69.0.3.bin) firmware(i915/icl_guc_70.1.1.bin) firmware(i915/icl_huc_9.0.0.bin) firmware(i915/icl_huc_ver8_4_3238.bin) firmware(i915/kbl_dmc_ver1.bin) firmware(i915/kbl_dmc_ver1_01.bin) firmware(i915/kbl_dmc_ver1_04.bin) firmware(i915/kbl_guc_32.0.3.bin) firmware(i915/kbl_guc_33.0.0.bin) firmware(i915/kbl_guc_49.0.1.bin) firmware(i915/kbl_guc_62.0.0.bin) firmware(i915/kbl_guc_69.0.3.bin) firmware(i915/kbl_guc_70.1.1.bin) firmware(i915/kbl_guc_ver9_14.bin) firmware(i915/kbl_guc_ver9_39.bin) firmware(i915/kbl_huc_4.0.0.bin) firmware(i915/kbl_huc_ver02_00_1810.bin) firmware(i915/mtl_dmc.bin) firmware(i915/mtl_dmc_ver2_10.bin) firmware(i915/rkl_dmc_ver2_02.bin) firmware(i915/rkl_dmc_ver2_03.bin) firmware(i915/skl_dmc_ver1.bin) firmware(i915/skl_dmc_ver1_23.bin) firmware(i915/skl_dmc_ver1_26.bin) firmware(i915/skl_dmc_ver1_27.bin) firmware(i915/skl_guc_32.0.3.bin) firmware(i915/skl_guc_33.0.0.bin) firmware(i915/skl_guc_49.0.1.bin) firmware(i915/skl_guc_62.0.0.bin) firmware(i915/skl_guc_69.0.3.bin) firmware(i915/skl_guc_70.1.1.bin) firmware(i915/skl_guc_ver1.bin) firmware(i915/skl_guc_ver4.bin) firmware(i915/skl_guc_ver6.bin) firmware(i915/skl_guc_ver6_1.bin) firmware(i915/skl_guc_ver9_33.bin) firmware(i915/skl_huc_2.0.0.bin) firmware(i915/skl_huc_ver01_07_1398.bin) firmware(i915/tgl_dmc_ver2_04.bin) firmware(i915/tgl_dmc_ver2_06.bin) firmware(i915/tgl_dmc_ver2_08.bin) firmware(i915/tgl_dmc_ver2_12.bin) firmware(i915/tgl_guc_35.2.0.bin) firmware(i915/tgl_guc_49.0.1.bin) firmware(i915/tgl_guc_62.0.0.bin) firmware(i915/tgl_guc_69.0.3.bin) firmware(i915/tgl_guc_70.1.1.bin) firmware(i915/tgl_guc_70.bin) firmware(i915/tgl_huc.bin) firmware(i915/tgl_huc_7.0.12.bin) firmware(i915/tgl_huc_7.0.3.bin) firmware(i915/tgl_huc_7.5.0.bin) firmware(i915/tgl_huc_7.9.3.bin) firmware(imx/sdma/sdma-imx6q.bin) firmware(imx/sdma/sdma-imx7d.bin) firmware(inside-secure/eip197_minifw/ifpp.bin) firmware(inside-secure/eip197_minifw/ipue.bin) firmware(intel/IntcSST2.bin) firmware(intel/avs/apl/dsp_basefw.bin) firmware(intel/avs/cnl/dsp_basefw.bin) firmware(intel/avs/skl/dsp_basefw.bin) firmware(intel/avs/skl/dsp_mod_7CAD0808-AB10-CD23-EF45-12AB34CD56EF.bin) firmware(intel/catpt/bdw/dsp_basefw.bin) firmware(intel/dsp_fw_bxtn.bin) firmware(intel/dsp_fw_bxtn_v2219.bin) firmware(intel/dsp_fw_bxtn_v3366.bin) firmware(intel/dsp_fw_cnl.bin) firmware(intel/dsp_fw_cnl_v1191.bin) firmware(intel/dsp_fw_cnl_v1858.bin) firmware(intel/dsp_fw_glk.bin) firmware(intel/dsp_fw_glk_v1814.bin) firmware(intel/dsp_fw_glk_v2768.bin) firmware(intel/dsp_fw_glk_v2880.bin) firmware(intel/dsp_fw_glk_v3366.bin) firmware(intel/dsp_fw_kbl.bin) firmware(intel/dsp_fw_kbl_v1037.bin) firmware(intel/dsp_fw_kbl_v2042.bin) firmware(intel/dsp_fw_kbl_v2630.bin) firmware(intel/dsp_fw_kbl_v3266.bin) firmware(intel/dsp_fw_kbl_v3402.bin) firmware(intel/dsp_fw_kbl_v3420.bin) firmware(intel/dsp_fw_kbl_v701.bin) firmware(intel/dsp_fw_release.bin) firmware(intel/dsp_fw_release_v3402.bin) firmware(intel/dsp_fw_release_v969.bin) firmware(intel/fw_sst_0f28.bin) firmware(intel/fw_sst_0f28.bin-48kHz_i2s_master) firmware(intel/fw_sst_0f28_ssp0.bin) firmware(intel/fw_sst_22a8.bin) firmware(intel/ibt-0040-0041.ddc) firmware(intel/ibt-0040-0041.sfi) firmware(intel/ibt-0040-1020.ddc) firmware(intel/ibt-0040-1020.sfi) firmware(intel/ibt-0040-2120.ddc) firmware(intel/ibt-0040-2120.sfi) firmware(intel/ibt-0040-4150.ddc) firmware(intel/ibt-0040-4150.sfi) firmware(intel/ibt-0041-0041.ddc) firmware(intel/ibt-0041-0041.sfi) firmware(intel/ibt-1040-0041.ddc) firmware(intel/ibt-1040-0041.sfi) firmware(intel/ibt-1040-1020.ddc) firmware(intel/ibt-1040-1020.sfi) firmware(intel/ibt-1040-2120.ddc) firmware(intel/ibt-1040-2120.sfi) firmware(intel/ibt-1040-4150.ddc) firmware(intel/ibt-1040-4150.sfi) firmware(intel/ibt-11-5.ddc) firmware(intel/ibt-11-5.sfi) firmware(intel/ibt-12-16.ddc) firmware(intel/ibt-12-16.sfi) firmware(intel/ibt-17-0-1.ddc) firmware(intel/ibt-17-0-1.sfi) firmware(intel/ibt-17-1.ddc) firmware(intel/ibt-17-1.sfi) firmware(intel/ibt-17-16-1.ddc) firmware(intel/ibt-17-16-1.sfi) firmware(intel/ibt-17-2.ddc) firmware(intel/ibt-17-2.sfi) firmware(intel/ibt-18-0-1.ddc) firmware(intel/ibt-18-0-1.sfi) firmware(intel/ibt-18-1.ddc) firmware(intel/ibt-18-1.sfi) firmware(intel/ibt-18-16-1.ddc) firmware(intel/ibt-18-16-1.sfi) firmware(intel/ibt-18-2.ddc) firmware(intel/ibt-18-2.sfi) firmware(intel/ibt-19-0-0.ddc) firmware(intel/ibt-19-0-0.sfi) firmware(intel/ibt-19-0-1.ddc) firmware(intel/ibt-19-0-1.sfi) firmware(intel/ibt-19-0-3.ddc) firmware(intel/ibt-19-0-3.sfi) firmware(intel/ibt-19-0-4.ddc) firmware(intel/ibt-19-0-4.sfi) firmware(intel/ibt-19-16-4.ddc) firmware(intel/ibt-19-16-4.sfi) firmware(intel/ibt-19-240-1.ddc) firmware(intel/ibt-19-240-1.sfi) firmware(intel/ibt-19-240-4.ddc) firmware(intel/ibt-19-240-4.sfi) firmware(intel/ibt-19-32-0.ddc) firmware(intel/ibt-19-32-0.sfi) firmware(intel/ibt-19-32-1.ddc) firmware(intel/ibt-19-32-1.sfi) firmware(intel/ibt-19-32-4.ddc) firmware(intel/ibt-19-32-4.sfi) firmware(intel/ibt-20-0-3.ddc) firmware(intel/ibt-20-0-3.sfi) firmware(intel/ibt-20-1-3.ddc) firmware(intel/ibt-20-1-3.sfi) firmware(intel/ibt-20-1-4.ddc) firmware(intel/ibt-20-1-4.sfi) firmware(intel/ibt-hw-37.7.10-fw-1.0.1.2d.d.bseq) firmware(intel/ibt-hw-37.7.10-fw-1.0.2.3.d.bseq) firmware(intel/ibt-hw-37.7.10-fw-1.80.1.2d.d.bseq) firmware(intel/ibt-hw-37.7.10-fw-1.80.2.3.d.bseq) firmware(intel/ibt-hw-37.7.bseq) firmware(intel/ibt-hw-37.8.10-fw-1.10.2.27.d.bseq) firmware(intel/ibt-hw-37.8.10-fw-1.10.3.11.e.bseq) firmware(intel/ibt-hw-37.8.10-fw-22.50.19.14.f.bseq) firmware(intel/ibt-hw-37.8.bseq) firmware(intel/ice/ddp-comms/ice_comms-1.3.31.0.pkg) firmware(intel/ice/ddp-wireless_edge/ice_wireless_edge-1.3.7.0.pkg) firmware(intel/ice/ddp/ice-1.3.30.0.pkg) firmware(intel/ice/ddp/ice.pkg) firmware(intel/ipu3-fw.bin) firmware(intel/irci_irci_ecr-master_20161208_0213_20170112_1500.bin) firmware(isci/isci_firmware.bin) firmware(isdbt_nova_12mhz.inp) firmware(isdbt_nova_12mhz_b0.inp) firmware(isdbt_rio.inp) firmware(iwlwifi-100-5.ucode) firmware(iwlwifi-1000-5.ucode) firmware(iwlwifi-105-6.ucode) firmware(iwlwifi-135-6.ucode) firmware(iwlwifi-2000-6.ucode) firmware(iwlwifi-2030-6.ucode) firmware(iwlwifi-3160-17.ucode) firmware(iwlwifi-3168-29.ucode) firmware(iwlwifi-3945-2.ucode) firmware(iwlwifi-4965-2.ucode) firmware(iwlwifi-5000-5.ucode) firmware(iwlwifi-5150-2.ucode) firmware(iwlwifi-6000-4.ucode) firmware(iwlwifi-6000g2a-6.ucode) firmware(iwlwifi-6000g2b-6.ucode) firmware(iwlwifi-6050-5.ucode) firmware(iwlwifi-7260-17.ucode) firmware(iwlwifi-7265-17.ucode) firmware(iwlwifi-7265D-29.ucode) firmware(iwlwifi-8000C-34.ucode) firmware(iwlwifi-8000C-36.ucode) firmware(iwlwifi-8265-34.ucode) firmware(iwlwifi-8265-36.ucode) firmware(iwlwifi-9000-pu-b0-jf-b0-34.ucode) firmware(iwlwifi-9000-pu-b0-jf-b0-38.ucode) firmware(iwlwifi-9000-pu-b0-jf-b0-46.ucode) firmware(iwlwifi-9260-th-b0-jf-b0-34.ucode) firmware(iwlwifi-9260-th-b0-jf-b0-38.ucode) firmware(iwlwifi-9260-th-b0-jf-b0-46.ucode) firmware(iwlwifi-Qu-b0-hr-b0-50.ucode) firmware(iwlwifi-Qu-b0-hr-b0-59.ucode) firmware(iwlwifi-Qu-b0-hr-b0-66.ucode) firmware(iwlwifi-Qu-b0-hr-b0-72.ucode) firmware(iwlwifi-Qu-b0-hr-b0-73.ucode) firmware(iwlwifi-Qu-b0-hr-b0-74.ucode) firmware(iwlwifi-Qu-b0-hr-b0-77.ucode) firmware(iwlwifi-Qu-b0-jf-b0-50.ucode) firmware(iwlwifi-Qu-b0-jf-b0-59.ucode) firmware(iwlwifi-Qu-b0-jf-b0-66.ucode) firmware(iwlwifi-Qu-b0-jf-b0-72.ucode) firmware(iwlwifi-Qu-b0-jf-b0-73.ucode) firmware(iwlwifi-Qu-b0-jf-b0-74.ucode) firmware(iwlwifi-Qu-b0-jf-b0-77.ucode) firmware(iwlwifi-Qu-c0-hr-b0-50.ucode) firmware(iwlwifi-Qu-c0-hr-b0-59.ucode) firmware(iwlwifi-Qu-c0-hr-b0-66.ucode) firmware(iwlwifi-Qu-c0-hr-b0-72.ucode) firmware(iwlwifi-Qu-c0-hr-b0-73.ucode) firmware(iwlwifi-Qu-c0-hr-b0-74.ucode) firmware(iwlwifi-Qu-c0-hr-b0-77.ucode) firmware(iwlwifi-Qu-c0-jf-b0-50.ucode) firmware(iwlwifi-Qu-c0-jf-b0-59.ucode) firmware(iwlwifi-Qu-c0-jf-b0-66.ucode) firmware(iwlwifi-Qu-c0-jf-b0-72.ucode) firmware(iwlwifi-Qu-c0-jf-b0-73.ucode) firmware(iwlwifi-Qu-c0-jf-b0-74.ucode) firmware(iwlwifi-Qu-c0-jf-b0-77.ucode) firmware(iwlwifi-QuZ-a0-hr-b0-50.ucode) firmware(iwlwifi-QuZ-a0-hr-b0-59.ucode) firmware(iwlwifi-QuZ-a0-hr-b0-66.ucode) firmware(iwlwifi-QuZ-a0-hr-b0-72.ucode) firmware(iwlwifi-QuZ-a0-hr-b0-73.ucode) firmware(iwlwifi-QuZ-a0-hr-b0-74.ucode) firmware(iwlwifi-QuZ-a0-hr-b0-77.ucode) firmware(iwlwifi-QuZ-a0-jf-b0-50.ucode) firmware(iwlwifi-QuZ-a0-jf-b0-59.ucode) firmware(iwlwifi-QuZ-a0-jf-b0-66.ucode) firmware(iwlwifi-QuZ-a0-jf-b0-72.ucode) firmware(iwlwifi-QuZ-a0-jf-b0-73.ucode) firmware(iwlwifi-QuZ-a0-jf-b0-74.ucode) firmware(iwlwifi-QuZ-a0-jf-b0-77.ucode) firmware(iwlwifi-cc-a0-50.ucode) firmware(iwlwifi-cc-a0-59.ucode) firmware(iwlwifi-cc-a0-66.ucode) firmware(iwlwifi-cc-a0-72.ucode) firmware(iwlwifi-cc-a0-73.ucode) firmware(iwlwifi-cc-a0-74.ucode) firmware(iwlwifi-cc-a0-77.ucode) firmware(iwlwifi-so-a0-gf-a0-72.ucode) firmware(iwlwifi-so-a0-gf-a0-73.ucode) firmware(iwlwifi-so-a0-gf-a0-74.ucode) firmware(iwlwifi-so-a0-gf-a0-77.ucode) firmware(iwlwifi-so-a0-gf-a0-78.ucode) firmware(iwlwifi-so-a0-gf-a0-79.ucode) firmware(iwlwifi-so-a0-gf-a0-81.ucode) firmware(iwlwifi-so-a0-gf-a0.pnvm) firmware(iwlwifi-so-a0-gf4-a0-72.ucode) firmware(iwlwifi-so-a0-gf4-a0-73.ucode) firmware(iwlwifi-so-a0-gf4-a0-74.ucode) firmware(iwlwifi-so-a0-gf4-a0-77.ucode) firmware(iwlwifi-so-a0-gf4-a0-78.ucode) firmware(iwlwifi-so-a0-gf4-a0-79.ucode) firmware(iwlwifi-so-a0-gf4-a0-81.ucode) firmware(iwlwifi-so-a0-gf4-a0.pnvm) firmware(iwlwifi-so-a0-hr-b0-72.ucode) firmware(iwlwifi-so-a0-hr-b0-73.ucode) firmware(iwlwifi-so-a0-hr-b0-74.ucode) firmware(iwlwifi-so-a0-hr-b0-77.ucode) firmware(iwlwifi-so-a0-hr-b0-79.ucode) firmware(iwlwifi-so-a0-hr-b0-81.ucode) firmware(iwlwifi-so-a0-jf-b0-72.ucode) firmware(iwlwifi-so-a0-jf-b0-73.ucode) firmware(iwlwifi-so-a0-jf-b0-74.ucode) firmware(iwlwifi-so-a0-jf-b0-77.ucode) firmware(iwlwifi-ty-a0-gf-a0-59.ucode) firmware(iwlwifi-ty-a0-gf-a0-66.ucode) firmware(iwlwifi-ty-a0-gf-a0-72.ucode) firmware(iwlwifi-ty-a0-gf-a0-73.ucode) firmware(iwlwifi-ty-a0-gf-a0-74.ucode) firmware(iwlwifi-ty-a0-gf-a0-77.ucode) firmware(iwlwifi-ty-a0-gf-a0-78.ucode) firmware(iwlwifi-ty-a0-gf-a0-79.ucode) firmware(iwlwifi-ty-a0-gf-a0-81.ucode) firmware(iwlwifi-ty-a0-gf-a0.pnvm) firmware(kaweth/new_code.bin) firmware(kaweth/new_code_fix.bin) firmware(kaweth/trigger_code.bin) firmware(kaweth/trigger_code_fix.bin) firmware(keyspan/mpr.fw) firmware(keyspan/usa18x.fw) firmware(keyspan/usa19.fw) firmware(keyspan/usa19qi.fw) firmware(keyspan/usa19qw.fw) firmware(keyspan/usa19w.fw) firmware(keyspan/usa28.fw) firmware(keyspan/usa28x.fw) firmware(keyspan/usa28xa.fw) firmware(keyspan/usa28xb.fw) firmware(keyspan/usa49w.fw) firmware(keyspan/usa49wlc.fw) firmware(keyspan_pda/keyspan_pda.fw) firmware(keyspan_pda/xircom_pgs.fw) firmware(korg/k1212.dsp) firmware(lbtf_usb.bin) firmware(lgs8g75.fw) firmware(libertas/cf8381.bin) firmware(libertas/cf8381_helper.bin) firmware(libertas/cf8385.bin) firmware(libertas/cf8385_helper.bin) firmware(libertas/gspi8682.bin) firmware(libertas/gspi8682_helper.bin) firmware(libertas/gspi8686_v9.bin) firmware(libertas/gspi8686_v9_helper.bin) firmware(libertas/gspi8688.bin) firmware(libertas/gspi8688_helper.bin) firmware(libertas/lbtf_sdio.bin) firmware(libertas/sd8385.bin) firmware(libertas/sd8385_helper.bin) firmware(libertas/sd8682.bin) firmware(libertas/sd8682_helper.bin) firmware(libertas/sd8686_v8.bin) firmware(libertas/sd8686_v8_helper.bin) firmware(libertas/sd8686_v9.bin) firmware(libertas/sd8686_v9_helper.bin) firmware(libertas/sd8688.bin) firmware(libertas/sd8688_helper.bin) firmware(libertas/usb8388_olpc.bin) firmware(libertas/usb8388_v5.bin) firmware(libertas/usb8388_v9.bin) firmware(libertas/usb8682.bin) firmware(liquidio/lio_210nv_nic.bin) firmware(liquidio/lio_210sv_nic.bin) firmware(liquidio/lio_23xx_nic.bin) firmware(liquidio/lio_410nv_nic.bin) firmware(lt9611uxc_fw.bin) firmware(matrox/g200_warp.fw) firmware(matrox/g400_warp.fw) firmware(mediatek/BT_RAM_CODE_MT7922_1_1_hdr.bin) firmware(mediatek/BT_RAM_CODE_MT7961_1_2_hdr.bin) firmware(mediatek/WIFI_MT7922_patch_mcu_1_1_hdr.bin) firmware(mediatek/WIFI_MT7961_patch_mcu_1_2_hdr.bin) firmware(mediatek/WIFI_RAM_CODE_MT7922_1.bin) firmware(mediatek/WIFI_RAM_CODE_MT7961_1.bin) firmware(mediatek/mt7601u.bin) firmware(mediatek/mt7610e.bin) firmware(mediatek/mt7610u.bin) firmware(mediatek/mt7615_cr4.bin) firmware(mediatek/mt7615_n9.bin) firmware(mediatek/mt7615_rom_patch.bin) firmware(mediatek/mt7622_n9.bin) firmware(mediatek/mt7622_rom_patch.bin) firmware(mediatek/mt7622pr2h.bin) firmware(mediatek/mt7650.bin) firmware(mediatek/mt7650e.bin) firmware(mediatek/mt7662.bin) firmware(mediatek/mt7662_rom_patch.bin) firmware(mediatek/mt7662u.bin) firmware(mediatek/mt7662u_rom_patch.bin) firmware(mediatek/mt7663_n9_rebb.bin) firmware(mediatek/mt7663_n9_v3.bin) firmware(mediatek/mt7663pr2h.bin) firmware(mediatek/mt7663pr2h_rebb.bin) firmware(mediatek/mt7668pr2h.bin) firmware(mediatek/mt7915_eeprom.bin) firmware(mediatek/mt7915_eeprom_dbdc.bin) firmware(mediatek/mt7915_rom_patch.bin) firmware(mediatek/mt7915_wa.bin) firmware(mediatek/mt7915_wm.bin) firmware(mediatek/mt7916_eeprom.bin) firmware(mediatek/mt7916_rom_patch.bin) firmware(mediatek/mt7916_wa.bin) firmware(mediatek/mt7916_wm.bin) firmware(mediatek/mt7981_rom_patch.bin) firmware(mediatek/mt7981_wa.bin) firmware(mediatek/mt7981_wm.bin) firmware(mediatek/mt7981_wo.bin) firmware(mediatek/mt7986_eeprom_mt7975_dual.bin) firmware(mediatek/mt7986_eeprom_mt7976.bin) firmware(mediatek/mt7986_eeprom_mt7976_dbdc.bin) firmware(mediatek/mt7986_eeprom_mt7976_dual.bin) firmware(mediatek/mt7986_rom_patch.bin) firmware(mediatek/mt7986_rom_patch_mt7975.bin) firmware(mediatek/mt7986_wa.bin) firmware(mediatek/mt7986_wm.bin) firmware(mediatek/mt7986_wm_mt7975.bin) firmware(mediatek/mt7986_wo_0.bin) firmware(mediatek/mt7986_wo_1.bin) firmware(mediatek/mt8173/vpu_d.bin) firmware(mediatek/mt8173/vpu_p.bin) firmware(mediatek/mt8183/scp.img) firmware(mediatek/mt8186/scp.img) firmware(mediatek/mt8192/scp.img) firmware(mediatek/mt8195/scp.img) firmware(mediatek/sof-tplg/sof-mt8186.tplg) firmware(mediatek/sof-tplg/sof-mt8195-mt6359-rt1019-rt5682-dts.tplg) firmware(mediatek/sof-tplg/sof-mt8195-mt6359-rt1019-rt5682.tplg) firmware(mediatek/sof/sof-mt8186.ldc) firmware(mediatek/sof/sof-mt8186.ri) firmware(mediatek/sof/sof-mt8195.ldc) firmware(mediatek/sof/sof-mt8195.ri) firmware(mellanox/lc_ini_bundle_2010_1006.bin) firmware(mellanox/lc_ini_bundle_2010_1502.bin) firmware(mellanox/lc_ini_bundle_2010_3020.bin) firmware(mellanox/lc_ini_bundle_2010_3146.bin) firmware(mellanox/mlxsw_spectrum-13.1420.122.mfa2) firmware(mellanox/mlxsw_spectrum-13.1530.152.mfa2) firmware(mellanox/mlxsw_spectrum-13.1620.192.mfa2) firmware(mellanox/mlxsw_spectrum-13.1702.6.mfa2) firmware(mellanox/mlxsw_spectrum-13.1703.4.mfa2) firmware(mellanox/mlxsw_spectrum-13.1910.622.mfa2) firmware(mellanox/mlxsw_spectrum-13.2000.1122.mfa2) firmware(mellanox/mlxsw_spectrum-13.2000.1886.mfa2) firmware(mellanox/mlxsw_spectrum-13.2000.2308.mfa2) firmware(mellanox/mlxsw_spectrum-13.2000.2714.mfa2) firmware(mellanox/mlxsw_spectrum-13.2007.1168.mfa2) firmware(mellanox/mlxsw_spectrum-13.2008.1036.mfa2) firmware(mellanox/mlxsw_spectrum-13.2008.1310.mfa2) firmware(mellanox/mlxsw_spectrum-13.2008.1312.mfa2) firmware(mellanox/mlxsw_spectrum-13.2008.2018.mfa2) firmware(mellanox/mlxsw_spectrum-13.2008.2304.mfa2) firmware(mellanox/mlxsw_spectrum-13.2008.2406.mfa2) firmware(mellanox/mlxsw_spectrum-13.2008.2438.mfa2) firmware(mellanox/mlxsw_spectrum-13.2008.2946.mfa2) firmware(mellanox/mlxsw_spectrum-13.2008.3326.mfa2) firmware(mellanox/mlxsw_spectrum-13.2010.1006.mfa2) firmware(mellanox/mlxsw_spectrum-13.2010.1232.mfa2) firmware(mellanox/mlxsw_spectrum-13.2010.1406.mfa2) firmware(mellanox/mlxsw_spectrum-13.2010.1502.mfa2) firmware(mellanox/mlxsw_spectrum-13.2010.3020.mfa2) firmware(mellanox/mlxsw_spectrum-13.2010.3146.mfa2) firmware(mellanox/mlxsw_spectrum2-29.2000.2308.mfa2) firmware(mellanox/mlxsw_spectrum2-29.2000.2714.mfa2) firmware(mellanox/mlxsw_spectrum2-29.2007.1168.mfa2) firmware(mellanox/mlxsw_spectrum2-29.2008.1036.mfa2) firmware(mellanox/mlxsw_spectrum2-29.2008.1310.mfa2) firmware(mellanox/mlxsw_spectrum2-29.2008.1312.mfa2) firmware(mellanox/mlxsw_spectrum2-29.2008.2018.mfa2) firmware(mellanox/mlxsw_spectrum2-29.2008.2304.mfa2) firmware(mellanox/mlxsw_spectrum2-29.2008.2406.mfa2) firmware(mellanox/mlxsw_spectrum2-29.2008.2438.mfa2) firmware(mellanox/mlxsw_spectrum2-29.2008.2946.mfa2) firmware(mellanox/mlxsw_spectrum2-29.2008.3326.mfa2) firmware(mellanox/mlxsw_spectrum2-29.2010.1006.mfa2) firmware(mellanox/mlxsw_spectrum2-29.2010.1232.mfa2) firmware(mellanox/mlxsw_spectrum2-29.2010.1406.mfa2) firmware(mellanox/mlxsw_spectrum2-29.2010.1502.mfa2) firmware(mellanox/mlxsw_spectrum2-29.2010.3020.mfa2) firmware(mellanox/mlxsw_spectrum2-29.2010.3146.mfa2) firmware(mellanox/mlxsw_spectrum3-30.2007.1168.mfa2) firmware(mellanox/mlxsw_spectrum3-30.2008.1036.mfa2) firmware(mellanox/mlxsw_spectrum3-30.2008.1310.mfa2) firmware(mellanox/mlxsw_spectrum3-30.2008.1312.mfa2) firmware(mellanox/mlxsw_spectrum3-30.2008.2018.mfa2) firmware(mellanox/mlxsw_spectrum3-30.2008.2304.mfa2) firmware(mellanox/mlxsw_spectrum3-30.2008.2406.mfa2) firmware(mellanox/mlxsw_spectrum3-30.2008.2438.mfa2) firmware(mellanox/mlxsw_spectrum3-30.2008.2946.mfa2) firmware(mellanox/mlxsw_spectrum3-30.2008.3326.mfa2) firmware(mellanox/mlxsw_spectrum3-30.2010.1006.mfa2) firmware(mellanox/mlxsw_spectrum3-30.2010.1232.mfa2) firmware(mellanox/mlxsw_spectrum3-30.2010.1406.mfa2) firmware(mellanox/mlxsw_spectrum3-30.2010.1502.mfa2) firmware(mellanox/mlxsw_spectrum3-30.2010.3020.mfa2) firmware(mellanox/mlxsw_spectrum3-30.2010.3146.mfa2) firmware(meson/vdec/g12a_h264.bin) firmware(meson/vdec/g12a_hevc_mmu.bin) firmware(meson/vdec/g12a_vp9.bin) firmware(meson/vdec/gxbb_h264.bin) firmware(meson/vdec/gxl_h263.bin) firmware(meson/vdec/gxl_h264.bin) firmware(meson/vdec/gxl_hevc.bin) firmware(meson/vdec/gxl_hevc_mmu.bin) firmware(meson/vdec/gxl_mjpeg.bin) firmware(meson/vdec/gxl_mpeg12.bin) firmware(meson/vdec/gxl_mpeg4_5.bin) firmware(meson/vdec/gxl_vp9.bin) firmware(meson/vdec/gxm_h264.bin) firmware(meson/vdec/sm1_hevc_mmu.bin) firmware(meson/vdec/sm1_vp9_mmu.bin) firmware(microchip/mscc_vsc8574_revb_int8051_29e8.bin) firmware(microchip/mscc_vsc8584_revb_int8051_fb48.bin) firmware(moxa/moxa-1110.fw) firmware(moxa/moxa-1130.fw) firmware(moxa/moxa-1131.fw) firmware(moxa/moxa-1150.fw) firmware(moxa/moxa-1151.fw) firmware(moxa/moxa-1250.fw) firmware(moxa/moxa-1251.fw) firmware(moxa/moxa-1410.fw) firmware(moxa/moxa-1450.fw) firmware(moxa/moxa-1451.fw) firmware(moxa/moxa-1613.fw) firmware(moxa/moxa-1618.fw) firmware(moxa/moxa-1653.fw) firmware(moxa/moxa-1658.fw) firmware(mrvl/cpt01/ae.out) firmware(mrvl/cpt01/ie.out) firmware(mrvl/cpt01/se.out) firmware(mrvl/cpt02/ae.out) firmware(mrvl/cpt02/ie.out) firmware(mrvl/cpt02/se.out) firmware(mrvl/cpt03/ae.out) firmware(mrvl/cpt03/ie.out) firmware(mrvl/cpt03/se.out) firmware(mrvl/cpt04/ae.out) firmware(mrvl/cpt04/ie.out) firmware(mrvl/cpt04/se.out) firmware(mrvl/pcie8897_uapsta.bin) firmware(mrvl/pcie8997_wlan_v4.bin) firmware(mrvl/pcieuart8997_combo_v4.bin) firmware(mrvl/pcieusb8997_combo_v4.bin) firmware(mrvl/prestera/mvsw_prestera_fw-v2.0.img) firmware(mrvl/prestera/mvsw_prestera_fw-v3.0.img) firmware(mrvl/prestera/mvsw_prestera_fw-v4.0.img) firmware(mrvl/prestera/mvsw_prestera_fw-v4.1.img) firmware(mrvl/prestera/mvsw_prestera_fw_arm64-v4.1.img) firmware(mrvl/sd8688.bin) firmware(mrvl/sd8688_helper.bin) firmware(mrvl/sd8787_uapsta.bin) firmware(mrvl/sd8797_uapsta.bin) firmware(mrvl/sd8801_uapsta.bin) firmware(mrvl/sd8887_uapsta.bin) firmware(mrvl/sd8897_uapsta.bin) firmware(mrvl/sdsd8977_combo_v2.bin) firmware(mrvl/sdsd8997_combo_v4.bin) firmware(mrvl/usb8766_uapsta.bin) firmware(mrvl/usb8797_uapsta.bin) firmware(mrvl/usb8801_uapsta.bin) firmware(mrvl/usb8897_uapsta.bin) firmware(mrvl/usbusb8997_combo_v4.bin) firmware(mt7601u.bin) firmware(mt7650.bin) firmware(mt7662.bin) firmware(mt7662_rom_patch.bin) firmware(mts_cdma.fw) firmware(mts_edge.fw) firmware(mts_gsm.fw) firmware(mts_mt9234mu.fw) firmware(mts_mt9234zba.fw) firmware(mwl8k/fmimage_8366.fw) firmware(mwl8k/fmimage_8366_ap-1.fw) firmware(mwl8k/fmimage_8366_ap-2.fw) firmware(mwl8k/fmimage_8366_ap-3.fw) firmware(mwl8k/fmimage_8687.fw) firmware(mwl8k/fmimage_8764_ap-1.fw) firmware(mwl8k/helper_8366.fw) firmware(mwl8k/helper_8687.fw) firmware(mwlwifi/88W8864.bin) firmware(mwlwifi/88W8897.bin) firmware(myri10ge_eth_big_z8e.dat) firmware(myri10ge_eth_z8e.dat) firmware(myri10ge_ethp_big_z8e.dat) firmware(myri10ge_ethp_z8e.dat) firmware(myri10ge_rss_eth_big_z8e.dat) firmware(myri10ge_rss_eth_z8e.dat) firmware(myri10ge_rss_ethp_big_z8e.dat) firmware(myri10ge_rss_ethp_z8e.dat) firmware(myricom/lanai.bin) firmware(netronome/bpf/nic_AMDA0058-0011_2x40.nffw) firmware(netronome/bpf/nic_AMDA0058-0012_2x40.nffw) firmware(netronome/bpf/nic_AMDA0078-0011_1x100.nffw) firmware(netronome/bpf/nic_AMDA0081-0001_1x40.nffw) firmware(netronome/bpf/nic_AMDA0081-0001_4x10.nffw) firmware(netronome/bpf/nic_AMDA0096-0001_2x10.nffw) firmware(netronome/bpf/nic_AMDA0097-0001_2x40.nffw) firmware(netronome/bpf/nic_AMDA0097-0001_4x10_1x40.nffw) firmware(netronome/bpf/nic_AMDA0097-0001_8x10.nffw) firmware(netronome/bpf/nic_AMDA0099-0001_1x10_1x25.nffw) firmware(netronome/bpf/nic_AMDA0099-0001_2x10.nffw) firmware(netronome/bpf/nic_AMDA0099-0001_2x25.nffw) firmware(netronome/flower/nic_AMDA0058-0011_1x100.nffw) firmware(netronome/flower/nic_AMDA0058-0011_2x40.nffw) firmware(netronome/flower/nic_AMDA0058-0011_4x10_1x40.nffw) firmware(netronome/flower/nic_AMDA0058-0011_8x10.nffw) firmware(netronome/flower/nic_AMDA0058-0012_1x100.nffw) firmware(netronome/flower/nic_AMDA0058-0012_2x40.nffw) firmware(netronome/flower/nic_AMDA0058-0012_4x10_1x40.nffw) firmware(netronome/flower/nic_AMDA0058-0012_8x10.nffw) firmware(netronome/flower/nic_AMDA0058.nffw) firmware(netronome/flower/nic_AMDA0078-0011_1x100.nffw) firmware(netronome/flower/nic_AMDA0078-0011_2x40.nffw) firmware(netronome/flower/nic_AMDA0078-0011_4x10_1x40.nffw) firmware(netronome/flower/nic_AMDA0078-0011_8x10.nffw) firmware(netronome/flower/nic_AMDA0078-0012_1x100.nffw) firmware(netronome/flower/nic_AMDA0078-0012_2x40.nffw) firmware(netronome/flower/nic_AMDA0078-0012_4x10_1x40.nffw) firmware(netronome/flower/nic_AMDA0078-0012_8x10.nffw) firmware(netronome/flower/nic_AMDA0081-0001_1x40.nffw) firmware(netronome/flower/nic_AMDA0081-0001_4x10.nffw) firmware(netronome/flower/nic_AMDA0081.nffw) firmware(netronome/flower/nic_AMDA0096-0001_2x10.nffw) firmware(netronome/flower/nic_AMDA0096.nffw) firmware(netronome/flower/nic_AMDA0097-0001_2x40.nffw) firmware(netronome/flower/nic_AMDA0097-0001_4x10_1x40.nffw) firmware(netronome/flower/nic_AMDA0097-0001_8x10.nffw) firmware(netronome/flower/nic_AMDA0097.nffw) firmware(netronome/flower/nic_AMDA0099-0001_1x10_1x25.nffw) firmware(netronome/flower/nic_AMDA0099-0001_2x10.nffw) firmware(netronome/flower/nic_AMDA0099-0001_2x25.nffw) firmware(netronome/flower/nic_AMDA0099.nffw) firmware(netronome/nic-sriov/nic_AMDA0058-0011_2x40.nffw) firmware(netronome/nic-sriov/nic_AMDA0058-0012_2x40.nffw) firmware(netronome/nic-sriov/nic_AMDA0078-0011_1x100.nffw) firmware(netronome/nic-sriov/nic_AMDA0081-0001_1x40.nffw) firmware(netronome/nic-sriov/nic_AMDA0081-0001_4x10.nffw) firmware(netronome/nic-sriov/nic_AMDA0096-0001_2x10.nffw) firmware(netronome/nic-sriov/nic_AMDA0097-0001_2x40.nffw) firmware(netronome/nic-sriov/nic_AMDA0097-0001_4x10_1x40.nffw) firmware(netronome/nic-sriov/nic_AMDA0097-0001_8x10.nffw) firmware(netronome/nic-sriov/nic_AMDA0099-0001_1x10_1x25.nffw) firmware(netronome/nic-sriov/nic_AMDA0099-0001_2x10.nffw) firmware(netronome/nic-sriov/nic_AMDA0099-0001_2x25.nffw) firmware(netronome/nic/nic_AMDA0058-0011_2x40.nffw) firmware(netronome/nic/nic_AMDA0058-0012_2x40.nffw) firmware(netronome/nic/nic_AMDA0078-0011_1x100.nffw) firmware(netronome/nic/nic_AMDA0081-0001_1x40.nffw) firmware(netronome/nic/nic_AMDA0081-0001_4x10.nffw) firmware(netronome/nic/nic_AMDA0096-0001_2x10.nffw) firmware(netronome/nic/nic_AMDA0097-0001_2x40.nffw) firmware(netronome/nic/nic_AMDA0097-0001_4x10_1x40.nffw) firmware(netronome/nic/nic_AMDA0097-0001_8x10.nffw) firmware(netronome/nic/nic_AMDA0099-0001_1x10_1x25.nffw) firmware(netronome/nic/nic_AMDA0099-0001_2x10.nffw) firmware(netronome/nic/nic_AMDA0099-0001_2x25.nffw) firmware(netronome/nic_AMDA0058-0011_2x40.nffw) firmware(netronome/nic_AMDA0058-0012_2x40.nffw) firmware(netronome/nic_AMDA0078-0011_1x100.nffw) firmware(netronome/nic_AMDA0081-0001_1x40.nffw) firmware(netronome/nic_AMDA0081-0001_4x10.nffw) firmware(netronome/nic_AMDA0096-0001_2x10.nffw) firmware(netronome/nic_AMDA0097-0001_2x40.nffw) firmware(netronome/nic_AMDA0097-0001_4x10_1x40.nffw) firmware(netronome/nic_AMDA0097-0001_8x10.nffw) firmware(netronome/nic_AMDA0099-0001_1x10_1x25.nffw) firmware(netronome/nic_AMDA0099-0001_2x10.nffw) firmware(netronome/nic_AMDA0099-0001_2x25.nffw) firmware(nvidia/ga102/acr/ucode_ahesasc.bin) firmware(nvidia/ga102/acr/ucode_asb.bin) firmware(nvidia/ga102/acr/ucode_unload.bin) firmware(nvidia/ga102/gr/NET_img.bin) firmware(nvidia/ga102/gr/fecs_bl.bin) firmware(nvidia/ga102/gr/fecs_sig.bin) firmware(nvidia/ga102/gr/gpccs_bl.bin) firmware(nvidia/ga102/gr/gpccs_sig.bin) firmware(nvidia/ga102/nvdec/scrubber.bin) firmware(nvidia/ga102/sec2/desc.bin) firmware(nvidia/ga102/sec2/hs_bl_sig.bin) firmware(nvidia/ga102/sec2/image.bin) firmware(nvidia/ga102/sec2/sig.bin) firmware(nvidia/ga103/acr/ucode_ahesasc.bin) firmware(nvidia/ga103/acr/ucode_asb.bin) firmware(nvidia/ga103/acr/ucode_unload.bin) firmware(nvidia/ga103/gr/NET_img.bin) firmware(nvidia/ga103/gr/fecs_bl.bin) firmware(nvidia/ga103/gr/fecs_sig.bin) firmware(nvidia/ga103/gr/gpccs_bl.bin) firmware(nvidia/ga103/gr/gpccs_sig.bin) firmware(nvidia/ga103/nvdec/scrubber.bin) firmware(nvidia/ga103/sec2/desc.bin) firmware(nvidia/ga103/sec2/hs_bl_sig.bin) firmware(nvidia/ga103/sec2/image.bin) firmware(nvidia/ga103/sec2/sig.bin) firmware(nvidia/ga104/acr/ucode_ahesasc.bin) firmware(nvidia/ga104/acr/ucode_asb.bin) firmware(nvidia/ga104/acr/ucode_unload.bin) firmware(nvidia/ga104/gr/NET_img.bin) firmware(nvidia/ga104/gr/fecs_bl.bin) firmware(nvidia/ga104/gr/fecs_sig.bin) firmware(nvidia/ga104/gr/gpccs_bl.bin) firmware(nvidia/ga104/gr/gpccs_sig.bin) firmware(nvidia/ga104/nvdec/scrubber.bin) firmware(nvidia/ga104/sec2/desc.bin) firmware(nvidia/ga104/sec2/hs_bl_sig.bin) firmware(nvidia/ga104/sec2/image.bin) firmware(nvidia/ga104/sec2/sig.bin) firmware(nvidia/ga106/acr/ucode_ahesasc.bin) firmware(nvidia/ga106/acr/ucode_asb.bin) firmware(nvidia/ga106/acr/ucode_unload.bin) firmware(nvidia/ga106/gr/NET_img.bin) firmware(nvidia/ga106/gr/fecs_bl.bin) firmware(nvidia/ga106/gr/fecs_sig.bin) firmware(nvidia/ga106/gr/gpccs_bl.bin) firmware(nvidia/ga106/gr/gpccs_sig.bin) firmware(nvidia/ga106/nvdec/scrubber.bin) firmware(nvidia/ga106/sec2/desc.bin) firmware(nvidia/ga106/sec2/hs_bl_sig.bin) firmware(nvidia/ga106/sec2/image.bin) firmware(nvidia/ga106/sec2/sig.bin) firmware(nvidia/ga107/acr/ucode_ahesasc.bin) firmware(nvidia/ga107/acr/ucode_asb.bin) firmware(nvidia/ga107/acr/ucode_unload.bin) firmware(nvidia/ga107/gr/NET_img.bin) firmware(nvidia/ga107/gr/fecs_bl.bin) firmware(nvidia/ga107/gr/fecs_sig.bin) firmware(nvidia/ga107/gr/gpccs_bl.bin) firmware(nvidia/ga107/gr/gpccs_sig.bin) firmware(nvidia/ga107/nvdec/scrubber.bin) firmware(nvidia/ga107/sec2/desc.bin) firmware(nvidia/ga107/sec2/hs_bl_sig.bin) firmware(nvidia/ga107/sec2/image.bin) firmware(nvidia/ga107/sec2/sig.bin) firmware(nvidia/gk20a/fecs_data.bin) firmware(nvidia/gk20a/fecs_inst.bin) firmware(nvidia/gk20a/gpccs_data.bin) firmware(nvidia/gk20a/gpccs_inst.bin) firmware(nvidia/gk20a/sw_bundle_init.bin) firmware(nvidia/gk20a/sw_ctx.bin) firmware(nvidia/gk20a/sw_method_init.bin) firmware(nvidia/gk20a/sw_nonctx.bin) firmware(nvidia/gm200/acr/bl.bin) firmware(nvidia/gm200/acr/ucode_load.bin) firmware(nvidia/gm200/acr/ucode_unload.bin) firmware(nvidia/gm200/gr/fecs_bl.bin) firmware(nvidia/gm200/gr/fecs_data.bin) firmware(nvidia/gm200/gr/fecs_inst.bin) firmware(nvidia/gm200/gr/fecs_sig.bin) firmware(nvidia/gm200/gr/gpccs_bl.bin) firmware(nvidia/gm200/gr/gpccs_data.bin) firmware(nvidia/gm200/gr/gpccs_inst.bin) firmware(nvidia/gm200/gr/gpccs_sig.bin) firmware(nvidia/gm200/gr/sw_bundle_init.bin) firmware(nvidia/gm200/gr/sw_ctx.bin) firmware(nvidia/gm200/gr/sw_method_init.bin) firmware(nvidia/gm200/gr/sw_nonctx.bin) firmware(nvidia/gm204/acr/bl.bin) firmware(nvidia/gm204/acr/ucode_load.bin) firmware(nvidia/gm204/acr/ucode_unload.bin) firmware(nvidia/gm204/gr/fecs_bl.bin) firmware(nvidia/gm204/gr/fecs_data.bin) firmware(nvidia/gm204/gr/fecs_inst.bin) firmware(nvidia/gm204/gr/fecs_sig.bin) firmware(nvidia/gm204/gr/gpccs_bl.bin) firmware(nvidia/gm204/gr/gpccs_data.bin) firmware(nvidia/gm204/gr/gpccs_inst.bin) firmware(nvidia/gm204/gr/gpccs_sig.bin) firmware(nvidia/gm204/gr/sw_bundle_init.bin) firmware(nvidia/gm204/gr/sw_ctx.bin) firmware(nvidia/gm204/gr/sw_method_init.bin) firmware(nvidia/gm204/gr/sw_nonctx.bin) firmware(nvidia/gm206/acr/bl.bin) firmware(nvidia/gm206/acr/ucode_load.bin) firmware(nvidia/gm206/acr/ucode_unload.bin) firmware(nvidia/gm206/gr/fecs_bl.bin) firmware(nvidia/gm206/gr/fecs_data.bin) firmware(nvidia/gm206/gr/fecs_inst.bin) firmware(nvidia/gm206/gr/fecs_sig.bin) firmware(nvidia/gm206/gr/gpccs_bl.bin) firmware(nvidia/gm206/gr/gpccs_data.bin) firmware(nvidia/gm206/gr/gpccs_inst.bin) firmware(nvidia/gm206/gr/gpccs_sig.bin) firmware(nvidia/gm206/gr/sw_bundle_init.bin) firmware(nvidia/gm206/gr/sw_ctx.bin) firmware(nvidia/gm206/gr/sw_method_init.bin) firmware(nvidia/gm206/gr/sw_nonctx.bin) firmware(nvidia/gm20b/acr/bl.bin) firmware(nvidia/gm20b/acr/ucode_load.bin) firmware(nvidia/gm20b/gr/fecs_bl.bin) firmware(nvidia/gm20b/gr/fecs_data.bin) firmware(nvidia/gm20b/gr/fecs_inst.bin) firmware(nvidia/gm20b/gr/fecs_sig.bin) firmware(nvidia/gm20b/gr/gpccs_data.bin) firmware(nvidia/gm20b/gr/gpccs_inst.bin) firmware(nvidia/gm20b/gr/sw_bundle_init.bin) firmware(nvidia/gm20b/gr/sw_ctx.bin) firmware(nvidia/gm20b/gr/sw_method_init.bin) firmware(nvidia/gm20b/gr/sw_nonctx.bin) firmware(nvidia/gm20b/pmu/desc.bin) firmware(nvidia/gm20b/pmu/image.bin) firmware(nvidia/gm20b/pmu/sig.bin) firmware(nvidia/gp100/acr/bl.bin) firmware(nvidia/gp100/acr/ucode_load.bin) firmware(nvidia/gp100/acr/ucode_unload.bin) firmware(nvidia/gp100/gr/fecs_bl.bin) firmware(nvidia/gp100/gr/fecs_data.bin) firmware(nvidia/gp100/gr/fecs_inst.bin) firmware(nvidia/gp100/gr/fecs_sig.bin) firmware(nvidia/gp100/gr/gpccs_bl.bin) firmware(nvidia/gp100/gr/gpccs_data.bin) firmware(nvidia/gp100/gr/gpccs_inst.bin) firmware(nvidia/gp100/gr/gpccs_sig.bin) firmware(nvidia/gp100/gr/sw_bundle_init.bin) firmware(nvidia/gp100/gr/sw_ctx.bin) firmware(nvidia/gp100/gr/sw_method_init.bin) firmware(nvidia/gp100/gr/sw_nonctx.bin) firmware(nvidia/gp102/acr/bl.bin) firmware(nvidia/gp102/acr/ucode_load.bin) firmware(nvidia/gp102/acr/ucode_unload.bin) firmware(nvidia/gp102/acr/unload_bl.bin) firmware(nvidia/gp102/gr/fecs_bl.bin) firmware(nvidia/gp102/gr/fecs_data.bin) firmware(nvidia/gp102/gr/fecs_inst.bin) firmware(nvidia/gp102/gr/fecs_sig.bin) firmware(nvidia/gp102/gr/gpccs_bl.bin) firmware(nvidia/gp102/gr/gpccs_data.bin) firmware(nvidia/gp102/gr/gpccs_inst.bin) firmware(nvidia/gp102/gr/gpccs_sig.bin) firmware(nvidia/gp102/gr/sw_bundle_init.bin) firmware(nvidia/gp102/gr/sw_ctx.bin) firmware(nvidia/gp102/gr/sw_method_init.bin) firmware(nvidia/gp102/gr/sw_nonctx.bin) firmware(nvidia/gp102/nvdec/scrubber.bin) firmware(nvidia/gp102/sec2/desc-1.bin) firmware(nvidia/gp102/sec2/desc.bin) firmware(nvidia/gp102/sec2/image-1.bin) firmware(nvidia/gp102/sec2/image.bin) firmware(nvidia/gp102/sec2/sig-1.bin) firmware(nvidia/gp102/sec2/sig.bin) firmware(nvidia/gp104/acr/bl.bin) firmware(nvidia/gp104/acr/ucode_load.bin) firmware(nvidia/gp104/acr/ucode_unload.bin) firmware(nvidia/gp104/acr/unload_bl.bin) firmware(nvidia/gp104/gr/fecs_bl.bin) firmware(nvidia/gp104/gr/fecs_data.bin) firmware(nvidia/gp104/gr/fecs_inst.bin) firmware(nvidia/gp104/gr/fecs_sig.bin) firmware(nvidia/gp104/gr/gpccs_bl.bin) firmware(nvidia/gp104/gr/gpccs_data.bin) firmware(nvidia/gp104/gr/gpccs_inst.bin) firmware(nvidia/gp104/gr/gpccs_sig.bin) firmware(nvidia/gp104/gr/sw_bundle_init.bin) firmware(nvidia/gp104/gr/sw_ctx.bin) firmware(nvidia/gp104/gr/sw_method_init.bin) firmware(nvidia/gp104/gr/sw_nonctx.bin) firmware(nvidia/gp104/nvdec/scrubber.bin) firmware(nvidia/gp104/sec2/desc-1.bin) firmware(nvidia/gp104/sec2/desc.bin) firmware(nvidia/gp104/sec2/image-1.bin) firmware(nvidia/gp104/sec2/image.bin) firmware(nvidia/gp104/sec2/sig-1.bin) firmware(nvidia/gp104/sec2/sig.bin) firmware(nvidia/gp106/acr/bl.bin) firmware(nvidia/gp106/acr/ucode_load.bin) firmware(nvidia/gp106/acr/ucode_unload.bin) firmware(nvidia/gp106/acr/unload_bl.bin) firmware(nvidia/gp106/gr/fecs_bl.bin) firmware(nvidia/gp106/gr/fecs_data.bin) firmware(nvidia/gp106/gr/fecs_inst.bin) firmware(nvidia/gp106/gr/fecs_sig.bin) firmware(nvidia/gp106/gr/gpccs_bl.bin) firmware(nvidia/gp106/gr/gpccs_data.bin) firmware(nvidia/gp106/gr/gpccs_inst.bin) firmware(nvidia/gp106/gr/gpccs_sig.bin) firmware(nvidia/gp106/gr/sw_bundle_init.bin) firmware(nvidia/gp106/gr/sw_ctx.bin) firmware(nvidia/gp106/gr/sw_method_init.bin) firmware(nvidia/gp106/gr/sw_nonctx.bin) firmware(nvidia/gp106/nvdec/scrubber.bin) firmware(nvidia/gp106/sec2/desc-1.bin) firmware(nvidia/gp106/sec2/desc.bin) firmware(nvidia/gp106/sec2/image-1.bin) firmware(nvidia/gp106/sec2/image.bin) firmware(nvidia/gp106/sec2/sig-1.bin) firmware(nvidia/gp106/sec2/sig.bin) firmware(nvidia/gp107/acr/bl.bin) firmware(nvidia/gp107/acr/ucode_load.bin) firmware(nvidia/gp107/acr/ucode_unload.bin) firmware(nvidia/gp107/acr/unload_bl.bin) firmware(nvidia/gp107/gr/fecs_bl.bin) firmware(nvidia/gp107/gr/fecs_data.bin) firmware(nvidia/gp107/gr/fecs_inst.bin) firmware(nvidia/gp107/gr/fecs_sig.bin) firmware(nvidia/gp107/gr/gpccs_bl.bin) firmware(nvidia/gp107/gr/gpccs_data.bin) firmware(nvidia/gp107/gr/gpccs_inst.bin) firmware(nvidia/gp107/gr/gpccs_sig.bin) firmware(nvidia/gp107/gr/sw_bundle_init.bin) firmware(nvidia/gp107/gr/sw_ctx.bin) firmware(nvidia/gp107/gr/sw_method_init.bin) firmware(nvidia/gp107/gr/sw_nonctx.bin) firmware(nvidia/gp107/nvdec/scrubber.bin) firmware(nvidia/gp107/sec2/desc-1.bin) firmware(nvidia/gp107/sec2/desc.bin) firmware(nvidia/gp107/sec2/image-1.bin) firmware(nvidia/gp107/sec2/image.bin) firmware(nvidia/gp107/sec2/sig-1.bin) firmware(nvidia/gp107/sec2/sig.bin) firmware(nvidia/gp108/acr/bl.bin) firmware(nvidia/gp108/acr/ucode_load.bin) firmware(nvidia/gp108/acr/ucode_unload.bin) firmware(nvidia/gp108/acr/unload_bl.bin) firmware(nvidia/gp108/gr/fecs_bl.bin) firmware(nvidia/gp108/gr/fecs_data.bin) firmware(nvidia/gp108/gr/fecs_inst.bin) firmware(nvidia/gp108/gr/fecs_sig.bin) firmware(nvidia/gp108/gr/gpccs_bl.bin) firmware(nvidia/gp108/gr/gpccs_data.bin) firmware(nvidia/gp108/gr/gpccs_inst.bin) firmware(nvidia/gp108/gr/gpccs_sig.bin) firmware(nvidia/gp108/gr/sw_bundle_init.bin) firmware(nvidia/gp108/gr/sw_ctx.bin) firmware(nvidia/gp108/gr/sw_method_init.bin) firmware(nvidia/gp108/gr/sw_nonctx.bin) firmware(nvidia/gp108/nvdec/scrubber.bin) firmware(nvidia/gp108/sec2/desc.bin) firmware(nvidia/gp108/sec2/image.bin) firmware(nvidia/gp108/sec2/sig.bin) firmware(nvidia/gp10b/acr/bl.bin) firmware(nvidia/gp10b/acr/ucode_load.bin) firmware(nvidia/gp10b/gr/fecs_bl.bin) firmware(nvidia/gp10b/gr/fecs_data.bin) firmware(nvidia/gp10b/gr/fecs_inst.bin) firmware(nvidia/gp10b/gr/fecs_sig.bin) firmware(nvidia/gp10b/gr/gpccs_bl.bin) firmware(nvidia/gp10b/gr/gpccs_data.bin) firmware(nvidia/gp10b/gr/gpccs_inst.bin) firmware(nvidia/gp10b/gr/gpccs_sig.bin) firmware(nvidia/gp10b/gr/sw_bundle_init.bin) firmware(nvidia/gp10b/gr/sw_ctx.bin) firmware(nvidia/gp10b/gr/sw_method_init.bin) firmware(nvidia/gp10b/gr/sw_nonctx.bin) firmware(nvidia/gp10b/pmu/desc.bin) firmware(nvidia/gp10b/pmu/image.bin) firmware(nvidia/gp10b/pmu/sig.bin) firmware(nvidia/gv100/acr/bl.bin) firmware(nvidia/gv100/acr/ucode_load.bin) firmware(nvidia/gv100/acr/ucode_unload.bin) firmware(nvidia/gv100/acr/unload_bl.bin) firmware(nvidia/gv100/gr/fecs_bl.bin) firmware(nvidia/gv100/gr/fecs_data.bin) firmware(nvidia/gv100/gr/fecs_inst.bin) firmware(nvidia/gv100/gr/fecs_sig.bin) firmware(nvidia/gv100/gr/gpccs_bl.bin) firmware(nvidia/gv100/gr/gpccs_data.bin) firmware(nvidia/gv100/gr/gpccs_inst.bin) firmware(nvidia/gv100/gr/gpccs_sig.bin) firmware(nvidia/gv100/gr/sw_bundle_init.bin) firmware(nvidia/gv100/gr/sw_ctx.bin) firmware(nvidia/gv100/gr/sw_method_init.bin) firmware(nvidia/gv100/gr/sw_nonctx.bin) firmware(nvidia/gv100/nvdec/scrubber.bin) firmware(nvidia/gv100/sec2/desc.bin) firmware(nvidia/gv100/sec2/image.bin) firmware(nvidia/gv100/sec2/sig.bin) firmware(nvidia/tegra124/vic.bin) firmware(nvidia/tegra124/vic03_ucode.bin) firmware(nvidia/tegra124/xusb.bin) firmware(nvidia/tegra186/vic.bin) firmware(nvidia/tegra186/vic04_ucode.bin) firmware(nvidia/tegra186/xusb.bin) firmware(nvidia/tegra194/vic.bin) firmware(nvidia/tegra194/xusb.bin) firmware(nvidia/tegra210/vic.bin) firmware(nvidia/tegra210/vic04_ucode.bin) firmware(nvidia/tegra210/xusb.bin) firmware(nvidia/tu102/acr/bl.bin) firmware(nvidia/tu102/acr/ucode_ahesasc.bin) firmware(nvidia/tu102/acr/ucode_asb.bin) firmware(nvidia/tu102/acr/ucode_unload.bin) firmware(nvidia/tu102/acr/unload_bl.bin) firmware(nvidia/tu102/gr/fecs_bl.bin) firmware(nvidia/tu102/gr/fecs_data.bin) firmware(nvidia/tu102/gr/fecs_inst.bin) firmware(nvidia/tu102/gr/fecs_sig.bin) firmware(nvidia/tu102/gr/gpccs_bl.bin) firmware(nvidia/tu102/gr/gpccs_data.bin) firmware(nvidia/tu102/gr/gpccs_inst.bin) firmware(nvidia/tu102/gr/gpccs_sig.bin) firmware(nvidia/tu102/gr/sw_bundle_init.bin) firmware(nvidia/tu102/gr/sw_ctx.bin) firmware(nvidia/tu102/gr/sw_method_init.bin) firmware(nvidia/tu102/gr/sw_nonctx.bin) firmware(nvidia/tu102/gr/sw_veid_bundle_init.bin) firmware(nvidia/tu102/nvdec/scrubber.bin) firmware(nvidia/tu102/sec2/desc.bin) firmware(nvidia/tu102/sec2/image.bin) firmware(nvidia/tu102/sec2/sig.bin) firmware(nvidia/tu104/acr/bl.bin) firmware(nvidia/tu104/acr/ucode_ahesasc.bin) firmware(nvidia/tu104/acr/ucode_asb.bin) firmware(nvidia/tu104/acr/ucode_unload.bin) firmware(nvidia/tu104/acr/unload_bl.bin) firmware(nvidia/tu104/gr/fecs_bl.bin) firmware(nvidia/tu104/gr/fecs_data.bin) firmware(nvidia/tu104/gr/fecs_inst.bin) firmware(nvidia/tu104/gr/fecs_sig.bin) firmware(nvidia/tu104/gr/gpccs_bl.bin) firmware(nvidia/tu104/gr/gpccs_data.bin) firmware(nvidia/tu104/gr/gpccs_inst.bin) firmware(nvidia/tu104/gr/gpccs_sig.bin) firmware(nvidia/tu104/gr/sw_bundle_init.bin) firmware(nvidia/tu104/gr/sw_ctx.bin) firmware(nvidia/tu104/gr/sw_method_init.bin) firmware(nvidia/tu104/gr/sw_nonctx.bin) firmware(nvidia/tu104/gr/sw_veid_bundle_init.bin) firmware(nvidia/tu104/nvdec/scrubber.bin) firmware(nvidia/tu104/sec2/desc.bin) firmware(nvidia/tu104/sec2/image.bin) firmware(nvidia/tu104/sec2/sig.bin) firmware(nvidia/tu106/acr/bl.bin) firmware(nvidia/tu106/acr/ucode_ahesasc.bin) firmware(nvidia/tu106/acr/ucode_asb.bin) firmware(nvidia/tu106/acr/ucode_unload.bin) firmware(nvidia/tu106/acr/unload_bl.bin) firmware(nvidia/tu106/gr/fecs_bl.bin) firmware(nvidia/tu106/gr/fecs_data.bin) firmware(nvidia/tu106/gr/fecs_inst.bin) firmware(nvidia/tu106/gr/fecs_sig.bin) firmware(nvidia/tu106/gr/gpccs_bl.bin) firmware(nvidia/tu106/gr/gpccs_data.bin) firmware(nvidia/tu106/gr/gpccs_inst.bin) firmware(nvidia/tu106/gr/gpccs_sig.bin) firmware(nvidia/tu106/gr/sw_bundle_init.bin) firmware(nvidia/tu106/gr/sw_ctx.bin) firmware(nvidia/tu106/gr/sw_method_init.bin) firmware(nvidia/tu106/gr/sw_nonctx.bin) firmware(nvidia/tu106/gr/sw_veid_bundle_init.bin) firmware(nvidia/tu106/nvdec/scrubber.bin) firmware(nvidia/tu106/sec2/desc.bin) firmware(nvidia/tu106/sec2/image.bin) firmware(nvidia/tu106/sec2/sig.bin) firmware(nvidia/tu10x/typec/ccg_boot.cyacd) firmware(nvidia/tu10x/typec/ccg_primary.cyacd) firmware(nvidia/tu10x/typec/ccg_secondary.cyacd) firmware(nvidia/tu116/acr/bl.bin) firmware(nvidia/tu116/acr/ucode_ahesasc.bin) firmware(nvidia/tu116/acr/ucode_asb.bin) firmware(nvidia/tu116/acr/ucode_unload.bin) firmware(nvidia/tu116/acr/unload_bl.bin) firmware(nvidia/tu116/gr/fecs_bl.bin) firmware(nvidia/tu116/gr/fecs_data.bin) firmware(nvidia/tu116/gr/fecs_inst.bin) firmware(nvidia/tu116/gr/fecs_sig.bin) firmware(nvidia/tu116/gr/gpccs_bl.bin) firmware(nvidia/tu116/gr/gpccs_data.bin) firmware(nvidia/tu116/gr/gpccs_inst.bin) firmware(nvidia/tu116/gr/gpccs_sig.bin) firmware(nvidia/tu116/gr/sw_bundle_init.bin) firmware(nvidia/tu116/gr/sw_ctx.bin) firmware(nvidia/tu116/gr/sw_method_init.bin) firmware(nvidia/tu116/gr/sw_nonctx.bin) firmware(nvidia/tu116/gr/sw_veid_bundle_init.bin) firmware(nvidia/tu116/nvdec/scrubber.bin) firmware(nvidia/tu116/sec2/desc.bin) firmware(nvidia/tu116/sec2/image.bin) firmware(nvidia/tu116/sec2/sig.bin) firmware(nvidia/tu117/acr/bl.bin) firmware(nvidia/tu117/acr/ucode_ahesasc.bin) firmware(nvidia/tu117/acr/ucode_asb.bin) firmware(nvidia/tu117/acr/ucode_unload.bin) firmware(nvidia/tu117/acr/unload_bl.bin) firmware(nvidia/tu117/gr/fecs_bl.bin) firmware(nvidia/tu117/gr/fecs_data.bin) firmware(nvidia/tu117/gr/fecs_inst.bin) firmware(nvidia/tu117/gr/fecs_sig.bin) firmware(nvidia/tu117/gr/gpccs_bl.bin) firmware(nvidia/tu117/gr/gpccs_data.bin) firmware(nvidia/tu117/gr/gpccs_inst.bin) firmware(nvidia/tu117/gr/gpccs_sig.bin) firmware(nvidia/tu117/gr/sw_bundle_init.bin) firmware(nvidia/tu117/gr/sw_ctx.bin) firmware(nvidia/tu117/gr/sw_method_init.bin) firmware(nvidia/tu117/gr/sw_nonctx.bin) firmware(nvidia/tu117/gr/sw_veid_bundle_init.bin) firmware(nvidia/tu117/nvdec/scrubber.bin) firmware(nvidia/tu117/sec2/desc.bin) firmware(nvidia/tu117/sec2/image.bin) firmware(nvidia/tu117/sec2/sig.bin) firmware(nxp/helper_uart_3000000.bin) firmware(nxp/sr150_fw.bin) firmware(nxp/uartiw416_bt_v0.bin) firmware(nxp/uartspi_n61x_v1.bin.se) firmware(nxp/uartuart8987_bt.bin) firmware(nxp/uartuart8997_bt_v4.bin) firmware(nxp/uartuart9098_bt_v1.bin) firmware(ositech/Xilinx7OD.bin) firmware(phanfw.bin) firmware(qat_4xxx.bin) firmware(qat_4xxx_mmp.bin) firmware(qat_895xcc.bin) firmware(qat_895xcc_mmp.bin) firmware(qat_c3xxx.bin) firmware(qat_c3xxx_mmp.bin) firmware(qat_c62x.bin) firmware(qat_c62x_mmp.bin) firmware(qat_mmp.bin) firmware(qca/crbtfw21.tlv) firmware(qca/crbtfw32.tlv) firmware(qca/crnv21.bin) firmware(qca/crnv32.bin) firmware(qca/crnv32u.bin) firmware(qca/hpbtfw21.tlv) firmware(qca/hpnv21.301) firmware(qca/hpnv21.302) firmware(qca/hpnv21.bin) firmware(qca/hpnv21g.301) firmware(qca/hpnv21g.302) firmware(qca/hpnv21g.bin) firmware(qca/htbtfw20.tlv) firmware(qca/htnv20.bin) firmware(qca/msbtfw11.mbn) firmware(qca/msbtfw11.tlv) firmware(qca/msnv11.b09) firmware(qca/msnv11.b0a) firmware(qca/msnv11.bin) firmware(qca/nvm_00130300.bin) firmware(qca/nvm_00130302.bin) firmware(qca/nvm_00230302.bin) firmware(qca/nvm_00440302.bin) firmware(qca/nvm_00440302_eu.bin) firmware(qca/nvm_00440302_i2s_eu.bin) firmware(qca/nvm_usb_00000200.bin) firmware(qca/nvm_usb_00000201.bin) firmware(qca/nvm_usb_00000300.bin) firmware(qca/nvm_usb_00000302.bin) firmware(qca/nvm_usb_00000302_eu.bin) firmware(qca/nvm_usb_00130200.bin) firmware(qca/nvm_usb_00130200_0104.bin) firmware(qca/nvm_usb_00130200_0105.bin) firmware(qca/nvm_usb_00130200_0106.bin) firmware(qca/nvm_usb_00130200_0107.bin) firmware(qca/nvm_usb_00130200_0109.bin) firmware(qca/nvm_usb_00130200_0110.bin) firmware(qca/nvm_usb_00130201.bin) firmware(qca/nvm_usb_00130201_010a.bin) firmware(qca/nvm_usb_00130201_010b.bin) firmware(qca/nvm_usb_00130201_0303.bin) firmware(qca/nvm_usb_00130201_gf.bin) firmware(qca/nvm_usb_00130201_gf_010a.bin) firmware(qca/nvm_usb_00130201_gf_010b.bin) firmware(qca/nvm_usb_00130201_gf_0303.bin) firmware(qca/nvm_usb_00190200.bin) firmware(qca/rampatch_00130300.bin) firmware(qca/rampatch_00130302.bin) firmware(qca/rampatch_00230302.bin) firmware(qca/rampatch_00440302.bin) firmware(qca/rampatch_usb_00000200.bin) firmware(qca/rampatch_usb_00000201.bin) firmware(qca/rampatch_usb_00000300.bin) firmware(qca/rampatch_usb_00000302.bin) firmware(qca/rampatch_usb_00130200.bin) firmware(qca/rampatch_usb_00130201.bin) firmware(qca/rampatch_usb_00190200.bin) firmware(qcom/a300_pfp.fw) firmware(qcom/a300_pm4.fw) firmware(qcom/a330_pfp.fw) firmware(qcom/a330_pm4.fw) firmware(qcom/a420_pfp.fw) firmware(qcom/a420_pm4.fw) firmware(qcom/a530_pfp.fw) firmware(qcom/a530_pm4.fw) firmware(qcom/a530_zap.mdt) firmware(qcom/a530v3_gpmu.fw2) firmware(qcom/a630_gmu.bin) firmware(qcom/a630_sqe.fw) firmware(qcom/a650_gmu.bin) firmware(qcom/a650_sqe.fw) firmware(qcom/a660_gmu.bin) firmware(qcom/a660_sqe.fw) firmware(qcom/apq8096/a530_zap.mbn) firmware(qcom/apq8096/adsp.mbn) firmware(qcom/apq8096/adspr.jsn) firmware(qcom/apq8096/adspua.jsn) firmware(qcom/apq8096/mba.mbn) firmware(qcom/apq8096/modem.mbn) firmware(qcom/apq8096/modemr.jsn) firmware(qcom/leia_pfp_470.fw) firmware(qcom/leia_pm4_470.fw) firmware(qcom/sc8280xp/LENOVO/21BX/adspr.jsn) firmware(qcom/sc8280xp/LENOVO/21BX/adspua.jsn) firmware(qcom/sc8280xp/LENOVO/21BX/battmgr.jsn) firmware(qcom/sc8280xp/LENOVO/21BX/cdspr.jsn) firmware(qcom/sc8280xp/LENOVO/21BX/qcadsp8280.mbn) firmware(qcom/sc8280xp/LENOVO/21BX/qccdsp8280.mbn) firmware(qcom/sc8280xp/LENOVO/21BX/qcdxkmsuc8280.mbn) firmware(qcom/sc8280xp/LENOVO/21BX/qcslpi8280.mbn) firmware(qcom/sdm845/a630_zap.mbn) firmware(qcom/sdm845/adsp.mbn) firmware(qcom/sdm845/adspr.jsn) firmware(qcom/sdm845/adspua.jsn) firmware(qcom/sdm845/cdsp.mbn) firmware(qcom/sdm845/cdspr.jsn) firmware(qcom/sdm845/mba.mbn) firmware(qcom/sdm845/modem.mbn) firmware(qcom/sdm845/modemuw.jsn) firmware(qcom/sdm845/wlanmdsp.mbn) firmware(qcom/sm8250/a650_zap.mbn) firmware(qcom/sm8250/adsp.mbn) firmware(qcom/sm8250/adspr.jsn) firmware(qcom/sm8250/adspua.jsn) firmware(qcom/sm8250/cdsp.mbn) firmware(qcom/sm8250/cdspr.jsn) firmware(qcom/venus-1.8/venus.mbn) firmware(qcom/venus-1.8/venus.mdt) firmware(qcom/venus-4.2/venus.mbn) firmware(qcom/venus-4.2/venus.mdt) firmware(qcom/venus-5.2/venus.mbn) firmware(qcom/venus-5.2/venus.mdt) firmware(qcom/venus-5.4/venus.mbn) firmware(qcom/venus-5.4/venus.mdt) firmware(qcom/vpu-1.0/venus.mbn) firmware(qcom/vpu-1.0/venus.mdt) firmware(qcom/vpu-2.0/venus.mbn) firmware(qcom/yamato_pfp.fw) firmware(qcom/yamato_pm4.fw) firmware(qed/qed_init_values-8.10.9.0.bin) firmware(qed/qed_init_values-8.14.6.0.bin) firmware(qed/qed_init_values-8.18.9.0.bin) firmware(qed/qed_init_values-8.20.0.0.bin) firmware(qed/qed_init_values-8.30.12.0.bin) firmware(qed/qed_init_values-8.33.12.0.bin) firmware(qed/qed_init_values-8.37.7.0.bin) firmware(qed/qed_init_values-8.40.33.0.bin) firmware(qed/qed_init_values_zipped-8.10.10.0.bin) firmware(qed/qed_init_values_zipped-8.10.5.0.bin) firmware(qed/qed_init_values_zipped-8.15.3.0.bin) firmware(qed/qed_init_values_zipped-8.20.0.0.bin) firmware(qed/qed_init_values_zipped-8.33.1.0.bin) firmware(qed/qed_init_values_zipped-8.33.11.0.bin) firmware(qed/qed_init_values_zipped-8.37.2.0.bin) firmware(qed/qed_init_values_zipped-8.37.7.0.bin) firmware(qed/qed_init_values_zipped-8.4.2.0.bin) firmware(qed/qed_init_values_zipped-8.42.2.0.bin) firmware(qed/qed_init_values_zipped-8.59.1.0.bin) firmware(qed/qed_init_values_zipped-8.7.3.0.bin) firmware(ql2100_fw.bin) firmware(ql2200_fw.bin) firmware(ql2300_fw.bin) firmware(ql2322_fw.bin) firmware(ql2400_fw.bin) firmware(ql2500_fw.bin) firmware(ql2600_fw.bin) firmware(ql2700_fw.bin) firmware(ql8300_fw.bin) firmware(qlogic/1040.bin) firmware(qlogic/12160.bin) firmware(qlogic/1280.bin) firmware(qlogic/isp1000.bin) firmware(qlogic/sd7220.fw) firmware(r128/r128_cce.bin) firmware(r8a779x_usb3_v1.dlmem) firmware(r8a779x_usb3_v2.dlmem) firmware(r8a779x_usb3_v3.dlmem) firmware(radeon/ARUBA_me.bin) firmware(radeon/ARUBA_pfp.bin) firmware(radeon/ARUBA_rlc.bin) firmware(radeon/BARTS_mc.bin) firmware(radeon/BARTS_me.bin) firmware(radeon/BARTS_pfp.bin) firmware(radeon/BARTS_smc.bin) firmware(radeon/BONAIRE_ce.bin) firmware(radeon/BONAIRE_mc.bin) firmware(radeon/BONAIRE_mc2.bin) firmware(radeon/BONAIRE_me.bin) firmware(radeon/BONAIRE_mec.bin) firmware(radeon/BONAIRE_pfp.bin) firmware(radeon/BONAIRE_rlc.bin) firmware(radeon/BONAIRE_sdma.bin) firmware(radeon/BONAIRE_smc.bin) firmware(radeon/BONAIRE_uvd.bin) firmware(radeon/BONAIRE_vce.bin) firmware(radeon/BTC_rlc.bin) firmware(radeon/CAICOS_mc.bin) firmware(radeon/CAICOS_me.bin) firmware(radeon/CAICOS_pfp.bin) firmware(radeon/CAICOS_smc.bin) firmware(radeon/CAYMAN_mc.bin) firmware(radeon/CAYMAN_me.bin) firmware(radeon/CAYMAN_pfp.bin) firmware(radeon/CAYMAN_rlc.bin) firmware(radeon/CAYMAN_smc.bin) firmware(radeon/CEDAR_me.bin) firmware(radeon/CEDAR_pfp.bin) firmware(radeon/CEDAR_rlc.bin) firmware(radeon/CEDAR_smc.bin) firmware(radeon/CYPRESS_me.bin) firmware(radeon/CYPRESS_pfp.bin) firmware(radeon/CYPRESS_rlc.bin) firmware(radeon/CYPRESS_smc.bin) firmware(radeon/CYPRESS_uvd.bin) firmware(radeon/HAINAN_ce.bin) firmware(radeon/HAINAN_mc.bin) firmware(radeon/HAINAN_mc2.bin) firmware(radeon/HAINAN_me.bin) firmware(radeon/HAINAN_pfp.bin) firmware(radeon/HAINAN_rlc.bin) firmware(radeon/HAINAN_smc.bin) firmware(radeon/HAWAII_ce.bin) firmware(radeon/HAWAII_mc.bin) firmware(radeon/HAWAII_mc2.bin) firmware(radeon/HAWAII_me.bin) firmware(radeon/HAWAII_mec.bin) firmware(radeon/HAWAII_pfp.bin) firmware(radeon/HAWAII_rlc.bin) firmware(radeon/HAWAII_sdma.bin) firmware(radeon/HAWAII_smc.bin) firmware(radeon/JUNIPER_me.bin) firmware(radeon/JUNIPER_pfp.bin) firmware(radeon/JUNIPER_rlc.bin) firmware(radeon/JUNIPER_smc.bin) firmware(radeon/KABINI_ce.bin) firmware(radeon/KABINI_me.bin) firmware(radeon/KABINI_mec.bin) firmware(radeon/KABINI_pfp.bin) firmware(radeon/KABINI_rlc.bin) firmware(radeon/KABINI_sdma.bin) firmware(radeon/KAVERI_ce.bin) firmware(radeon/KAVERI_me.bin) firmware(radeon/KAVERI_mec.bin) firmware(radeon/KAVERI_pfp.bin) firmware(radeon/KAVERI_rlc.bin) firmware(radeon/KAVERI_sdma.bin) firmware(radeon/MULLINS_ce.bin) firmware(radeon/MULLINS_me.bin) firmware(radeon/MULLINS_mec.bin) firmware(radeon/MULLINS_pfp.bin) firmware(radeon/MULLINS_rlc.bin) firmware(radeon/MULLINS_sdma.bin) firmware(radeon/OLAND_ce.bin) firmware(radeon/OLAND_mc.bin) firmware(radeon/OLAND_mc2.bin) firmware(radeon/OLAND_me.bin) firmware(radeon/OLAND_pfp.bin) firmware(radeon/OLAND_rlc.bin) firmware(radeon/OLAND_smc.bin) firmware(radeon/PALM_me.bin) firmware(radeon/PALM_pfp.bin) firmware(radeon/PITCAIRN_ce.bin) firmware(radeon/PITCAIRN_mc.bin) firmware(radeon/PITCAIRN_mc2.bin) firmware(radeon/PITCAIRN_me.bin) firmware(radeon/PITCAIRN_pfp.bin) firmware(radeon/PITCAIRN_rlc.bin) firmware(radeon/PITCAIRN_smc.bin) firmware(radeon/R100_cp.bin) firmware(radeon/R200_cp.bin) firmware(radeon/R300_cp.bin) firmware(radeon/R420_cp.bin) firmware(radeon/R520_cp.bin) firmware(radeon/R600_me.bin) firmware(radeon/R600_pfp.bin) firmware(radeon/R600_rlc.bin) firmware(radeon/R600_uvd.bin) firmware(radeon/R700_rlc.bin) firmware(radeon/REDWOOD_me.bin) firmware(radeon/REDWOOD_pfp.bin) firmware(radeon/REDWOOD_rlc.bin) firmware(radeon/REDWOOD_smc.bin) firmware(radeon/RS600_cp.bin) firmware(radeon/RS690_cp.bin) firmware(radeon/RS780_me.bin) firmware(radeon/RS780_pfp.bin) firmware(radeon/RS780_uvd.bin) firmware(radeon/RV610_me.bin) firmware(radeon/RV610_pfp.bin) firmware(radeon/RV620_me.bin) firmware(radeon/RV620_pfp.bin) firmware(radeon/RV630_me.bin) firmware(radeon/RV630_pfp.bin) firmware(radeon/RV635_me.bin) firmware(radeon/RV635_pfp.bin) firmware(radeon/RV670_me.bin) firmware(radeon/RV670_pfp.bin) firmware(radeon/RV710_me.bin) firmware(radeon/RV710_pfp.bin) firmware(radeon/RV710_smc.bin) firmware(radeon/RV710_uvd.bin) firmware(radeon/RV730_me.bin) firmware(radeon/RV730_pfp.bin) firmware(radeon/RV730_smc.bin) firmware(radeon/RV740_smc.bin) firmware(radeon/RV770_me.bin) firmware(radeon/RV770_pfp.bin) firmware(radeon/RV770_smc.bin) firmware(radeon/RV770_uvd.bin) firmware(radeon/SUMO2_me.bin) firmware(radeon/SUMO2_pfp.bin) firmware(radeon/SUMO_me.bin) firmware(radeon/SUMO_pfp.bin) firmware(radeon/SUMO_rlc.bin) firmware(radeon/SUMO_uvd.bin) firmware(radeon/TAHITI_ce.bin) firmware(radeon/TAHITI_mc.bin) firmware(radeon/TAHITI_mc2.bin) firmware(radeon/TAHITI_me.bin) firmware(radeon/TAHITI_pfp.bin) firmware(radeon/TAHITI_rlc.bin) firmware(radeon/TAHITI_smc.bin) firmware(radeon/TAHITI_uvd.bin) firmware(radeon/TAHITI_vce.bin) firmware(radeon/TURKS_mc.bin) firmware(radeon/TURKS_me.bin) firmware(radeon/TURKS_pfp.bin) firmware(radeon/TURKS_smc.bin) firmware(radeon/VERDE_ce.bin) firmware(radeon/VERDE_mc.bin) firmware(radeon/VERDE_mc2.bin) firmware(radeon/VERDE_me.bin) firmware(radeon/VERDE_pfp.bin) firmware(radeon/VERDE_rlc.bin) firmware(radeon/VERDE_smc.bin) firmware(radeon/banks_k_2_smc.bin) firmware(radeon/bonaire_ce.bin) firmware(radeon/bonaire_k_smc.bin) firmware(radeon/bonaire_mc.bin) firmware(radeon/bonaire_me.bin) firmware(radeon/bonaire_mec.bin) firmware(radeon/bonaire_pfp.bin) firmware(radeon/bonaire_rlc.bin) firmware(radeon/bonaire_sdma.bin) firmware(radeon/bonaire_sdma1.bin) firmware(radeon/bonaire_smc.bin) firmware(radeon/bonaire_uvd.bin) firmware(radeon/bonaire_vce.bin) firmware(radeon/hainan_ce.bin) firmware(radeon/hainan_k_smc.bin) firmware(radeon/hainan_mc.bin) firmware(radeon/hainan_me.bin) firmware(radeon/hainan_pfp.bin) firmware(radeon/hainan_rlc.bin) firmware(radeon/hainan_smc.bin) firmware(radeon/hawaii_ce.bin) firmware(radeon/hawaii_k_smc.bin) firmware(radeon/hawaii_mc.bin) firmware(radeon/hawaii_me.bin) firmware(radeon/hawaii_mec.bin) firmware(radeon/hawaii_pfp.bin) firmware(radeon/hawaii_rlc.bin) firmware(radeon/hawaii_sdma.bin) firmware(radeon/hawaii_sdma1.bin) firmware(radeon/hawaii_smc.bin) firmware(radeon/hawaii_uvd.bin) firmware(radeon/hawaii_vce.bin) firmware(radeon/kabini_ce.bin) firmware(radeon/kabini_me.bin) firmware(radeon/kabini_mec.bin) firmware(radeon/kabini_pfp.bin) firmware(radeon/kabini_rlc.bin) firmware(radeon/kabini_sdma.bin) firmware(radeon/kabini_sdma1.bin) firmware(radeon/kabini_uvd.bin) firmware(radeon/kabini_vce.bin) firmware(radeon/kaveri_ce.bin) firmware(radeon/kaveri_me.bin) firmware(radeon/kaveri_mec.bin) firmware(radeon/kaveri_mec2.bin) firmware(radeon/kaveri_pfp.bin) firmware(radeon/kaveri_rlc.bin) firmware(radeon/kaveri_sdma.bin) firmware(radeon/kaveri_sdma1.bin) firmware(radeon/kaveri_uvd.bin) firmware(radeon/kaveri_vce.bin) firmware(radeon/mullins_ce.bin) firmware(radeon/mullins_me.bin) firmware(radeon/mullins_mec.bin) firmware(radeon/mullins_pfp.bin) firmware(radeon/mullins_rlc.bin) firmware(radeon/mullins_sdma.bin) firmware(radeon/mullins_sdma1.bin) firmware(radeon/mullins_uvd.bin) firmware(radeon/mullins_vce.bin) firmware(radeon/oland_ce.bin) firmware(radeon/oland_k_smc.bin) firmware(radeon/oland_mc.bin) firmware(radeon/oland_me.bin) firmware(radeon/oland_pfp.bin) firmware(radeon/oland_rlc.bin) firmware(radeon/oland_smc.bin) firmware(radeon/pitcairn_ce.bin) firmware(radeon/pitcairn_k_smc.bin) firmware(radeon/pitcairn_mc.bin) firmware(radeon/pitcairn_me.bin) firmware(radeon/pitcairn_pfp.bin) firmware(radeon/pitcairn_rlc.bin) firmware(radeon/pitcairn_smc.bin) firmware(radeon/si58_mc.bin) firmware(radeon/tahiti_ce.bin) firmware(radeon/tahiti_k_smc.bin) firmware(radeon/tahiti_mc.bin) firmware(radeon/tahiti_me.bin) firmware(radeon/tahiti_pfp.bin) firmware(radeon/tahiti_rlc.bin) firmware(radeon/tahiti_smc.bin) firmware(radeon/verde_ce.bin) firmware(radeon/verde_k_smc.bin) firmware(radeon/verde_mc.bin) firmware(radeon/verde_me.bin) firmware(radeon/verde_pfp.bin) firmware(radeon/verde_rlc.bin) firmware(radeon/verde_smc.bin) firmware(rockchip/dptx.bin) firmware(rp2.fw) firmware(rsi/rs9113_ap_bt_dual_mode.rps) firmware(rsi/rs9113_wlan_bt_dual_mode.rps) firmware(rsi/rs9113_wlan_qspi.rps) firmware(rsi/rs9116_wlan.rps) firmware(rsi/rs9116_wlan_bt_classic.rps) firmware(rsi_91x.fw) firmware(rt2561.bin) firmware(rt2561s.bin) firmware(rt2661.bin) firmware(rt2860.bin) firmware(rt2870.bin) firmware(rt3070.bin) firmware(rt3071.bin) firmware(rt3090.bin) firmware(rt3290.bin) firmware(rt73.bin) firmware(rtl_bt/rtl8192ee_fw.bin) firmware(rtl_bt/rtl8192eu_fw.bin) firmware(rtl_bt/rtl8723a_fw.bin) firmware(rtl_bt/rtl8723b_fw.bin) firmware(rtl_bt/rtl8723bs_config-OBDA0623.bin) firmware(rtl_bt/rtl8723bs_config-OBDA8723.bin) firmware(rtl_bt/rtl8723bs_fw.bin) firmware(rtl_bt/rtl8723d_config.bin) firmware(rtl_bt/rtl8723d_fw.bin) firmware(rtl_bt/rtl8761a_fw.bin) firmware(rtl_bt/rtl8761b_config.bin) firmware(rtl_bt/rtl8761b_fw.bin) firmware(rtl_bt/rtl8761bu_config.bin) firmware(rtl_bt/rtl8761bu_fw.bin) firmware(rtl_bt/rtl8812ae_fw.bin) firmware(rtl_bt/rtl8821a_config.bin) firmware(rtl_bt/rtl8821a_fw.bin) firmware(rtl_bt/rtl8821c_config.bin) firmware(rtl_bt/rtl8821c_fw.bin) firmware(rtl_bt/rtl8821cs_config.bin) firmware(rtl_bt/rtl8821cs_fw.bin) firmware(rtl_bt/rtl8822b_config.bin) firmware(rtl_bt/rtl8822b_fw.bin) firmware(rtl_bt/rtl8822cs_config.bin) firmware(rtl_bt/rtl8822cs_fw.bin) firmware(rtl_bt/rtl8822cu_config.bin) firmware(rtl_bt/rtl8822cu_fw.bin) firmware(rtl_bt/rtl8851bu_config.bin) firmware(rtl_bt/rtl8851bu_fw.bin) firmware(rtl_bt/rtl8852au_config.bin) firmware(rtl_bt/rtl8852au_fw.bin) firmware(rtl_bt/rtl8852bu_config.bin) firmware(rtl_bt/rtl8852bu_fw.bin) firmware(rtl_bt/rtl8852cu_config.bin) firmware(rtl_bt/rtl8852cu_fw.bin) firmware(rtl_nic/rtl8105e-1.fw) firmware(rtl_nic/rtl8106e-1.fw) firmware(rtl_nic/rtl8106e-2.fw) firmware(rtl_nic/rtl8107e-1.fw) firmware(rtl_nic/rtl8107e-2.fw) firmware(rtl_nic/rtl8125a-3.fw) firmware(rtl_nic/rtl8125b-1.fw) firmware(rtl_nic/rtl8125b-2.fw) firmware(rtl_nic/rtl8153a-2.fw) firmware(rtl_nic/rtl8153a-3.fw) firmware(rtl_nic/rtl8153a-4.fw) firmware(rtl_nic/rtl8153b-2.fw) firmware(rtl_nic/rtl8153c-1.fw) firmware(rtl_nic/rtl8156a-2.fw) firmware(rtl_nic/rtl8156b-2.fw) firmware(rtl_nic/rtl8168d-1.fw) firmware(rtl_nic/rtl8168d-2.fw) firmware(rtl_nic/rtl8168e-1.fw) firmware(rtl_nic/rtl8168e-2.fw) firmware(rtl_nic/rtl8168e-3.fw) firmware(rtl_nic/rtl8168f-1.fw) firmware(rtl_nic/rtl8168f-2.fw) firmware(rtl_nic/rtl8168fp-3.fw) firmware(rtl_nic/rtl8168g-1.fw) firmware(rtl_nic/rtl8168g-2.fw) firmware(rtl_nic/rtl8168g-3.fw) firmware(rtl_nic/rtl8168h-1.fw) firmware(rtl_nic/rtl8168h-2.fw) firmware(rtl_nic/rtl8402-1.fw) firmware(rtl_nic/rtl8411-1.fw) firmware(rtl_nic/rtl8411-2.fw) firmware(rtlwifi/rtl8188efw.bin) firmware(rtlwifi/rtl8188eufw.bin) firmware(rtlwifi/rtl8188fufw.bin) firmware(rtlwifi/rtl8192cfw.bin) firmware(rtlwifi/rtl8192cfwU.bin) firmware(rtlwifi/rtl8192cfwU_B.bin) firmware(rtlwifi/rtl8192cufw.bin) firmware(rtlwifi/rtl8192cufw_A.bin) firmware(rtlwifi/rtl8192cufw_B.bin) firmware(rtlwifi/rtl8192cufw_TMSC.bin) firmware(rtlwifi/rtl8192defw.bin) firmware(rtlwifi/rtl8192eefw.bin) firmware(rtlwifi/rtl8192eu_ap_wowlan.bin) firmware(rtlwifi/rtl8192eu_nic.bin) firmware(rtlwifi/rtl8192eu_wowlan.bin) firmware(rtlwifi/rtl8192sefw.bin) firmware(rtlwifi/rtl8710bufw_SMIC.bin) firmware(rtlwifi/rtl8710bufw_UMC.bin) firmware(rtlwifi/rtl8712u.bin) firmware(rtlwifi/rtl8723aufw_A.bin) firmware(rtlwifi/rtl8723aufw_B.bin) firmware(rtlwifi/rtl8723aufw_B_NoBT.bin) firmware(rtlwifi/rtl8723befw.bin) firmware(rtlwifi/rtl8723befw_36.bin) firmware(rtlwifi/rtl8723bs_ap_wowlan.bin) firmware(rtlwifi/rtl8723bs_bt.bin) firmware(rtlwifi/rtl8723bs_nic.bin) firmware(rtlwifi/rtl8723bs_wowlan.bin) firmware(rtlwifi/rtl8723bu_ap_wowlan.bin) firmware(rtlwifi/rtl8723bu_nic.bin) firmware(rtlwifi/rtl8723bu_wowlan.bin) firmware(rtlwifi/rtl8723defw.bin) firmware(rtlwifi/rtl8723fw.bin) firmware(rtlwifi/rtl8723fw_B.bin) firmware(rtlwifi/rtl8812aefw.bin) firmware(rtlwifi/rtl8812aefw_wowlan.bin) firmware(rtlwifi/rtl8821aefw.bin) firmware(rtlwifi/rtl8821aefw_29.bin) firmware(rtlwifi/rtl8821aefw_wowlan.bin) firmware(rtlwifi/rtl8822befw.bin) firmware(rtw88/README) firmware(rtw88/rtw8723d_fw.bin) firmware(rtw88/rtw8821c_fw.bin) firmware(rtw88/rtw8822b_fw.bin) firmware(rtw88/rtw8822c_fw.bin) firmware(rtw88/rtw8822c_wow_fw.bin) firmware(rtw89/rtw8852a_fw.bin) firmware(rtw89/rtw8852b_fw-1.bin) firmware(rtw89/rtw8852b_fw.bin) firmware(rtw89/rtw8852c_fw.bin) firmware(s2250.fw) firmware(s2250_loader.fw) firmware(s5p-mfc-v6-v2.fw) firmware(s5p-mfc-v6.fw) firmware(s5p-mfc-v7.fw) firmware(s5p-mfc-v8.fw) firmware(s5p-mfc.fw) firmware(sb16/alaw_main.csp) firmware(sb16/ima_adpcm_capture.csp) firmware(sb16/ima_adpcm_init.csp) firmware(sb16/ima_adpcm_playback.csp) firmware(sb16/mulaw_main.csp) firmware(sdd_sagrad_1091_1098.bin) firmware(slicoss/gbdownload.sys) firmware(slicoss/gbrcvucode.sys) firmware(slicoss/oasisdbgdownload.sys) firmware(slicoss/oasisdownload.sys) firmware(slicoss/oasisrcvucode.sys) firmware(sms1xxx-hcw-55xxx-dvbt-02.fw) firmware(sms1xxx-hcw-55xxx-isdbt-02.fw) firmware(sms1xxx-nova-a-dvbt-01.fw) firmware(sms1xxx-nova-b-dvbt-01.fw) firmware(sms1xxx-stellar-dvbt-01.fw) firmware(sun/cassini.bin) firmware(sxg/saharadbgdownloadB.sys) firmware(sxg/saharadownloadB.sys) firmware(tdmb_nova_12mhz.inp) firmware(tehuti/bdx.bin) firmware(ti-connectivity/TIInit_6.2.31.bts) firmware(ti-connectivity/TIInit_6.6.15.bts) firmware(ti-connectivity/TIInit_7.2.31.bts) firmware(ti-connectivity/wl1251-fw.bin) firmware(ti-connectivity/wl1251-nvs.bin) firmware(ti-connectivity/wl1271-fw-2.bin) firmware(ti-connectivity/wl1271-fw-ap.bin) firmware(ti-connectivity/wl1271-fw.bin) firmware(ti-connectivity/wl1271-nvs.bin) firmware(ti-connectivity/wl127x-fw-3.bin) firmware(ti-connectivity/wl127x-fw-4-mr.bin) firmware(ti-connectivity/wl127x-fw-4-plt.bin) firmware(ti-connectivity/wl127x-fw-4-sr.bin) firmware(ti-connectivity/wl127x-fw-5-mr.bin) firmware(ti-connectivity/wl127x-fw-5-plt.bin) firmware(ti-connectivity/wl127x-fw-5-sr.bin) firmware(ti-connectivity/wl127x-fw-plt-3.bin) firmware(ti-connectivity/wl127x-nvs.bin) firmware(ti-connectivity/wl128x-fw-3.bin) firmware(ti-connectivity/wl128x-fw-4-mr.bin) firmware(ti-connectivity/wl128x-fw-4-plt.bin) firmware(ti-connectivity/wl128x-fw-4-sr.bin) firmware(ti-connectivity/wl128x-fw-5-mr.bin) firmware(ti-connectivity/wl128x-fw-5-plt.bin) firmware(ti-connectivity/wl128x-fw-5-sr.bin) firmware(ti-connectivity/wl128x-fw-ap.bin) firmware(ti-connectivity/wl128x-fw-plt-3.bin) firmware(ti-connectivity/wl128x-fw.bin) firmware(ti-connectivity/wl128x-nvs.bin) firmware(ti-connectivity/wl12xx-nvs.bin) firmware(ti-connectivity/wl18xx-fw-2.bin) firmware(ti-connectivity/wl18xx-fw-3.bin) firmware(ti-connectivity/wl18xx-fw-4.bin) firmware(ti-connectivity/wl18xx-fw.bin) firmware(ti-keystone/ks2_qmss_pdsp_acc48_k2_le_1_0_0_9.bin) firmware(ti/vpdma-1b8.bin) firmware(ti_3410.fw) firmware(ti_5052.fw) firmware(tigon/tg3.bin) firmware(tigon/tg357766.bin) firmware(tigon/tg3_tso.bin) firmware(tigon/tg3_tso5.bin) firmware(tlg2300_firmware.bin) firmware(ttusb-budget/dspbootcode.bin) firmware(ueagle-atm/930-fpga.bin) firmware(ueagle-atm/CMV4p.bin.v2) firmware(ueagle-atm/CMV9i.bin) firmware(ueagle-atm/CMV9p.bin) firmware(ueagle-atm/CMVei.bin) firmware(ueagle-atm/CMVeiWO.bin) firmware(ueagle-atm/CMVep.bin) firmware(ueagle-atm/CMVepES.bin) firmware(ueagle-atm/CMVepES03.bin) firmware(ueagle-atm/CMVepFR.bin) firmware(ueagle-atm/CMVepFR04.bin) firmware(ueagle-atm/CMVepFR10.bin) firmware(ueagle-atm/CMVepIT.bin) firmware(ueagle-atm/CMVepWO.bin) firmware(ueagle-atm/DSP4p.bin) firmware(ueagle-atm/DSP9i.bin) firmware(ueagle-atm/DSP9p.bin) firmware(ueagle-atm/DSPei.bin) firmware(ueagle-atm/DSPep.bin) firmware(ueagle-atm/adi930.fw) firmware(ueagle-atm/eagleI.fw) firmware(ueagle-atm/eagleII.fw) firmware(ueagle-atm/eagleIII.fw) firmware(ueagle-atm/eagleIV.fw) firmware(usbdux_firmware.bin) firmware(usbduxfast_firmware.bin) firmware(usbduxsigma_firmware.bin) firmware(v4l-cx231xx-avcore-01.fw) firmware(v4l-cx23418-apu.fw) firmware(v4l-cx23418-cpu.fw) firmware(v4l-cx23418-dig.fw) firmware(v4l-cx23885-avcore-01.fw) firmware(v4l-cx25840.fw) firmware(vicam/firmware.fw) firmware(vntwusb.fw) firmware(vpu_d.bin) firmware(vpu_p.bin) firmware(vxge/X3fw-pxe.ncf) firmware(vxge/X3fw.ncf) firmware(wfx/brd4001a.pds) firmware(wfx/brd8022a.pds) firmware(wfx/brd8023a.pds) firmware(wfx/wfm_wf200_C0.sec) firmware(whiteheat.fw) firmware(whiteheat_loader.fw) firmware(wil6210.brd) firmware(wil6210.fw) firmware(wsm_22.bin) firmware(yam/1200.bin) firmware(yam/9600.bin) firmware(yamaha/ds1_ctrl.fw) firmware(yamaha/ds1_dsp.fw) firmware(yamaha/ds1e_ctrl.fw) firmware(yamaha/yss225_registers.bin) iwl100-ucode iwl1000-ucode iwl3945-ucode iwl4965-ucode iwl5000-ucode iwl5150-ucode iwl6000-ucode iwl6000g2-ucode iwl6050-ucode kernel-firmware model-zero-2-w.txt) model-zero-w.txt) nanopi-r1.txt) pinebook-pro.txt) pinephone-pro.txt) qlogic-firmware quartz64-b.txt) ralink-firmware rock960.txt) tolino-shine2hd.txt) vim2.txt) visionfive-v1.txt)"
RDEPENDS:${PN} += "/bin/sh /usr/bin/mkdir /usr/bin/touch"

inherit rpm
