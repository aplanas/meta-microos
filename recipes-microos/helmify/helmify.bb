SUMMARY = "Creates Helm chart from Kubernetes yaml"
DESCRIPTION = "CLI that creates Helm charts from kubernetes yamls. \
 \
Helmify reads a list of supported k8s objects from stdin and converts it to a helm chart. Designed to generate charts for k8s operators but not limited to. See examples of charts generated by helmify. \
 \
Supports Helm >=v3.6.0"
LICENSE = "MIT"

PV = "0.4.3"

RPM_NAME = "helmify-0.4.3-1.1.aarch64.rpm"
RPM_HASH = "d0ab168e2d6d13ab45b6cf50057668dd9582e6fdef455906a82212ddf55ca5eb3c376148834d116a62c8f8a1b8bb9191c3ddb4d03901faff967e7608a840dc76"

RPROVIDES:${PN} += "helmify helmify(aarch-64)"
RDEPENDS:${PN} += "libc.so.6(GLIBC_2.34)(64bit)"

inherit rpm
