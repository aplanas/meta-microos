SUMMARY = "LaTeX support for EBGaramond fonts"
DESCRIPTION = "EB Garamond is a revival by Georg Duffner of the 16th century \
fonts designed by Claude Garamond. The LaTeX support package \
works for (pdf)LaTeX, XeLaTeX and LuaLaTeX users; configuration \
files for use with microtype are provided."
LICENSE = "OFL-1.1"

PV = "2023.201.svn64343"

RPM_NAME = "texlive-ebgaramond-2023.201.svn64343-53.1.noarch.rpm"
RPM_HASH = "b7121ca1f6bb3fa95ede920aad21fdbc691c6a216c2030fb89bd5146f3dffb99e203c94f5e8dd677aee70d8b8d968c9b4228efe3bef89e014ce753a4e94356db"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex(EBGaramond-Bold-inf-lgr.tfm) tex(EBGaramond-Bold-inf-ly1.tfm) tex(EBGaramond-Bold-inf-ot1.tfm) tex(EBGaramond-Bold-inf-t1--base.tfm) tex(EBGaramond-Bold-inf-t1.tfm) tex(EBGaramond-Bold-inf-t1.vf) tex(EBGaramond-Bold-lf-lgr.tfm) tex(EBGaramond-Bold-lf-ly1.tfm) tex(EBGaramond-Bold-lf-ot1.tfm) tex(EBGaramond-Bold-lf-sc-lgr.tfm) tex(EBGaramond-Bold-lf-sc-ly1--base.tfm) tex(EBGaramond-Bold-lf-sc-ly1.tfm) tex(EBGaramond-Bold-lf-sc-ly1.vf) tex(EBGaramond-Bold-lf-sc-ot1--base.tfm) tex(EBGaramond-Bold-lf-sc-ot1.tfm) tex(EBGaramond-Bold-lf-sc-ot1.vf) tex(EBGaramond-Bold-lf-sc-t1--base.tfm) tex(EBGaramond-Bold-lf-sc-t1.tfm) tex(EBGaramond-Bold-lf-sc-t1.vf) tex(EBGaramond-Bold-lf-swash-lgr.tfm) tex(EBGaramond-Bold-lf-swash-ly1.tfm) tex(EBGaramond-Bold-lf-swash-ot1.tfm) tex(EBGaramond-Bold-lf-swash-t1--base.tfm) tex(EBGaramond-Bold-lf-swash-t1.tfm) tex(EBGaramond-Bold-lf-swash-t1.vf) tex(EBGaramond-Bold-lf-t1--base.tfm) tex(EBGaramond-Bold-lf-t1.tfm) tex(EBGaramond-Bold-lf-t1.vf) tex(EBGaramond-Bold-lf-ts1--base.tfm) tex(EBGaramond-Bold-lf-ts1.tfm) tex(EBGaramond-Bold-lf-ts1.vf) tex(EBGaramond-Bold-osf-lgr.tfm) tex(EBGaramond-Bold-osf-ly1.tfm) tex(EBGaramond-Bold-osf-ot1.tfm) tex(EBGaramond-Bold-osf-sc-lgr.tfm) tex(EBGaramond-Bold-osf-sc-ly1--base.tfm) tex(EBGaramond-Bold-osf-sc-ly1.tfm) tex(EBGaramond-Bold-osf-sc-ly1.vf) tex(EBGaramond-Bold-osf-sc-ot1--base.tfm) tex(EBGaramond-Bold-osf-sc-ot1.tfm) tex(EBGaramond-Bold-osf-sc-ot1.vf) tex(EBGaramond-Bold-osf-sc-t1--base.tfm) tex(EBGaramond-Bold-osf-sc-t1.tfm) tex(EBGaramond-Bold-osf-sc-t1.vf) tex(EBGaramond-Bold-osf-swash-lgr.tfm) tex(EBGaramond-Bold-osf-swash-ly1.tfm) tex(EBGaramond-Bold-osf-swash-ot1.tfm) tex(EBGaramond-Bold-osf-swash-t1--base.tfm) tex(EBGaramond-Bold-osf-swash-t1.tfm) tex(EBGaramond-Bold-osf-swash-t1.vf) tex(EBGaramond-Bold-osf-t1--base.tfm) tex(EBGaramond-Bold-osf-t1.tfm) tex(EBGaramond-Bold-osf-t1.vf) tex(EBGaramond-Bold-osf-ts1--base.tfm) tex(EBGaramond-Bold-osf-ts1.tfm) tex(EBGaramond-Bold-osf-ts1.vf) tex(EBGaramond-Bold-sup-lgr.tfm) tex(EBGaramond-Bold-sup-ly1.tfm) tex(EBGaramond-Bold-sup-ot1.tfm) tex(EBGaramond-Bold-sup-t1--base.tfm) tex(EBGaramond-Bold-sup-t1.tfm) tex(EBGaramond-Bold-sup-t1.vf) tex(EBGaramond-Bold-tlf-lgr.tfm) tex(EBGaramond-Bold-tlf-ly1.tfm) tex(EBGaramond-Bold-tlf-ot1.tfm) tex(EBGaramond-Bold-tlf-sc-lgr.tfm) tex(EBGaramond-Bold-tlf-sc-ly1--base.tfm) tex(EBGaramond-Bold-tlf-sc-ly1.tfm) tex(EBGaramond-Bold-tlf-sc-ly1.vf) tex(EBGaramond-Bold-tlf-sc-ot1--base.tfm) tex(EBGaramond-Bold-tlf-sc-ot1.tfm) tex(EBGaramond-Bold-tlf-sc-ot1.vf) tex(EBGaramond-Bold-tlf-sc-t1--base.tfm) tex(EBGaramond-Bold-tlf-sc-t1.tfm) tex(EBGaramond-Bold-tlf-sc-t1.vf) tex(EBGaramond-Bold-tlf-swash-lgr.tfm) tex(EBGaramond-Bold-tlf-swash-ly1.tfm) tex(EBGaramond-Bold-tlf-swash-ot1.tfm) tex(EBGaramond-Bold-tlf-swash-t1--base.tfm) tex(EBGaramond-Bold-tlf-swash-t1.tfm) tex(EBGaramond-Bold-tlf-swash-t1.vf) tex(EBGaramond-Bold-tlf-t1--base.tfm) tex(EBGaramond-Bold-tlf-t1.tfm) tex(EBGaramond-Bold-tlf-t1.vf) tex(EBGaramond-Bold-tlf-ts1--base.tfm) tex(EBGaramond-Bold-tlf-ts1.tfm) tex(EBGaramond-Bold-tlf-ts1.vf) tex(EBGaramond-Bold-tosf-lgr.tfm) tex(EBGaramond-Bold-tosf-ly1.tfm) tex(EBGaramond-Bold-tosf-ot1.tfm) tex(EBGaramond-Bold-tosf-sc-lgr.tfm) tex(EBGaramond-Bold-tosf-sc-ly1--base.tfm) tex(EBGaramond-Bold-tosf-sc-ly1.tfm) tex(EBGaramond-Bold-tosf-sc-ly1.vf) tex(EBGaramond-Bold-tosf-sc-ot1--base.tfm) tex(EBGaramond-Bold-tosf-sc-ot1.tfm) tex(EBGaramond-Bold-tosf-sc-ot1.vf) tex(EBGaramond-Bold-tosf-sc-t1--base.tfm) tex(EBGaramond-Bold-tosf-sc-t1.tfm) tex(EBGaramond-Bold-tosf-sc-t1.vf) tex(EBGaramond-Bold-tosf-swash-lgr.tfm) tex(EBGaramond-Bold-tosf-swash-ly1.tfm) tex(EBGaramond-Bold-tosf-swash-ot1.tfm) tex(EBGaramond-Bold-tosf-swash-t1--base.tfm) tex(EBGaramond-Bold-tosf-swash-t1.tfm) tex(EBGaramond-Bold-tosf-swash-t1.vf) tex(EBGaramond-Bold-tosf-t1--base.tfm) tex(EBGaramond-Bold-tosf-t1.tfm) tex(EBGaramond-Bold-tosf-t1.vf) tex(EBGaramond-Bold-tosf-ts1--base.tfm) tex(EBGaramond-Bold-tosf-ts1.tfm) tex(EBGaramond-Bold-tosf-ts1.vf) tex(EBGaramond-BoldItalic-inf-lgr.tfm) tex(EBGaramond-BoldItalic-inf-ly1.tfm) tex(EBGaramond-BoldItalic-inf-ot1.tfm) tex(EBGaramond-BoldItalic-inf-t1--base.tfm) tex(EBGaramond-BoldItalic-inf-t1.tfm) tex(EBGaramond-BoldItalic-inf-t1.vf) tex(EBGaramond-BoldItalic-lf-lgr.tfm) tex(EBGaramond-BoldItalic-lf-ly1.tfm) tex(EBGaramond-BoldItalic-lf-ot1.tfm) tex(EBGaramond-BoldItalic-lf-sc-lgr.tfm) tex(EBGaramond-BoldItalic-lf-sc-ly1--base.tfm) tex(EBGaramond-BoldItalic-lf-sc-ly1.tfm) tex(EBGaramond-BoldItalic-lf-sc-ly1.vf) tex(EBGaramond-BoldItalic-lf-sc-ot1--base.tfm) tex(EBGaramond-BoldItalic-lf-sc-ot1.tfm) tex(EBGaramond-BoldItalic-lf-sc-ot1.vf) tex(EBGaramond-BoldItalic-lf-sc-t1--base.tfm) tex(EBGaramond-BoldItalic-lf-sc-t1.tfm) tex(EBGaramond-BoldItalic-lf-sc-t1.vf) tex(EBGaramond-BoldItalic-lf-swash-lgr.tfm) tex(EBGaramond-BoldItalic-lf-swash-ly1.tfm) tex(EBGaramond-BoldItalic-lf-swash-ot1.tfm) tex(EBGaramond-BoldItalic-lf-swash-t1--base.tfm) tex(EBGaramond-BoldItalic-lf-swash-t1.tfm) tex(EBGaramond-BoldItalic-lf-swash-t1.vf) tex(EBGaramond-BoldItalic-lf-t1--base.tfm) tex(EBGaramond-BoldItalic-lf-t1.tfm) tex(EBGaramond-BoldItalic-lf-t1.vf) tex(EBGaramond-BoldItalic-lf-ts1--base.tfm) tex(EBGaramond-BoldItalic-lf-ts1.tfm) tex(EBGaramond-BoldItalic-lf-ts1.vf) tex(EBGaramond-BoldItalic-osf-lgr.tfm) tex(EBGaramond-BoldItalic-osf-ly1.tfm) tex(EBGaramond-BoldItalic-osf-ot1.tfm) tex(EBGaramond-BoldItalic-osf-sc-lgr.tfm) tex(EBGaramond-BoldItalic-osf-sc-ly1--base.tfm) tex(EBGaramond-BoldItalic-osf-sc-ly1.tfm) tex(EBGaramond-BoldItalic-osf-sc-ly1.vf) tex(EBGaramond-BoldItalic-osf-sc-ot1--base.tfm) tex(EBGaramond-BoldItalic-osf-sc-ot1.tfm) tex(EBGaramond-BoldItalic-osf-sc-ot1.vf) tex(EBGaramond-BoldItalic-osf-sc-t1--base.tfm) tex(EBGaramond-BoldItalic-osf-sc-t1.tfm) tex(EBGaramond-BoldItalic-osf-sc-t1.vf) tex(EBGaramond-BoldItalic-osf-swash-lgr.tfm) tex(EBGaramond-BoldItalic-osf-swash-ly1.tfm) tex(EBGaramond-BoldItalic-osf-swash-ot1.tfm) tex(EBGaramond-BoldItalic-osf-swash-t1--base.tfm) tex(EBGaramond-BoldItalic-osf-swash-t1.tfm) tex(EBGaramond-BoldItalic-osf-swash-t1.vf) tex(EBGaramond-BoldItalic-osf-t1--base.tfm) tex(EBGaramond-BoldItalic-osf-t1.tfm) tex(EBGaramond-BoldItalic-osf-t1.vf) tex(EBGaramond-BoldItalic-osf-ts1--base.tfm) tex(EBGaramond-BoldItalic-osf-ts1.tfm) tex(EBGaramond-BoldItalic-osf-ts1.vf) tex(EBGaramond-BoldItalic-sup-lgr.tfm) tex(EBGaramond-BoldItalic-sup-ly1.tfm) tex(EBGaramond-BoldItalic-sup-ot1.tfm) tex(EBGaramond-BoldItalic-sup-t1--base.tfm) tex(EBGaramond-BoldItalic-sup-t1.tfm) tex(EBGaramond-BoldItalic-sup-t1.vf) tex(EBGaramond-BoldItalic-tlf-lgr.tfm) tex(EBGaramond-BoldItalic-tlf-ly1.tfm) tex(EBGaramond-BoldItalic-tlf-ot1.tfm) tex(EBGaramond-BoldItalic-tlf-sc-lgr.tfm) tex(EBGaramond-BoldItalic-tlf-sc-ly1--base.tfm) tex(EBGaramond-BoldItalic-tlf-sc-ly1.tfm) tex(EBGaramond-BoldItalic-tlf-sc-ly1.vf) tex(EBGaramond-BoldItalic-tlf-sc-ot1--base.tfm) tex(EBGaramond-BoldItalic-tlf-sc-ot1.tfm) tex(EBGaramond-BoldItalic-tlf-sc-ot1.vf) tex(EBGaramond-BoldItalic-tlf-sc-t1--base.tfm) tex(EBGaramond-BoldItalic-tlf-sc-t1.tfm) tex(EBGaramond-BoldItalic-tlf-sc-t1.vf) tex(EBGaramond-BoldItalic-tlf-swash-lgr.tfm) tex(EBGaramond-BoldItalic-tlf-swash-ly1.tfm) tex(EBGaramond-BoldItalic-tlf-swash-ot1.tfm) tex(EBGaramond-BoldItalic-tlf-swash-t1--base.tfm) tex(EBGaramond-BoldItalic-tlf-swash-t1.tfm) tex(EBGaramond-BoldItalic-tlf-swash-t1.vf) tex(EBGaramond-BoldItalic-tlf-t1--base.tfm) tex(EBGaramond-BoldItalic-tlf-t1.tfm) tex(EBGaramond-BoldItalic-tlf-t1.vf) tex(EBGaramond-BoldItalic-tlf-ts1--base.tfm) tex(EBGaramond-BoldItalic-tlf-ts1.tfm) tex(EBGaramond-BoldItalic-tlf-ts1.vf) tex(EBGaramond-BoldItalic-tosf-lgr.tfm) tex(EBGaramond-BoldItalic-tosf-ly1.tfm) tex(EBGaramond-BoldItalic-tosf-ot1.tfm) tex(EBGaramond-BoldItalic-tosf-sc-lgr.tfm) tex(EBGaramond-BoldItalic-tosf-sc-ly1--base.tfm) tex(EBGaramond-BoldItalic-tosf-sc-ly1.tfm) tex(EBGaramond-BoldItalic-tosf-sc-ly1.vf) tex(EBGaramond-BoldItalic-tosf-sc-ot1--base.tfm) tex(EBGaramond-BoldItalic-tosf-sc-ot1.tfm) tex(EBGaramond-BoldItalic-tosf-sc-ot1.vf) tex(EBGaramond-BoldItalic-tosf-sc-t1--base.tfm) tex(EBGaramond-BoldItalic-tosf-sc-t1.tfm) tex(EBGaramond-BoldItalic-tosf-sc-t1.vf) tex(EBGaramond-BoldItalic-tosf-swash-lgr.tfm) tex(EBGaramond-BoldItalic-tosf-swash-ly1.tfm) tex(EBGaramond-BoldItalic-tosf-swash-ot1.tfm) tex(EBGaramond-BoldItalic-tosf-swash-t1--base.tfm) tex(EBGaramond-BoldItalic-tosf-swash-t1.tfm) tex(EBGaramond-BoldItalic-tosf-swash-t1.vf) tex(EBGaramond-BoldItalic-tosf-t1--base.tfm) tex(EBGaramond-BoldItalic-tosf-t1.tfm) tex(EBGaramond-BoldItalic-tosf-t1.vf) tex(EBGaramond-BoldItalic-tosf-ts1--base.tfm) tex(EBGaramond-BoldItalic-tosf-ts1.tfm) tex(EBGaramond-BoldItalic-tosf-ts1.vf) tex(EBGaramond-ExtraBold-inf-lgr.tfm) tex(EBGaramond-ExtraBold-inf-ly1.tfm) tex(EBGaramond-ExtraBold-inf-ot1.tfm) tex(EBGaramond-ExtraBold-inf-t1--base.tfm) tex(EBGaramond-ExtraBold-inf-t1.tfm) tex(EBGaramond-ExtraBold-inf-t1.vf) tex(EBGaramond-ExtraBold-lf-lgr.tfm) tex(EBGaramond-ExtraBold-lf-ly1.tfm) tex(EBGaramond-ExtraBold-lf-ot1.tfm) tex(EBGaramond-ExtraBold-lf-sc-lgr.tfm) tex(EBGaramond-ExtraBold-lf-sc-ly1--base.tfm) tex(EBGaramond-ExtraBold-lf-sc-ly1.tfm) tex(EBGaramond-ExtraBold-lf-sc-ly1.vf) tex(EBGaramond-ExtraBold-lf-sc-ot1--base.tfm) tex(EBGaramond-ExtraBold-lf-sc-ot1.tfm) tex(EBGaramond-ExtraBold-lf-sc-ot1.vf) tex(EBGaramond-ExtraBold-lf-sc-t1--base.tfm) tex(EBGaramond-ExtraBold-lf-sc-t1.tfm) tex(EBGaramond-ExtraBold-lf-sc-t1.vf) tex(EBGaramond-ExtraBold-lf-swash-lgr.tfm) tex(EBGaramond-ExtraBold-lf-swash-ly1.tfm) tex(EBGaramond-ExtraBold-lf-swash-ot1.tfm) tex(EBGaramond-ExtraBold-lf-swash-t1--base.tfm) tex(EBGaramond-ExtraBold-lf-swash-t1.tfm) tex(EBGaramond-ExtraBold-lf-swash-t1.vf) tex(EBGaramond-ExtraBold-lf-t1--base.tfm) tex(EBGaramond-ExtraBold-lf-t1.tfm) tex(EBGaramond-ExtraBold-lf-t1.vf) tex(EBGaramond-ExtraBold-lf-ts1--base.tfm) tex(EBGaramond-ExtraBold-lf-ts1.tfm) tex(EBGaramond-ExtraBold-lf-ts1.vf) tex(EBGaramond-ExtraBold-osf-lgr.tfm) tex(EBGaramond-ExtraBold-osf-ly1.tfm) tex(EBGaramond-ExtraBold-osf-ot1.tfm) tex(EBGaramond-ExtraBold-osf-sc-lgr.tfm) tex(EBGaramond-ExtraBold-osf-sc-ly1--base.tfm) tex(EBGaramond-ExtraBold-osf-sc-ly1.tfm) tex(EBGaramond-ExtraBold-osf-sc-ly1.vf) tex(EBGaramond-ExtraBold-osf-sc-ot1--base.tfm) tex(EBGaramond-ExtraBold-osf-sc-ot1.tfm) tex(EBGaramond-ExtraBold-osf-sc-ot1.vf) tex(EBGaramond-ExtraBold-osf-sc-t1--base.tfm) tex(EBGaramond-ExtraBold-osf-sc-t1.tfm) tex(EBGaramond-ExtraBold-osf-sc-t1.vf) tex(EBGaramond-ExtraBold-osf-swash-lgr.tfm) tex(EBGaramond-ExtraBold-osf-swash-ly1.tfm) tex(EBGaramond-ExtraBold-osf-swash-ot1.tfm) tex(EBGaramond-ExtraBold-osf-swash-t1--base.tfm) tex(EBGaramond-ExtraBold-osf-swash-t1.tfm) tex(EBGaramond-ExtraBold-osf-swash-t1.vf) tex(EBGaramond-ExtraBold-osf-t1--base.tfm) tex(EBGaramond-ExtraBold-osf-t1.tfm) tex(EBGaramond-ExtraBold-osf-t1.vf) tex(EBGaramond-ExtraBold-osf-ts1--base.tfm) tex(EBGaramond-ExtraBold-osf-ts1.tfm) tex(EBGaramond-ExtraBold-osf-ts1.vf) tex(EBGaramond-ExtraBold-sup-lgr.tfm) tex(EBGaramond-ExtraBold-sup-ly1.tfm) tex(EBGaramond-ExtraBold-sup-ot1.tfm) tex(EBGaramond-ExtraBold-sup-t1--base.tfm) tex(EBGaramond-ExtraBold-sup-t1.tfm) tex(EBGaramond-ExtraBold-sup-t1.vf) tex(EBGaramond-ExtraBold-tlf-lgr.tfm) tex(EBGaramond-ExtraBold-tlf-ly1.tfm) tex(EBGaramond-ExtraBold-tlf-ot1.tfm) tex(EBGaramond-ExtraBold-tlf-sc-lgr.tfm) tex(EBGaramond-ExtraBold-tlf-sc-ly1--base.tfm) tex(EBGaramond-ExtraBold-tlf-sc-ly1.tfm) tex(EBGaramond-ExtraBold-tlf-sc-ly1.vf) tex(EBGaramond-ExtraBold-tlf-sc-ot1--base.tfm) tex(EBGaramond-ExtraBold-tlf-sc-ot1.tfm) tex(EBGaramond-ExtraBold-tlf-sc-ot1.vf) tex(EBGaramond-ExtraBold-tlf-sc-t1--base.tfm) tex(EBGaramond-ExtraBold-tlf-sc-t1.tfm) tex(EBGaramond-ExtraBold-tlf-sc-t1.vf) tex(EBGaramond-ExtraBold-tlf-swash-lgr.tfm) tex(EBGaramond-ExtraBold-tlf-swash-ly1.tfm) tex(EBGaramond-ExtraBold-tlf-swash-ot1.tfm) tex(EBGaramond-ExtraBold-tlf-swash-t1--base.tfm) tex(EBGaramond-ExtraBold-tlf-swash-t1.tfm) tex(EBGaramond-ExtraBold-tlf-swash-t1.vf) tex(EBGaramond-ExtraBold-tlf-t1--base.tfm) tex(EBGaramond-ExtraBold-tlf-t1.tfm) tex(EBGaramond-ExtraBold-tlf-t1.vf) tex(EBGaramond-ExtraBold-tlf-ts1--base.tfm) tex(EBGaramond-ExtraBold-tlf-ts1.tfm) tex(EBGaramond-ExtraBold-tlf-ts1.vf) tex(EBGaramond-ExtraBold-tosf-lgr.tfm) tex(EBGaramond-ExtraBold-tosf-ly1.tfm) tex(EBGaramond-ExtraBold-tosf-ot1.tfm) tex(EBGaramond-ExtraBold-tosf-sc-lgr.tfm) tex(EBGaramond-ExtraBold-tosf-sc-ly1--base.tfm) tex(EBGaramond-ExtraBold-tosf-sc-ly1.tfm) tex(EBGaramond-ExtraBold-tosf-sc-ly1.vf) tex(EBGaramond-ExtraBold-tosf-sc-ot1--base.tfm) tex(EBGaramond-ExtraBold-tosf-sc-ot1.tfm) tex(EBGaramond-ExtraBold-tosf-sc-ot1.vf) tex(EBGaramond-ExtraBold-tosf-sc-t1--base.tfm) tex(EBGaramond-ExtraBold-tosf-sc-t1.tfm) tex(EBGaramond-ExtraBold-tosf-sc-t1.vf) tex(EBGaramond-ExtraBold-tosf-swash-lgr.tfm) tex(EBGaramond-ExtraBold-tosf-swash-ly1.tfm) tex(EBGaramond-ExtraBold-tosf-swash-ot1.tfm) tex(EBGaramond-ExtraBold-tosf-swash-t1--base.tfm) tex(EBGaramond-ExtraBold-tosf-swash-t1.tfm) tex(EBGaramond-ExtraBold-tosf-swash-t1.vf) tex(EBGaramond-ExtraBold-tosf-t1--base.tfm) tex(EBGaramond-ExtraBold-tosf-t1.tfm) tex(EBGaramond-ExtraBold-tosf-t1.vf) tex(EBGaramond-ExtraBold-tosf-ts1--base.tfm) tex(EBGaramond-ExtraBold-tosf-ts1.tfm) tex(EBGaramond-ExtraBold-tosf-ts1.vf) tex(EBGaramond-ExtraBoldItalic-inf-lgr.tfm) tex(EBGaramond-ExtraBoldItalic-inf-ly1.tfm) tex(EBGaramond-ExtraBoldItalic-inf-ot1.tfm) tex(EBGaramond-ExtraBoldItalic-inf-t1--base.tfm) tex(EBGaramond-ExtraBoldItalic-inf-t1.tfm) tex(EBGaramond-ExtraBoldItalic-inf-t1.vf) tex(EBGaramond-ExtraBoldItalic-lf-lgr.tfm) tex(EBGaramond-ExtraBoldItalic-lf-ly1.tfm) tex(EBGaramond-ExtraBoldItalic-lf-ot1.tfm) tex(EBGaramond-ExtraBoldItalic-lf-sc-lgr.tfm) tex(EBGaramond-ExtraBoldItalic-lf-sc-ly1--base.tfm) tex(EBGaramond-ExtraBoldItalic-lf-sc-ly1.tfm) tex(EBGaramond-ExtraBoldItalic-lf-sc-ly1.vf) tex(EBGaramond-ExtraBoldItalic-lf-sc-ot1--base.tfm) tex(EBGaramond-ExtraBoldItalic-lf-sc-ot1.tfm) tex(EBGaramond-ExtraBoldItalic-lf-sc-ot1.vf) tex(EBGaramond-ExtraBoldItalic-lf-sc-t1--base.tfm) tex(EBGaramond-ExtraBoldItalic-lf-sc-t1.tfm) tex(EBGaramond-ExtraBoldItalic-lf-sc-t1.vf) tex(EBGaramond-ExtraBoldItalic-lf-swash-lgr.tfm) tex(EBGaramond-ExtraBoldItalic-lf-swash-ly1.tfm) tex(EBGaramond-ExtraBoldItalic-lf-swash-ot1.tfm) tex(EBGaramond-ExtraBoldItalic-lf-swash-t1--base.tfm) tex(EBGaramond-ExtraBoldItalic-lf-swash-t1.tfm) tex(EBGaramond-ExtraBoldItalic-lf-swash-t1.vf) tex(EBGaramond-ExtraBoldItalic-lf-t1--base.tfm) tex(EBGaramond-ExtraBoldItalic-lf-t1.tfm) tex(EBGaramond-ExtraBoldItalic-lf-t1.vf) tex(EBGaramond-ExtraBoldItalic-lf-ts1--base.tfm) tex(EBGaramond-ExtraBoldItalic-lf-ts1.tfm) tex(EBGaramond-ExtraBoldItalic-lf-ts1.vf) tex(EBGaramond-ExtraBoldItalic-osf-lgr.tfm) tex(EBGaramond-ExtraBoldItalic-osf-ly1.tfm) tex(EBGaramond-ExtraBoldItalic-osf-ot1.tfm) tex(EBGaramond-ExtraBoldItalic-osf-sc-lgr.tfm) tex(EBGaramond-ExtraBoldItalic-osf-sc-ly1--base.tfm) tex(EBGaramond-ExtraBoldItalic-osf-sc-ly1.tfm) tex(EBGaramond-ExtraBoldItalic-osf-sc-ly1.vf) tex(EBGaramond-ExtraBoldItalic-osf-sc-ot1--base.tfm) tex(EBGaramond-ExtraBoldItalic-osf-sc-ot1.tfm) tex(EBGaramond-ExtraBoldItalic-osf-sc-ot1.vf) tex(EBGaramond-ExtraBoldItalic-osf-sc-t1--base.tfm) tex(EBGaramond-ExtraBoldItalic-osf-sc-t1.tfm) tex(EBGaramond-ExtraBoldItalic-osf-sc-t1.vf) tex(EBGaramond-ExtraBoldItalic-osf-swash-lgr.tfm) tex(EBGaramond-ExtraBoldItalic-osf-swash-ly1.tfm) tex(EBGaramond-ExtraBoldItalic-osf-swash-ot1.tfm) tex(EBGaramond-ExtraBoldItalic-osf-swash-t1--base.tfm) tex(EBGaramond-ExtraBoldItalic-osf-swash-t1.tfm) tex(EBGaramond-ExtraBoldItalic-osf-swash-t1.vf) tex(EBGaramond-ExtraBoldItalic-osf-t1--base.tfm) tex(EBGaramond-ExtraBoldItalic-osf-t1.tfm) tex(EBGaramond-ExtraBoldItalic-osf-t1.vf) tex(EBGaramond-ExtraBoldItalic-osf-ts1--base.tfm) tex(EBGaramond-ExtraBoldItalic-osf-ts1.tfm) tex(EBGaramond-ExtraBoldItalic-osf-ts1.vf) tex(EBGaramond-ExtraBoldItalic-sup-lgr.tfm) tex(EBGaramond-ExtraBoldItalic-sup-ly1.tfm) tex(EBGaramond-ExtraBoldItalic-sup-ot1.tfm) tex(EBGaramond-ExtraBoldItalic-sup-t1--base.tfm) tex(EBGaramond-ExtraBoldItalic-sup-t1.tfm) tex(EBGaramond-ExtraBoldItalic-sup-t1.vf) tex(EBGaramond-ExtraBoldItalic-tlf-lgr.tfm) tex(EBGaramond-ExtraBoldItalic-tlf-ly1.tfm) tex(EBGaramond-ExtraBoldItalic-tlf-ot1.tfm) tex(EBGaramond-ExtraBoldItalic-tlf-sc-lgr.tfm) tex(EBGaramond-ExtraBoldItalic-tlf-sc-ly1--base.tfm) tex(EBGaramond-ExtraBoldItalic-tlf-sc-ly1.tfm) tex(EBGaramond-ExtraBoldItalic-tlf-sc-ly1.vf) tex(EBGaramond-ExtraBoldItalic-tlf-sc-ot1--base.tfm) tex(EBGaramond-ExtraBoldItalic-tlf-sc-ot1.tfm) tex(EBGaramond-ExtraBoldItalic-tlf-sc-ot1.vf) tex(EBGaramond-ExtraBoldItalic-tlf-sc-t1--base.tfm) tex(EBGaramond-ExtraBoldItalic-tlf-sc-t1.tfm) tex(EBGaramond-ExtraBoldItalic-tlf-sc-t1.vf) tex(EBGaramond-ExtraBoldItalic-tlf-swash-lgr.tfm) tex(EBGaramond-ExtraBoldItalic-tlf-swash-ly1.tfm) tex(EBGaramond-ExtraBoldItalic-tlf-swash-ot1.tfm) tex(EBGaramond-ExtraBoldItalic-tlf-swash-t1--base.tfm) tex(EBGaramond-ExtraBoldItalic-tlf-swash-t1.tfm) tex(EBGaramond-ExtraBoldItalic-tlf-swash-t1.vf) tex(EBGaramond-ExtraBoldItalic-tlf-t1--base.tfm) tex(EBGaramond-ExtraBoldItalic-tlf-t1.tfm) tex(EBGaramond-ExtraBoldItalic-tlf-t1.vf) tex(EBGaramond-ExtraBoldItalic-tlf-ts1--base.tfm) tex(EBGaramond-ExtraBoldItalic-tlf-ts1.tfm) tex(EBGaramond-ExtraBoldItalic-tlf-ts1.vf) tex(EBGaramond-ExtraBoldItalic-tosf-lgr.tfm) tex(EBGaramond-ExtraBoldItalic-tosf-ly1.tfm) tex(EBGaramond-ExtraBoldItalic-tosf-ot1.tfm) tex(EBGaramond-ExtraBoldItalic-tosf-sc-lgr.tfm) tex(EBGaramond-ExtraBoldItalic-tosf-sc-ly1--base.tfm) tex(EBGaramond-ExtraBoldItalic-tosf-sc-ly1.tfm) tex(EBGaramond-ExtraBoldItalic-tosf-sc-ly1.vf) tex(EBGaramond-ExtraBoldItalic-tosf-sc-ot1--base.tfm) tex(EBGaramond-ExtraBoldItalic-tosf-sc-ot1.tfm) tex(EBGaramond-ExtraBoldItalic-tosf-sc-ot1.vf) tex(EBGaramond-ExtraBoldItalic-tosf-sc-t1--base.tfm) tex(EBGaramond-ExtraBoldItalic-tosf-sc-t1.tfm) tex(EBGaramond-ExtraBoldItalic-tosf-sc-t1.vf) tex(EBGaramond-ExtraBoldItalic-tosf-swash-lgr.tfm) tex(EBGaramond-ExtraBoldItalic-tosf-swash-ly1.tfm) tex(EBGaramond-ExtraBoldItalic-tosf-swash-ot1.tfm) tex(EBGaramond-ExtraBoldItalic-tosf-swash-t1--base.tfm) tex(EBGaramond-ExtraBoldItalic-tosf-swash-t1.tfm) tex(EBGaramond-ExtraBoldItalic-tosf-swash-t1.vf) tex(EBGaramond-ExtraBoldItalic-tosf-t1--base.tfm) tex(EBGaramond-ExtraBoldItalic-tosf-t1.tfm) tex(EBGaramond-ExtraBoldItalic-tosf-t1.vf) tex(EBGaramond-ExtraBoldItalic-tosf-ts1--base.tfm) tex(EBGaramond-ExtraBoldItalic-tosf-ts1.tfm) tex(EBGaramond-ExtraBoldItalic-tosf-ts1.vf) tex(EBGaramond-Italic-inf-lgr.tfm) tex(EBGaramond-Italic-inf-ly1.tfm) tex(EBGaramond-Italic-inf-ot1.tfm) tex(EBGaramond-Italic-inf-t1--base.tfm) tex(EBGaramond-Italic-inf-t1.tfm) tex(EBGaramond-Italic-inf-t1.vf) tex(EBGaramond-Italic-lf-lgr.tfm) tex(EBGaramond-Italic-lf-ly1.tfm) tex(EBGaramond-Italic-lf-ot1.tfm) tex(EBGaramond-Italic-lf-sc-lgr.tfm) tex(EBGaramond-Italic-lf-sc-ly1--base.tfm) tex(EBGaramond-Italic-lf-sc-ly1.tfm) tex(EBGaramond-Italic-lf-sc-ly1.vf) tex(EBGaramond-Italic-lf-sc-ot1--base.tfm) tex(EBGaramond-Italic-lf-sc-ot1.tfm) tex(EBGaramond-Italic-lf-sc-ot1.vf) tex(EBGaramond-Italic-lf-sc-t1--base.tfm) tex(EBGaramond-Italic-lf-sc-t1.tfm) tex(EBGaramond-Italic-lf-sc-t1.vf) tex(EBGaramond-Italic-lf-swash-lgr.tfm) tex(EBGaramond-Italic-lf-swash-ly1.tfm) tex(EBGaramond-Italic-lf-swash-ot1.tfm) tex(EBGaramond-Italic-lf-swash-t1--base.tfm) tex(EBGaramond-Italic-lf-swash-t1.tfm) tex(EBGaramond-Italic-lf-swash-t1.vf) tex(EBGaramond-Italic-lf-t1--base.tfm) tex(EBGaramond-Italic-lf-t1.tfm) tex(EBGaramond-Italic-lf-t1.vf) tex(EBGaramond-Italic-lf-ts1--base.tfm) tex(EBGaramond-Italic-lf-ts1.tfm) tex(EBGaramond-Italic-lf-ts1.vf) tex(EBGaramond-Italic-osf-lgr.tfm) tex(EBGaramond-Italic-osf-ly1.tfm) tex(EBGaramond-Italic-osf-ot1.tfm) tex(EBGaramond-Italic-osf-sc-lgr.tfm) tex(EBGaramond-Italic-osf-sc-ly1--base.tfm) tex(EBGaramond-Italic-osf-sc-ly1.tfm) tex(EBGaramond-Italic-osf-sc-ly1.vf) tex(EBGaramond-Italic-osf-sc-ot1--base.tfm) tex(EBGaramond-Italic-osf-sc-ot1.tfm) tex(EBGaramond-Italic-osf-sc-ot1.vf) tex(EBGaramond-Italic-osf-sc-t1--base.tfm) tex(EBGaramond-Italic-osf-sc-t1.tfm) tex(EBGaramond-Italic-osf-sc-t1.vf) tex(EBGaramond-Italic-osf-swash-lgr.tfm) tex(EBGaramond-Italic-osf-swash-ly1.tfm) tex(EBGaramond-Italic-osf-swash-ot1.tfm) tex(EBGaramond-Italic-osf-swash-t1--base.tfm) tex(EBGaramond-Italic-osf-swash-t1.tfm) tex(EBGaramond-Italic-osf-swash-t1.vf) tex(EBGaramond-Italic-osf-t1--base.tfm) tex(EBGaramond-Italic-osf-t1.tfm) tex(EBGaramond-Italic-osf-t1.vf) tex(EBGaramond-Italic-osf-ts1--base.tfm) tex(EBGaramond-Italic-osf-ts1.tfm) tex(EBGaramond-Italic-osf-ts1.vf) tex(EBGaramond-Italic-sup-lgr.tfm) tex(EBGaramond-Italic-sup-ly1.tfm) tex(EBGaramond-Italic-sup-ot1.tfm) tex(EBGaramond-Italic-sup-t1--base.tfm) tex(EBGaramond-Italic-sup-t1.tfm) tex(EBGaramond-Italic-sup-t1.vf) tex(EBGaramond-Italic-tlf-lgr.tfm) tex(EBGaramond-Italic-tlf-ly1.tfm) tex(EBGaramond-Italic-tlf-ot1.tfm) tex(EBGaramond-Italic-tlf-sc-lgr.tfm) tex(EBGaramond-Italic-tlf-sc-ly1--base.tfm) tex(EBGaramond-Italic-tlf-sc-ly1.tfm) tex(EBGaramond-Italic-tlf-sc-ly1.vf) tex(EBGaramond-Italic-tlf-sc-ot1--base.tfm) tex(EBGaramond-Italic-tlf-sc-ot1.tfm) tex(EBGaramond-Italic-tlf-sc-ot1.vf) tex(EBGaramond-Italic-tlf-sc-t1--base.tfm) tex(EBGaramond-Italic-tlf-sc-t1.tfm) tex(EBGaramond-Italic-tlf-sc-t1.vf) tex(EBGaramond-Italic-tlf-swash-lgr.tfm) tex(EBGaramond-Italic-tlf-swash-ly1.tfm) tex(EBGaramond-Italic-tlf-swash-ot1.tfm) tex(EBGaramond-Italic-tlf-swash-t1--base.tfm) tex(EBGaramond-Italic-tlf-swash-t1.tfm) tex(EBGaramond-Italic-tlf-swash-t1.vf) tex(EBGaramond-Italic-tlf-t1--base.tfm) tex(EBGaramond-Italic-tlf-t1.tfm) tex(EBGaramond-Italic-tlf-t1.vf) tex(EBGaramond-Italic-tlf-ts1--base.tfm) tex(EBGaramond-Italic-tlf-ts1.tfm) tex(EBGaramond-Italic-tlf-ts1.vf) tex(EBGaramond-Italic-tosf-lgr.tfm) tex(EBGaramond-Italic-tosf-ly1.tfm) tex(EBGaramond-Italic-tosf-ot1.tfm) tex(EBGaramond-Italic-tosf-sc-lgr.tfm) tex(EBGaramond-Italic-tosf-sc-ly1--base.tfm) tex(EBGaramond-Italic-tosf-sc-ly1.tfm) tex(EBGaramond-Italic-tosf-sc-ly1.vf) tex(EBGaramond-Italic-tosf-sc-ot1--base.tfm) tex(EBGaramond-Italic-tosf-sc-ot1.tfm) tex(EBGaramond-Italic-tosf-sc-ot1.vf) tex(EBGaramond-Italic-tosf-sc-t1--base.tfm) tex(EBGaramond-Italic-tosf-sc-t1.tfm) tex(EBGaramond-Italic-tosf-sc-t1.vf) tex(EBGaramond-Italic-tosf-swash-lgr.tfm) tex(EBGaramond-Italic-tosf-swash-ly1.tfm) tex(EBGaramond-Italic-tosf-swash-ot1.tfm) tex(EBGaramond-Italic-tosf-swash-t1--base.tfm) tex(EBGaramond-Italic-tosf-swash-t1.tfm) tex(EBGaramond-Italic-tosf-swash-t1.vf) tex(EBGaramond-Italic-tosf-t1--base.tfm) tex(EBGaramond-Italic-tosf-t1.tfm) tex(EBGaramond-Italic-tosf-t1.vf) tex(EBGaramond-Italic-tosf-ts1--base.tfm) tex(EBGaramond-Italic-tosf-ts1.tfm) tex(EBGaramond-Italic-tosf-ts1.vf) tex(EBGaramond-Medium-inf-lgr.tfm) tex(EBGaramond-Medium-inf-ly1.tfm) tex(EBGaramond-Medium-inf-ot1.tfm) tex(EBGaramond-Medium-inf-t1--base.tfm) tex(EBGaramond-Medium-inf-t1.tfm) tex(EBGaramond-Medium-inf-t1.vf) tex(EBGaramond-Medium-lf-lgr.tfm) tex(EBGaramond-Medium-lf-ly1.tfm) tex(EBGaramond-Medium-lf-ot1.tfm) tex(EBGaramond-Medium-lf-sc-lgr.tfm) tex(EBGaramond-Medium-lf-sc-ly1--base.tfm) tex(EBGaramond-Medium-lf-sc-ly1.tfm) tex(EBGaramond-Medium-lf-sc-ly1.vf) tex(EBGaramond-Medium-lf-sc-ot1--base.tfm) tex(EBGaramond-Medium-lf-sc-ot1.tfm) tex(EBGaramond-Medium-lf-sc-ot1.vf) tex(EBGaramond-Medium-lf-sc-t1--base.tfm) tex(EBGaramond-Medium-lf-sc-t1.tfm) tex(EBGaramond-Medium-lf-sc-t1.vf) tex(EBGaramond-Medium-lf-swash-lgr.tfm) tex(EBGaramond-Medium-lf-swash-ly1.tfm) tex(EBGaramond-Medium-lf-swash-ot1.tfm) tex(EBGaramond-Medium-lf-swash-t1--base.tfm) tex(EBGaramond-Medium-lf-swash-t1.tfm) tex(EBGaramond-Medium-lf-swash-t1.vf) tex(EBGaramond-Medium-lf-t1--base.tfm) tex(EBGaramond-Medium-lf-t1.tfm) tex(EBGaramond-Medium-lf-t1.vf) tex(EBGaramond-Medium-lf-ts1--base.tfm) tex(EBGaramond-Medium-lf-ts1.tfm) tex(EBGaramond-Medium-lf-ts1.vf) tex(EBGaramond-Medium-osf-lgr.tfm) tex(EBGaramond-Medium-osf-ly1.tfm) tex(EBGaramond-Medium-osf-ot1.tfm) tex(EBGaramond-Medium-osf-sc-lgr.tfm) tex(EBGaramond-Medium-osf-sc-ly1--base.tfm) tex(EBGaramond-Medium-osf-sc-ly1.tfm) tex(EBGaramond-Medium-osf-sc-ly1.vf) tex(EBGaramond-Medium-osf-sc-ot1--base.tfm) tex(EBGaramond-Medium-osf-sc-ot1.tfm) tex(EBGaramond-Medium-osf-sc-ot1.vf) tex(EBGaramond-Medium-osf-sc-t1--base.tfm) tex(EBGaramond-Medium-osf-sc-t1.tfm) tex(EBGaramond-Medium-osf-sc-t1.vf) tex(EBGaramond-Medium-osf-swash-lgr.tfm) tex(EBGaramond-Medium-osf-swash-ly1.tfm) tex(EBGaramond-Medium-osf-swash-ot1.tfm) tex(EBGaramond-Medium-osf-swash-t1--base.tfm) tex(EBGaramond-Medium-osf-swash-t1.tfm) tex(EBGaramond-Medium-osf-swash-t1.vf) tex(EBGaramond-Medium-osf-t1--base.tfm) tex(EBGaramond-Medium-osf-t1.tfm) tex(EBGaramond-Medium-osf-t1.vf) tex(EBGaramond-Medium-osf-ts1--base.tfm) tex(EBGaramond-Medium-osf-ts1.tfm) tex(EBGaramond-Medium-osf-ts1.vf) tex(EBGaramond-Medium-sup-lgr.tfm) tex(EBGaramond-Medium-sup-ly1.tfm) tex(EBGaramond-Medium-sup-ot1.tfm) tex(EBGaramond-Medium-sup-t1--base.tfm) tex(EBGaramond-Medium-sup-t1.tfm) tex(EBGaramond-Medium-sup-t1.vf) tex(EBGaramond-Medium-tlf-lgr.tfm) tex(EBGaramond-Medium-tlf-ly1.tfm) tex(EBGaramond-Medium-tlf-ot1.tfm) tex(EBGaramond-Medium-tlf-sc-lgr.tfm) tex(EBGaramond-Medium-tlf-sc-ly1--base.tfm) tex(EBGaramond-Medium-tlf-sc-ly1.tfm) tex(EBGaramond-Medium-tlf-sc-ly1.vf) tex(EBGaramond-Medium-tlf-sc-ot1--base.tfm) tex(EBGaramond-Medium-tlf-sc-ot1.tfm) tex(EBGaramond-Medium-tlf-sc-ot1.vf) tex(EBGaramond-Medium-tlf-sc-t1--base.tfm) tex(EBGaramond-Medium-tlf-sc-t1.tfm) tex(EBGaramond-Medium-tlf-sc-t1.vf) tex(EBGaramond-Medium-tlf-swash-lgr.tfm) tex(EBGaramond-Medium-tlf-swash-ly1.tfm) tex(EBGaramond-Medium-tlf-swash-ot1.tfm) tex(EBGaramond-Medium-tlf-swash-t1--base.tfm) tex(EBGaramond-Medium-tlf-swash-t1.tfm) tex(EBGaramond-Medium-tlf-swash-t1.vf) tex(EBGaramond-Medium-tlf-t1--base.tfm) tex(EBGaramond-Medium-tlf-t1.tfm) tex(EBGaramond-Medium-tlf-t1.vf) tex(EBGaramond-Medium-tlf-ts1--base.tfm) tex(EBGaramond-Medium-tlf-ts1.tfm) tex(EBGaramond-Medium-tlf-ts1.vf) tex(EBGaramond-Medium-tosf-lgr.tfm) tex(EBGaramond-Medium-tosf-ly1.tfm) tex(EBGaramond-Medium-tosf-ot1.tfm) tex(EBGaramond-Medium-tosf-sc-lgr.tfm) tex(EBGaramond-Medium-tosf-sc-ly1--base.tfm) tex(EBGaramond-Medium-tosf-sc-ly1.tfm) tex(EBGaramond-Medium-tosf-sc-ly1.vf) tex(EBGaramond-Medium-tosf-sc-ot1--base.tfm) tex(EBGaramond-Medium-tosf-sc-ot1.tfm) tex(EBGaramond-Medium-tosf-sc-ot1.vf) tex(EBGaramond-Medium-tosf-sc-t1--base.tfm) tex(EBGaramond-Medium-tosf-sc-t1.tfm) tex(EBGaramond-Medium-tosf-sc-t1.vf) tex(EBGaramond-Medium-tosf-swash-lgr.tfm) tex(EBGaramond-Medium-tosf-swash-ly1.tfm) tex(EBGaramond-Medium-tosf-swash-ot1.tfm) tex(EBGaramond-Medium-tosf-swash-t1--base.tfm) tex(EBGaramond-Medium-tosf-swash-t1.tfm) tex(EBGaramond-Medium-tosf-swash-t1.vf) tex(EBGaramond-Medium-tosf-t1--base.tfm) tex(EBGaramond-Medium-tosf-t1.tfm) tex(EBGaramond-Medium-tosf-t1.vf) tex(EBGaramond-Medium-tosf-ts1--base.tfm) tex(EBGaramond-Medium-tosf-ts1.tfm) tex(EBGaramond-Medium-tosf-ts1.vf) tex(EBGaramond-MediumItalic-inf-lgr.tfm) tex(EBGaramond-MediumItalic-inf-ly1.tfm) tex(EBGaramond-MediumItalic-inf-ot1.tfm) tex(EBGaramond-MediumItalic-inf-t1--base.tfm) tex(EBGaramond-MediumItalic-inf-t1.tfm) tex(EBGaramond-MediumItalic-inf-t1.vf) tex(EBGaramond-MediumItalic-lf-lgr.tfm) tex(EBGaramond-MediumItalic-lf-ly1.tfm) tex(EBGaramond-MediumItalic-lf-ot1.tfm) tex(EBGaramond-MediumItalic-lf-sc-lgr.tfm) tex(EBGaramond-MediumItalic-lf-sc-ly1--base.tfm) tex(EBGaramond-MediumItalic-lf-sc-ly1.tfm) tex(EBGaramond-MediumItalic-lf-sc-ly1.vf) tex(EBGaramond-MediumItalic-lf-sc-ot1--base.tfm) tex(EBGaramond-MediumItalic-lf-sc-ot1.tfm) tex(EBGaramond-MediumItalic-lf-sc-ot1.vf) tex(EBGaramond-MediumItalic-lf-sc-t1--base.tfm) tex(EBGaramond-MediumItalic-lf-sc-t1.tfm) tex(EBGaramond-MediumItalic-lf-sc-t1.vf) tex(EBGaramond-MediumItalic-lf-swash-lgr.tfm) tex(EBGaramond-MediumItalic-lf-swash-ly1.tfm) tex(EBGaramond-MediumItalic-lf-swash-ot1.tfm) tex(EBGaramond-MediumItalic-lf-swash-t1--base.tfm) tex(EBGaramond-MediumItalic-lf-swash-t1.tfm) tex(EBGaramond-MediumItalic-lf-swash-t1.vf) tex(EBGaramond-MediumItalic-lf-t1--base.tfm) tex(EBGaramond-MediumItalic-lf-t1.tfm) tex(EBGaramond-MediumItalic-lf-t1.vf) tex(EBGaramond-MediumItalic-lf-ts1--base.tfm) tex(EBGaramond-MediumItalic-lf-ts1.tfm) tex(EBGaramond-MediumItalic-lf-ts1.vf) tex(EBGaramond-MediumItalic-osf-lgr.tfm) tex(EBGaramond-MediumItalic-osf-ly1.tfm) tex(EBGaramond-MediumItalic-osf-ot1.tfm) tex(EBGaramond-MediumItalic-osf-sc-lgr.tfm) tex(EBGaramond-MediumItalic-osf-sc-ly1--base.tfm) tex(EBGaramond-MediumItalic-osf-sc-ly1.tfm) tex(EBGaramond-MediumItalic-osf-sc-ly1.vf) tex(EBGaramond-MediumItalic-osf-sc-ot1--base.tfm) tex(EBGaramond-MediumItalic-osf-sc-ot1.tfm) tex(EBGaramond-MediumItalic-osf-sc-ot1.vf) tex(EBGaramond-MediumItalic-osf-sc-t1--base.tfm) tex(EBGaramond-MediumItalic-osf-sc-t1.tfm) tex(EBGaramond-MediumItalic-osf-sc-t1.vf) tex(EBGaramond-MediumItalic-osf-swash-lgr.tfm) tex(EBGaramond-MediumItalic-osf-swash-ly1.tfm) tex(EBGaramond-MediumItalic-osf-swash-ot1.tfm) tex(EBGaramond-MediumItalic-osf-swash-t1--base.tfm) tex(EBGaramond-MediumItalic-osf-swash-t1.tfm) tex(EBGaramond-MediumItalic-osf-swash-t1.vf) tex(EBGaramond-MediumItalic-osf-t1--base.tfm) tex(EBGaramond-MediumItalic-osf-t1.tfm) tex(EBGaramond-MediumItalic-osf-t1.vf) tex(EBGaramond-MediumItalic-osf-ts1--base.tfm) tex(EBGaramond-MediumItalic-osf-ts1.tfm) tex(EBGaramond-MediumItalic-osf-ts1.vf) tex(EBGaramond-MediumItalic-sup-lgr.tfm) tex(EBGaramond-MediumItalic-sup-ly1.tfm) tex(EBGaramond-MediumItalic-sup-ot1.tfm) tex(EBGaramond-MediumItalic-sup-t1--base.tfm) tex(EBGaramond-MediumItalic-sup-t1.tfm) tex(EBGaramond-MediumItalic-sup-t1.vf) tex(EBGaramond-MediumItalic-tlf-lgr.tfm) tex(EBGaramond-MediumItalic-tlf-ly1.tfm) tex(EBGaramond-MediumItalic-tlf-ot1.tfm) tex(EBGaramond-MediumItalic-tlf-sc-lgr.tfm) tex(EBGaramond-MediumItalic-tlf-sc-ly1--base.tfm) tex(EBGaramond-MediumItalic-tlf-sc-ly1.tfm) tex(EBGaramond-MediumItalic-tlf-sc-ly1.vf) tex(EBGaramond-MediumItalic-tlf-sc-ot1--base.tfm) tex(EBGaramond-MediumItalic-tlf-sc-ot1.tfm) tex(EBGaramond-MediumItalic-tlf-sc-ot1.vf) tex(EBGaramond-MediumItalic-tlf-sc-t1--base.tfm) tex(EBGaramond-MediumItalic-tlf-sc-t1.tfm) tex(EBGaramond-MediumItalic-tlf-sc-t1.vf) tex(EBGaramond-MediumItalic-tlf-swash-lgr.tfm) tex(EBGaramond-MediumItalic-tlf-swash-ly1.tfm) tex(EBGaramond-MediumItalic-tlf-swash-ot1.tfm) tex(EBGaramond-MediumItalic-tlf-swash-t1--base.tfm) tex(EBGaramond-MediumItalic-tlf-swash-t1.tfm) tex(EBGaramond-MediumItalic-tlf-swash-t1.vf) tex(EBGaramond-MediumItalic-tlf-t1--base.tfm) tex(EBGaramond-MediumItalic-tlf-t1.tfm) tex(EBGaramond-MediumItalic-tlf-t1.vf) tex(EBGaramond-MediumItalic-tlf-ts1--base.tfm) tex(EBGaramond-MediumItalic-tlf-ts1.tfm) tex(EBGaramond-MediumItalic-tlf-ts1.vf) tex(EBGaramond-MediumItalic-tosf-lgr.tfm) tex(EBGaramond-MediumItalic-tosf-ly1.tfm) tex(EBGaramond-MediumItalic-tosf-ot1.tfm) tex(EBGaramond-MediumItalic-tosf-sc-lgr.tfm) tex(EBGaramond-MediumItalic-tosf-sc-ly1--base.tfm) tex(EBGaramond-MediumItalic-tosf-sc-ly1.tfm) tex(EBGaramond-MediumItalic-tosf-sc-ly1.vf) tex(EBGaramond-MediumItalic-tosf-sc-ot1--base.tfm) tex(EBGaramond-MediumItalic-tosf-sc-ot1.tfm) tex(EBGaramond-MediumItalic-tosf-sc-ot1.vf) tex(EBGaramond-MediumItalic-tosf-sc-t1--base.tfm) tex(EBGaramond-MediumItalic-tosf-sc-t1.tfm) tex(EBGaramond-MediumItalic-tosf-sc-t1.vf) tex(EBGaramond-MediumItalic-tosf-swash-lgr.tfm) tex(EBGaramond-MediumItalic-tosf-swash-ly1.tfm) tex(EBGaramond-MediumItalic-tosf-swash-ot1.tfm) tex(EBGaramond-MediumItalic-tosf-swash-t1--base.tfm) tex(EBGaramond-MediumItalic-tosf-swash-t1.tfm) tex(EBGaramond-MediumItalic-tosf-swash-t1.vf) tex(EBGaramond-MediumItalic-tosf-t1--base.tfm) tex(EBGaramond-MediumItalic-tosf-t1.tfm) tex(EBGaramond-MediumItalic-tosf-t1.vf) tex(EBGaramond-MediumItalic-tosf-ts1--base.tfm) tex(EBGaramond-MediumItalic-tosf-ts1.tfm) tex(EBGaramond-MediumItalic-tosf-ts1.vf) tex(EBGaramond-Regular-inf-lgr.tfm) tex(EBGaramond-Regular-inf-ly1.tfm) tex(EBGaramond-Regular-inf-ot1.tfm) tex(EBGaramond-Regular-inf-t1--base.tfm) tex(EBGaramond-Regular-inf-t1.tfm) tex(EBGaramond-Regular-inf-t1.vf) tex(EBGaramond-Regular-lf-lgr.tfm) tex(EBGaramond-Regular-lf-ly1.tfm) tex(EBGaramond-Regular-lf-ot1.tfm) tex(EBGaramond-Regular-lf-sc-lgr.tfm) tex(EBGaramond-Regular-lf-sc-ly1--base.tfm) tex(EBGaramond-Regular-lf-sc-ly1.tfm) tex(EBGaramond-Regular-lf-sc-ly1.vf) tex(EBGaramond-Regular-lf-sc-ot1--base.tfm) tex(EBGaramond-Regular-lf-sc-ot1.tfm) tex(EBGaramond-Regular-lf-sc-ot1.vf) tex(EBGaramond-Regular-lf-sc-t1--base.tfm) tex(EBGaramond-Regular-lf-sc-t1.tfm) tex(EBGaramond-Regular-lf-sc-t1.vf) tex(EBGaramond-Regular-lf-swash-lgr.tfm) tex(EBGaramond-Regular-lf-swash-ly1.tfm) tex(EBGaramond-Regular-lf-swash-ot1.tfm) tex(EBGaramond-Regular-lf-swash-t1--base.tfm) tex(EBGaramond-Regular-lf-swash-t1.tfm) tex(EBGaramond-Regular-lf-swash-t1.vf) tex(EBGaramond-Regular-lf-t1--base.tfm) tex(EBGaramond-Regular-lf-t1.tfm) tex(EBGaramond-Regular-lf-t1.vf) tex(EBGaramond-Regular-lf-ts1--base.tfm) tex(EBGaramond-Regular-lf-ts1.tfm) tex(EBGaramond-Regular-lf-ts1.vf) tex(EBGaramond-Regular-osf-lgr.tfm) tex(EBGaramond-Regular-osf-ly1.tfm) tex(EBGaramond-Regular-osf-ot1.tfm) tex(EBGaramond-Regular-osf-sc-lgr.tfm) tex(EBGaramond-Regular-osf-sc-ly1--base.tfm) tex(EBGaramond-Regular-osf-sc-ly1.tfm) tex(EBGaramond-Regular-osf-sc-ly1.vf) tex(EBGaramond-Regular-osf-sc-ot1--base.tfm) tex(EBGaramond-Regular-osf-sc-ot1.tfm) tex(EBGaramond-Regular-osf-sc-ot1.vf) tex(EBGaramond-Regular-osf-sc-t1--base.tfm) tex(EBGaramond-Regular-osf-sc-t1.tfm) tex(EBGaramond-Regular-osf-sc-t1.vf) tex(EBGaramond-Regular-osf-swash-lgr.tfm) tex(EBGaramond-Regular-osf-swash-ly1.tfm) tex(EBGaramond-Regular-osf-swash-ot1.tfm) tex(EBGaramond-Regular-osf-swash-t1--base.tfm) tex(EBGaramond-Regular-osf-swash-t1.tfm) tex(EBGaramond-Regular-osf-swash-t1.vf) tex(EBGaramond-Regular-osf-t1--base.tfm) tex(EBGaramond-Regular-osf-t1.tfm) tex(EBGaramond-Regular-osf-t1.vf) tex(EBGaramond-Regular-osf-ts1--base.tfm) tex(EBGaramond-Regular-osf-ts1.tfm) tex(EBGaramond-Regular-osf-ts1.vf) tex(EBGaramond-Regular-sup-lgr.tfm) tex(EBGaramond-Regular-sup-ly1.tfm) tex(EBGaramond-Regular-sup-ot1.tfm) tex(EBGaramond-Regular-sup-t1--base.tfm) tex(EBGaramond-Regular-sup-t1.tfm) tex(EBGaramond-Regular-sup-t1.vf) tex(EBGaramond-Regular-tlf-lgr.tfm) tex(EBGaramond-Regular-tlf-ly1.tfm) tex(EBGaramond-Regular-tlf-ot1.tfm) tex(EBGaramond-Regular-tlf-sc-lgr.tfm) tex(EBGaramond-Regular-tlf-sc-ly1--base.tfm) tex(EBGaramond-Regular-tlf-sc-ly1.tfm) tex(EBGaramond-Regular-tlf-sc-ly1.vf) tex(EBGaramond-Regular-tlf-sc-ot1--base.tfm) tex(EBGaramond-Regular-tlf-sc-ot1.tfm) tex(EBGaramond-Regular-tlf-sc-ot1.vf) tex(EBGaramond-Regular-tlf-sc-t1--base.tfm) tex(EBGaramond-Regular-tlf-sc-t1.tfm) tex(EBGaramond-Regular-tlf-sc-t1.vf) tex(EBGaramond-Regular-tlf-swash-lgr.tfm) tex(EBGaramond-Regular-tlf-swash-ly1.tfm) tex(EBGaramond-Regular-tlf-swash-ot1.tfm) tex(EBGaramond-Regular-tlf-swash-t1--base.tfm) tex(EBGaramond-Regular-tlf-swash-t1.tfm) tex(EBGaramond-Regular-tlf-swash-t1.vf) tex(EBGaramond-Regular-tlf-t1--base.tfm) tex(EBGaramond-Regular-tlf-t1.tfm) tex(EBGaramond-Regular-tlf-t1.vf) tex(EBGaramond-Regular-tlf-ts1--base.tfm) tex(EBGaramond-Regular-tlf-ts1.tfm) tex(EBGaramond-Regular-tlf-ts1.vf) tex(EBGaramond-Regular-tosf-lgr.tfm) tex(EBGaramond-Regular-tosf-ly1.tfm) tex(EBGaramond-Regular-tosf-ot1.tfm) tex(EBGaramond-Regular-tosf-sc-lgr.tfm) tex(EBGaramond-Regular-tosf-sc-ly1--base.tfm) tex(EBGaramond-Regular-tosf-sc-ly1.tfm) tex(EBGaramond-Regular-tosf-sc-ly1.vf) tex(EBGaramond-Regular-tosf-sc-ot1--base.tfm) tex(EBGaramond-Regular-tosf-sc-ot1.tfm) tex(EBGaramond-Regular-tosf-sc-ot1.vf) tex(EBGaramond-Regular-tosf-sc-t1--base.tfm) tex(EBGaramond-Regular-tosf-sc-t1.tfm) tex(EBGaramond-Regular-tosf-sc-t1.vf) tex(EBGaramond-Regular-tosf-swash-lgr.tfm) tex(EBGaramond-Regular-tosf-swash-ly1.tfm) tex(EBGaramond-Regular-tosf-swash-ot1.tfm) tex(EBGaramond-Regular-tosf-swash-t1--base.tfm) tex(EBGaramond-Regular-tosf-swash-t1.tfm) tex(EBGaramond-Regular-tosf-swash-t1.vf) tex(EBGaramond-Regular-tosf-t1--base.tfm) tex(EBGaramond-Regular-tosf-t1.tfm) tex(EBGaramond-Regular-tosf-t1.vf) tex(EBGaramond-Regular-tosf-ts1--base.tfm) tex(EBGaramond-Regular-tosf-ts1.tfm) tex(EBGaramond-Regular-tosf-ts1.vf) tex(EBGaramond-SemiBold-inf-lgr.tfm) tex(EBGaramond-SemiBold-inf-ly1.tfm) tex(EBGaramond-SemiBold-inf-ot1.tfm) tex(EBGaramond-SemiBold-inf-t1--base.tfm) tex(EBGaramond-SemiBold-inf-t1.tfm) tex(EBGaramond-SemiBold-inf-t1.vf) tex(EBGaramond-SemiBold-lf-lgr.tfm) tex(EBGaramond-SemiBold-lf-ly1.tfm) tex(EBGaramond-SemiBold-lf-ot1.tfm) tex(EBGaramond-SemiBold-lf-sc-lgr.tfm) tex(EBGaramond-SemiBold-lf-sc-ly1--base.tfm) tex(EBGaramond-SemiBold-lf-sc-ly1.tfm) tex(EBGaramond-SemiBold-lf-sc-ly1.vf) tex(EBGaramond-SemiBold-lf-sc-ot1--base.tfm) tex(EBGaramond-SemiBold-lf-sc-ot1.tfm) tex(EBGaramond-SemiBold-lf-sc-ot1.vf) tex(EBGaramond-SemiBold-lf-sc-t1--base.tfm) tex(EBGaramond-SemiBold-lf-sc-t1.tfm) tex(EBGaramond-SemiBold-lf-sc-t1.vf) tex(EBGaramond-SemiBold-lf-swash-lgr.tfm) tex(EBGaramond-SemiBold-lf-swash-ly1.tfm) tex(EBGaramond-SemiBold-lf-swash-ot1.tfm) tex(EBGaramond-SemiBold-lf-swash-t1--base.tfm) tex(EBGaramond-SemiBold-lf-swash-t1.tfm) tex(EBGaramond-SemiBold-lf-swash-t1.vf) tex(EBGaramond-SemiBold-lf-t1--base.tfm) tex(EBGaramond-SemiBold-lf-t1.tfm) tex(EBGaramond-SemiBold-lf-t1.vf) tex(EBGaramond-SemiBold-lf-ts1--base.tfm) tex(EBGaramond-SemiBold-lf-ts1.tfm) tex(EBGaramond-SemiBold-lf-ts1.vf) tex(EBGaramond-SemiBold-osf-lgr.tfm) tex(EBGaramond-SemiBold-osf-ly1.tfm) tex(EBGaramond-SemiBold-osf-ot1.tfm) tex(EBGaramond-SemiBold-osf-sc-lgr.tfm) tex(EBGaramond-SemiBold-osf-sc-ly1--base.tfm) tex(EBGaramond-SemiBold-osf-sc-ly1.tfm) tex(EBGaramond-SemiBold-osf-sc-ly1.vf) tex(EBGaramond-SemiBold-osf-sc-ot1--base.tfm) tex(EBGaramond-SemiBold-osf-sc-ot1.tfm) tex(EBGaramond-SemiBold-osf-sc-ot1.vf) tex(EBGaramond-SemiBold-osf-sc-t1--base.tfm) tex(EBGaramond-SemiBold-osf-sc-t1.tfm) tex(EBGaramond-SemiBold-osf-sc-t1.vf) tex(EBGaramond-SemiBold-osf-swash-lgr.tfm) tex(EBGaramond-SemiBold-osf-swash-ly1.tfm) tex(EBGaramond-SemiBold-osf-swash-ot1.tfm) tex(EBGaramond-SemiBold-osf-swash-t1--base.tfm) tex(EBGaramond-SemiBold-osf-swash-t1.tfm) tex(EBGaramond-SemiBold-osf-swash-t1.vf) tex(EBGaramond-SemiBold-osf-t1--base.tfm) tex(EBGaramond-SemiBold-osf-t1.tfm) tex(EBGaramond-SemiBold-osf-t1.vf) tex(EBGaramond-SemiBold-osf-ts1--base.tfm) tex(EBGaramond-SemiBold-osf-ts1.tfm) tex(EBGaramond-SemiBold-osf-ts1.vf) tex(EBGaramond-SemiBold-sup-lgr.tfm) tex(EBGaramond-SemiBold-sup-ly1.tfm) tex(EBGaramond-SemiBold-sup-ot1.tfm) tex(EBGaramond-SemiBold-sup-t1--base.tfm) tex(EBGaramond-SemiBold-sup-t1.tfm) tex(EBGaramond-SemiBold-sup-t1.vf) tex(EBGaramond-SemiBold-tlf-lgr.tfm) tex(EBGaramond-SemiBold-tlf-ly1.tfm) tex(EBGaramond-SemiBold-tlf-ot1.tfm) tex(EBGaramond-SemiBold-tlf-sc-lgr.tfm) tex(EBGaramond-SemiBold-tlf-sc-ly1--base.tfm) tex(EBGaramond-SemiBold-tlf-sc-ly1.tfm) tex(EBGaramond-SemiBold-tlf-sc-ly1.vf) tex(EBGaramond-SemiBold-tlf-sc-ot1--base.tfm) tex(EBGaramond-SemiBold-tlf-sc-ot1.tfm) tex(EBGaramond-SemiBold-tlf-sc-ot1.vf) tex(EBGaramond-SemiBold-tlf-sc-t1--base.tfm) tex(EBGaramond-SemiBold-tlf-sc-t1.tfm) tex(EBGaramond-SemiBold-tlf-sc-t1.vf) tex(EBGaramond-SemiBold-tlf-swash-lgr.tfm) tex(EBGaramond-SemiBold-tlf-swash-ly1.tfm) tex(EBGaramond-SemiBold-tlf-swash-ot1.tfm) tex(EBGaramond-SemiBold-tlf-swash-t1--base.tfm) tex(EBGaramond-SemiBold-tlf-swash-t1.tfm) tex(EBGaramond-SemiBold-tlf-swash-t1.vf) tex(EBGaramond-SemiBold-tlf-t1--base.tfm) tex(EBGaramond-SemiBold-tlf-t1.tfm) tex(EBGaramond-SemiBold-tlf-t1.vf) tex(EBGaramond-SemiBold-tlf-ts1--base.tfm) tex(EBGaramond-SemiBold-tlf-ts1.tfm) tex(EBGaramond-SemiBold-tlf-ts1.vf) tex(EBGaramond-SemiBold-tosf-lgr.tfm) tex(EBGaramond-SemiBold-tosf-ly1.tfm) tex(EBGaramond-SemiBold-tosf-ot1.tfm) tex(EBGaramond-SemiBold-tosf-sc-lgr.tfm) tex(EBGaramond-SemiBold-tosf-sc-ly1--base.tfm) tex(EBGaramond-SemiBold-tosf-sc-ly1.tfm) tex(EBGaramond-SemiBold-tosf-sc-ly1.vf) tex(EBGaramond-SemiBold-tosf-sc-ot1--base.tfm) tex(EBGaramond-SemiBold-tosf-sc-ot1.tfm) tex(EBGaramond-SemiBold-tosf-sc-ot1.vf) tex(EBGaramond-SemiBold-tosf-sc-t1--base.tfm) tex(EBGaramond-SemiBold-tosf-sc-t1.tfm) tex(EBGaramond-SemiBold-tosf-sc-t1.vf) tex(EBGaramond-SemiBold-tosf-swash-lgr.tfm) tex(EBGaramond-SemiBold-tosf-swash-ly1.tfm) tex(EBGaramond-SemiBold-tosf-swash-ot1.tfm) tex(EBGaramond-SemiBold-tosf-swash-t1--base.tfm) tex(EBGaramond-SemiBold-tosf-swash-t1.tfm) tex(EBGaramond-SemiBold-tosf-swash-t1.vf) tex(EBGaramond-SemiBold-tosf-t1--base.tfm) tex(EBGaramond-SemiBold-tosf-t1.tfm) tex(EBGaramond-SemiBold-tosf-t1.vf) tex(EBGaramond-SemiBold-tosf-ts1--base.tfm) tex(EBGaramond-SemiBold-tosf-ts1.tfm) tex(EBGaramond-SemiBold-tosf-ts1.vf) tex(EBGaramond-SemiBoldItalic-inf-lgr.tfm) tex(EBGaramond-SemiBoldItalic-inf-ly1.tfm) tex(EBGaramond-SemiBoldItalic-inf-ot1.tfm) tex(EBGaramond-SemiBoldItalic-inf-t1--base.tfm) tex(EBGaramond-SemiBoldItalic-inf-t1.tfm) tex(EBGaramond-SemiBoldItalic-inf-t1.vf) tex(EBGaramond-SemiBoldItalic-lf-lgr.tfm) tex(EBGaramond-SemiBoldItalic-lf-ly1.tfm) tex(EBGaramond-SemiBoldItalic-lf-ot1.tfm) tex(EBGaramond-SemiBoldItalic-lf-sc-lgr.tfm) tex(EBGaramond-SemiBoldItalic-lf-sc-ly1--base.tfm) tex(EBGaramond-SemiBoldItalic-lf-sc-ly1.tfm) tex(EBGaramond-SemiBoldItalic-lf-sc-ly1.vf) tex(EBGaramond-SemiBoldItalic-lf-sc-ot1--base.tfm) tex(EBGaramond-SemiBoldItalic-lf-sc-ot1.tfm) tex(EBGaramond-SemiBoldItalic-lf-sc-ot1.vf) tex(EBGaramond-SemiBoldItalic-lf-sc-t1--base.tfm) tex(EBGaramond-SemiBoldItalic-lf-sc-t1.tfm) tex(EBGaramond-SemiBoldItalic-lf-sc-t1.vf) tex(EBGaramond-SemiBoldItalic-lf-swash-lgr.tfm) tex(EBGaramond-SemiBoldItalic-lf-swash-ly1.tfm) tex(EBGaramond-SemiBoldItalic-lf-swash-ot1.tfm) tex(EBGaramond-SemiBoldItalic-lf-swash-t1--base.tfm) tex(EBGaramond-SemiBoldItalic-lf-swash-t1.tfm) tex(EBGaramond-SemiBoldItalic-lf-swash-t1.vf) tex(EBGaramond-SemiBoldItalic-lf-t1--base.tfm) tex(EBGaramond-SemiBoldItalic-lf-t1.tfm) tex(EBGaramond-SemiBoldItalic-lf-t1.vf) tex(EBGaramond-SemiBoldItalic-lf-ts1--base.tfm) tex(EBGaramond-SemiBoldItalic-lf-ts1.tfm) tex(EBGaramond-SemiBoldItalic-lf-ts1.vf) tex(EBGaramond-SemiBoldItalic-osf-lgr.tfm) tex(EBGaramond-SemiBoldItalic-osf-ly1.tfm) tex(EBGaramond-SemiBoldItalic-osf-ot1.tfm) tex(EBGaramond-SemiBoldItalic-osf-sc-lgr.tfm) tex(EBGaramond-SemiBoldItalic-osf-sc-ly1--base.tfm) tex(EBGaramond-SemiBoldItalic-osf-sc-ly1.tfm) tex(EBGaramond-SemiBoldItalic-osf-sc-ly1.vf) tex(EBGaramond-SemiBoldItalic-osf-sc-ot1--base.tfm) tex(EBGaramond-SemiBoldItalic-osf-sc-ot1.tfm) tex(EBGaramond-SemiBoldItalic-osf-sc-ot1.vf) tex(EBGaramond-SemiBoldItalic-osf-sc-t1--base.tfm) tex(EBGaramond-SemiBoldItalic-osf-sc-t1.tfm) tex(EBGaramond-SemiBoldItalic-osf-sc-t1.vf) tex(EBGaramond-SemiBoldItalic-osf-swash-lgr.tfm) tex(EBGaramond-SemiBoldItalic-osf-swash-ly1.tfm) tex(EBGaramond-SemiBoldItalic-osf-swash-ot1.tfm) tex(EBGaramond-SemiBoldItalic-osf-swash-t1--base.tfm) tex(EBGaramond-SemiBoldItalic-osf-swash-t1.tfm) tex(EBGaramond-SemiBoldItalic-osf-swash-t1.vf) tex(EBGaramond-SemiBoldItalic-osf-t1--base.tfm) tex(EBGaramond-SemiBoldItalic-osf-t1.tfm) tex(EBGaramond-SemiBoldItalic-osf-t1.vf) tex(EBGaramond-SemiBoldItalic-osf-ts1--base.tfm) tex(EBGaramond-SemiBoldItalic-osf-ts1.tfm) tex(EBGaramond-SemiBoldItalic-osf-ts1.vf) tex(EBGaramond-SemiBoldItalic-sup-lgr.tfm) tex(EBGaramond-SemiBoldItalic-sup-ly1.tfm) tex(EBGaramond-SemiBoldItalic-sup-ot1.tfm) tex(EBGaramond-SemiBoldItalic-sup-t1--base.tfm) tex(EBGaramond-SemiBoldItalic-sup-t1.tfm) tex(EBGaramond-SemiBoldItalic-sup-t1.vf) tex(EBGaramond-SemiBoldItalic-tlf-lgr.tfm) tex(EBGaramond-SemiBoldItalic-tlf-ly1.tfm) tex(EBGaramond-SemiBoldItalic-tlf-ot1.tfm) tex(EBGaramond-SemiBoldItalic-tlf-sc-lgr.tfm) tex(EBGaramond-SemiBoldItalic-tlf-sc-ly1--base.tfm) tex(EBGaramond-SemiBoldItalic-tlf-sc-ly1.tfm) tex(EBGaramond-SemiBoldItalic-tlf-sc-ly1.vf) tex(EBGaramond-SemiBoldItalic-tlf-sc-ot1--base.tfm) tex(EBGaramond-SemiBoldItalic-tlf-sc-ot1.tfm) tex(EBGaramond-SemiBoldItalic-tlf-sc-ot1.vf) tex(EBGaramond-SemiBoldItalic-tlf-sc-t1--base.tfm) tex(EBGaramond-SemiBoldItalic-tlf-sc-t1.tfm) tex(EBGaramond-SemiBoldItalic-tlf-sc-t1.vf) tex(EBGaramond-SemiBoldItalic-tlf-swash-lgr.tfm) tex(EBGaramond-SemiBoldItalic-tlf-swash-ly1.tfm) tex(EBGaramond-SemiBoldItalic-tlf-swash-ot1.tfm) tex(EBGaramond-SemiBoldItalic-tlf-swash-t1--base.tfm) tex(EBGaramond-SemiBoldItalic-tlf-swash-t1.tfm) tex(EBGaramond-SemiBoldItalic-tlf-swash-t1.vf) tex(EBGaramond-SemiBoldItalic-tlf-t1--base.tfm) tex(EBGaramond-SemiBoldItalic-tlf-t1.tfm) tex(EBGaramond-SemiBoldItalic-tlf-t1.vf) tex(EBGaramond-SemiBoldItalic-tlf-ts1--base.tfm) tex(EBGaramond-SemiBoldItalic-tlf-ts1.tfm) tex(EBGaramond-SemiBoldItalic-tlf-ts1.vf) tex(EBGaramond-SemiBoldItalic-tosf-lgr.tfm) tex(EBGaramond-SemiBoldItalic-tosf-ly1.tfm) tex(EBGaramond-SemiBoldItalic-tosf-ot1.tfm) tex(EBGaramond-SemiBoldItalic-tosf-sc-lgr.tfm) tex(EBGaramond-SemiBoldItalic-tosf-sc-ly1--base.tfm) tex(EBGaramond-SemiBoldItalic-tosf-sc-ly1.tfm) tex(EBGaramond-SemiBoldItalic-tosf-sc-ly1.vf) tex(EBGaramond-SemiBoldItalic-tosf-sc-ot1--base.tfm) tex(EBGaramond-SemiBoldItalic-tosf-sc-ot1.tfm) tex(EBGaramond-SemiBoldItalic-tosf-sc-ot1.vf) tex(EBGaramond-SemiBoldItalic-tosf-sc-t1--base.tfm) tex(EBGaramond-SemiBoldItalic-tosf-sc-t1.tfm) tex(EBGaramond-SemiBoldItalic-tosf-sc-t1.vf) tex(EBGaramond-SemiBoldItalic-tosf-swash-lgr.tfm) tex(EBGaramond-SemiBoldItalic-tosf-swash-ly1.tfm) tex(EBGaramond-SemiBoldItalic-tosf-swash-ot1.tfm) tex(EBGaramond-SemiBoldItalic-tosf-swash-t1--base.tfm) tex(EBGaramond-SemiBoldItalic-tosf-swash-t1.tfm) tex(EBGaramond-SemiBoldItalic-tosf-swash-t1.vf) tex(EBGaramond-SemiBoldItalic-tosf-t1--base.tfm) tex(EBGaramond-SemiBoldItalic-tosf-t1.tfm) tex(EBGaramond-SemiBoldItalic-tosf-t1.vf) tex(EBGaramond-SemiBoldItalic-tosf-ts1--base.tfm) tex(EBGaramond-SemiBoldItalic-tosf-ts1.tfm) tex(EBGaramond-SemiBoldItalic-tosf-ts1.vf) tex(EBGaramond.map) tex(EBGaramondInitials-tlf-lgr.tfm) tex(EBGaramondInitials-tlf-lgr.vf) tex(EBGaramondInitials-tlf-ly1--base.tfm) tex(EBGaramondInitials-tlf-ly1.tfm) tex(EBGaramondInitials-tlf-ly1.vf) tex(EBGaramondInitials-tlf-ot1.tfm) tex(EBGaramondInitials-tlf-t1--base.tfm) tex(EBGaramondInitials-tlf-t1.tfm) tex(EBGaramondInitials-tlf-t1.vf) tex(EBGaramondInitials-tlf-ts1.tfm) tex(EBGaramondInitials-tlf-ts1.vf) tex(LGREBGaramond-Inf.fd) tex(LGREBGaramond-LF.fd) tex(LGREBGaramond-OsF.fd) tex(LGREBGaramond-Sup.fd) tex(LGREBGaramond-TLF.fd) tex(LGREBGaramond-TOsF.fd) tex(LGREBGaramondInitials-TLF.fd) tex(LY1EBGaramond-Inf.fd) tex(LY1EBGaramond-LF.fd) tex(LY1EBGaramond-OsF.fd) tex(LY1EBGaramond-Sup.fd) tex(LY1EBGaramond-TLF.fd) tex(LY1EBGaramond-TOsF.fd) tex(LY1EBGaramondInitials-TLF.fd) tex(OT1EBGaramond-Inf.fd) tex(OT1EBGaramond-LF.fd) tex(OT1EBGaramond-OsF.fd) tex(OT1EBGaramond-Sup.fd) tex(OT1EBGaramond-TLF.fd) tex(OT1EBGaramond-TOsF.fd) tex(OT1EBGaramondInitials-TLF.fd) tex(T1EBGaramond-Inf.fd) tex(T1EBGaramond-LF.fd) tex(T1EBGaramond-OsF.fd) tex(T1EBGaramond-Sup.fd) tex(T1EBGaramond-TLF.fd) tex(T1EBGaramond-TOsF.fd) tex(T1EBGaramondInitials-TLF.fd) tex(TS1EBGaramond-LF.fd) tex(TS1EBGaramond-OsF.fd) tex(TS1EBGaramond-TLF.fd) tex(TS1EBGaramond-TOsF.fd) tex(TS1EBGaramondInitials-TLF.fd) tex(ebgaramond.sty) tex(ebgm_2hp5cx.enc) tex(ebgm_2ybfsp.enc) tex(ebgm_34tkje.enc) tex(ebgm_3veehr.enc) tex(ebgm_3zuots.enc) tex(ebgm_4ljeza.enc) tex(ebgm_4v7kvs.enc) tex(ebgm_524p5k.enc) tex(ebgm_535mcm.enc) tex(ebgm_57ulwi.enc) tex(ebgm_5cvcse.enc) tex(ebgm_5xwr64.enc) tex(ebgm_5ysuwq.enc) tex(ebgm_67ivnh.enc) tex(ebgm_6qtp6p.enc) tex(ebgm_7tc6ve.enc) tex(ebgm_7zgzer.enc) tex(ebgm_a23bap.enc) tex(ebgm_a37mnv.enc) tex(ebgm_a56nal.enc) tex(ebgm_ancics.enc) tex(ebgm_ao6kf7.enc) tex(ebgm_bevor6.enc) tex(ebgm_bisgyq.enc) tex(ebgm_bj5npy.enc) tex(ebgm_bszlvl.enc) tex(ebgm_byuyni.enc) tex(ebgm_c6t5bp.enc) tex(ebgm_chpilv.enc) tex(ebgm_cqx43s.enc) tex(ebgm_d2h6lj.enc) tex(ebgm_doset5.enc) tex(ebgm_egoty6.enc) tex(ebgm_epwp2l.enc) tex(ebgm_fbpsnn.enc) tex(ebgm_fc2mbn.enc) tex(ebgm_fc5dte.enc) tex(ebgm_fhs5ay.enc) tex(ebgm_fl2mea.enc) tex(ebgm_g63n4u.enc) tex(ebgm_gaaohp.enc) tex(ebgm_gf4ecr.enc) tex(ebgm_gfppum.enc) tex(ebgm_gspomo.enc) tex(ebgm_h2c7fw.enc) tex(ebgm_h5djnb.enc) tex(ebgm_hfyizy.enc) tex(ebgm_hrbra6.enc) tex(ebgm_i3ibnm.enc) tex(ebgm_ipm435.enc) tex(ebgm_j2crie.enc) tex(ebgm_j4bgam.enc) tex(ebgm_k24cav.enc) tex(ebgm_k5z2jz.enc) tex(ebgm_k7jns3.enc) tex(ebgm_kfeykp.enc) tex(ebgm_lbrscz.enc) tex(ebgm_ld6df2.enc) tex(ebgm_ldtcgl.enc) tex(ebgm_liamow.enc) tex(ebgm_ljow5q.enc) tex(ebgm_lmhdpa.enc) tex(ebgm_lybnup.enc) tex(ebgm_ndsebz.enc) tex(ebgm_nhfy4v.enc) tex(ebgm_oahxim.enc) tex(ebgm_oge4ze.enc) tex(ebgm_oskdwa.enc) tex(ebgm_pdqo3a.enc) tex(ebgm_puit2n.enc) tex(ebgm_qhp2au.enc) tex(ebgm_qip76a.enc) tex(ebgm_qwnohr.enc) tex(ebgm_rdmgdp.enc) tex(ebgm_rtavnu.enc) tex(ebgm_s7tpqt.enc) tex(ebgm_sqqqn7.enc) tex(ebgm_t3ctnr.enc) tex(ebgm_t6g5sq.enc) tex(ebgm_tcdnmr.enc) tex(ebgm_tsrvmb.enc) tex(ebgm_u7qtot.enc) tex(ebgm_utfkrl.enc) tex(ebgm_vqv3w3.enc) tex(ebgm_w7jvgc.enc) tex(ebgm_xgcnbw.enc) tex(ebgm_xhqcff.enc) tex(ebgm_xoskhe.enc) tex(ebgm_ybjcp2.enc) tex(ebgm_yddfsn.enc) tex(ebgm_yjkoc2.enc) tex(ebgm_yqpahr.enc) tex(ebgm_z6ekgm.enc) tex(ebgm_zbngqq.enc) tex(ebgm_zcffwk.enc) tex(ebgm_zor4nh.enc) texlive-ebgaramond"
RDEPENDS:${PN} += "/bin/sh coreutils ed findutils grep sed tex(fontaxes.sty) tex(fontenc.sty) tex(fontspec.sty) tex(ifluatex.sty) tex(ifxetex.sty) tex(mweights.sty) tex(textcomp.sty) tex(updmap.cfg) tex(xkeyval.sty) texlive texlive-ebgaramond-fonts texlive-filesystem texlive-kpathsea texlive-kpathsea-bin texlive-scripts texlive-scripts-bin"

inherit rpm
