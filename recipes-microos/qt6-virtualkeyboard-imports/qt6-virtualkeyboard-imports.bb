SUMMARY = "Qt 6 VirtualKeyboard QML files and plugins"
DESCRIPTION = "QML files and plugins from the Qt 6 VirtualKeyboard module."
LICENSE = "GPL-3.0-only"

PV = "6.5.0"

RPM_NAME = "qt6-virtualkeyboard-imports-6.5.0-1.1.aarch64.rpm"
RPM_HASH = "6dcbad3a52f4665207f30f77acde158a576c6d1a5c7bfd1af5968dcbb80e3751ea042fcdf6aff0e2520e5c5e3ba0ea9ac8c17cc021d749c862825d89d2851b4d"

RPROVIDES:${PN} += "libqtvkbbuiltinstylesplugin.so()(64bit) libqtvkbbuiltinstylesplugin.so(Qt_6)(64bit) libqtvkbbuiltinstylesplugin.so(Qt_6.0)(64bit) libqtvkbbuiltinstylesplugin.so(Qt_6.1)(64bit) libqtvkbbuiltinstylesplugin.so(Qt_6.2)(64bit) libqtvkbbuiltinstylesplugin.so(Qt_6.3)(64bit) libqtvkbbuiltinstylesplugin.so(Qt_6.4)(64bit) libqtvkbbuiltinstylesplugin.so(Qt_6.5)(64bit) libqtvkbbuiltinstylesplugin.so(Qt_6.5.0_PRIVATE_API)(64bit) libqtvkbcomponentsplugin.so()(64bit) libqtvkbcomponentsplugin.so(Qt_6)(64bit) libqtvkbcomponentsplugin.so(Qt_6.0)(64bit) libqtvkbcomponentsplugin.so(Qt_6.1)(64bit) libqtvkbcomponentsplugin.so(Qt_6.2)(64bit) libqtvkbcomponentsplugin.so(Qt_6.3)(64bit) libqtvkbcomponentsplugin.so(Qt_6.4)(64bit) libqtvkbcomponentsplugin.so(Qt_6.5)(64bit) libqtvkbcomponentsplugin.so(Qt_6.5.0_PRIVATE_API)(64bit) libqtvkbhangulplugin.so()(64bit) libqtvkbhangulplugin.so(Qt_6)(64bit) libqtvkbhangulplugin.so(Qt_6.0)(64bit) libqtvkbhangulplugin.so(Qt_6.1)(64bit) libqtvkbhangulplugin.so(Qt_6.2)(64bit) libqtvkbhangulplugin.so(Qt_6.3)(64bit) libqtvkbhangulplugin.so(Qt_6.4)(64bit) libqtvkbhangulplugin.so(Qt_6.5)(64bit) libqtvkbhangulplugin.so(Qt_6.5.0_PRIVATE_API)(64bit) libqtvkbhunspellplugin.so()(64bit) libqtvkbhunspellplugin.so(Qt_6)(64bit) libqtvkbhunspellplugin.so(Qt_6.0)(64bit) libqtvkbhunspellplugin.so(Qt_6.1)(64bit) libqtvkbhunspellplugin.so(Qt_6.2)(64bit) libqtvkbhunspellplugin.so(Qt_6.3)(64bit) libqtvkbhunspellplugin.so(Qt_6.4)(64bit) libqtvkbhunspellplugin.so(Qt_6.5)(64bit) libqtvkbhunspellplugin.so(Qt_6.5.0_PRIVATE_API)(64bit) libqtvkblayoutsplugin.so()(64bit) libqtvkblayoutsplugin.so(Qt_6)(64bit) libqtvkblayoutsplugin.so(Qt_6.0)(64bit) libqtvkblayoutsplugin.so(Qt_6.1)(64bit) libqtvkblayoutsplugin.so(Qt_6.2)(64bit) libqtvkblayoutsplugin.so(Qt_6.3)(64bit) libqtvkblayoutsplugin.so(Qt_6.4)(64bit) libqtvkblayoutsplugin.so(Qt_6.5)(64bit) libqtvkblayoutsplugin.so(Qt_6.5.0_PRIVATE_API)(64bit) libqtvkbopenwnnplugin.so()(64bit) libqtvkbopenwnnplugin.so(Qt_6)(64bit) libqtvkbopenwnnplugin.so(Qt_6.0)(64bit) libqtvkbopenwnnplugin.so(Qt_6.1)(64bit) libqtvkbopenwnnplugin.so(Qt_6.2)(64bit) libqtvkbopenwnnplugin.so(Qt_6.3)(64bit) libqtvkbopenwnnplugin.so(Qt_6.4)(64bit) libqtvkbopenwnnplugin.so(Qt_6.5)(64bit) libqtvkbopenwnnplugin.so(Qt_6.5.0_PRIVATE_API)(64bit) libqtvkbpinyinplugin.so()(64bit) libqtvkbpinyinplugin.so(Qt_6)(64bit) libqtvkbpinyinplugin.so(Qt_6.0)(64bit) libqtvkbpinyinplugin.so(Qt_6.1)(64bit) libqtvkbpinyinplugin.so(Qt_6.2)(64bit) libqtvkbpinyinplugin.so(Qt_6.3)(64bit) libqtvkbpinyinplugin.so(Qt_6.4)(64bit) libqtvkbpinyinplugin.so(Qt_6.5)(64bit) libqtvkbpinyinplugin.so(Qt_6.5.0_PRIVATE_API)(64bit) libqtvkbplugin.so()(64bit) libqtvkbplugin.so(Qt_6)(64bit) libqtvkbplugin.so(Qt_6.0)(64bit) libqtvkbplugin.so(Qt_6.1)(64bit) libqtvkbplugin.so(Qt_6.2)(64bit) libqtvkbplugin.so(Qt_6.3)(64bit) libqtvkbplugin.so(Qt_6.4)(64bit) libqtvkbplugin.so(Qt_6.5)(64bit) libqtvkbplugin.so(Qt_6.5.0_PRIVATE_API)(64bit) libqtvkbpluginsplugin.so()(64bit) libqtvkbpluginsplugin.so(Qt_6)(64bit) libqtvkbpluginsplugin.so(Qt_6.0)(64bit) libqtvkbpluginsplugin.so(Qt_6.1)(64bit) libqtvkbpluginsplugin.so(Qt_6.2)(64bit) libqtvkbpluginsplugin.so(Qt_6.3)(64bit) libqtvkbpluginsplugin.so(Qt_6.4)(64bit) libqtvkbpluginsplugin.so(Qt_6.5)(64bit) libqtvkbpluginsplugin.so(Qt_6.5.0_PRIVATE_API)(64bit) libqtvkbsettingsplugin.so()(64bit) libqtvkbsettingsplugin.so(Qt_6)(64bit) libqtvkbsettingsplugin.so(Qt_6.0)(64bit) libqtvkbsettingsplugin.so(Qt_6.1)(64bit) libqtvkbsettingsplugin.so(Qt_6.2)(64bit) libqtvkbsettingsplugin.so(Qt_6.3)(64bit) libqtvkbsettingsplugin.so(Qt_6.4)(64bit) libqtvkbsettingsplugin.so(Qt_6.5)(64bit) libqtvkbsettingsplugin.so(Qt_6.5.0_PRIVATE_API)(64bit) libqtvkbstylesplugin.so()(64bit) libqtvkbstylesplugin.so(Qt_6)(64bit) libqtvkbstylesplugin.so(Qt_6.0)(64bit) libqtvkbstylesplugin.so(Qt_6.1)(64bit) libqtvkbstylesplugin.so(Qt_6.2)(64bit) libqtvkbstylesplugin.so(Qt_6.3)(64bit) libqtvkbstylesplugin.so(Qt_6.4)(64bit) libqtvkbstylesplugin.so(Qt_6.5)(64bit) libqtvkbstylesplugin.so(Qt_6.5.0_PRIVATE_API)(64bit) libqtvkbtcimeplugin.so()(64bit) libqtvkbtcimeplugin.so(Qt_6)(64bit) libqtvkbtcimeplugin.so(Qt_6.0)(64bit) libqtvkbtcimeplugin.so(Qt_6.1)(64bit) libqtvkbtcimeplugin.so(Qt_6.2)(64bit) libqtvkbtcimeplugin.so(Qt_6.3)(64bit) libqtvkbtcimeplugin.so(Qt_6.4)(64bit) libqtvkbtcimeplugin.so(Qt_6.5)(64bit) libqtvkbtcimeplugin.so(Qt_6.5.0_PRIVATE_API)(64bit) libqtvkbthaiplugin.so()(64bit) libqtvkbthaiplugin.so(Qt_6)(64bit) libqtvkbthaiplugin.so(Qt_6.0)(64bit) libqtvkbthaiplugin.so(Qt_6.1)(64bit) libqtvkbthaiplugin.so(Qt_6.2)(64bit) libqtvkbthaiplugin.so(Qt_6.3)(64bit) libqtvkbthaiplugin.so(Qt_6.4)(64bit) libqtvkbthaiplugin.so(Qt_6.5)(64bit) libqtvkbthaiplugin.so(Qt_6.5.0_PRIVATE_API)(64bit) qt6-virtualkeyboard-imports qt6-virtualkeyboard-imports(aarch-64) qt6qmlimport(QtQuick.VirtualKeyboard.1) qt6qmlimport(QtQuick.VirtualKeyboard.2) qt6qmlimport(QtQuick.VirtualKeyboard.6) qt6qmlimport(QtQuick.VirtualKeyboard.Components.1) qt6qmlimport(QtQuick.VirtualKeyboard.Components.2) qt6qmlimport(QtQuick.VirtualKeyboard.Components.6) qt6qmlimport(QtQuick.VirtualKeyboard.Layouts.1) qt6qmlimport(QtQuick.VirtualKeyboard.Layouts.2) qt6qmlimport(QtQuick.VirtualKeyboard.Layouts.6) qt6qmlimport(QtQuick.VirtualKeyboard.Plugins.Hangul.6) qt6qmlimport(QtQuick.VirtualKeyboard.Plugins.Hunspell.6) qt6qmlimport(QtQuick.VirtualKeyboard.Plugins.OpenWNN.6) qt6qmlimport(QtQuick.VirtualKeyboard.Plugins.Pinyin.6) qt6qmlimport(QtQuick.VirtualKeyboard.Plugins.TCIme.6) qt6qmlimport(QtQuick.VirtualKeyboard.Plugins.Thai.6) qt6qmlimport(QtQuick.VirtualKeyboard.Settings.1) qt6qmlimport(QtQuick.VirtualKeyboard.Settings.2) qt6qmlimport(QtQuick.VirtualKeyboard.Settings.6) qt6qmlimport(QtQuick.VirtualKeyboard.Styles.1) qt6qmlimport(QtQuick.VirtualKeyboard.Styles.2) qt6qmlimport(QtQuick.VirtualKeyboard.Styles.6) qt6qmlimport(QtQuick.VirtualKeyboard.Styles.Builtin.6)"
RDEPENDS:${PN} += "ld-linux-aarch64.so.1()(64bit) ld-linux-aarch64.so.1(GLIBC_2.17)(64bit) libQt6Core.so.6()(64bit) libQt6Core.so.6(Qt_6)(64bit) libQt6Core.so.6(Qt_6.5)(64bit) libQt6Core.so.6(Qt_6.5.0_PRIVATE_API)(64bit) libQt6Gui.so.6()(64bit) libQt6Gui.so.6(Qt_6)(64bit) libQt6HunspellInputMethod.so.6()(64bit) libQt6HunspellInputMethod.so.6(Qt_6)(64bit) libQt6HunspellInputMethod.so.6(Qt_6.5.0_PRIVATE_API)(64bit) libQt6Qml.so.6()(64bit) libQt6Qml.so.6(Qt_6)(64bit) libQt6Quick.so.6()(64bit) libQt6Quick.so.6(Qt_6)(64bit) libQt6Svg.so.6()(64bit) libQt6Svg.so.6(Qt_6)(64bit) libQt6VirtualKeyboard.so.6()(64bit) libQt6VirtualKeyboard.so.6(Qt_6)(64bit) libQt6VirtualKeyboard.so.6(Qt_6.5.0_PRIVATE_API)(64bit) libc.so.6(GLIBC_2.34)(64bit) libm.so.6()(64bit) libm.so.6(GLIBC_2.29)(64bit) libstdc++.so.6()(64bit) libstdc++.so.6(CXXABI_1.3)(64bit) libstdc++.so.6(CXXABI_1.3.9)(64bit) libstdc++.so.6(GLIBCXX_3.4)(64bit)"

inherit rpm
