SUMMARY = "A TrueType font for mediaevalists"
DESCRIPTION = "Junicode is a TrueType font with many OpenType features for \
antiquarians (especially medievalists) based on typefaces used \
by the Oxford Press in the late 17th and early 18th centuries. \
It works well with Xe(La)TeX."
LICENSE = "OFL-1.1"

PV = "2023.201.1.0.2svn61719"

RPM_NAME = "texlive-junicode-2023.201.1.0.2svn61719-55.1.noarch.rpm"
RPM_HASH = "c6a55d909919dfdb5904d011cdee1324fd58ea56def20394dc16a137121c70c9245c5946d54492c4a12aae24c85c143ce076e8e74cf63dbdc2dfc1aff743b0bd"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex(Junicode-Bold-sup-ly1.tfm) \
tex(Junicode-Bold-sup-ot1.tfm) \
tex(Junicode-Bold-sup-t1--base.tfm) \
tex(Junicode-Bold-sup-t1.tfm) \
tex(Junicode-Bold-sup-t1.vf) \
tex(Junicode-Bold-sup-t3--base.tfm) \
tex(Junicode-Bold-sup-t3.tfm) \
tex(Junicode-Bold-sup-t3.vf) \
tex(Junicode-Bold-sup-ts3.tfm) \
tex(Junicode-Bold-tlf-ly1.tfm) \
tex(Junicode-Bold-tlf-ot1--base.tfm) \
tex(Junicode-Bold-tlf-ot1.tfm) \
tex(Junicode-Bold-tlf-ot1.vf) \
tex(Junicode-Bold-tlf-sc-ly1--base.tfm) \
tex(Junicode-Bold-tlf-sc-ly1.tfm) \
tex(Junicode-Bold-tlf-sc-ly1.vf) \
tex(Junicode-Bold-tlf-sc-ot1--base.tfm) \
tex(Junicode-Bold-tlf-sc-ot1.tfm) \
tex(Junicode-Bold-tlf-sc-ot1.vf) \
tex(Junicode-Bold-tlf-sc-t1--base.tfm) \
tex(Junicode-Bold-tlf-sc-t1.tfm) \
tex(Junicode-Bold-tlf-sc-t1.vf) \
tex(Junicode-Bold-tlf-sc-t3--base.tfm) \
tex(Junicode-Bold-tlf-sc-t3.tfm) \
tex(Junicode-Bold-tlf-sc-t3.vf) \
tex(Junicode-Bold-tlf-sc-ts3.tfm) \
tex(Junicode-Bold-tlf-swash-ly1--base.tfm) \
tex(Junicode-Bold-tlf-swash-ly1.tfm) \
tex(Junicode-Bold-tlf-swash-ly1.vf) \
tex(Junicode-Bold-tlf-swash-ot1--base.tfm) \
tex(Junicode-Bold-tlf-swash-ot1.tfm) \
tex(Junicode-Bold-tlf-swash-ot1.vf) \
tex(Junicode-Bold-tlf-swash-t1--base.tfm) \
tex(Junicode-Bold-tlf-swash-t1.tfm) \
tex(Junicode-Bold-tlf-swash-t1.vf) \
tex(Junicode-Bold-tlf-swash-t3--base.tfm) \
tex(Junicode-Bold-tlf-swash-t3.tfm) \
tex(Junicode-Bold-tlf-swash-t3.vf) \
tex(Junicode-Bold-tlf-swash-ts3.tfm) \
tex(Junicode-Bold-tlf-t1--base.tfm) \
tex(Junicode-Bold-tlf-t1.tfm) \
tex(Junicode-Bold-tlf-t1.vf) \
tex(Junicode-Bold-tlf-t3--base.tfm) \
tex(Junicode-Bold-tlf-t3.tfm) \
tex(Junicode-Bold-tlf-t3.vf) \
tex(Junicode-Bold-tlf-ts1--base.tfm) \
tex(Junicode-Bold-tlf-ts1.tfm) \
tex(Junicode-Bold-tlf-ts1.vf) \
tex(Junicode-Bold-tlf-ts3.tfm) \
tex(Junicode-Bold-tosf-ly1.tfm) \
tex(Junicode-Bold-tosf-ot1--base.tfm) \
tex(Junicode-Bold-tosf-ot1.tfm) \
tex(Junicode-Bold-tosf-ot1.vf) \
tex(Junicode-Bold-tosf-sc-ly1--base.tfm) \
tex(Junicode-Bold-tosf-sc-ly1.tfm) \
tex(Junicode-Bold-tosf-sc-ly1.vf) \
tex(Junicode-Bold-tosf-sc-ot1--base.tfm) \
tex(Junicode-Bold-tosf-sc-ot1.tfm) \
tex(Junicode-Bold-tosf-sc-ot1.vf) \
tex(Junicode-Bold-tosf-sc-t1--base.tfm) \
tex(Junicode-Bold-tosf-sc-t1.tfm) \
tex(Junicode-Bold-tosf-sc-t1.vf) \
tex(Junicode-Bold-tosf-sc-t3--base.tfm) \
tex(Junicode-Bold-tosf-sc-t3.tfm) \
tex(Junicode-Bold-tosf-sc-t3.vf) \
tex(Junicode-Bold-tosf-sc-ts3.tfm) \
tex(Junicode-Bold-tosf-swash-ly1--base.tfm) \
tex(Junicode-Bold-tosf-swash-ly1.tfm) \
tex(Junicode-Bold-tosf-swash-ly1.vf) \
tex(Junicode-Bold-tosf-swash-ot1--base.tfm) \
tex(Junicode-Bold-tosf-swash-ot1.tfm) \
tex(Junicode-Bold-tosf-swash-ot1.vf) \
tex(Junicode-Bold-tosf-swash-t1--base.tfm) \
tex(Junicode-Bold-tosf-swash-t1.tfm) \
tex(Junicode-Bold-tosf-swash-t1.vf) \
tex(Junicode-Bold-tosf-swash-t3--base.tfm) \
tex(Junicode-Bold-tosf-swash-t3.tfm) \
tex(Junicode-Bold-tosf-swash-t3.vf) \
tex(Junicode-Bold-tosf-swash-ts3.tfm) \
tex(Junicode-Bold-tosf-t1--base.tfm) \
tex(Junicode-Bold-tosf-t1.tfm) \
tex(Junicode-Bold-tosf-t1.vf) \
tex(Junicode-Bold-tosf-t3--base.tfm) \
tex(Junicode-Bold-tosf-t3.tfm) \
tex(Junicode-Bold-tosf-t3.vf) \
tex(Junicode-Bold-tosf-ts1--base.tfm) \
tex(Junicode-Bold-tosf-ts1.tfm) \
tex(Junicode-Bold-tosf-ts1.vf) \
tex(Junicode-Bold-tosf-ts3.tfm) \
tex(Junicode-BoldItalic-sup-ly1.tfm) \
tex(Junicode-BoldItalic-sup-ot1.tfm) \
tex(Junicode-BoldItalic-sup-t1--base.tfm) \
tex(Junicode-BoldItalic-sup-t1.tfm) \
tex(Junicode-BoldItalic-sup-t1.vf) \
tex(Junicode-BoldItalic-sup-t3--base.tfm) \
tex(Junicode-BoldItalic-sup-t3.tfm) \
tex(Junicode-BoldItalic-sup-t3.vf) \
tex(Junicode-BoldItalic-sup-ts3.tfm) \
tex(Junicode-BoldItalic-tlf-ly1.tfm) \
tex(Junicode-BoldItalic-tlf-ot1--base.tfm) \
tex(Junicode-BoldItalic-tlf-ot1.tfm) \
tex(Junicode-BoldItalic-tlf-ot1.vf) \
tex(Junicode-BoldItalic-tlf-swash-ly1--base.tfm) \
tex(Junicode-BoldItalic-tlf-swash-ly1.tfm) \
tex(Junicode-BoldItalic-tlf-swash-ly1.vf) \
tex(Junicode-BoldItalic-tlf-swash-ot1--base.tfm) \
tex(Junicode-BoldItalic-tlf-swash-ot1.tfm) \
tex(Junicode-BoldItalic-tlf-swash-ot1.vf) \
tex(Junicode-BoldItalic-tlf-swash-t1--base.tfm) \
tex(Junicode-BoldItalic-tlf-swash-t1.tfm) \
tex(Junicode-BoldItalic-tlf-swash-t1.vf) \
tex(Junicode-BoldItalic-tlf-swash-t3--base.tfm) \
tex(Junicode-BoldItalic-tlf-swash-t3.tfm) \
tex(Junicode-BoldItalic-tlf-swash-t3.vf) \
tex(Junicode-BoldItalic-tlf-swash-ts3.tfm) \
tex(Junicode-BoldItalic-tlf-t1--base.tfm) \
tex(Junicode-BoldItalic-tlf-t1.tfm) \
tex(Junicode-BoldItalic-tlf-t1.vf) \
tex(Junicode-BoldItalic-tlf-t3--base.tfm) \
tex(Junicode-BoldItalic-tlf-t3.tfm) \
tex(Junicode-BoldItalic-tlf-t3.vf) \
tex(Junicode-BoldItalic-tlf-ts1--base.tfm) \
tex(Junicode-BoldItalic-tlf-ts1.tfm) \
tex(Junicode-BoldItalic-tlf-ts1.vf) \
tex(Junicode-BoldItalic-tlf-ts3.tfm) \
tex(Junicode-BoldItalic-tosf-ly1.tfm) \
tex(Junicode-BoldItalic-tosf-ot1--base.tfm) \
tex(Junicode-BoldItalic-tosf-ot1.tfm) \
tex(Junicode-BoldItalic-tosf-ot1.vf) \
tex(Junicode-BoldItalic-tosf-swash-ly1--base.tfm) \
tex(Junicode-BoldItalic-tosf-swash-ly1.tfm) \
tex(Junicode-BoldItalic-tosf-swash-ly1.vf) \
tex(Junicode-BoldItalic-tosf-swash-ot1--base.tfm) \
tex(Junicode-BoldItalic-tosf-swash-ot1.tfm) \
tex(Junicode-BoldItalic-tosf-swash-ot1.vf) \
tex(Junicode-BoldItalic-tosf-swash-t1--base.tfm) \
tex(Junicode-BoldItalic-tosf-swash-t1.tfm) \
tex(Junicode-BoldItalic-tosf-swash-t1.vf) \
tex(Junicode-BoldItalic-tosf-swash-t3--base.tfm) \
tex(Junicode-BoldItalic-tosf-swash-t3.tfm) \
tex(Junicode-BoldItalic-tosf-swash-t3.vf) \
tex(Junicode-BoldItalic-tosf-swash-ts3.tfm) \
tex(Junicode-BoldItalic-tosf-t1--base.tfm) \
tex(Junicode-BoldItalic-tosf-t1.tfm) \
tex(Junicode-BoldItalic-tosf-t1.vf) \
tex(Junicode-BoldItalic-tosf-t3--base.tfm) \
tex(Junicode-BoldItalic-tosf-t3.tfm) \
tex(Junicode-BoldItalic-tosf-t3.vf) \
tex(Junicode-BoldItalic-tosf-ts1--base.tfm) \
tex(Junicode-BoldItalic-tosf-ts1.tfm) \
tex(Junicode-BoldItalic-tosf-ts1.vf) \
tex(Junicode-BoldItalic-tosf-ts3.tfm) \
tex(Junicode-Italic-inf-ly1.tfm) \
tex(Junicode-Italic-inf-ot1.tfm) \
tex(Junicode-Italic-inf-t1--base.tfm) \
tex(Junicode-Italic-inf-t1.tfm) \
tex(Junicode-Italic-inf-t1.vf) \
tex(Junicode-Italic-inf-t3--base.tfm) \
tex(Junicode-Italic-inf-t3.tfm) \
tex(Junicode-Italic-inf-t3.vf) \
tex(Junicode-Italic-inf-ts3--base.tfm) \
tex(Junicode-Italic-inf-ts3.tfm) \
tex(Junicode-Italic-inf-ts3.vf) \
tex(Junicode-Italic-sup-ly1.tfm) \
tex(Junicode-Italic-sup-ot1.tfm) \
tex(Junicode-Italic-sup-t1--base.tfm) \
tex(Junicode-Italic-sup-t1.tfm) \
tex(Junicode-Italic-sup-t1.vf) \
tex(Junicode-Italic-sup-t3--base.tfm) \
tex(Junicode-Italic-sup-t3.tfm) \
tex(Junicode-Italic-sup-t3.vf) \
tex(Junicode-Italic-sup-ts3--base.tfm) \
tex(Junicode-Italic-sup-ts3.tfm) \
tex(Junicode-Italic-sup-ts3.vf) \
tex(Junicode-Italic-tlf-ly1.tfm) \
tex(Junicode-Italic-tlf-ot1.tfm) \
tex(Junicode-Italic-tlf-sc-ly1--base.tfm) \
tex(Junicode-Italic-tlf-sc-ly1.tfm) \
tex(Junicode-Italic-tlf-sc-ly1.vf) \
tex(Junicode-Italic-tlf-sc-ot1--base.tfm) \
tex(Junicode-Italic-tlf-sc-ot1.tfm) \
tex(Junicode-Italic-tlf-sc-ot1.vf) \
tex(Junicode-Italic-tlf-sc-t1--base.tfm) \
tex(Junicode-Italic-tlf-sc-t1.tfm) \
tex(Junicode-Italic-tlf-sc-t1.vf) \
tex(Junicode-Italic-tlf-sc-t3--base.tfm) \
tex(Junicode-Italic-tlf-sc-t3.tfm) \
tex(Junicode-Italic-tlf-sc-t3.vf) \
tex(Junicode-Italic-tlf-sc-ts3--base.tfm) \
tex(Junicode-Italic-tlf-sc-ts3.tfm) \
tex(Junicode-Italic-tlf-sc-ts3.vf) \
tex(Junicode-Italic-tlf-swash-ly1.tfm) \
tex(Junicode-Italic-tlf-swash-ot1--base.tfm) \
tex(Junicode-Italic-tlf-swash-ot1.tfm) \
tex(Junicode-Italic-tlf-swash-ot1.vf) \
tex(Junicode-Italic-tlf-swash-t1--base.tfm) \
tex(Junicode-Italic-tlf-swash-t1.tfm) \
tex(Junicode-Italic-tlf-swash-t1.vf) \
tex(Junicode-Italic-tlf-swash-t3--base.tfm) \
tex(Junicode-Italic-tlf-swash-t3.tfm) \
tex(Junicode-Italic-tlf-swash-t3.vf) \
tex(Junicode-Italic-tlf-swash-ts3--base.tfm) \
tex(Junicode-Italic-tlf-swash-ts3.tfm) \
tex(Junicode-Italic-tlf-swash-ts3.vf) \
tex(Junicode-Italic-tlf-t1--base.tfm) \
tex(Junicode-Italic-tlf-t1.tfm) \
tex(Junicode-Italic-tlf-t1.vf) \
tex(Junicode-Italic-tlf-t3--base.tfm) \
tex(Junicode-Italic-tlf-t3.tfm) \
tex(Junicode-Italic-tlf-t3.vf) \
tex(Junicode-Italic-tlf-ts1--base.tfm) \
tex(Junicode-Italic-tlf-ts1.tfm) \
tex(Junicode-Italic-tlf-ts1.vf) \
tex(Junicode-Italic-tlf-ts3--base.tfm) \
tex(Junicode-Italic-tlf-ts3.tfm) \
tex(Junicode-Italic-tlf-ts3.vf) \
tex(Junicode-Italic-tosf-ly1.tfm) \
tex(Junicode-Italic-tosf-ot1.tfm) \
tex(Junicode-Italic-tosf-sc-ly1--base.tfm) \
tex(Junicode-Italic-tosf-sc-ly1.tfm) \
tex(Junicode-Italic-tosf-sc-ly1.vf) \
tex(Junicode-Italic-tosf-sc-ot1--base.tfm) \
tex(Junicode-Italic-tosf-sc-ot1.tfm) \
tex(Junicode-Italic-tosf-sc-ot1.vf) \
tex(Junicode-Italic-tosf-sc-t1--base.tfm) \
tex(Junicode-Italic-tosf-sc-t1.tfm) \
tex(Junicode-Italic-tosf-sc-t1.vf) \
tex(Junicode-Italic-tosf-sc-t3--base.tfm) \
tex(Junicode-Italic-tosf-sc-t3.tfm) \
tex(Junicode-Italic-tosf-sc-t3.vf) \
tex(Junicode-Italic-tosf-sc-ts3--base.tfm) \
tex(Junicode-Italic-tosf-sc-ts3.tfm) \
tex(Junicode-Italic-tosf-sc-ts3.vf) \
tex(Junicode-Italic-tosf-swash-ly1.tfm) \
tex(Junicode-Italic-tosf-swash-ot1--base.tfm) \
tex(Junicode-Italic-tosf-swash-ot1.tfm) \
tex(Junicode-Italic-tosf-swash-ot1.vf) \
tex(Junicode-Italic-tosf-swash-t1--base.tfm) \
tex(Junicode-Italic-tosf-swash-t1.tfm) \
tex(Junicode-Italic-tosf-swash-t1.vf) \
tex(Junicode-Italic-tosf-swash-t3--base.tfm) \
tex(Junicode-Italic-tosf-swash-t3.tfm) \
tex(Junicode-Italic-tosf-swash-t3.vf) \
tex(Junicode-Italic-tosf-swash-ts3--base.tfm) \
tex(Junicode-Italic-tosf-swash-ts3.tfm) \
tex(Junicode-Italic-tosf-swash-ts3.vf) \
tex(Junicode-Italic-tosf-t1--base.tfm) \
tex(Junicode-Italic-tosf-t1.tfm) \
tex(Junicode-Italic-tosf-t1.vf) \
tex(Junicode-Italic-tosf-t3--base.tfm) \
tex(Junicode-Italic-tosf-t3.tfm) \
tex(Junicode-Italic-tosf-t3.vf) \
tex(Junicode-Italic-tosf-ts1--base.tfm) \
tex(Junicode-Italic-tosf-ts1.tfm) \
tex(Junicode-Italic-tosf-ts1.vf) \
tex(Junicode-Italic-tosf-ts3--base.tfm) \
tex(Junicode-Italic-tosf-ts3.tfm) \
tex(Junicode-Italic-tosf-ts3.vf) \
tex(Junicode-inf-ly1.tfm) \
tex(Junicode-inf-ot1.tfm) \
tex(Junicode-inf-t1--base.tfm) \
tex(Junicode-inf-t1.tfm) \
tex(Junicode-inf-t1.vf) \
tex(Junicode-inf-t3--base.tfm) \
tex(Junicode-inf-t3.tfm) \
tex(Junicode-inf-t3.vf) \
tex(Junicode-inf-ts3--base.tfm) \
tex(Junicode-inf-ts3.tfm) \
tex(Junicode-inf-ts3.vf) \
tex(Junicode-sup-ly1.tfm) \
tex(Junicode-sup-ot1.tfm) \
tex(Junicode-sup-t1--base.tfm) \
tex(Junicode-sup-t1.tfm) \
tex(Junicode-sup-t1.vf) \
tex(Junicode-sup-t3--base.tfm) \
tex(Junicode-sup-t3.tfm) \
tex(Junicode-sup-t3.vf) \
tex(Junicode-sup-ts3--base.tfm) \
tex(Junicode-sup-ts3.tfm) \
tex(Junicode-sup-ts3.vf) \
tex(Junicode-tlf-ly1.tfm) \
tex(Junicode-tlf-ot1.tfm) \
tex(Junicode-tlf-sc-ly1--base.tfm) \
tex(Junicode-tlf-sc-ly1.tfm) \
tex(Junicode-tlf-sc-ly1.vf) \
tex(Junicode-tlf-sc-ot1--base.tfm) \
tex(Junicode-tlf-sc-ot1.tfm) \
tex(Junicode-tlf-sc-ot1.vf) \
tex(Junicode-tlf-sc-t1--base.tfm) \
tex(Junicode-tlf-sc-t1.tfm) \
tex(Junicode-tlf-sc-t1.vf) \
tex(Junicode-tlf-sc-t3--base.tfm) \
tex(Junicode-tlf-sc-t3.tfm) \
tex(Junicode-tlf-sc-t3.vf) \
tex(Junicode-tlf-sc-ts3--base.tfm) \
tex(Junicode-tlf-sc-ts3.tfm) \
tex(Junicode-tlf-sc-ts3.vf) \
tex(Junicode-tlf-swash-ly1.tfm) \
tex(Junicode-tlf-swash-ot1--base.tfm) \
tex(Junicode-tlf-swash-ot1.tfm) \
tex(Junicode-tlf-swash-ot1.vf) \
tex(Junicode-tlf-swash-t1--base.tfm) \
tex(Junicode-tlf-swash-t1.tfm) \
tex(Junicode-tlf-swash-t1.vf) \
tex(Junicode-tlf-swash-t3--base.tfm) \
tex(Junicode-tlf-swash-t3.tfm) \
tex(Junicode-tlf-swash-t3.vf) \
tex(Junicode-tlf-swash-ts3--base.tfm) \
tex(Junicode-tlf-swash-ts3.tfm) \
tex(Junicode-tlf-swash-ts3.vf) \
tex(Junicode-tlf-t1--base.tfm) \
tex(Junicode-tlf-t1.tfm) \
tex(Junicode-tlf-t1.vf) \
tex(Junicode-tlf-t3--base.tfm) \
tex(Junicode-tlf-t3.tfm) \
tex(Junicode-tlf-t3.vf) \
tex(Junicode-tlf-ts1--base.tfm) \
tex(Junicode-tlf-ts1.tfm) \
tex(Junicode-tlf-ts1.vf) \
tex(Junicode-tlf-ts3--base.tfm) \
tex(Junicode-tlf-ts3.tfm) \
tex(Junicode-tlf-ts3.vf) \
tex(Junicode-tosf-ly1.tfm) \
tex(Junicode-tosf-ot1.tfm) \
tex(Junicode-tosf-sc-ly1--base.tfm) \
tex(Junicode-tosf-sc-ly1.tfm) \
tex(Junicode-tosf-sc-ly1.vf) \
tex(Junicode-tosf-sc-ot1--base.tfm) \
tex(Junicode-tosf-sc-ot1.tfm) \
tex(Junicode-tosf-sc-ot1.vf) \
tex(Junicode-tosf-sc-t1--base.tfm) \
tex(Junicode-tosf-sc-t1.tfm) \
tex(Junicode-tosf-sc-t1.vf) \
tex(Junicode-tosf-sc-t3--base.tfm) \
tex(Junicode-tosf-sc-t3.tfm) \
tex(Junicode-tosf-sc-t3.vf) \
tex(Junicode-tosf-sc-ts3--base.tfm) \
tex(Junicode-tosf-sc-ts3.tfm) \
tex(Junicode-tosf-sc-ts3.vf) \
tex(Junicode-tosf-swash-ly1.tfm) \
tex(Junicode-tosf-swash-ot1--base.tfm) \
tex(Junicode-tosf-swash-ot1.tfm) \
tex(Junicode-tosf-swash-ot1.vf) \
tex(Junicode-tosf-swash-t1--base.tfm) \
tex(Junicode-tosf-swash-t1.tfm) \
tex(Junicode-tosf-swash-t1.vf) \
tex(Junicode-tosf-swash-t3--base.tfm) \
tex(Junicode-tosf-swash-t3.tfm) \
tex(Junicode-tosf-swash-t3.vf) \
tex(Junicode-tosf-swash-ts3--base.tfm) \
tex(Junicode-tosf-swash-ts3.tfm) \
tex(Junicode-tosf-swash-ts3.vf) \
tex(Junicode-tosf-t1--base.tfm) \
tex(Junicode-tosf-t1.tfm) \
tex(Junicode-tosf-t1.vf) \
tex(Junicode-tosf-t3--base.tfm) \
tex(Junicode-tosf-t3.tfm) \
tex(Junicode-tosf-t3.vf) \
tex(Junicode-tosf-ts1--base.tfm) \
tex(Junicode-tosf-ts1.tfm) \
tex(Junicode-tosf-ts1.vf) \
tex(Junicode-tosf-ts3--base.tfm) \
tex(Junicode-tosf-ts3.tfm) \
tex(Junicode-tosf-ts3.vf) \
tex(Junicode.map) \
tex(LY1Junicode-Inf.fd) \
tex(LY1Junicode-Sup.fd) \
tex(LY1Junicode-TLF.fd) \
tex(LY1Junicode-TOsF.fd) \
tex(OT1Junicode-Inf.fd) \
tex(OT1Junicode-Sup.fd) \
tex(OT1Junicode-TLF.fd) \
tex(OT1Junicode-TOsF.fd) \
tex(T1Junicode-Inf.fd) \
tex(T1Junicode-Sup.fd) \
tex(T1Junicode-TLF.fd) \
tex(T1Junicode-TOsF.fd) \
tex(T3Junicode-Inf.fd) \
tex(T3Junicode-Sup.fd) \
tex(T3Junicode-TLF.fd) \
tex(T3Junicode-TOsF.fd) \
tex(TS1Junicode-TLF.fd) \
tex(TS1Junicode-TOsF.fd) \
tex(TS3Junicode-Inf.fd) \
tex(TS3Junicode-Sup.fd) \
tex(TS3Junicode-TLF.fd) \
tex(TS3Junicode-TOsF.fd) \
tex(a_2bpv3m.enc) \
tex(a_2mm3c2.enc) \
tex(a_2p6ois.enc) \
tex(a_2sfipb.enc) \
tex(a_3lniep.enc) \
tex(a_3oiwi3.enc) \
tex(a_3volwp.enc) \
tex(a_3xz3h2.enc) \
tex(a_4n6crv.enc) \
tex(a_4wispq.enc) \
tex(a_4ycye2.enc) \
tex(a_5swlfy.enc) \
tex(a_6u5uu4.enc) \
tex(a_7ds3wq.enc) \
tex(a_b5lvdl.enc) \
tex(a_b5zcir.enc) \
tex(a_bt27yq.enc) \
tex(a_buzzjq.enc) \
tex(a_bxn3t2.enc) \
tex(a_c3r5id.enc) \
tex(a_ciujvo.enc) \
tex(a_czanfn.enc) \
tex(a_daqx6o.enc) \
tex(a_ddgo45.enc) \
tex(a_dh7eks.enc) \
tex(a_dsxmxh.enc) \
tex(a_e224kq.enc) \
tex(a_e24h5d.enc) \
tex(a_eegkrc.enc) \
tex(a_egdeql.enc) \
tex(a_equvmx.enc) \
tex(a_ewwy5y.enc) \
tex(a_eyvcqg.enc) \
tex(a_fb4xbs.enc) \
tex(a_fsg22v.enc) \
tex(a_ghwqhd.enc) \
tex(a_gus7sm.enc) \
tex(a_h747e4.enc) \
tex(a_hlkg6v.enc) \
tex(a_hzunuz.enc) \
tex(a_iahbda.enc) \
tex(a_iapetj.enc) \
tex(a_iqg3f5.enc) \
tex(a_jddr6t.enc) \
tex(a_jg27fn.enc) \
tex(a_jjpsim.enc) \
tex(a_jtxgor.enc) \
tex(a_l3mb37.enc) \
tex(a_leirnf.enc) \
tex(a_lzmc63.enc) \
tex(a_m5vvpo.enc) \
tex(a_msm5ja.enc) \
tex(a_myi6mz.enc) \
tex(a_n574it.enc) \
tex(a_n5rwri.enc) \
tex(a_ncdqoi.enc) \
tex(a_nfgurc.enc) \
tex(a_ng574l.enc) \
tex(a_nxovao.enc) \
tex(a_ocfo6w.enc) \
tex(a_ofg65e.enc) \
tex(a_ovuqp7.enc) \
tex(a_oyqcvc.enc) \
tex(a_oz2voy.enc) \
tex(a_p42lhv.enc) \
tex(a_pjlm4h.enc) \
tex(a_pyi5bn.enc) \
tex(a_q5oomy.enc) \
tex(a_qojq43.enc) \
tex(a_qrnvns.enc) \
tex(a_r5vqsy.enc) \
tex(a_re7epd.enc) \
tex(a_reswd7.enc) \
tex(a_riy3vj.enc) \
tex(a_rld3th.enc) \
tex(a_rq7kaz.enc) \
tex(a_rufiuz.enc) \
tex(a_senygh.enc) \
tex(a_skkj5j.enc) \
tex(a_tgx5t5.enc) \
tex(a_ud6k5n.enc) \
tex(a_ue6kia.enc) \
tex(a_uqrabr.enc) \
tex(a_uteiqb.enc) \
tex(a_uui4bo.enc) \
tex(a_vd2fo2.enc) \
tex(a_w3oimd.enc) \
tex(a_wqhzsa.enc) \
tex(a_x5gcu6.enc) \
tex(a_xafpoq.enc) \
tex(a_xzdxuw.enc) \
tex(a_yabl64.enc) \
tex(a_yt7kgf.enc) \
tex(a_z2b6ll.enc) \
tex(a_zbjpie.enc) \
tex(a_zw22co.enc) \
tex(a_zyf2d6.enc) \
tex(junicode.sty) \
tex(mt-Junicode.cfg) \
texlive-junicode"
RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex(fontaxes.sty) \
tex(mweights.sty) \
tex(textcomp.sty) \
tex(updmap.cfg) \
tex(xkeyval.sty) \
texlive \
texlive-filesystem \
texlive-junicode-fonts \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
