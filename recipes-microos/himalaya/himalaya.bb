SUMMARY = "Command-line interface for email management"
DESCRIPTION = "Command-line interface for email management."
LICENSE = "MIT"

PV = "0.7.3~0"

RPM_NAME = "himalaya-0.7.3~0-1.1.aarch64.rpm"
RPM_HASH = "66a01b34c6a28003b557f922b5aa366561b6000cbc9766d6d4406084ff64538e5a5e889e0338ba69c50b3326eba051557f406dfbfca6484a615cc474edf99fb0"

RPROVIDES:${PN} += "bundled(rust-crate:Inflector) \
bundled(rust-crate:ahash) \
bundled(rust-crate:aho-corasick) \
bundled(rust-crate:aliasable) \
bundled(rust-crate:ammonia) \
bundled(rust-crate:anstream) \
bundled(rust-crate:anstyle) \
bundled(rust-crate:anstyle-parse) \
bundled(rust-crate:anstyle-query) \
bundled(rust-crate:anyhow) \
bundled(rust-crate:atty) \
bundled(rust-crate:autocfg) \
bundled(rust-crate:base64) \
bundled(rust-crate:bitflags) \
bundled(rust-crate:bufstream) \
bundled(rust-crate:cc) \
bundled(rust-crate:cfg-if) \
bundled(rust-crate:charset) \
bundled(rust-crate:chrono) \
bundled(rust-crate:chumsky) \
bundled(rust-crate:clap) \
bundled(rust-crate:clap_builder) \
bundled(rust-crate:clap_complete) \
bundled(rust-crate:clap_lex) \
bundled(rust-crate:clap_mangen) \
bundled(rust-crate:colorchoice) \
bundled(rust-crate:console) \
bundled(rust-crate:const-random) \
bundled(rust-crate:const-random-macro) \
bundled(rust-crate:convert_case) \
bundled(rust-crate:crossbeam-channel) \
bundled(rust-crate:crossbeam-deque) \
bundled(rust-crate:crossbeam-epoch) \
bundled(rust-crate:crossbeam-utils) \
bundled(rust-crate:crunchy) \
bundled(rust-crate:darling) \
bundled(rust-crate:darling_core) \
bundled(rust-crate:darling_macro) \
bundled(rust-crate:data-encoding) \
bundled(rust-crate:dialoguer) \
bundled(rust-crate:dirs) \
bundled(rust-crate:dirs-sys) \
bundled(rust-crate:either) \
bundled(rust-crate:email-encoding) \
bundled(rust-crate:email_address) \
bundled(rust-crate:encoding_rs) \
bundled(rust-crate:env_logger) \
bundled(rust-crate:erased-serde) \
bundled(rust-crate:fallible-iterator) \
bundled(rust-crate:fallible-streaming-iterator) \
bundled(rust-crate:fastrand) \
bundled(rust-crate:fixedbitset) \
bundled(rust-crate:fnv) \
bundled(rust-crate:form_urlencoded) \
bundled(rust-crate:fs2) \
bundled(rust-crate:futf) \
bundled(rust-crate:futures-core) \
bundled(rust-crate:futures-io) \
bundled(rust-crate:futures-task) \
bundled(rust-crate:futures-util) \
bundled(rust-crate:gethostname) \
bundled(rust-crate:getrandom) \
bundled(rust-crate:hashbrown) \
bundled(rust-crate:hashlink) \
bundled(rust-crate:himalaya) \
bundled(rust-crate:hostname) \
bundled(rust-crate:html-escape) \
bundled(rust-crate:html5ever) \
bundled(rust-crate:httpdate) \
bundled(rust-crate:humantime) \
bundled(rust-crate:iana-time-zone) \
bundled(rust-crate:ident_case) \
bundled(rust-crate:idna) \
bundled(rust-crate:imap) \
bundled(rust-crate:imap-proto) \
bundled(rust-crate:indexmap) \
bundled(rust-crate:indicatif) \
bundled(rust-crate:io-lifetimes) \
bundled(rust-crate:is-terminal) \
bundled(rust-crate:itoa) \
bundled(rust-crate:lazy_static) \
bundled(rust-crate:lettre) \
bundled(rust-crate:libc) \
bundled(rust-crate:libsqlite3-sys) \
bundled(rust-crate:linux-raw-sys) \
bundled(rust-crate:lock_api) \
bundled(rust-crate:log) \
bundled(rust-crate:mac) \
bundled(rust-crate:mail-parser) \
bundled(rust-crate:maildir) \
bundled(rust-crate:mailparse) \
bundled(rust-crate:maplit) \
bundled(rust-crate:markup5ever) \
bundled(rust-crate:match_cfg) \
bundled(rust-crate:md5) \
bundled(rust-crate:memchr) \
bundled(rust-crate:memmap2) \
bundled(rust-crate:memoffset) \
bundled(rust-crate:mime) \
bundled(rust-crate:mime-msg-builder) \
bundled(rust-crate:minimal-lexical) \
bundled(rust-crate:mio) \
bundled(rust-crate:new_debug_unreachable) \
bundled(rust-crate:nom) \
bundled(rust-crate:num-integer) \
bundled(rust-crate:num-traits) \
bundled(rust-crate:num_cpus) \
bundled(rust-crate:number_prefix) \
bundled(rust-crate:once_cell) \
bundled(rust-crate:openssl-probe) \
bundled(rust-crate:ouroboros) \
bundled(rust-crate:ouroboros_macro) \
bundled(rust-crate:parking_lot) \
bundled(rust-crate:parking_lot_core) \
bundled(rust-crate:percent-encoding) \
bundled(rust-crate:petgraph) \
bundled(rust-crate:phf) \
bundled(rust-crate:phf_codegen) \
bundled(rust-crate:phf_generator) \
bundled(rust-crate:phf_shared) \
bundled(rust-crate:pimalaya-email) \
bundled(rust-crate:pin-project-lite) \
bundled(rust-crate:pin-utils) \
bundled(rust-crate:pkg-config) \
bundled(rust-crate:portable-atomic) \
bundled(rust-crate:ppv-lite86) \
bundled(rust-crate:precomputed-hash) \
bundled(rust-crate:proc-lock) \
bundled(rust-crate:proc-lock-api) \
bundled(rust-crate:proc-lock-macro) \
bundled(rust-crate:proc-macro-error) \
bundled(rust-crate:proc-macro-error-attr) \
bundled(rust-crate:proc-macro-hack) \
bundled(rust-crate:proc-macro2) \
bundled(rust-crate:psm) \
bundled(rust-crate:quote) \
bundled(rust-crate:quoted_printable) \
bundled(rust-crate:rand) \
bundled(rust-crate:rand_chacha) \
bundled(rust-crate:rand_core) \
bundled(rust-crate:rayon) \
bundled(rust-crate:rayon-core) \
bundled(rust-crate:regex) \
bundled(rust-crate:regex-syntax) \
bundled(rust-crate:rfc2047-decoder) \
bundled(rust-crate:ring) \
bundled(rust-crate:roff) \
bundled(rust-crate:rusqlite) \
bundled(rust-crate:rustix) \
bundled(rust-crate:rustls) \
bundled(rust-crate:rustls-connector) \
bundled(rust-crate:rustls-native-certs) \
bundled(rust-crate:rustls-pemfile) \
bundled(rust-crate:ryu) \
bundled(rust-crate:scopeguard) \
bundled(rust-crate:sct) \
bundled(rust-crate:serde) \
bundled(rust-crate:serde_derive) \
bundled(rust-crate:serde_json) \
bundled(rust-crate:serde_spanned) \
bundled(rust-crate:shell-words) \
bundled(rust-crate:shellexpand) \
bundled(rust-crate:siphasher) \
bundled(rust-crate:slab) \
bundled(rust-crate:smallvec) \
bundled(rust-crate:socket2) \
bundled(rust-crate:spin) \
bundled(rust-crate:stacker) \
bundled(rust-crate:string_cache) \
bundled(rust-crate:string_cache_codegen) \
bundled(rust-crate:strsim) \
bundled(rust-crate:syn) \
bundled(rust-crate:tempfile) \
bundled(rust-crate:tendril) \
bundled(rust-crate:termcolor) \
bundled(rust-crate:terminal_size) \
bundled(rust-crate:thiserror) \
bundled(rust-crate:thiserror-impl) \
bundled(rust-crate:time) \
bundled(rust-crate:tiny-keccak) \
bundled(rust-crate:tinyvec) \
bundled(rust-crate:tinyvec_macros) \
bundled(rust-crate:tokio) \
bundled(rust-crate:toml) \
bundled(rust-crate:toml_datetime) \
bundled(rust-crate:toml_edit) \
bundled(rust-crate:tree_magic) \
bundled(rust-crate:unicode-bidi) \
bundled(rust-crate:unicode-ident) \
bundled(rust-crate:unicode-normalization) \
bundled(rust-crate:unicode-width) \
bundled(rust-crate:untrusted) \
bundled(rust-crate:url) \
bundled(rust-crate:urlencoding) \
bundled(rust-crate:utf-8) \
bundled(rust-crate:utf7-imap) \
bundled(rust-crate:utf8-width) \
bundled(rust-crate:utf8parse) \
bundled(rust-crate:uuid) \
bundled(rust-crate:vcpkg) \
bundled(rust-crate:version_check) \
bundled(rust-crate:webpki) \
bundled(rust-crate:webpki-roots) \
bundled(rust-crate:winnow) \
bundled(rust-crate:zeroize) \
himalaya \
himalaya(aarch-64)"
RDEPENDS:${PN} += "ld-linux-aarch64.so.1()(64bit) \
ld-linux-aarch64.so.1(GLIBC_2.17)(64bit) \
libc.so.6(GLIBC_2.34)(64bit) \
libgcc_s.so.1()(64bit) \
libgcc_s.so.1(GCC_3.0)(64bit) \
libgcc_s.so.1(GCC_3.3)(64bit) \
libgcc_s.so.1(GCC_4.2.0)(64bit) \
libm.so.6()(64bit) \
libm.so.6(GLIBC_2.17)(64bit) \
libm.so.6(GLIBC_2.29)(64bit)"

inherit rpm
