SUMMARY = "Integrated Development Environment targeting Qt apps"
DESCRIPTION = "Qt Creator is an integrated development environment (IDE) designed to \
facilitate development with the Qt application framework."
LICENSE = "BSD-3-Clause & GPL-3.0-only & GPL-3.0-with-Qt-Company-Qt-exception-1.1 & (LGPL-2.1-only | LGPL-3.0-only) & LGPL-3.0-only"

PV = "10.0.1"

RPM_NAME = "qt6-creator-10.0.1-2.2.aarch64.rpm"
RPM_HASH = "5226179481621f64ede7dad8f6e84f1eb3b57f0de6be3b73e198060f34f4a07192fc67258415162d2fed0d278934ebdbaa6e932cf2c05b50152a73984b04da69"

RPROVIDES:${PN} += "application() \
application(org.qt-project.qtcreator.desktop) \
libAdvancedDockingSystem.so.10()(64bit) \
libAggregation.so.10()(64bit) \
libAndroid.so()(64bit) \
libAutoTest.so()(64bit) \
libAutotoolsProjectManager.so()(64bit) \
libBareMetal.so()(64bit) \
libBazaar.so()(64bit) \
libBeautifier.so()(64bit) \
libBinEditor.so()(64bit) \
libBookmarks.so()(64bit) \
libBoot2Qt.so()(64bit) \
libCMakeProjectManager.so()(64bit) \
libCPlusPlus.so.10()(64bit) \
libCVS.so()(64bit) \
libClangCodeModel.so()(64bit) \
libClangTools.so()(64bit) \
libClassView.so()(64bit) \
libClearCase.so()(64bit) \
libCoco.so()(64bit) \
libCodePaster.so()(64bit) \
libCompilationDatabaseProjectManager.so()(64bit) \
libConan.so()(64bit) \
libCore.so()(64bit) \
libCppEditor.so()(64bit) \
libCppcheck.so()(64bit) \
libCtfVisualizer.so()(64bit) \
libDebugger.so()(64bit) \
libDesigner.so()(64bit) \
libDiffEditor.so()(64bit) \
libDocker.so()(64bit) \
libEmacsKeys.so()(64bit) \
libExtensionSystem.so.10()(64bit) \
libFakeVim.so()(64bit) \
libFossil.so()(64bit) \
libGLSL.so.10()(64bit) \
libGLSLEditor.so()(64bit) \
libGenericProjectManager.so()(64bit) \
libGit.so()(64bit) \
libGitLab.so()(64bit) \
libHaskell.so()(64bit) \
libHelloWorld.so()(64bit) \
libHelp.so()(64bit) \
libImageViewer.so()(64bit) \
libIncrediBuild.so()(64bit) \
libIos.so()(64bit) \
libKSyntaxHighlighting.so.10()(64bit) \
libLanguageClient.so()(64bit) \
libLanguageServerProtocol.so.10()(64bit) \
libLanguageUtils.so.10()(64bit) \
libMacros.so()(64bit) \
libMarketplace.so()(64bit) \
libMcuSupport.so()(64bit) \
libMercurial.so()(64bit) \
libMesonProjectManager.so()(64bit) \
libModelEditor.so()(64bit) \
libModeling.so.10()(64bit) \
libNim.so()(64bit) \
libPerfProfiler.so()(64bit) \
libPerforce.so()(64bit) \
libProParser.so.10()(64bit) \
libProjectExplorer.so()(64bit) \
libPython.so()(64bit) \
libQbsProjectManager.so()(64bit) \
libQmakeProjectManager.so()(64bit) \
libQmlDebug.so.10()(64bit) \
libQmlDesigner.so()(64bit) \
libQmlEditorWidgets.so.10()(64bit) \
libQmlJS.so.10()(64bit) \
libQmlJSEditor.so()(64bit) \
libQmlJSTools.so()(64bit) \
libQmlPreview.so()(64bit) \
libQmlProfiler.so()(64bit) \
libQmlProjectManager.so()(64bit) \
libQnx.so()(64bit) \
libQtSupport.so()(64bit) \
libRemoteLinux.so()(64bit) \
libResourceEditor.so()(64bit) \
libSafeRenderer.so()(64bit) \
libScxmlEditor.so()(64bit) \
libSerialTerminal.so()(64bit) \
libSilverSearcher.so()(64bit) \
libSqlite.so.10()(64bit) \
libSquish.so()(64bit) \
libStudioPlugin.so()(64bit) \
libStudioWelcome.so()(64bit) \
libSubversion.so()(64bit) \
libTextEditor.so()(64bit) \
libTodo.so()(64bit) \
libTracing.so.10()(64bit) \
libUtils.so.10()(64bit) \
libValgrind.so()(64bit) \
libVcsBase.so()(64bit) \
libWebAssembly.so()(64bit) \
libWelcome.so()(64bit) \
libassetexporterplugin.so()(64bit) \
libcomponentsplugin.so()(64bit) \
libqlitehtml.so.10()(64bit) \
libqmlpreviewplugin.so()(64bit) \
libqt5-creator \
libqtquickplugin.so()(64bit) \
metainfo() \
metainfo(org.qt-project.qtcreator.appdata.xml) \
mimehandler(application/vnd.qt.qmakeprofile) \
mimehandler(application/vnd.qt.xml.resource) \
mimehandler(application/x-designer) \
mimehandler(text/x-c++hdr) \
mimehandler(text/x-c++src) \
mimehandler(text/x-xsrc) \
qt5-creator \
qt6-creator \
qt6-creator(aarch-64)"
RDEPENDS:${PN} += "/sbin/ldconfig \
hicolor-icon-theme \
ld-linux-aarch64.so.1()(64bit) \
ld-linux-aarch64.so.1(GLIBC_2.17)(64bit) \
libQt6Concurrent.so.6()(64bit) \
libQt6Concurrent.so.6(Qt_6)(64bit) \
libQt6Core.so.6()(64bit) \
libQt6Core.so.6(Qt_6)(64bit) \
libQt6Core.so.6(Qt_6.5)(64bit) \
libQt6Core.so.6(Qt_6.5.1_PRIVATE_API)(64bit) \
libQt6Core5Compat.so.6()(64bit) \
libQt6Core5Compat.so.6(Qt_6)(64bit) \
libQt6Designer.so.6()(64bit) \
libQt6Designer.so.6(Qt_6)(64bit) \
libQt6DesignerComponents.so.6()(64bit) \
libQt6DesignerComponents.so.6(Qt_6)(64bit) \
libQt6Gui.so.6()(64bit) \
libQt6Gui.so.6(Qt_6)(64bit) \
libQt6Gui.so.6(Qt_6.5.1_PRIVATE_API)(64bit) \
libQt6Help.so.6()(64bit) \
libQt6Help.so.6(Qt_6)(64bit) \
libQt6Network.so.6()(64bit) \
libQt6Network.so.6(Qt_6)(64bit) \
libQt6PrintSupport.so.6()(64bit) \
libQt6PrintSupport.so.6(Qt_6)(64bit) \
libQt6Qml.so.6()(64bit) \
libQt6Qml.so.6(Qt_6)(64bit) \
libQt6Qml.so.6(Qt_6.5.1_PRIVATE_API)(64bit) \
libQt6Quick.so.6()(64bit) \
libQt6Quick.so.6(Qt_6)(64bit) \
libQt6Quick.so.6(Qt_6.5.1_PRIVATE_API)(64bit) \
libQt6Quick3D.so.6()(64bit) \
libQt6Quick3D.so.6(Qt_6)(64bit) \
libQt6Quick3D.so.6(Qt_6.5.1_PRIVATE_API)(64bit) \
libQt6Quick3DAssetImport.so.6()(64bit) \
libQt6Quick3DAssetImport.so.6(Qt_6.5.1_PRIVATE_API)(64bit) \
libQt6Quick3DAssetUtils.so.6()(64bit) \
libQt6Quick3DAssetUtils.so.6(Qt_6.5.1_PRIVATE_API)(64bit) \
libQt6Quick3DParticles.so.6()(64bit) \
libQt6Quick3DParticles.so.6(Qt_6.5.1_PRIVATE_API)(64bit) \
libQt6Quick3DRuntimeRender.so.6()(64bit) \
libQt6Quick3DRuntimeRender.so.6(Qt_6.5.1_PRIVATE_API)(64bit) \
libQt6Quick3DUtils.so.6()(64bit) \
libQt6Quick3DUtils.so.6(Qt_6)(64bit) \
libQt6QuickWidgets.so.6()(64bit) \
libQt6QuickWidgets.so.6(Qt_6)(64bit) \
libQt6SerialPort.so.6()(64bit) \
libQt6SerialPort.so.6(Qt_6)(64bit) \
libQt6Sql.so.6()(64bit) \
libQt6Sql.so.6(Qt_6)(64bit) \
libQt6Svg.so.6()(64bit) \
libQt6Svg.so.6(Qt_6)(64bit) \
libQt6SvgWidgets.so.6()(64bit) \
libQt6SvgWidgets.so.6(Qt_6)(64bit) \
libQt6Widgets.so.6()(64bit) \
libQt6Widgets.so.6(Qt_6)(64bit) \
libQt6Xml.so.6()(64bit) \
libQt6Xml.so.6(Qt_6)(64bit) \
libc.so.6(GLIBC_2.34)(64bit) \
libdw.so.1()(64bit) \
libdw.so.1(ELFUTILS_0.122)(64bit) \
libdw.so.1(ELFUTILS_0.127)(64bit) \
libdw.so.1(ELFUTILS_0.130)(64bit) \
libdw.so.1(ELFUTILS_0.143)(64bit) \
libdw.so.1(ELFUTILS_0.156)(64bit) \
libdw.so.1(ELFUTILS_0.158)(64bit) \
libelf.so.1()(64bit) \
libelf.so.1(ELFUTILS_1.0)(64bit) \
libelf.so.1(ELFUTILS_1.5)(64bit) \
libgcc_s.so.1()(64bit) \
libgcc_s.so.1(GCC_3.0)(64bit) \
libm.so.6()(64bit) \
libm.so.6(GLIBC_2.17)(64bit) \
libm.so.6(GLIBC_2.27)(64bit) \
libm.so.6(GLIBC_2.29)(64bit) \
libm.so.6(GLIBC_2.35)(64bit) \
libstdc++.so.6()(64bit) \
libstdc++.so.6(CXXABI_1.3)(64bit) \
libstdc++.so.6(CXXABI_1.3.13)(64bit) \
libstdc++.so.6(CXXABI_1.3.2)(64bit) \
libstdc++.so.6(CXXABI_1.3.3)(64bit) \
libstdc++.so.6(CXXABI_1.3.5)(64bit) \
libstdc++.so.6(CXXABI_1.3.8)(64bit) \
libstdc++.so.6(CXXABI_1.3.9)(64bit) \
libstdc++.so.6(GLIBCXX_3.4)(64bit) \
libstdc++.so.6(GLIBCXX_3.4.11)(64bit) \
libstdc++.so.6(GLIBCXX_3.4.14)(64bit) \
libstdc++.so.6(GLIBCXX_3.4.15)(64bit) \
libstdc++.so.6(GLIBCXX_3.4.18)(64bit) \
libstdc++.so.6(GLIBCXX_3.4.19)(64bit) \
libstdc++.so.6(GLIBCXX_3.4.20)(64bit) \
libstdc++.so.6(GLIBCXX_3.4.21)(64bit) \
libstdc++.so.6(GLIBCXX_3.4.22)(64bit) \
libstdc++.so.6(GLIBCXX_3.4.26)(64bit) \
libstdc++.so.6(GLIBCXX_3.4.29)(64bit) \
libstdc++.so.6(GLIBCXX_3.4.30)(64bit) \
libstdc++.so.6(GLIBCXX_3.4.32)(64bit) \
libstdc++.so.6(GLIBCXX_3.4.9)(64bit) \
libyaml-cpp.so.0.7()(64bit) \
libzstd.so.1()(64bit) \
qt6-sql-sqlite"

inherit rpm
