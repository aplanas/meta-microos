SUMMARY = "Representation of Python source as an AST for pylint"
DESCRIPTION = "This module provides a common base representation of Python source code for \
projects such as pychecker, pyreverse, pylint. The development of this library \
is governed by pylint's needs. \
 \
It provides a compatible representation which comes from the _ast \
module. It rebuilds the tree generated by the builtin _ast module by \
recursively walking down the AST and building an extended ast. The new \
node classes have additional methods and attributes for different \
usages. They include some support for static inference and local name \
scopes. Furthermore, astroid builds partial trees by inspecting living \
objects."
LICENSE = "LGPL-2.1-or-later"

PV = "2.15.4"

RPM_NAME = "python39-astroid-2.15.4-2.1.noarch.rpm"
RPM_HASH = "cf3db2c45ce8925499ca63a8d181eb3b5a8793b1cb50efd7ba78eff8b3ab91bd56ec6f7fa15592abbc7e35f1dc98607884624e88864642ee9df4712cde376449"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "python3.9dist(astroid) python39-astroid python3dist(astroid)"
RDEPENDS:${PN} += "python(abi) python39-lazy-object-proxy python39-typing-extensions python39-wrapt"

inherit rpm
