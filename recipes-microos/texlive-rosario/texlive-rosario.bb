SUMMARY = "Using the free Rosario fonts with LaTeX"
DESCRIPTION = "The package provides the files required to use the Rosario \
fonts with LaTeX. Rosario is a set of four fonts provided by \
Hector Gatti, Adobe Typekit & Omnibus-Type Team under the Open \
Font License (OFL), version 1.1. The fonts are copyright (c) \
2012-2015, Omnibus-Type."
LICENSE = "LPPL-1.0"

PV = "2023.201.2.1svn51688"

RPM_NAME = "texlive-rosario-2023.201.2.1svn51688-53.1.noarch.rpm"
RPM_HASH = "b058c682a3ad0d80130e0e1605aa81e5f6f69501b4bc969efb4dc78e98d5885b065da4c77f62a97dc967555333dde0cbbee11e95f602e8364f4cd111ae44b775"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex(LY1Rosario-Dnom.fd) \
tex(LY1Rosario-Inf.fd) \
tex(LY1Rosario-LF.fd) \
tex(LY1Rosario-Numr.fd) \
tex(LY1Rosario-OsF.fd) \
tex(LY1Rosario-Sup.fd) \
tex(LY1Rosario-TLF.fd) \
tex(LY1Rosario-TOsF.fd) \
tex(OT1Rosario-Dnom.fd) \
tex(OT1Rosario-Inf.fd) \
tex(OT1Rosario-LF.fd) \
tex(OT1Rosario-Numr.fd) \
tex(OT1Rosario-OsF.fd) \
tex(OT1Rosario-Sup.fd) \
tex(OT1Rosario-TLF.fd) \
tex(OT1Rosario-TOsF.fd) \
tex(Rosario-Bold-dnom-ly1--base.tfm) \
tex(Rosario-Bold-dnom-ly1.tfm) \
tex(Rosario-Bold-dnom-ly1.vf) \
tex(Rosario-Bold-dnom-ot1.tfm) \
tex(Rosario-Bold-dnom-t1--base.tfm) \
tex(Rosario-Bold-dnom-t1.tfm) \
tex(Rosario-Bold-dnom-t1.vf) \
tex(Rosario-Bold-inf-ly1--base.tfm) \
tex(Rosario-Bold-inf-ly1.tfm) \
tex(Rosario-Bold-inf-ly1.vf) \
tex(Rosario-Bold-inf-ot1.tfm) \
tex(Rosario-Bold-inf-t1--base.tfm) \
tex(Rosario-Bold-inf-t1.tfm) \
tex(Rosario-Bold-inf-t1.vf) \
tex(Rosario-Bold-lf-ly1--base.tfm) \
tex(Rosario-Bold-lf-ly1.tfm) \
tex(Rosario-Bold-lf-ly1.vf) \
tex(Rosario-Bold-lf-ot1.tfm) \
tex(Rosario-Bold-lf-t1--base.tfm) \
tex(Rosario-Bold-lf-t1.tfm) \
tex(Rosario-Bold-lf-t1.vf) \
tex(Rosario-Bold-lf-ts1--base.tfm) \
tex(Rosario-Bold-lf-ts1.tfm) \
tex(Rosario-Bold-lf-ts1.vf) \
tex(Rosario-Bold-numr-ly1--base.tfm) \
tex(Rosario-Bold-numr-ly1.tfm) \
tex(Rosario-Bold-numr-ly1.vf) \
tex(Rosario-Bold-numr-ot1.tfm) \
tex(Rosario-Bold-numr-t1--base.tfm) \
tex(Rosario-Bold-numr-t1.tfm) \
tex(Rosario-Bold-numr-t1.vf) \
tex(Rosario-Bold-osf-ly1--base.tfm) \
tex(Rosario-Bold-osf-ly1.tfm) \
tex(Rosario-Bold-osf-ly1.vf) \
tex(Rosario-Bold-osf-ot1.tfm) \
tex(Rosario-Bold-osf-t1--base.tfm) \
tex(Rosario-Bold-osf-t1.tfm) \
tex(Rosario-Bold-osf-t1.vf) \
tex(Rosario-Bold-osf-ts1--base.tfm) \
tex(Rosario-Bold-osf-ts1.tfm) \
tex(Rosario-Bold-osf-ts1.vf) \
tex(Rosario-Bold-sup-ly1--base.tfm) \
tex(Rosario-Bold-sup-ly1.tfm) \
tex(Rosario-Bold-sup-ly1.vf) \
tex(Rosario-Bold-sup-ot1.tfm) \
tex(Rosario-Bold-sup-t1--base.tfm) \
tex(Rosario-Bold-sup-t1.tfm) \
tex(Rosario-Bold-sup-t1.vf) \
tex(Rosario-Bold-tlf-ly1--base.tfm) \
tex(Rosario-Bold-tlf-ly1.tfm) \
tex(Rosario-Bold-tlf-ly1.vf) \
tex(Rosario-Bold-tlf-ot1.tfm) \
tex(Rosario-Bold-tlf-t1--base.tfm) \
tex(Rosario-Bold-tlf-t1.tfm) \
tex(Rosario-Bold-tlf-t1.vf) \
tex(Rosario-Bold-tlf-ts1--base.tfm) \
tex(Rosario-Bold-tlf-ts1.tfm) \
tex(Rosario-Bold-tlf-ts1.vf) \
tex(Rosario-Bold-tosf-ly1--base.tfm) \
tex(Rosario-Bold-tosf-ly1.tfm) \
tex(Rosario-Bold-tosf-ly1.vf) \
tex(Rosario-Bold-tosf-ot1.tfm) \
tex(Rosario-Bold-tosf-t1--base.tfm) \
tex(Rosario-Bold-tosf-t1.tfm) \
tex(Rosario-Bold-tosf-t1.vf) \
tex(Rosario-Bold-tosf-ts1--base.tfm) \
tex(Rosario-Bold-tosf-ts1.tfm) \
tex(Rosario-Bold-tosf-ts1.vf) \
tex(Rosario-BoldItalic-dnom-ly1--base.tfm) \
tex(Rosario-BoldItalic-dnom-ly1.tfm) \
tex(Rosario-BoldItalic-dnom-ly1.vf) \
tex(Rosario-BoldItalic-dnom-ot1.tfm) \
tex(Rosario-BoldItalic-dnom-t1--base.tfm) \
tex(Rosario-BoldItalic-dnom-t1.tfm) \
tex(Rosario-BoldItalic-dnom-t1.vf) \
tex(Rosario-BoldItalic-inf-ly1--base.tfm) \
tex(Rosario-BoldItalic-inf-ly1.tfm) \
tex(Rosario-BoldItalic-inf-ly1.vf) \
tex(Rosario-BoldItalic-inf-ot1.tfm) \
tex(Rosario-BoldItalic-inf-t1--base.tfm) \
tex(Rosario-BoldItalic-inf-t1.tfm) \
tex(Rosario-BoldItalic-inf-t1.vf) \
tex(Rosario-BoldItalic-lf-ly1--base.tfm) \
tex(Rosario-BoldItalic-lf-ly1.tfm) \
tex(Rosario-BoldItalic-lf-ly1.vf) \
tex(Rosario-BoldItalic-lf-ot1.tfm) \
tex(Rosario-BoldItalic-lf-t1--base.tfm) \
tex(Rosario-BoldItalic-lf-t1.tfm) \
tex(Rosario-BoldItalic-lf-t1.vf) \
tex(Rosario-BoldItalic-lf-ts1--base.tfm) \
tex(Rosario-BoldItalic-lf-ts1.tfm) \
tex(Rosario-BoldItalic-lf-ts1.vf) \
tex(Rosario-BoldItalic-numr-ly1--base.tfm) \
tex(Rosario-BoldItalic-numr-ly1.tfm) \
tex(Rosario-BoldItalic-numr-ly1.vf) \
tex(Rosario-BoldItalic-numr-ot1.tfm) \
tex(Rosario-BoldItalic-numr-t1--base.tfm) \
tex(Rosario-BoldItalic-numr-t1.tfm) \
tex(Rosario-BoldItalic-numr-t1.vf) \
tex(Rosario-BoldItalic-osf-ly1--base.tfm) \
tex(Rosario-BoldItalic-osf-ly1.tfm) \
tex(Rosario-BoldItalic-osf-ly1.vf) \
tex(Rosario-BoldItalic-osf-ot1.tfm) \
tex(Rosario-BoldItalic-osf-t1--base.tfm) \
tex(Rosario-BoldItalic-osf-t1.tfm) \
tex(Rosario-BoldItalic-osf-t1.vf) \
tex(Rosario-BoldItalic-osf-ts1--base.tfm) \
tex(Rosario-BoldItalic-osf-ts1.tfm) \
tex(Rosario-BoldItalic-osf-ts1.vf) \
tex(Rosario-BoldItalic-sup-ly1--base.tfm) \
tex(Rosario-BoldItalic-sup-ly1.tfm) \
tex(Rosario-BoldItalic-sup-ly1.vf) \
tex(Rosario-BoldItalic-sup-ot1.tfm) \
tex(Rosario-BoldItalic-sup-t1--base.tfm) \
tex(Rosario-BoldItalic-sup-t1.tfm) \
tex(Rosario-BoldItalic-sup-t1.vf) \
tex(Rosario-BoldItalic-tlf-ly1--base.tfm) \
tex(Rosario-BoldItalic-tlf-ly1.tfm) \
tex(Rosario-BoldItalic-tlf-ly1.vf) \
tex(Rosario-BoldItalic-tlf-ot1.tfm) \
tex(Rosario-BoldItalic-tlf-t1--base.tfm) \
tex(Rosario-BoldItalic-tlf-t1.tfm) \
tex(Rosario-BoldItalic-tlf-t1.vf) \
tex(Rosario-BoldItalic-tlf-ts1--base.tfm) \
tex(Rosario-BoldItalic-tlf-ts1.tfm) \
tex(Rosario-BoldItalic-tlf-ts1.vf) \
tex(Rosario-BoldItalic-tosf-ly1--base.tfm) \
tex(Rosario-BoldItalic-tosf-ly1.tfm) \
tex(Rosario-BoldItalic-tosf-ly1.vf) \
tex(Rosario-BoldItalic-tosf-ot1.tfm) \
tex(Rosario-BoldItalic-tosf-t1--base.tfm) \
tex(Rosario-BoldItalic-tosf-t1.tfm) \
tex(Rosario-BoldItalic-tosf-t1.vf) \
tex(Rosario-BoldItalic-tosf-ts1--base.tfm) \
tex(Rosario-BoldItalic-tosf-ts1.tfm) \
tex(Rosario-BoldItalic-tosf-ts1.vf) \
tex(Rosario-Italic-dnom-ly1--base.tfm) \
tex(Rosario-Italic-dnom-ly1.tfm) \
tex(Rosario-Italic-dnom-ly1.vf) \
tex(Rosario-Italic-dnom-ot1.tfm) \
tex(Rosario-Italic-dnom-t1--base.tfm) \
tex(Rosario-Italic-dnom-t1.tfm) \
tex(Rosario-Italic-dnom-t1.vf) \
tex(Rosario-Italic-inf-ly1--base.tfm) \
tex(Rosario-Italic-inf-ly1.tfm) \
tex(Rosario-Italic-inf-ly1.vf) \
tex(Rosario-Italic-inf-ot1.tfm) \
tex(Rosario-Italic-inf-t1--base.tfm) \
tex(Rosario-Italic-inf-t1.tfm) \
tex(Rosario-Italic-inf-t1.vf) \
tex(Rosario-Italic-lf-ly1--base.tfm) \
tex(Rosario-Italic-lf-ly1.tfm) \
tex(Rosario-Italic-lf-ly1.vf) \
tex(Rosario-Italic-lf-ot1.tfm) \
tex(Rosario-Italic-lf-t1--base.tfm) \
tex(Rosario-Italic-lf-t1.tfm) \
tex(Rosario-Italic-lf-t1.vf) \
tex(Rosario-Italic-lf-ts1--base.tfm) \
tex(Rosario-Italic-lf-ts1.tfm) \
tex(Rosario-Italic-lf-ts1.vf) \
tex(Rosario-Italic-numr-ly1--base.tfm) \
tex(Rosario-Italic-numr-ly1.tfm) \
tex(Rosario-Italic-numr-ly1.vf) \
tex(Rosario-Italic-numr-ot1.tfm) \
tex(Rosario-Italic-numr-t1--base.tfm) \
tex(Rosario-Italic-numr-t1.tfm) \
tex(Rosario-Italic-numr-t1.vf) \
tex(Rosario-Italic-osf-ly1--base.tfm) \
tex(Rosario-Italic-osf-ly1.tfm) \
tex(Rosario-Italic-osf-ly1.vf) \
tex(Rosario-Italic-osf-ot1.tfm) \
tex(Rosario-Italic-osf-t1--base.tfm) \
tex(Rosario-Italic-osf-t1.tfm) \
tex(Rosario-Italic-osf-t1.vf) \
tex(Rosario-Italic-osf-ts1--base.tfm) \
tex(Rosario-Italic-osf-ts1.tfm) \
tex(Rosario-Italic-osf-ts1.vf) \
tex(Rosario-Italic-sup-ly1--base.tfm) \
tex(Rosario-Italic-sup-ly1.tfm) \
tex(Rosario-Italic-sup-ly1.vf) \
tex(Rosario-Italic-sup-ot1.tfm) \
tex(Rosario-Italic-sup-t1--base.tfm) \
tex(Rosario-Italic-sup-t1.tfm) \
tex(Rosario-Italic-sup-t1.vf) \
tex(Rosario-Italic-tlf-ly1--base.tfm) \
tex(Rosario-Italic-tlf-ly1.tfm) \
tex(Rosario-Italic-tlf-ly1.vf) \
tex(Rosario-Italic-tlf-ot1.tfm) \
tex(Rosario-Italic-tlf-t1--base.tfm) \
tex(Rosario-Italic-tlf-t1.tfm) \
tex(Rosario-Italic-tlf-t1.vf) \
tex(Rosario-Italic-tlf-ts1--base.tfm) \
tex(Rosario-Italic-tlf-ts1.tfm) \
tex(Rosario-Italic-tlf-ts1.vf) \
tex(Rosario-Italic-tosf-ly1--base.tfm) \
tex(Rosario-Italic-tosf-ly1.tfm) \
tex(Rosario-Italic-tosf-ly1.vf) \
tex(Rosario-Italic-tosf-ot1.tfm) \
tex(Rosario-Italic-tosf-t1--base.tfm) \
tex(Rosario-Italic-tosf-t1.tfm) \
tex(Rosario-Italic-tosf-t1.vf) \
tex(Rosario-Italic-tosf-ts1--base.tfm) \
tex(Rosario-Italic-tosf-ts1.tfm) \
tex(Rosario-Italic-tosf-ts1.vf) \
tex(Rosario-Light-dnom-ly1--base.tfm) \
tex(Rosario-Light-dnom-ly1.tfm) \
tex(Rosario-Light-dnom-ly1.vf) \
tex(Rosario-Light-dnom-ot1.tfm) \
tex(Rosario-Light-dnom-t1--base.tfm) \
tex(Rosario-Light-dnom-t1.tfm) \
tex(Rosario-Light-dnom-t1.vf) \
tex(Rosario-Light-inf-ly1--base.tfm) \
tex(Rosario-Light-inf-ly1.tfm) \
tex(Rosario-Light-inf-ly1.vf) \
tex(Rosario-Light-inf-ot1.tfm) \
tex(Rosario-Light-inf-t1--base.tfm) \
tex(Rosario-Light-inf-t1.tfm) \
tex(Rosario-Light-inf-t1.vf) \
tex(Rosario-Light-lf-ly1--base.tfm) \
tex(Rosario-Light-lf-ly1.tfm) \
tex(Rosario-Light-lf-ly1.vf) \
tex(Rosario-Light-lf-ot1.tfm) \
tex(Rosario-Light-lf-t1--base.tfm) \
tex(Rosario-Light-lf-t1.tfm) \
tex(Rosario-Light-lf-t1.vf) \
tex(Rosario-Light-lf-ts1--base.tfm) \
tex(Rosario-Light-lf-ts1.tfm) \
tex(Rosario-Light-lf-ts1.vf) \
tex(Rosario-Light-numr-ly1--base.tfm) \
tex(Rosario-Light-numr-ly1.tfm) \
tex(Rosario-Light-numr-ly1.vf) \
tex(Rosario-Light-numr-ot1.tfm) \
tex(Rosario-Light-numr-t1--base.tfm) \
tex(Rosario-Light-numr-t1.tfm) \
tex(Rosario-Light-numr-t1.vf) \
tex(Rosario-Light-osf-ly1--base.tfm) \
tex(Rosario-Light-osf-ly1.tfm) \
tex(Rosario-Light-osf-ly1.vf) \
tex(Rosario-Light-osf-ot1.tfm) \
tex(Rosario-Light-osf-t1--base.tfm) \
tex(Rosario-Light-osf-t1.tfm) \
tex(Rosario-Light-osf-t1.vf) \
tex(Rosario-Light-osf-ts1--base.tfm) \
tex(Rosario-Light-osf-ts1.tfm) \
tex(Rosario-Light-osf-ts1.vf) \
tex(Rosario-Light-sup-ly1--base.tfm) \
tex(Rosario-Light-sup-ly1.tfm) \
tex(Rosario-Light-sup-ly1.vf) \
tex(Rosario-Light-sup-ot1.tfm) \
tex(Rosario-Light-sup-t1--base.tfm) \
tex(Rosario-Light-sup-t1.tfm) \
tex(Rosario-Light-sup-t1.vf) \
tex(Rosario-Light-tlf-ly1--base.tfm) \
tex(Rosario-Light-tlf-ly1.tfm) \
tex(Rosario-Light-tlf-ly1.vf) \
tex(Rosario-Light-tlf-ot1.tfm) \
tex(Rosario-Light-tlf-t1--base.tfm) \
tex(Rosario-Light-tlf-t1.tfm) \
tex(Rosario-Light-tlf-t1.vf) \
tex(Rosario-Light-tlf-ts1--base.tfm) \
tex(Rosario-Light-tlf-ts1.tfm) \
tex(Rosario-Light-tlf-ts1.vf) \
tex(Rosario-Light-tosf-ly1--base.tfm) \
tex(Rosario-Light-tosf-ly1.tfm) \
tex(Rosario-Light-tosf-ly1.vf) \
tex(Rosario-Light-tosf-ot1.tfm) \
tex(Rosario-Light-tosf-t1--base.tfm) \
tex(Rosario-Light-tosf-t1.tfm) \
tex(Rosario-Light-tosf-t1.vf) \
tex(Rosario-Light-tosf-ts1--base.tfm) \
tex(Rosario-Light-tosf-ts1.tfm) \
tex(Rosario-Light-tosf-ts1.vf) \
tex(Rosario-LightItalic-dnom-ly1--base.tfm) \
tex(Rosario-LightItalic-dnom-ly1.tfm) \
tex(Rosario-LightItalic-dnom-ly1.vf) \
tex(Rosario-LightItalic-dnom-ot1.tfm) \
tex(Rosario-LightItalic-dnom-t1--base.tfm) \
tex(Rosario-LightItalic-dnom-t1.tfm) \
tex(Rosario-LightItalic-dnom-t1.vf) \
tex(Rosario-LightItalic-inf-ly1--base.tfm) \
tex(Rosario-LightItalic-inf-ly1.tfm) \
tex(Rosario-LightItalic-inf-ly1.vf) \
tex(Rosario-LightItalic-inf-ot1.tfm) \
tex(Rosario-LightItalic-inf-t1--base.tfm) \
tex(Rosario-LightItalic-inf-t1.tfm) \
tex(Rosario-LightItalic-inf-t1.vf) \
tex(Rosario-LightItalic-lf-ly1--base.tfm) \
tex(Rosario-LightItalic-lf-ly1.tfm) \
tex(Rosario-LightItalic-lf-ly1.vf) \
tex(Rosario-LightItalic-lf-ot1.tfm) \
tex(Rosario-LightItalic-lf-t1--base.tfm) \
tex(Rosario-LightItalic-lf-t1.tfm) \
tex(Rosario-LightItalic-lf-t1.vf) \
tex(Rosario-LightItalic-lf-ts1--base.tfm) \
tex(Rosario-LightItalic-lf-ts1.tfm) \
tex(Rosario-LightItalic-lf-ts1.vf) \
tex(Rosario-LightItalic-numr-ly1--base.tfm) \
tex(Rosario-LightItalic-numr-ly1.tfm) \
tex(Rosario-LightItalic-numr-ly1.vf) \
tex(Rosario-LightItalic-numr-ot1.tfm) \
tex(Rosario-LightItalic-numr-t1--base.tfm) \
tex(Rosario-LightItalic-numr-t1.tfm) \
tex(Rosario-LightItalic-numr-t1.vf) \
tex(Rosario-LightItalic-osf-ly1--base.tfm) \
tex(Rosario-LightItalic-osf-ly1.tfm) \
tex(Rosario-LightItalic-osf-ly1.vf) \
tex(Rosario-LightItalic-osf-ot1.tfm) \
tex(Rosario-LightItalic-osf-t1--base.tfm) \
tex(Rosario-LightItalic-osf-t1.tfm) \
tex(Rosario-LightItalic-osf-t1.vf) \
tex(Rosario-LightItalic-osf-ts1--base.tfm) \
tex(Rosario-LightItalic-osf-ts1.tfm) \
tex(Rosario-LightItalic-osf-ts1.vf) \
tex(Rosario-LightItalic-sup-ly1--base.tfm) \
tex(Rosario-LightItalic-sup-ly1.tfm) \
tex(Rosario-LightItalic-sup-ly1.vf) \
tex(Rosario-LightItalic-sup-ot1.tfm) \
tex(Rosario-LightItalic-sup-t1--base.tfm) \
tex(Rosario-LightItalic-sup-t1.tfm) \
tex(Rosario-LightItalic-sup-t1.vf) \
tex(Rosario-LightItalic-tlf-ly1--base.tfm) \
tex(Rosario-LightItalic-tlf-ly1.tfm) \
tex(Rosario-LightItalic-tlf-ly1.vf) \
tex(Rosario-LightItalic-tlf-ot1.tfm) \
tex(Rosario-LightItalic-tlf-t1--base.tfm) \
tex(Rosario-LightItalic-tlf-t1.tfm) \
tex(Rosario-LightItalic-tlf-t1.vf) \
tex(Rosario-LightItalic-tlf-ts1--base.tfm) \
tex(Rosario-LightItalic-tlf-ts1.tfm) \
tex(Rosario-LightItalic-tlf-ts1.vf) \
tex(Rosario-LightItalic-tosf-ly1--base.tfm) \
tex(Rosario-LightItalic-tosf-ly1.tfm) \
tex(Rosario-LightItalic-tosf-ly1.vf) \
tex(Rosario-LightItalic-tosf-ot1.tfm) \
tex(Rosario-LightItalic-tosf-t1--base.tfm) \
tex(Rosario-LightItalic-tosf-t1.tfm) \
tex(Rosario-LightItalic-tosf-t1.vf) \
tex(Rosario-LightItalic-tosf-ts1--base.tfm) \
tex(Rosario-LightItalic-tosf-ts1.tfm) \
tex(Rosario-LightItalic-tosf-ts1.vf) \
tex(Rosario-Regular-dnom-ly1--base.tfm) \
tex(Rosario-Regular-dnom-ly1.tfm) \
tex(Rosario-Regular-dnom-ly1.vf) \
tex(Rosario-Regular-dnom-ot1.tfm) \
tex(Rosario-Regular-dnom-t1--base.tfm) \
tex(Rosario-Regular-dnom-t1.tfm) \
tex(Rosario-Regular-dnom-t1.vf) \
tex(Rosario-Regular-inf-ly1--base.tfm) \
tex(Rosario-Regular-inf-ly1.tfm) \
tex(Rosario-Regular-inf-ly1.vf) \
tex(Rosario-Regular-inf-ot1.tfm) \
tex(Rosario-Regular-inf-t1--base.tfm) \
tex(Rosario-Regular-inf-t1.tfm) \
tex(Rosario-Regular-inf-t1.vf) \
tex(Rosario-Regular-lf-ly1--base.tfm) \
tex(Rosario-Regular-lf-ly1.tfm) \
tex(Rosario-Regular-lf-ly1.vf) \
tex(Rosario-Regular-lf-ot1.tfm) \
tex(Rosario-Regular-lf-t1--base.tfm) \
tex(Rosario-Regular-lf-t1.tfm) \
tex(Rosario-Regular-lf-t1.vf) \
tex(Rosario-Regular-lf-ts1--base.tfm) \
tex(Rosario-Regular-lf-ts1.tfm) \
tex(Rosario-Regular-lf-ts1.vf) \
tex(Rosario-Regular-numr-ly1--base.tfm) \
tex(Rosario-Regular-numr-ly1.tfm) \
tex(Rosario-Regular-numr-ly1.vf) \
tex(Rosario-Regular-numr-ot1.tfm) \
tex(Rosario-Regular-numr-t1--base.tfm) \
tex(Rosario-Regular-numr-t1.tfm) \
tex(Rosario-Regular-numr-t1.vf) \
tex(Rosario-Regular-osf-ly1--base.tfm) \
tex(Rosario-Regular-osf-ly1.tfm) \
tex(Rosario-Regular-osf-ly1.vf) \
tex(Rosario-Regular-osf-ot1.tfm) \
tex(Rosario-Regular-osf-t1--base.tfm) \
tex(Rosario-Regular-osf-t1.tfm) \
tex(Rosario-Regular-osf-t1.vf) \
tex(Rosario-Regular-osf-ts1--base.tfm) \
tex(Rosario-Regular-osf-ts1.tfm) \
tex(Rosario-Regular-osf-ts1.vf) \
tex(Rosario-Regular-sup-ly1--base.tfm) \
tex(Rosario-Regular-sup-ly1.tfm) \
tex(Rosario-Regular-sup-ly1.vf) \
tex(Rosario-Regular-sup-ot1.tfm) \
tex(Rosario-Regular-sup-t1--base.tfm) \
tex(Rosario-Regular-sup-t1.tfm) \
tex(Rosario-Regular-sup-t1.vf) \
tex(Rosario-Regular-tlf-ly1--base.tfm) \
tex(Rosario-Regular-tlf-ly1.tfm) \
tex(Rosario-Regular-tlf-ly1.vf) \
tex(Rosario-Regular-tlf-ot1.tfm) \
tex(Rosario-Regular-tlf-t1--base.tfm) \
tex(Rosario-Regular-tlf-t1.tfm) \
tex(Rosario-Regular-tlf-t1.vf) \
tex(Rosario-Regular-tlf-ts1--base.tfm) \
tex(Rosario-Regular-tlf-ts1.tfm) \
tex(Rosario-Regular-tlf-ts1.vf) \
tex(Rosario-Regular-tosf-ly1--base.tfm) \
tex(Rosario-Regular-tosf-ly1.tfm) \
tex(Rosario-Regular-tosf-ly1.vf) \
tex(Rosario-Regular-tosf-ot1.tfm) \
tex(Rosario-Regular-tosf-t1--base.tfm) \
tex(Rosario-Regular-tosf-t1.tfm) \
tex(Rosario-Regular-tosf-t1.vf) \
tex(Rosario-Regular-tosf-ts1--base.tfm) \
tex(Rosario-Regular-tosf-ts1.tfm) \
tex(Rosario-Regular-tosf-ts1.vf) \
tex(Rosario-SemiBold-dnom-ly1--base.tfm) \
tex(Rosario-SemiBold-dnom-ly1.tfm) \
tex(Rosario-SemiBold-dnom-ly1.vf) \
tex(Rosario-SemiBold-dnom-ot1.tfm) \
tex(Rosario-SemiBold-dnom-t1--base.tfm) \
tex(Rosario-SemiBold-dnom-t1.tfm) \
tex(Rosario-SemiBold-dnom-t1.vf) \
tex(Rosario-SemiBold-inf-ly1--base.tfm) \
tex(Rosario-SemiBold-inf-ly1.tfm) \
tex(Rosario-SemiBold-inf-ly1.vf) \
tex(Rosario-SemiBold-inf-ot1.tfm) \
tex(Rosario-SemiBold-inf-t1--base.tfm) \
tex(Rosario-SemiBold-inf-t1.tfm) \
tex(Rosario-SemiBold-inf-t1.vf) \
tex(Rosario-SemiBold-lf-ly1--base.tfm) \
tex(Rosario-SemiBold-lf-ly1.tfm) \
tex(Rosario-SemiBold-lf-ly1.vf) \
tex(Rosario-SemiBold-lf-ot1.tfm) \
tex(Rosario-SemiBold-lf-t1--base.tfm) \
tex(Rosario-SemiBold-lf-t1.tfm) \
tex(Rosario-SemiBold-lf-t1.vf) \
tex(Rosario-SemiBold-lf-ts1--base.tfm) \
tex(Rosario-SemiBold-lf-ts1.tfm) \
tex(Rosario-SemiBold-lf-ts1.vf) \
tex(Rosario-SemiBold-numr-ly1--base.tfm) \
tex(Rosario-SemiBold-numr-ly1.tfm) \
tex(Rosario-SemiBold-numr-ly1.vf) \
tex(Rosario-SemiBold-numr-ot1.tfm) \
tex(Rosario-SemiBold-numr-t1--base.tfm) \
tex(Rosario-SemiBold-numr-t1.tfm) \
tex(Rosario-SemiBold-numr-t1.vf) \
tex(Rosario-SemiBold-osf-ly1--base.tfm) \
tex(Rosario-SemiBold-osf-ly1.tfm) \
tex(Rosario-SemiBold-osf-ly1.vf) \
tex(Rosario-SemiBold-osf-ot1.tfm) \
tex(Rosario-SemiBold-osf-t1--base.tfm) \
tex(Rosario-SemiBold-osf-t1.tfm) \
tex(Rosario-SemiBold-osf-t1.vf) \
tex(Rosario-SemiBold-osf-ts1--base.tfm) \
tex(Rosario-SemiBold-osf-ts1.tfm) \
tex(Rosario-SemiBold-osf-ts1.vf) \
tex(Rosario-SemiBold-sup-ly1--base.tfm) \
tex(Rosario-SemiBold-sup-ly1.tfm) \
tex(Rosario-SemiBold-sup-ly1.vf) \
tex(Rosario-SemiBold-sup-ot1.tfm) \
tex(Rosario-SemiBold-sup-t1--base.tfm) \
tex(Rosario-SemiBold-sup-t1.tfm) \
tex(Rosario-SemiBold-sup-t1.vf) \
tex(Rosario-SemiBold-tlf-ly1--base.tfm) \
tex(Rosario-SemiBold-tlf-ly1.tfm) \
tex(Rosario-SemiBold-tlf-ly1.vf) \
tex(Rosario-SemiBold-tlf-ot1.tfm) \
tex(Rosario-SemiBold-tlf-t1--base.tfm) \
tex(Rosario-SemiBold-tlf-t1.tfm) \
tex(Rosario-SemiBold-tlf-t1.vf) \
tex(Rosario-SemiBold-tlf-ts1--base.tfm) \
tex(Rosario-SemiBold-tlf-ts1.tfm) \
tex(Rosario-SemiBold-tlf-ts1.vf) \
tex(Rosario-SemiBold-tosf-ly1--base.tfm) \
tex(Rosario-SemiBold-tosf-ly1.tfm) \
tex(Rosario-SemiBold-tosf-ly1.vf) \
tex(Rosario-SemiBold-tosf-ot1.tfm) \
tex(Rosario-SemiBold-tosf-t1--base.tfm) \
tex(Rosario-SemiBold-tosf-t1.tfm) \
tex(Rosario-SemiBold-tosf-t1.vf) \
tex(Rosario-SemiBold-tosf-ts1--base.tfm) \
tex(Rosario-SemiBold-tosf-ts1.tfm) \
tex(Rosario-SemiBold-tosf-ts1.vf) \
tex(Rosario-SemiBoldItalic-dnom-ly1--base.tfm) \
tex(Rosario-SemiBoldItalic-dnom-ly1.tfm) \
tex(Rosario-SemiBoldItalic-dnom-ly1.vf) \
tex(Rosario-SemiBoldItalic-dnom-ot1.tfm) \
tex(Rosario-SemiBoldItalic-dnom-t1--base.tfm) \
tex(Rosario-SemiBoldItalic-dnom-t1.tfm) \
tex(Rosario-SemiBoldItalic-dnom-t1.vf) \
tex(Rosario-SemiBoldItalic-inf-ly1--base.tfm) \
tex(Rosario-SemiBoldItalic-inf-ly1.tfm) \
tex(Rosario-SemiBoldItalic-inf-ly1.vf) \
tex(Rosario-SemiBoldItalic-inf-ot1.tfm) \
tex(Rosario-SemiBoldItalic-inf-t1--base.tfm) \
tex(Rosario-SemiBoldItalic-inf-t1.tfm) \
tex(Rosario-SemiBoldItalic-inf-t1.vf) \
tex(Rosario-SemiBoldItalic-lf-ly1--base.tfm) \
tex(Rosario-SemiBoldItalic-lf-ly1.tfm) \
tex(Rosario-SemiBoldItalic-lf-ly1.vf) \
tex(Rosario-SemiBoldItalic-lf-ot1.tfm) \
tex(Rosario-SemiBoldItalic-lf-t1--base.tfm) \
tex(Rosario-SemiBoldItalic-lf-t1.tfm) \
tex(Rosario-SemiBoldItalic-lf-t1.vf) \
tex(Rosario-SemiBoldItalic-lf-ts1--base.tfm) \
tex(Rosario-SemiBoldItalic-lf-ts1.tfm) \
tex(Rosario-SemiBoldItalic-lf-ts1.vf) \
tex(Rosario-SemiBoldItalic-numr-ly1--base.tfm) \
tex(Rosario-SemiBoldItalic-numr-ly1.tfm) \
tex(Rosario-SemiBoldItalic-numr-ly1.vf) \
tex(Rosario-SemiBoldItalic-numr-ot1.tfm) \
tex(Rosario-SemiBoldItalic-numr-t1--base.tfm) \
tex(Rosario-SemiBoldItalic-numr-t1.tfm) \
tex(Rosario-SemiBoldItalic-numr-t1.vf) \
tex(Rosario-SemiBoldItalic-osf-ly1--base.tfm) \
tex(Rosario-SemiBoldItalic-osf-ly1.tfm) \
tex(Rosario-SemiBoldItalic-osf-ly1.vf) \
tex(Rosario-SemiBoldItalic-osf-ot1.tfm) \
tex(Rosario-SemiBoldItalic-osf-t1--base.tfm) \
tex(Rosario-SemiBoldItalic-osf-t1.tfm) \
tex(Rosario-SemiBoldItalic-osf-t1.vf) \
tex(Rosario-SemiBoldItalic-osf-ts1--base.tfm) \
tex(Rosario-SemiBoldItalic-osf-ts1.tfm) \
tex(Rosario-SemiBoldItalic-osf-ts1.vf) \
tex(Rosario-SemiBoldItalic-sup-ly1--base.tfm) \
tex(Rosario-SemiBoldItalic-sup-ly1.tfm) \
tex(Rosario-SemiBoldItalic-sup-ly1.vf) \
tex(Rosario-SemiBoldItalic-sup-ot1.tfm) \
tex(Rosario-SemiBoldItalic-sup-t1--base.tfm) \
tex(Rosario-SemiBoldItalic-sup-t1.tfm) \
tex(Rosario-SemiBoldItalic-sup-t1.vf) \
tex(Rosario-SemiBoldItalic-tlf-ly1--base.tfm) \
tex(Rosario-SemiBoldItalic-tlf-ly1.tfm) \
tex(Rosario-SemiBoldItalic-tlf-ly1.vf) \
tex(Rosario-SemiBoldItalic-tlf-ot1.tfm) \
tex(Rosario-SemiBoldItalic-tlf-t1--base.tfm) \
tex(Rosario-SemiBoldItalic-tlf-t1.tfm) \
tex(Rosario-SemiBoldItalic-tlf-t1.vf) \
tex(Rosario-SemiBoldItalic-tlf-ts1--base.tfm) \
tex(Rosario-SemiBoldItalic-tlf-ts1.tfm) \
tex(Rosario-SemiBoldItalic-tlf-ts1.vf) \
tex(Rosario-SemiBoldItalic-tosf-ly1--base.tfm) \
tex(Rosario-SemiBoldItalic-tosf-ly1.tfm) \
tex(Rosario-SemiBoldItalic-tosf-ly1.vf) \
tex(Rosario-SemiBoldItalic-tosf-ot1.tfm) \
tex(Rosario-SemiBoldItalic-tosf-t1--base.tfm) \
tex(Rosario-SemiBoldItalic-tosf-t1.tfm) \
tex(Rosario-SemiBoldItalic-tosf-t1.vf) \
tex(Rosario-SemiBoldItalic-tosf-ts1--base.tfm) \
tex(Rosario-SemiBoldItalic-tosf-ts1.tfm) \
tex(Rosario-SemiBoldItalic-tosf-ts1.vf) \
tex(Rosario.map) \
tex(Rosario.sty) \
tex(T1Rosario-Dnom.fd) \
tex(T1Rosario-Inf.fd) \
tex(T1Rosario-LF.fd) \
tex(T1Rosario-Numr.fd) \
tex(T1Rosario-OsF.fd) \
tex(T1Rosario-Sup.fd) \
tex(T1Rosario-TLF.fd) \
tex(T1Rosario-TOsF.fd) \
tex(TS1Rosario-LF.fd) \
tex(TS1Rosario-OsF.fd) \
tex(TS1Rosario-TLF.fd) \
tex(TS1Rosario-TOsF.fd) \
tex(ros_24xxsv.enc) \
tex(ros_2lqlus.enc) \
tex(ros_2sgwql.enc) \
tex(ros_3avctt.enc) \
tex(ros_7npxgm.enc) \
tex(ros_7yzfgj.enc) \
tex(ros_bv7x5e.enc) \
tex(ros_c6jprw.enc) \
tex(ros_f6ejpj.enc) \
tex(ros_fiyauo.enc) \
tex(ros_flfbvu.enc) \
tex(ros_h6jra2.enc) \
tex(ros_hhbfoh.enc) \
tex(ros_hlvv6p.enc) \
tex(ros_jo7tnr.enc) \
tex(ros_krtxg6.enc) \
tex(ros_lwgukc.enc) \
tex(ros_mq36jn.enc) \
tex(ros_pxrm2a.enc) \
tex(ros_ttjzpe.enc) \
tex(ros_utd4ik.enc) \
tex(ros_vgwtwr.enc) \
tex(ros_wlsyn3.enc) \
tex(ros_wxmaut.enc) \
tex(ros_znhcko.enc) \
texlive-rosario"
RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex(fontaxes.sty) \
tex(fontspec.sty) \
tex(ifluatex.sty) \
tex(ifxetex.sty) \
tex(kvoptions.sty) \
tex(mweights.sty) \
tex(updmap.cfg) \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-rosario-fonts \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
