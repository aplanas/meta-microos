SUMMARY = "Merriweather and MerriweatherSans fonts, with LaTeX support"
DESCRIPTION = "This package provides the Merriweather and MerriweatherSans \
families of fonts, designed by Eben Sorkin, with support for \
LaTeX, pdfLaTeX, XeLaTeX, and LuaLaTeX. Merriweather features a \
very large x height, slightly condensed letterforms, a mild \
diagonal stress, sturdy serifs and open forms. The Sans family \
closely harmonizes with the weights and styles of the serif \
family. There are four weights and italics for each."
LICENSE = "OFL-1.1"

PV = "2023.201.svn64452"

RPM_NAME = "texlive-merriweather-2023.201.svn64452-54.1.noarch.rpm"
RPM_HASH = "12f1cf57cf55824854241d047679e509f3bf5aa5eabcd2ae80100322b05eccdbc732c9b2e178a4aa47b3f3e5b86b05c98152b85ae21d778c041d13b460dff2d6"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex(LY1Merriwthr-LF.fd) \
tex(LY1Merriwthr-OsF.fd) \
tex(LY1Merriwthr-Sup.fd) \
tex(LY1Merriwthr-TLF.fd) \
tex(LY1Merriwthr-TOsF.fd) \
tex(LY1MerriwthrSans-LF.fd) \
tex(LY1MerriwthrSans-OsF.fd) \
tex(LY1MerriwthrSans-Sup.fd) \
tex(LY1MerriwthrSans-TLF.fd) \
tex(LY1MerriwthrSans-TOsF.fd) \
tex(Merriwthr-Black-lf-ly1.tfm) \
tex(Merriwthr-Black-lf-ot1.tfm) \
tex(Merriwthr-Black-lf-sc-ly1--base.tfm) \
tex(Merriwthr-Black-lf-sc-ly1.tfm) \
tex(Merriwthr-Black-lf-sc-ly1.vf) \
tex(Merriwthr-Black-lf-sc-ot1--base.tfm) \
tex(Merriwthr-Black-lf-sc-ot1.tfm) \
tex(Merriwthr-Black-lf-sc-ot1.vf) \
tex(Merriwthr-Black-lf-sc-t1--base.tfm) \
tex(Merriwthr-Black-lf-sc-t1.tfm) \
tex(Merriwthr-Black-lf-sc-t1.vf) \
tex(Merriwthr-Black-lf-t1--base.tfm) \
tex(Merriwthr-Black-lf-t1.tfm) \
tex(Merriwthr-Black-lf-t1.vf) \
tex(Merriwthr-Black-lf-ts1--base.tfm) \
tex(Merriwthr-Black-lf-ts1.tfm) \
tex(Merriwthr-Black-lf-ts1.vf) \
tex(Merriwthr-Black-osf-ly1.tfm) \
tex(Merriwthr-Black-osf-ot1.tfm) \
tex(Merriwthr-Black-osf-sc-ly1--base.tfm) \
tex(Merriwthr-Black-osf-sc-ly1.tfm) \
tex(Merriwthr-Black-osf-sc-ly1.vf) \
tex(Merriwthr-Black-osf-sc-ot1--base.tfm) \
tex(Merriwthr-Black-osf-sc-ot1.tfm) \
tex(Merriwthr-Black-osf-sc-ot1.vf) \
tex(Merriwthr-Black-osf-sc-t1--base.tfm) \
tex(Merriwthr-Black-osf-sc-t1.tfm) \
tex(Merriwthr-Black-osf-sc-t1.vf) \
tex(Merriwthr-Black-osf-t1--base.tfm) \
tex(Merriwthr-Black-osf-t1.tfm) \
tex(Merriwthr-Black-osf-t1.vf) \
tex(Merriwthr-Black-osf-ts1--base.tfm) \
tex(Merriwthr-Black-osf-ts1.tfm) \
tex(Merriwthr-Black-osf-ts1.vf) \
tex(Merriwthr-Black-sup-ly1.tfm) \
tex(Merriwthr-Black-sup-ot1.tfm) \
tex(Merriwthr-Black-sup-t1--base.tfm) \
tex(Merriwthr-Black-sup-t1.tfm) \
tex(Merriwthr-Black-sup-t1.vf) \
tex(Merriwthr-Black-tlf-ly1.tfm) \
tex(Merriwthr-Black-tlf-ot1.tfm) \
tex(Merriwthr-Black-tlf-sc-ly1--base.tfm) \
tex(Merriwthr-Black-tlf-sc-ly1.tfm) \
tex(Merriwthr-Black-tlf-sc-ly1.vf) \
tex(Merriwthr-Black-tlf-sc-ot1--base.tfm) \
tex(Merriwthr-Black-tlf-sc-ot1.tfm) \
tex(Merriwthr-Black-tlf-sc-ot1.vf) \
tex(Merriwthr-Black-tlf-sc-t1--base.tfm) \
tex(Merriwthr-Black-tlf-sc-t1.tfm) \
tex(Merriwthr-Black-tlf-sc-t1.vf) \
tex(Merriwthr-Black-tlf-t1--base.tfm) \
tex(Merriwthr-Black-tlf-t1.tfm) \
tex(Merriwthr-Black-tlf-t1.vf) \
tex(Merriwthr-Black-tlf-ts1--base.tfm) \
tex(Merriwthr-Black-tlf-ts1.tfm) \
tex(Merriwthr-Black-tlf-ts1.vf) \
tex(Merriwthr-Black-tosf-ly1.tfm) \
tex(Merriwthr-Black-tosf-ot1.tfm) \
tex(Merriwthr-Black-tosf-sc-ly1--base.tfm) \
tex(Merriwthr-Black-tosf-sc-ly1.tfm) \
tex(Merriwthr-Black-tosf-sc-ly1.vf) \
tex(Merriwthr-Black-tosf-sc-ot1--base.tfm) \
tex(Merriwthr-Black-tosf-sc-ot1.tfm) \
tex(Merriwthr-Black-tosf-sc-ot1.vf) \
tex(Merriwthr-Black-tosf-sc-t1--base.tfm) \
tex(Merriwthr-Black-tosf-sc-t1.tfm) \
tex(Merriwthr-Black-tosf-sc-t1.vf) \
tex(Merriwthr-Black-tosf-t1--base.tfm) \
tex(Merriwthr-Black-tosf-t1.tfm) \
tex(Merriwthr-Black-tosf-t1.vf) \
tex(Merriwthr-Black-tosf-ts1--base.tfm) \
tex(Merriwthr-Black-tosf-ts1.tfm) \
tex(Merriwthr-Black-tosf-ts1.vf) \
tex(Merriwthr-BlackItalic-lf-ly1.tfm) \
tex(Merriwthr-BlackItalic-lf-ot1.tfm) \
tex(Merriwthr-BlackItalic-lf-sc-ly1--base.tfm) \
tex(Merriwthr-BlackItalic-lf-sc-ly1.tfm) \
tex(Merriwthr-BlackItalic-lf-sc-ly1.vf) \
tex(Merriwthr-BlackItalic-lf-sc-ot1--base.tfm) \
tex(Merriwthr-BlackItalic-lf-sc-ot1.tfm) \
tex(Merriwthr-BlackItalic-lf-sc-ot1.vf) \
tex(Merriwthr-BlackItalic-lf-sc-t1--base.tfm) \
tex(Merriwthr-BlackItalic-lf-sc-t1.tfm) \
tex(Merriwthr-BlackItalic-lf-sc-t1.vf) \
tex(Merriwthr-BlackItalic-lf-t1--base.tfm) \
tex(Merriwthr-BlackItalic-lf-t1.tfm) \
tex(Merriwthr-BlackItalic-lf-t1.vf) \
tex(Merriwthr-BlackItalic-lf-ts1--base.tfm) \
tex(Merriwthr-BlackItalic-lf-ts1.tfm) \
tex(Merriwthr-BlackItalic-lf-ts1.vf) \
tex(Merriwthr-BlackItalic-osf-ly1.tfm) \
tex(Merriwthr-BlackItalic-osf-ot1.tfm) \
tex(Merriwthr-BlackItalic-osf-sc-ly1--base.tfm) \
tex(Merriwthr-BlackItalic-osf-sc-ly1.tfm) \
tex(Merriwthr-BlackItalic-osf-sc-ly1.vf) \
tex(Merriwthr-BlackItalic-osf-sc-ot1--base.tfm) \
tex(Merriwthr-BlackItalic-osf-sc-ot1.tfm) \
tex(Merriwthr-BlackItalic-osf-sc-ot1.vf) \
tex(Merriwthr-BlackItalic-osf-sc-t1--base.tfm) \
tex(Merriwthr-BlackItalic-osf-sc-t1.tfm) \
tex(Merriwthr-BlackItalic-osf-sc-t1.vf) \
tex(Merriwthr-BlackItalic-osf-t1--base.tfm) \
tex(Merriwthr-BlackItalic-osf-t1.tfm) \
tex(Merriwthr-BlackItalic-osf-t1.vf) \
tex(Merriwthr-BlackItalic-osf-ts1--base.tfm) \
tex(Merriwthr-BlackItalic-osf-ts1.tfm) \
tex(Merriwthr-BlackItalic-osf-ts1.vf) \
tex(Merriwthr-BlackItalic-sup-ly1.tfm) \
tex(Merriwthr-BlackItalic-sup-ot1.tfm) \
tex(Merriwthr-BlackItalic-sup-t1--base.tfm) \
tex(Merriwthr-BlackItalic-sup-t1.tfm) \
tex(Merriwthr-BlackItalic-sup-t1.vf) \
tex(Merriwthr-BlackItalic-tlf-ly1.tfm) \
tex(Merriwthr-BlackItalic-tlf-ot1.tfm) \
tex(Merriwthr-BlackItalic-tlf-sc-ly1--base.tfm) \
tex(Merriwthr-BlackItalic-tlf-sc-ly1.tfm) \
tex(Merriwthr-BlackItalic-tlf-sc-ly1.vf) \
tex(Merriwthr-BlackItalic-tlf-sc-ot1--base.tfm) \
tex(Merriwthr-BlackItalic-tlf-sc-ot1.tfm) \
tex(Merriwthr-BlackItalic-tlf-sc-ot1.vf) \
tex(Merriwthr-BlackItalic-tlf-sc-t1--base.tfm) \
tex(Merriwthr-BlackItalic-tlf-sc-t1.tfm) \
tex(Merriwthr-BlackItalic-tlf-sc-t1.vf) \
tex(Merriwthr-BlackItalic-tlf-t1--base.tfm) \
tex(Merriwthr-BlackItalic-tlf-t1.tfm) \
tex(Merriwthr-BlackItalic-tlf-t1.vf) \
tex(Merriwthr-BlackItalic-tlf-ts1--base.tfm) \
tex(Merriwthr-BlackItalic-tlf-ts1.tfm) \
tex(Merriwthr-BlackItalic-tlf-ts1.vf) \
tex(Merriwthr-BlackItalic-tosf-ly1.tfm) \
tex(Merriwthr-BlackItalic-tosf-ot1.tfm) \
tex(Merriwthr-BlackItalic-tosf-sc-ly1--base.tfm) \
tex(Merriwthr-BlackItalic-tosf-sc-ly1.tfm) \
tex(Merriwthr-BlackItalic-tosf-sc-ly1.vf) \
tex(Merriwthr-BlackItalic-tosf-sc-ot1--base.tfm) \
tex(Merriwthr-BlackItalic-tosf-sc-ot1.tfm) \
tex(Merriwthr-BlackItalic-tosf-sc-ot1.vf) \
tex(Merriwthr-BlackItalic-tosf-sc-t1--base.tfm) \
tex(Merriwthr-BlackItalic-tosf-sc-t1.tfm) \
tex(Merriwthr-BlackItalic-tosf-sc-t1.vf) \
tex(Merriwthr-BlackItalic-tosf-t1--base.tfm) \
tex(Merriwthr-BlackItalic-tosf-t1.tfm) \
tex(Merriwthr-BlackItalic-tosf-t1.vf) \
tex(Merriwthr-BlackItalic-tosf-ts1--base.tfm) \
tex(Merriwthr-BlackItalic-tosf-ts1.tfm) \
tex(Merriwthr-BlackItalic-tosf-ts1.vf) \
tex(Merriwthr-Bold-lf-ly1.tfm) \
tex(Merriwthr-Bold-lf-ot1.tfm) \
tex(Merriwthr-Bold-lf-sc-ly1--base.tfm) \
tex(Merriwthr-Bold-lf-sc-ly1.tfm) \
tex(Merriwthr-Bold-lf-sc-ly1.vf) \
tex(Merriwthr-Bold-lf-sc-ot1--base.tfm) \
tex(Merriwthr-Bold-lf-sc-ot1.tfm) \
tex(Merriwthr-Bold-lf-sc-ot1.vf) \
tex(Merriwthr-Bold-lf-sc-t1--base.tfm) \
tex(Merriwthr-Bold-lf-sc-t1.tfm) \
tex(Merriwthr-Bold-lf-sc-t1.vf) \
tex(Merriwthr-Bold-lf-t1--base.tfm) \
tex(Merriwthr-Bold-lf-t1.tfm) \
tex(Merriwthr-Bold-lf-t1.vf) \
tex(Merriwthr-Bold-lf-ts1--base.tfm) \
tex(Merriwthr-Bold-lf-ts1.tfm) \
tex(Merriwthr-Bold-lf-ts1.vf) \
tex(Merriwthr-Bold-osf-ly1.tfm) \
tex(Merriwthr-Bold-osf-ot1.tfm) \
tex(Merriwthr-Bold-osf-sc-ly1--base.tfm) \
tex(Merriwthr-Bold-osf-sc-ly1.tfm) \
tex(Merriwthr-Bold-osf-sc-ly1.vf) \
tex(Merriwthr-Bold-osf-sc-ot1--base.tfm) \
tex(Merriwthr-Bold-osf-sc-ot1.tfm) \
tex(Merriwthr-Bold-osf-sc-ot1.vf) \
tex(Merriwthr-Bold-osf-sc-t1--base.tfm) \
tex(Merriwthr-Bold-osf-sc-t1.tfm) \
tex(Merriwthr-Bold-osf-sc-t1.vf) \
tex(Merriwthr-Bold-osf-t1--base.tfm) \
tex(Merriwthr-Bold-osf-t1.tfm) \
tex(Merriwthr-Bold-osf-t1.vf) \
tex(Merriwthr-Bold-osf-ts1--base.tfm) \
tex(Merriwthr-Bold-osf-ts1.tfm) \
tex(Merriwthr-Bold-osf-ts1.vf) \
tex(Merriwthr-Bold-sup-ly1.tfm) \
tex(Merriwthr-Bold-sup-ot1.tfm) \
tex(Merriwthr-Bold-sup-t1--base.tfm) \
tex(Merriwthr-Bold-sup-t1.tfm) \
tex(Merriwthr-Bold-sup-t1.vf) \
tex(Merriwthr-Bold-tlf-ly1.tfm) \
tex(Merriwthr-Bold-tlf-ot1.tfm) \
tex(Merriwthr-Bold-tlf-sc-ly1--base.tfm) \
tex(Merriwthr-Bold-tlf-sc-ly1.tfm) \
tex(Merriwthr-Bold-tlf-sc-ly1.vf) \
tex(Merriwthr-Bold-tlf-sc-ot1--base.tfm) \
tex(Merriwthr-Bold-tlf-sc-ot1.tfm) \
tex(Merriwthr-Bold-tlf-sc-ot1.vf) \
tex(Merriwthr-Bold-tlf-sc-t1--base.tfm) \
tex(Merriwthr-Bold-tlf-sc-t1.tfm) \
tex(Merriwthr-Bold-tlf-sc-t1.vf) \
tex(Merriwthr-Bold-tlf-t1--base.tfm) \
tex(Merriwthr-Bold-tlf-t1.tfm) \
tex(Merriwthr-Bold-tlf-t1.vf) \
tex(Merriwthr-Bold-tlf-ts1--base.tfm) \
tex(Merriwthr-Bold-tlf-ts1.tfm) \
tex(Merriwthr-Bold-tlf-ts1.vf) \
tex(Merriwthr-Bold-tosf-ly1.tfm) \
tex(Merriwthr-Bold-tosf-ot1.tfm) \
tex(Merriwthr-Bold-tosf-sc-ly1--base.tfm) \
tex(Merriwthr-Bold-tosf-sc-ly1.tfm) \
tex(Merriwthr-Bold-tosf-sc-ly1.vf) \
tex(Merriwthr-Bold-tosf-sc-ot1--base.tfm) \
tex(Merriwthr-Bold-tosf-sc-ot1.tfm) \
tex(Merriwthr-Bold-tosf-sc-ot1.vf) \
tex(Merriwthr-Bold-tosf-sc-t1--base.tfm) \
tex(Merriwthr-Bold-tosf-sc-t1.tfm) \
tex(Merriwthr-Bold-tosf-sc-t1.vf) \
tex(Merriwthr-Bold-tosf-t1--base.tfm) \
tex(Merriwthr-Bold-tosf-t1.tfm) \
tex(Merriwthr-Bold-tosf-t1.vf) \
tex(Merriwthr-Bold-tosf-ts1--base.tfm) \
tex(Merriwthr-Bold-tosf-ts1.tfm) \
tex(Merriwthr-Bold-tosf-ts1.vf) \
tex(Merriwthr-BoldItalic-lf-ly1.tfm) \
tex(Merriwthr-BoldItalic-lf-ot1.tfm) \
tex(Merriwthr-BoldItalic-lf-sc-ly1--base.tfm) \
tex(Merriwthr-BoldItalic-lf-sc-ly1.tfm) \
tex(Merriwthr-BoldItalic-lf-sc-ly1.vf) \
tex(Merriwthr-BoldItalic-lf-sc-ot1--base.tfm) \
tex(Merriwthr-BoldItalic-lf-sc-ot1.tfm) \
tex(Merriwthr-BoldItalic-lf-sc-ot1.vf) \
tex(Merriwthr-BoldItalic-lf-sc-t1--base.tfm) \
tex(Merriwthr-BoldItalic-lf-sc-t1.tfm) \
tex(Merriwthr-BoldItalic-lf-sc-t1.vf) \
tex(Merriwthr-BoldItalic-lf-t1--base.tfm) \
tex(Merriwthr-BoldItalic-lf-t1.tfm) \
tex(Merriwthr-BoldItalic-lf-t1.vf) \
tex(Merriwthr-BoldItalic-lf-ts1--base.tfm) \
tex(Merriwthr-BoldItalic-lf-ts1.tfm) \
tex(Merriwthr-BoldItalic-lf-ts1.vf) \
tex(Merriwthr-BoldItalic-osf-ly1.tfm) \
tex(Merriwthr-BoldItalic-osf-ot1.tfm) \
tex(Merriwthr-BoldItalic-osf-sc-ly1--base.tfm) \
tex(Merriwthr-BoldItalic-osf-sc-ly1.tfm) \
tex(Merriwthr-BoldItalic-osf-sc-ly1.vf) \
tex(Merriwthr-BoldItalic-osf-sc-ot1--base.tfm) \
tex(Merriwthr-BoldItalic-osf-sc-ot1.tfm) \
tex(Merriwthr-BoldItalic-osf-sc-ot1.vf) \
tex(Merriwthr-BoldItalic-osf-sc-t1--base.tfm) \
tex(Merriwthr-BoldItalic-osf-sc-t1.tfm) \
tex(Merriwthr-BoldItalic-osf-sc-t1.vf) \
tex(Merriwthr-BoldItalic-osf-t1--base.tfm) \
tex(Merriwthr-BoldItalic-osf-t1.tfm) \
tex(Merriwthr-BoldItalic-osf-t1.vf) \
tex(Merriwthr-BoldItalic-osf-ts1--base.tfm) \
tex(Merriwthr-BoldItalic-osf-ts1.tfm) \
tex(Merriwthr-BoldItalic-osf-ts1.vf) \
tex(Merriwthr-BoldItalic-sup-ly1.tfm) \
tex(Merriwthr-BoldItalic-sup-ot1.tfm) \
tex(Merriwthr-BoldItalic-sup-t1--base.tfm) \
tex(Merriwthr-BoldItalic-sup-t1.tfm) \
tex(Merriwthr-BoldItalic-sup-t1.vf) \
tex(Merriwthr-BoldItalic-tlf-ly1.tfm) \
tex(Merriwthr-BoldItalic-tlf-ot1.tfm) \
tex(Merriwthr-BoldItalic-tlf-sc-ly1--base.tfm) \
tex(Merriwthr-BoldItalic-tlf-sc-ly1.tfm) \
tex(Merriwthr-BoldItalic-tlf-sc-ly1.vf) \
tex(Merriwthr-BoldItalic-tlf-sc-ot1--base.tfm) \
tex(Merriwthr-BoldItalic-tlf-sc-ot1.tfm) \
tex(Merriwthr-BoldItalic-tlf-sc-ot1.vf) \
tex(Merriwthr-BoldItalic-tlf-sc-t1--base.tfm) \
tex(Merriwthr-BoldItalic-tlf-sc-t1.tfm) \
tex(Merriwthr-BoldItalic-tlf-sc-t1.vf) \
tex(Merriwthr-BoldItalic-tlf-t1--base.tfm) \
tex(Merriwthr-BoldItalic-tlf-t1.tfm) \
tex(Merriwthr-BoldItalic-tlf-t1.vf) \
tex(Merriwthr-BoldItalic-tlf-ts1--base.tfm) \
tex(Merriwthr-BoldItalic-tlf-ts1.tfm) \
tex(Merriwthr-BoldItalic-tlf-ts1.vf) \
tex(Merriwthr-BoldItalic-tosf-ly1.tfm) \
tex(Merriwthr-BoldItalic-tosf-ot1.tfm) \
tex(Merriwthr-BoldItalic-tosf-sc-ly1--base.tfm) \
tex(Merriwthr-BoldItalic-tosf-sc-ly1.tfm) \
tex(Merriwthr-BoldItalic-tosf-sc-ly1.vf) \
tex(Merriwthr-BoldItalic-tosf-sc-ot1--base.tfm) \
tex(Merriwthr-BoldItalic-tosf-sc-ot1.tfm) \
tex(Merriwthr-BoldItalic-tosf-sc-ot1.vf) \
tex(Merriwthr-BoldItalic-tosf-sc-t1--base.tfm) \
tex(Merriwthr-BoldItalic-tosf-sc-t1.tfm) \
tex(Merriwthr-BoldItalic-tosf-sc-t1.vf) \
tex(Merriwthr-BoldItalic-tosf-t1--base.tfm) \
tex(Merriwthr-BoldItalic-tosf-t1.tfm) \
tex(Merriwthr-BoldItalic-tosf-t1.vf) \
tex(Merriwthr-BoldItalic-tosf-ts1--base.tfm) \
tex(Merriwthr-BoldItalic-tosf-ts1.tfm) \
tex(Merriwthr-BoldItalic-tosf-ts1.vf) \
tex(Merriwthr-Italic-lf-ly1.tfm) \
tex(Merriwthr-Italic-lf-ot1.tfm) \
tex(Merriwthr-Italic-lf-sc-ly1--base.tfm) \
tex(Merriwthr-Italic-lf-sc-ly1.tfm) \
tex(Merriwthr-Italic-lf-sc-ly1.vf) \
tex(Merriwthr-Italic-lf-sc-ot1--base.tfm) \
tex(Merriwthr-Italic-lf-sc-ot1.tfm) \
tex(Merriwthr-Italic-lf-sc-ot1.vf) \
tex(Merriwthr-Italic-lf-sc-t1--base.tfm) \
tex(Merriwthr-Italic-lf-sc-t1.tfm) \
tex(Merriwthr-Italic-lf-sc-t1.vf) \
tex(Merriwthr-Italic-lf-t1--base.tfm) \
tex(Merriwthr-Italic-lf-t1.tfm) \
tex(Merriwthr-Italic-lf-t1.vf) \
tex(Merriwthr-Italic-lf-ts1--base.tfm) \
tex(Merriwthr-Italic-lf-ts1.tfm) \
tex(Merriwthr-Italic-lf-ts1.vf) \
tex(Merriwthr-Italic-osf-ly1.tfm) \
tex(Merriwthr-Italic-osf-ot1.tfm) \
tex(Merriwthr-Italic-osf-sc-ly1--base.tfm) \
tex(Merriwthr-Italic-osf-sc-ly1.tfm) \
tex(Merriwthr-Italic-osf-sc-ly1.vf) \
tex(Merriwthr-Italic-osf-sc-ot1--base.tfm) \
tex(Merriwthr-Italic-osf-sc-ot1.tfm) \
tex(Merriwthr-Italic-osf-sc-ot1.vf) \
tex(Merriwthr-Italic-osf-sc-t1--base.tfm) \
tex(Merriwthr-Italic-osf-sc-t1.tfm) \
tex(Merriwthr-Italic-osf-sc-t1.vf) \
tex(Merriwthr-Italic-osf-t1--base.tfm) \
tex(Merriwthr-Italic-osf-t1.tfm) \
tex(Merriwthr-Italic-osf-t1.vf) \
tex(Merriwthr-Italic-osf-ts1--base.tfm) \
tex(Merriwthr-Italic-osf-ts1.tfm) \
tex(Merriwthr-Italic-osf-ts1.vf) \
tex(Merriwthr-Italic-sup-ly1.tfm) \
tex(Merriwthr-Italic-sup-ot1.tfm) \
tex(Merriwthr-Italic-sup-t1--base.tfm) \
tex(Merriwthr-Italic-sup-t1.tfm) \
tex(Merriwthr-Italic-sup-t1.vf) \
tex(Merriwthr-Italic-tlf-ly1.tfm) \
tex(Merriwthr-Italic-tlf-ot1.tfm) \
tex(Merriwthr-Italic-tlf-sc-ly1--base.tfm) \
tex(Merriwthr-Italic-tlf-sc-ly1.tfm) \
tex(Merriwthr-Italic-tlf-sc-ly1.vf) \
tex(Merriwthr-Italic-tlf-sc-ot1--base.tfm) \
tex(Merriwthr-Italic-tlf-sc-ot1.tfm) \
tex(Merriwthr-Italic-tlf-sc-ot1.vf) \
tex(Merriwthr-Italic-tlf-sc-t1--base.tfm) \
tex(Merriwthr-Italic-tlf-sc-t1.tfm) \
tex(Merriwthr-Italic-tlf-sc-t1.vf) \
tex(Merriwthr-Italic-tlf-t1--base.tfm) \
tex(Merriwthr-Italic-tlf-t1.tfm) \
tex(Merriwthr-Italic-tlf-t1.vf) \
tex(Merriwthr-Italic-tlf-ts1--base.tfm) \
tex(Merriwthr-Italic-tlf-ts1.tfm) \
tex(Merriwthr-Italic-tlf-ts1.vf) \
tex(Merriwthr-Italic-tosf-ly1.tfm) \
tex(Merriwthr-Italic-tosf-ot1.tfm) \
tex(Merriwthr-Italic-tosf-sc-ly1--base.tfm) \
tex(Merriwthr-Italic-tosf-sc-ly1.tfm) \
tex(Merriwthr-Italic-tosf-sc-ly1.vf) \
tex(Merriwthr-Italic-tosf-sc-ot1--base.tfm) \
tex(Merriwthr-Italic-tosf-sc-ot1.tfm) \
tex(Merriwthr-Italic-tosf-sc-ot1.vf) \
tex(Merriwthr-Italic-tosf-sc-t1--base.tfm) \
tex(Merriwthr-Italic-tosf-sc-t1.tfm) \
tex(Merriwthr-Italic-tosf-sc-t1.vf) \
tex(Merriwthr-Italic-tosf-t1--base.tfm) \
tex(Merriwthr-Italic-tosf-t1.tfm) \
tex(Merriwthr-Italic-tosf-t1.vf) \
tex(Merriwthr-Italic-tosf-ts1--base.tfm) \
tex(Merriwthr-Italic-tosf-ts1.tfm) \
tex(Merriwthr-Italic-tosf-ts1.vf) \
tex(Merriwthr-Light-lf-ly1.tfm) \
tex(Merriwthr-Light-lf-ot1.tfm) \
tex(Merriwthr-Light-lf-sc-ly1--base.tfm) \
tex(Merriwthr-Light-lf-sc-ly1.tfm) \
tex(Merriwthr-Light-lf-sc-ly1.vf) \
tex(Merriwthr-Light-lf-sc-ot1--base.tfm) \
tex(Merriwthr-Light-lf-sc-ot1.tfm) \
tex(Merriwthr-Light-lf-sc-ot1.vf) \
tex(Merriwthr-Light-lf-sc-t1--base.tfm) \
tex(Merriwthr-Light-lf-sc-t1.tfm) \
tex(Merriwthr-Light-lf-sc-t1.vf) \
tex(Merriwthr-Light-lf-t1--base.tfm) \
tex(Merriwthr-Light-lf-t1.tfm) \
tex(Merriwthr-Light-lf-t1.vf) \
tex(Merriwthr-Light-lf-ts1--base.tfm) \
tex(Merriwthr-Light-lf-ts1.tfm) \
tex(Merriwthr-Light-lf-ts1.vf) \
tex(Merriwthr-Light-osf-ly1.tfm) \
tex(Merriwthr-Light-osf-ot1.tfm) \
tex(Merriwthr-Light-osf-sc-ly1--base.tfm) \
tex(Merriwthr-Light-osf-sc-ly1.tfm) \
tex(Merriwthr-Light-osf-sc-ly1.vf) \
tex(Merriwthr-Light-osf-sc-ot1--base.tfm) \
tex(Merriwthr-Light-osf-sc-ot1.tfm) \
tex(Merriwthr-Light-osf-sc-ot1.vf) \
tex(Merriwthr-Light-osf-sc-t1--base.tfm) \
tex(Merriwthr-Light-osf-sc-t1.tfm) \
tex(Merriwthr-Light-osf-sc-t1.vf) \
tex(Merriwthr-Light-osf-t1--base.tfm) \
tex(Merriwthr-Light-osf-t1.tfm) \
tex(Merriwthr-Light-osf-t1.vf) \
tex(Merriwthr-Light-osf-ts1--base.tfm) \
tex(Merriwthr-Light-osf-ts1.tfm) \
tex(Merriwthr-Light-osf-ts1.vf) \
tex(Merriwthr-Light-sup-ly1.tfm) \
tex(Merriwthr-Light-sup-ot1.tfm) \
tex(Merriwthr-Light-sup-t1--base.tfm) \
tex(Merriwthr-Light-sup-t1.tfm) \
tex(Merriwthr-Light-sup-t1.vf) \
tex(Merriwthr-Light-tlf-ly1.tfm) \
tex(Merriwthr-Light-tlf-ot1.tfm) \
tex(Merriwthr-Light-tlf-sc-ly1--base.tfm) \
tex(Merriwthr-Light-tlf-sc-ly1.tfm) \
tex(Merriwthr-Light-tlf-sc-ly1.vf) \
tex(Merriwthr-Light-tlf-sc-ot1--base.tfm) \
tex(Merriwthr-Light-tlf-sc-ot1.tfm) \
tex(Merriwthr-Light-tlf-sc-ot1.vf) \
tex(Merriwthr-Light-tlf-sc-t1--base.tfm) \
tex(Merriwthr-Light-tlf-sc-t1.tfm) \
tex(Merriwthr-Light-tlf-sc-t1.vf) \
tex(Merriwthr-Light-tlf-t1--base.tfm) \
tex(Merriwthr-Light-tlf-t1.tfm) \
tex(Merriwthr-Light-tlf-t1.vf) \
tex(Merriwthr-Light-tlf-ts1--base.tfm) \
tex(Merriwthr-Light-tlf-ts1.tfm) \
tex(Merriwthr-Light-tlf-ts1.vf) \
tex(Merriwthr-Light-tosf-ly1.tfm) \
tex(Merriwthr-Light-tosf-ot1.tfm) \
tex(Merriwthr-Light-tosf-sc-ly1--base.tfm) \
tex(Merriwthr-Light-tosf-sc-ly1.tfm) \
tex(Merriwthr-Light-tosf-sc-ly1.vf) \
tex(Merriwthr-Light-tosf-sc-ot1--base.tfm) \
tex(Merriwthr-Light-tosf-sc-ot1.tfm) \
tex(Merriwthr-Light-tosf-sc-ot1.vf) \
tex(Merriwthr-Light-tosf-sc-t1--base.tfm) \
tex(Merriwthr-Light-tosf-sc-t1.tfm) \
tex(Merriwthr-Light-tosf-sc-t1.vf) \
tex(Merriwthr-Light-tosf-t1--base.tfm) \
tex(Merriwthr-Light-tosf-t1.tfm) \
tex(Merriwthr-Light-tosf-t1.vf) \
tex(Merriwthr-Light-tosf-ts1--base.tfm) \
tex(Merriwthr-Light-tosf-ts1.tfm) \
tex(Merriwthr-Light-tosf-ts1.vf) \
tex(Merriwthr-LightItalic-lf-ly1.tfm) \
tex(Merriwthr-LightItalic-lf-ot1.tfm) \
tex(Merriwthr-LightItalic-lf-sc-ly1--base.tfm) \
tex(Merriwthr-LightItalic-lf-sc-ly1.tfm) \
tex(Merriwthr-LightItalic-lf-sc-ly1.vf) \
tex(Merriwthr-LightItalic-lf-sc-ot1--base.tfm) \
tex(Merriwthr-LightItalic-lf-sc-ot1.tfm) \
tex(Merriwthr-LightItalic-lf-sc-ot1.vf) \
tex(Merriwthr-LightItalic-lf-sc-t1--base.tfm) \
tex(Merriwthr-LightItalic-lf-sc-t1.tfm) \
tex(Merriwthr-LightItalic-lf-sc-t1.vf) \
tex(Merriwthr-LightItalic-lf-t1--base.tfm) \
tex(Merriwthr-LightItalic-lf-t1.tfm) \
tex(Merriwthr-LightItalic-lf-t1.vf) \
tex(Merriwthr-LightItalic-lf-ts1--base.tfm) \
tex(Merriwthr-LightItalic-lf-ts1.tfm) \
tex(Merriwthr-LightItalic-lf-ts1.vf) \
tex(Merriwthr-LightItalic-osf-ly1.tfm) \
tex(Merriwthr-LightItalic-osf-ot1.tfm) \
tex(Merriwthr-LightItalic-osf-sc-ly1--base.tfm) \
tex(Merriwthr-LightItalic-osf-sc-ly1.tfm) \
tex(Merriwthr-LightItalic-osf-sc-ly1.vf) \
tex(Merriwthr-LightItalic-osf-sc-ot1--base.tfm) \
tex(Merriwthr-LightItalic-osf-sc-ot1.tfm) \
tex(Merriwthr-LightItalic-osf-sc-ot1.vf) \
tex(Merriwthr-LightItalic-osf-sc-t1--base.tfm) \
tex(Merriwthr-LightItalic-osf-sc-t1.tfm) \
tex(Merriwthr-LightItalic-osf-sc-t1.vf) \
tex(Merriwthr-LightItalic-osf-t1--base.tfm) \
tex(Merriwthr-LightItalic-osf-t1.tfm) \
tex(Merriwthr-LightItalic-osf-t1.vf) \
tex(Merriwthr-LightItalic-osf-ts1--base.tfm) \
tex(Merriwthr-LightItalic-osf-ts1.tfm) \
tex(Merriwthr-LightItalic-osf-ts1.vf) \
tex(Merriwthr-LightItalic-sup-ly1.tfm) \
tex(Merriwthr-LightItalic-sup-ot1.tfm) \
tex(Merriwthr-LightItalic-sup-t1--base.tfm) \
tex(Merriwthr-LightItalic-sup-t1.tfm) \
tex(Merriwthr-LightItalic-sup-t1.vf) \
tex(Merriwthr-LightItalic-tlf-ly1.tfm) \
tex(Merriwthr-LightItalic-tlf-ot1.tfm) \
tex(Merriwthr-LightItalic-tlf-sc-ly1--base.tfm) \
tex(Merriwthr-LightItalic-tlf-sc-ly1.tfm) \
tex(Merriwthr-LightItalic-tlf-sc-ly1.vf) \
tex(Merriwthr-LightItalic-tlf-sc-ot1--base.tfm) \
tex(Merriwthr-LightItalic-tlf-sc-ot1.tfm) \
tex(Merriwthr-LightItalic-tlf-sc-ot1.vf) \
tex(Merriwthr-LightItalic-tlf-sc-t1--base.tfm) \
tex(Merriwthr-LightItalic-tlf-sc-t1.tfm) \
tex(Merriwthr-LightItalic-tlf-sc-t1.vf) \
tex(Merriwthr-LightItalic-tlf-t1--base.tfm) \
tex(Merriwthr-LightItalic-tlf-t1.tfm) \
tex(Merriwthr-LightItalic-tlf-t1.vf) \
tex(Merriwthr-LightItalic-tlf-ts1--base.tfm) \
tex(Merriwthr-LightItalic-tlf-ts1.tfm) \
tex(Merriwthr-LightItalic-tlf-ts1.vf) \
tex(Merriwthr-LightItalic-tosf-ly1.tfm) \
tex(Merriwthr-LightItalic-tosf-ot1.tfm) \
tex(Merriwthr-LightItalic-tosf-sc-ly1--base.tfm) \
tex(Merriwthr-LightItalic-tosf-sc-ly1.tfm) \
tex(Merriwthr-LightItalic-tosf-sc-ly1.vf) \
tex(Merriwthr-LightItalic-tosf-sc-ot1--base.tfm) \
tex(Merriwthr-LightItalic-tosf-sc-ot1.tfm) \
tex(Merriwthr-LightItalic-tosf-sc-ot1.vf) \
tex(Merriwthr-LightItalic-tosf-sc-t1--base.tfm) \
tex(Merriwthr-LightItalic-tosf-sc-t1.tfm) \
tex(Merriwthr-LightItalic-tosf-sc-t1.vf) \
tex(Merriwthr-LightItalic-tosf-t1--base.tfm) \
tex(Merriwthr-LightItalic-tosf-t1.tfm) \
tex(Merriwthr-LightItalic-tosf-t1.vf) \
tex(Merriwthr-LightItalic-tosf-ts1--base.tfm) \
tex(Merriwthr-LightItalic-tosf-ts1.tfm) \
tex(Merriwthr-LightItalic-tosf-ts1.vf) \
tex(Merriwthr-Regular-lf-ly1.tfm) \
tex(Merriwthr-Regular-lf-ot1.tfm) \
tex(Merriwthr-Regular-lf-sc-ly1--base.tfm) \
tex(Merriwthr-Regular-lf-sc-ly1.tfm) \
tex(Merriwthr-Regular-lf-sc-ly1.vf) \
tex(Merriwthr-Regular-lf-sc-ot1--base.tfm) \
tex(Merriwthr-Regular-lf-sc-ot1.tfm) \
tex(Merriwthr-Regular-lf-sc-ot1.vf) \
tex(Merriwthr-Regular-lf-sc-t1--base.tfm) \
tex(Merriwthr-Regular-lf-sc-t1.tfm) \
tex(Merriwthr-Regular-lf-sc-t1.vf) \
tex(Merriwthr-Regular-lf-t1--base.tfm) \
tex(Merriwthr-Regular-lf-t1.tfm) \
tex(Merriwthr-Regular-lf-t1.vf) \
tex(Merriwthr-Regular-lf-ts1--base.tfm) \
tex(Merriwthr-Regular-lf-ts1.tfm) \
tex(Merriwthr-Regular-lf-ts1.vf) \
tex(Merriwthr-Regular-osf-ly1.tfm) \
tex(Merriwthr-Regular-osf-ot1.tfm) \
tex(Merriwthr-Regular-osf-sc-ly1--base.tfm) \
tex(Merriwthr-Regular-osf-sc-ly1.tfm) \
tex(Merriwthr-Regular-osf-sc-ly1.vf) \
tex(Merriwthr-Regular-osf-sc-ot1--base.tfm) \
tex(Merriwthr-Regular-osf-sc-ot1.tfm) \
tex(Merriwthr-Regular-osf-sc-ot1.vf) \
tex(Merriwthr-Regular-osf-sc-t1--base.tfm) \
tex(Merriwthr-Regular-osf-sc-t1.tfm) \
tex(Merriwthr-Regular-osf-sc-t1.vf) \
tex(Merriwthr-Regular-osf-t1--base.tfm) \
tex(Merriwthr-Regular-osf-t1.tfm) \
tex(Merriwthr-Regular-osf-t1.vf) \
tex(Merriwthr-Regular-osf-ts1--base.tfm) \
tex(Merriwthr-Regular-osf-ts1.tfm) \
tex(Merriwthr-Regular-osf-ts1.vf) \
tex(Merriwthr-Regular-sup-ly1.tfm) \
tex(Merriwthr-Regular-sup-ot1.tfm) \
tex(Merriwthr-Regular-sup-t1--base.tfm) \
tex(Merriwthr-Regular-sup-t1.tfm) \
tex(Merriwthr-Regular-sup-t1.vf) \
tex(Merriwthr-Regular-tlf-ly1.tfm) \
tex(Merriwthr-Regular-tlf-ot1.tfm) \
tex(Merriwthr-Regular-tlf-sc-ly1--base.tfm) \
tex(Merriwthr-Regular-tlf-sc-ly1.tfm) \
tex(Merriwthr-Regular-tlf-sc-ly1.vf) \
tex(Merriwthr-Regular-tlf-sc-ot1--base.tfm) \
tex(Merriwthr-Regular-tlf-sc-ot1.tfm) \
tex(Merriwthr-Regular-tlf-sc-ot1.vf) \
tex(Merriwthr-Regular-tlf-sc-t1--base.tfm) \
tex(Merriwthr-Regular-tlf-sc-t1.tfm) \
tex(Merriwthr-Regular-tlf-sc-t1.vf) \
tex(Merriwthr-Regular-tlf-t1--base.tfm) \
tex(Merriwthr-Regular-tlf-t1.tfm) \
tex(Merriwthr-Regular-tlf-t1.vf) \
tex(Merriwthr-Regular-tlf-ts1--base.tfm) \
tex(Merriwthr-Regular-tlf-ts1.tfm) \
tex(Merriwthr-Regular-tlf-ts1.vf) \
tex(Merriwthr-Regular-tosf-ly1.tfm) \
tex(Merriwthr-Regular-tosf-ot1.tfm) \
tex(Merriwthr-Regular-tosf-sc-ly1--base.tfm) \
tex(Merriwthr-Regular-tosf-sc-ly1.tfm) \
tex(Merriwthr-Regular-tosf-sc-ly1.vf) \
tex(Merriwthr-Regular-tosf-sc-ot1--base.tfm) \
tex(Merriwthr-Regular-tosf-sc-ot1.tfm) \
tex(Merriwthr-Regular-tosf-sc-ot1.vf) \
tex(Merriwthr-Regular-tosf-sc-t1--base.tfm) \
tex(Merriwthr-Regular-tosf-sc-t1.tfm) \
tex(Merriwthr-Regular-tosf-sc-t1.vf) \
tex(Merriwthr-Regular-tosf-t1--base.tfm) \
tex(Merriwthr-Regular-tosf-t1.tfm) \
tex(Merriwthr-Regular-tosf-t1.vf) \
tex(Merriwthr-Regular-tosf-ts1--base.tfm) \
tex(Merriwthr-Regular-tosf-ts1.tfm) \
tex(Merriwthr-Regular-tosf-ts1.vf) \
tex(MerriwthrSans-Bold-lf-ly1.tfm) \
tex(MerriwthrSans-Bold-lf-ot1.tfm) \
tex(MerriwthrSans-Bold-lf-sc-ly1--base.tfm) \
tex(MerriwthrSans-Bold-lf-sc-ly1.tfm) \
tex(MerriwthrSans-Bold-lf-sc-ly1.vf) \
tex(MerriwthrSans-Bold-lf-sc-ot1--base.tfm) \
tex(MerriwthrSans-Bold-lf-sc-ot1.tfm) \
tex(MerriwthrSans-Bold-lf-sc-ot1.vf) \
tex(MerriwthrSans-Bold-lf-sc-t1--base.tfm) \
tex(MerriwthrSans-Bold-lf-sc-t1.tfm) \
tex(MerriwthrSans-Bold-lf-sc-t1.vf) \
tex(MerriwthrSans-Bold-lf-t1--base.tfm) \
tex(MerriwthrSans-Bold-lf-t1.tfm) \
tex(MerriwthrSans-Bold-lf-t1.vf) \
tex(MerriwthrSans-Bold-lf-ts1--base.tfm) \
tex(MerriwthrSans-Bold-lf-ts1.tfm) \
tex(MerriwthrSans-Bold-lf-ts1.vf) \
tex(MerriwthrSans-Bold-osf-ly1.tfm) \
tex(MerriwthrSans-Bold-osf-ot1.tfm) \
tex(MerriwthrSans-Bold-osf-sc-ly1--base.tfm) \
tex(MerriwthrSans-Bold-osf-sc-ly1.tfm) \
tex(MerriwthrSans-Bold-osf-sc-ly1.vf) \
tex(MerriwthrSans-Bold-osf-sc-ot1--base.tfm) \
tex(MerriwthrSans-Bold-osf-sc-ot1.tfm) \
tex(MerriwthrSans-Bold-osf-sc-ot1.vf) \
tex(MerriwthrSans-Bold-osf-sc-t1--base.tfm) \
tex(MerriwthrSans-Bold-osf-sc-t1.tfm) \
tex(MerriwthrSans-Bold-osf-sc-t1.vf) \
tex(MerriwthrSans-Bold-osf-t1--base.tfm) \
tex(MerriwthrSans-Bold-osf-t1.tfm) \
tex(MerriwthrSans-Bold-osf-t1.vf) \
tex(MerriwthrSans-Bold-osf-ts1--base.tfm) \
tex(MerriwthrSans-Bold-osf-ts1.tfm) \
tex(MerriwthrSans-Bold-osf-ts1.vf) \
tex(MerriwthrSans-Bold-sup-ly1.tfm) \
tex(MerriwthrSans-Bold-sup-ot1.tfm) \
tex(MerriwthrSans-Bold-sup-t1--base.tfm) \
tex(MerriwthrSans-Bold-sup-t1.tfm) \
tex(MerriwthrSans-Bold-sup-t1.vf) \
tex(MerriwthrSans-Bold-tlf-ly1.tfm) \
tex(MerriwthrSans-Bold-tlf-ot1.tfm) \
tex(MerriwthrSans-Bold-tlf-sc-ly1--base.tfm) \
tex(MerriwthrSans-Bold-tlf-sc-ly1.tfm) \
tex(MerriwthrSans-Bold-tlf-sc-ly1.vf) \
tex(MerriwthrSans-Bold-tlf-sc-ot1--base.tfm) \
tex(MerriwthrSans-Bold-tlf-sc-ot1.tfm) \
tex(MerriwthrSans-Bold-tlf-sc-ot1.vf) \
tex(MerriwthrSans-Bold-tlf-sc-t1--base.tfm) \
tex(MerriwthrSans-Bold-tlf-sc-t1.tfm) \
tex(MerriwthrSans-Bold-tlf-sc-t1.vf) \
tex(MerriwthrSans-Bold-tlf-t1--base.tfm) \
tex(MerriwthrSans-Bold-tlf-t1.tfm) \
tex(MerriwthrSans-Bold-tlf-t1.vf) \
tex(MerriwthrSans-Bold-tlf-ts1--base.tfm) \
tex(MerriwthrSans-Bold-tlf-ts1.tfm) \
tex(MerriwthrSans-Bold-tlf-ts1.vf) \
tex(MerriwthrSans-Bold-tosf-ly1.tfm) \
tex(MerriwthrSans-Bold-tosf-ot1.tfm) \
tex(MerriwthrSans-Bold-tosf-sc-ly1--base.tfm) \
tex(MerriwthrSans-Bold-tosf-sc-ly1.tfm) \
tex(MerriwthrSans-Bold-tosf-sc-ly1.vf) \
tex(MerriwthrSans-Bold-tosf-sc-ot1--base.tfm) \
tex(MerriwthrSans-Bold-tosf-sc-ot1.tfm) \
tex(MerriwthrSans-Bold-tosf-sc-ot1.vf) \
tex(MerriwthrSans-Bold-tosf-sc-t1--base.tfm) \
tex(MerriwthrSans-Bold-tosf-sc-t1.tfm) \
tex(MerriwthrSans-Bold-tosf-sc-t1.vf) \
tex(MerriwthrSans-Bold-tosf-t1--base.tfm) \
tex(MerriwthrSans-Bold-tosf-t1.tfm) \
tex(MerriwthrSans-Bold-tosf-t1.vf) \
tex(MerriwthrSans-Bold-tosf-ts1--base.tfm) \
tex(MerriwthrSans-Bold-tosf-ts1.tfm) \
tex(MerriwthrSans-Bold-tosf-ts1.vf) \
tex(MerriwthrSans-BoldItalic-lf-ly1.tfm) \
tex(MerriwthrSans-BoldItalic-lf-ot1.tfm) \
tex(MerriwthrSans-BoldItalic-lf-sc-ly1--base.tfm) \
tex(MerriwthrSans-BoldItalic-lf-sc-ly1.tfm) \
tex(MerriwthrSans-BoldItalic-lf-sc-ly1.vf) \
tex(MerriwthrSans-BoldItalic-lf-sc-ot1--base.tfm) \
tex(MerriwthrSans-BoldItalic-lf-sc-ot1.tfm) \
tex(MerriwthrSans-BoldItalic-lf-sc-ot1.vf) \
tex(MerriwthrSans-BoldItalic-lf-sc-t1--base.tfm) \
tex(MerriwthrSans-BoldItalic-lf-sc-t1.tfm) \
tex(MerriwthrSans-BoldItalic-lf-sc-t1.vf) \
tex(MerriwthrSans-BoldItalic-lf-t1--base.tfm) \
tex(MerriwthrSans-BoldItalic-lf-t1.tfm) \
tex(MerriwthrSans-BoldItalic-lf-t1.vf) \
tex(MerriwthrSans-BoldItalic-lf-ts1--base.tfm) \
tex(MerriwthrSans-BoldItalic-lf-ts1.tfm) \
tex(MerriwthrSans-BoldItalic-lf-ts1.vf) \
tex(MerriwthrSans-BoldItalic-osf-ly1.tfm) \
tex(MerriwthrSans-BoldItalic-osf-ot1.tfm) \
tex(MerriwthrSans-BoldItalic-osf-sc-ly1--base.tfm) \
tex(MerriwthrSans-BoldItalic-osf-sc-ly1.tfm) \
tex(MerriwthrSans-BoldItalic-osf-sc-ly1.vf) \
tex(MerriwthrSans-BoldItalic-osf-sc-ot1--base.tfm) \
tex(MerriwthrSans-BoldItalic-osf-sc-ot1.tfm) \
tex(MerriwthrSans-BoldItalic-osf-sc-ot1.vf) \
tex(MerriwthrSans-BoldItalic-osf-sc-t1--base.tfm) \
tex(MerriwthrSans-BoldItalic-osf-sc-t1.tfm) \
tex(MerriwthrSans-BoldItalic-osf-sc-t1.vf) \
tex(MerriwthrSans-BoldItalic-osf-t1--base.tfm) \
tex(MerriwthrSans-BoldItalic-osf-t1.tfm) \
tex(MerriwthrSans-BoldItalic-osf-t1.vf) \
tex(MerriwthrSans-BoldItalic-osf-ts1--base.tfm) \
tex(MerriwthrSans-BoldItalic-osf-ts1.tfm) \
tex(MerriwthrSans-BoldItalic-osf-ts1.vf) \
tex(MerriwthrSans-BoldItalic-sup-ly1.tfm) \
tex(MerriwthrSans-BoldItalic-sup-ot1.tfm) \
tex(MerriwthrSans-BoldItalic-sup-t1--base.tfm) \
tex(MerriwthrSans-BoldItalic-sup-t1.tfm) \
tex(MerriwthrSans-BoldItalic-sup-t1.vf) \
tex(MerriwthrSans-BoldItalic-tlf-ly1.tfm) \
tex(MerriwthrSans-BoldItalic-tlf-ot1.tfm) \
tex(MerriwthrSans-BoldItalic-tlf-sc-ly1--base.tfm) \
tex(MerriwthrSans-BoldItalic-tlf-sc-ly1.tfm) \
tex(MerriwthrSans-BoldItalic-tlf-sc-ly1.vf) \
tex(MerriwthrSans-BoldItalic-tlf-sc-ot1--base.tfm) \
tex(MerriwthrSans-BoldItalic-tlf-sc-ot1.tfm) \
tex(MerriwthrSans-BoldItalic-tlf-sc-ot1.vf) \
tex(MerriwthrSans-BoldItalic-tlf-sc-t1--base.tfm) \
tex(MerriwthrSans-BoldItalic-tlf-sc-t1.tfm) \
tex(MerriwthrSans-BoldItalic-tlf-sc-t1.vf) \
tex(MerriwthrSans-BoldItalic-tlf-t1--base.tfm) \
tex(MerriwthrSans-BoldItalic-tlf-t1.tfm) \
tex(MerriwthrSans-BoldItalic-tlf-t1.vf) \
tex(MerriwthrSans-BoldItalic-tlf-ts1--base.tfm) \
tex(MerriwthrSans-BoldItalic-tlf-ts1.tfm) \
tex(MerriwthrSans-BoldItalic-tlf-ts1.vf) \
tex(MerriwthrSans-BoldItalic-tosf-ly1.tfm) \
tex(MerriwthrSans-BoldItalic-tosf-ot1.tfm) \
tex(MerriwthrSans-BoldItalic-tosf-sc-ly1--base.tfm) \
tex(MerriwthrSans-BoldItalic-tosf-sc-ly1.tfm) \
tex(MerriwthrSans-BoldItalic-tosf-sc-ly1.vf) \
tex(MerriwthrSans-BoldItalic-tosf-sc-ot1--base.tfm) \
tex(MerriwthrSans-BoldItalic-tosf-sc-ot1.tfm) \
tex(MerriwthrSans-BoldItalic-tosf-sc-ot1.vf) \
tex(MerriwthrSans-BoldItalic-tosf-sc-t1--base.tfm) \
tex(MerriwthrSans-BoldItalic-tosf-sc-t1.tfm) \
tex(MerriwthrSans-BoldItalic-tosf-sc-t1.vf) \
tex(MerriwthrSans-BoldItalic-tosf-t1--base.tfm) \
tex(MerriwthrSans-BoldItalic-tosf-t1.tfm) \
tex(MerriwthrSans-BoldItalic-tosf-t1.vf) \
tex(MerriwthrSans-BoldItalic-tosf-ts1--base.tfm) \
tex(MerriwthrSans-BoldItalic-tosf-ts1.tfm) \
tex(MerriwthrSans-BoldItalic-tosf-ts1.vf) \
tex(MerriwthrSans-ExtraBold-lf-ly1.tfm) \
tex(MerriwthrSans-ExtraBold-lf-ot1.tfm) \
tex(MerriwthrSans-ExtraBold-lf-sc-ly1--base.tfm) \
tex(MerriwthrSans-ExtraBold-lf-sc-ly1.tfm) \
tex(MerriwthrSans-ExtraBold-lf-sc-ly1.vf) \
tex(MerriwthrSans-ExtraBold-lf-sc-ot1--base.tfm) \
tex(MerriwthrSans-ExtraBold-lf-sc-ot1.tfm) \
tex(MerriwthrSans-ExtraBold-lf-sc-ot1.vf) \
tex(MerriwthrSans-ExtraBold-lf-sc-t1--base.tfm) \
tex(MerriwthrSans-ExtraBold-lf-sc-t1.tfm) \
tex(MerriwthrSans-ExtraBold-lf-sc-t1.vf) \
tex(MerriwthrSans-ExtraBold-lf-t1--base.tfm) \
tex(MerriwthrSans-ExtraBold-lf-t1.tfm) \
tex(MerriwthrSans-ExtraBold-lf-t1.vf) \
tex(MerriwthrSans-ExtraBold-lf-ts1--base.tfm) \
tex(MerriwthrSans-ExtraBold-lf-ts1.tfm) \
tex(MerriwthrSans-ExtraBold-lf-ts1.vf) \
tex(MerriwthrSans-ExtraBold-osf-ly1.tfm) \
tex(MerriwthrSans-ExtraBold-osf-ot1.tfm) \
tex(MerriwthrSans-ExtraBold-osf-sc-ly1--base.tfm) \
tex(MerriwthrSans-ExtraBold-osf-sc-ly1.tfm) \
tex(MerriwthrSans-ExtraBold-osf-sc-ly1.vf) \
tex(MerriwthrSans-ExtraBold-osf-sc-ot1--base.tfm) \
tex(MerriwthrSans-ExtraBold-osf-sc-ot1.tfm) \
tex(MerriwthrSans-ExtraBold-osf-sc-ot1.vf) \
tex(MerriwthrSans-ExtraBold-osf-sc-t1--base.tfm) \
tex(MerriwthrSans-ExtraBold-osf-sc-t1.tfm) \
tex(MerriwthrSans-ExtraBold-osf-sc-t1.vf) \
tex(MerriwthrSans-ExtraBold-osf-t1--base.tfm) \
tex(MerriwthrSans-ExtraBold-osf-t1.tfm) \
tex(MerriwthrSans-ExtraBold-osf-t1.vf) \
tex(MerriwthrSans-ExtraBold-osf-ts1--base.tfm) \
tex(MerriwthrSans-ExtraBold-osf-ts1.tfm) \
tex(MerriwthrSans-ExtraBold-osf-ts1.vf) \
tex(MerriwthrSans-ExtraBold-sup-ly1.tfm) \
tex(MerriwthrSans-ExtraBold-sup-ot1.tfm) \
tex(MerriwthrSans-ExtraBold-sup-t1--base.tfm) \
tex(MerriwthrSans-ExtraBold-sup-t1.tfm) \
tex(MerriwthrSans-ExtraBold-sup-t1.vf) \
tex(MerriwthrSans-ExtraBold-tlf-ly1.tfm) \
tex(MerriwthrSans-ExtraBold-tlf-ot1.tfm) \
tex(MerriwthrSans-ExtraBold-tlf-sc-ly1--base.tfm) \
tex(MerriwthrSans-ExtraBold-tlf-sc-ly1.tfm) \
tex(MerriwthrSans-ExtraBold-tlf-sc-ly1.vf) \
tex(MerriwthrSans-ExtraBold-tlf-sc-ot1--base.tfm) \
tex(MerriwthrSans-ExtraBold-tlf-sc-ot1.tfm) \
tex(MerriwthrSans-ExtraBold-tlf-sc-ot1.vf) \
tex(MerriwthrSans-ExtraBold-tlf-sc-t1--base.tfm) \
tex(MerriwthrSans-ExtraBold-tlf-sc-t1.tfm) \
tex(MerriwthrSans-ExtraBold-tlf-sc-t1.vf) \
tex(MerriwthrSans-ExtraBold-tlf-t1--base.tfm) \
tex(MerriwthrSans-ExtraBold-tlf-t1.tfm) \
tex(MerriwthrSans-ExtraBold-tlf-t1.vf) \
tex(MerriwthrSans-ExtraBold-tlf-ts1--base.tfm) \
tex(MerriwthrSans-ExtraBold-tlf-ts1.tfm) \
tex(MerriwthrSans-ExtraBold-tlf-ts1.vf) \
tex(MerriwthrSans-ExtraBold-tosf-ly1.tfm) \
tex(MerriwthrSans-ExtraBold-tosf-ot1.tfm) \
tex(MerriwthrSans-ExtraBold-tosf-sc-ly1--base.tfm) \
tex(MerriwthrSans-ExtraBold-tosf-sc-ly1.tfm) \
tex(MerriwthrSans-ExtraBold-tosf-sc-ly1.vf) \
tex(MerriwthrSans-ExtraBold-tosf-sc-ot1--base.tfm) \
tex(MerriwthrSans-ExtraBold-tosf-sc-ot1.tfm) \
tex(MerriwthrSans-ExtraBold-tosf-sc-ot1.vf) \
tex(MerriwthrSans-ExtraBold-tosf-sc-t1--base.tfm) \
tex(MerriwthrSans-ExtraBold-tosf-sc-t1.tfm) \
tex(MerriwthrSans-ExtraBold-tosf-sc-t1.vf) \
tex(MerriwthrSans-ExtraBold-tosf-t1--base.tfm) \
tex(MerriwthrSans-ExtraBold-tosf-t1.tfm) \
tex(MerriwthrSans-ExtraBold-tosf-t1.vf) \
tex(MerriwthrSans-ExtraBold-tosf-ts1--base.tfm) \
tex(MerriwthrSans-ExtraBold-tosf-ts1.tfm) \
tex(MerriwthrSans-ExtraBold-tosf-ts1.vf) \
tex(MerriwthrSans-ExtraBoldItalic-lf-ly1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-lf-ot1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-lf-sc-ly1--base.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-lf-sc-ly1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-lf-sc-ly1.vf) \
tex(MerriwthrSans-ExtraBoldItalic-lf-sc-ot1--base.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-lf-sc-ot1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-lf-sc-ot1.vf) \
tex(MerriwthrSans-ExtraBoldItalic-lf-sc-t1--base.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-lf-sc-t1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-lf-sc-t1.vf) \
tex(MerriwthrSans-ExtraBoldItalic-lf-t1--base.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-lf-t1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-lf-t1.vf) \
tex(MerriwthrSans-ExtraBoldItalic-lf-ts1--base.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-lf-ts1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-lf-ts1.vf) \
tex(MerriwthrSans-ExtraBoldItalic-osf-ly1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-osf-ot1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-osf-sc-ly1--base.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-osf-sc-ly1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-osf-sc-ly1.vf) \
tex(MerriwthrSans-ExtraBoldItalic-osf-sc-ot1--base.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-osf-sc-ot1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-osf-sc-ot1.vf) \
tex(MerriwthrSans-ExtraBoldItalic-osf-sc-t1--base.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-osf-sc-t1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-osf-sc-t1.vf) \
tex(MerriwthrSans-ExtraBoldItalic-osf-t1--base.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-osf-t1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-osf-t1.vf) \
tex(MerriwthrSans-ExtraBoldItalic-osf-ts1--base.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-osf-ts1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-osf-ts1.vf) \
tex(MerriwthrSans-ExtraBoldItalic-sup-ly1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-sup-ot1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-sup-t1--base.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-sup-t1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-sup-t1.vf) \
tex(MerriwthrSans-ExtraBoldItalic-tlf-ly1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-tlf-ot1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-tlf-sc-ly1--base.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-tlf-sc-ly1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-tlf-sc-ly1.vf) \
tex(MerriwthrSans-ExtraBoldItalic-tlf-sc-ot1--base.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-tlf-sc-ot1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-tlf-sc-ot1.vf) \
tex(MerriwthrSans-ExtraBoldItalic-tlf-sc-t1--base.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-tlf-sc-t1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-tlf-sc-t1.vf) \
tex(MerriwthrSans-ExtraBoldItalic-tlf-t1--base.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-tlf-t1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-tlf-t1.vf) \
tex(MerriwthrSans-ExtraBoldItalic-tlf-ts1--base.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-tlf-ts1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-tlf-ts1.vf) \
tex(MerriwthrSans-ExtraBoldItalic-tosf-ly1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-tosf-ot1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-tosf-sc-ly1--base.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-tosf-sc-ly1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-tosf-sc-ly1.vf) \
tex(MerriwthrSans-ExtraBoldItalic-tosf-sc-ot1--base.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-tosf-sc-ot1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-tosf-sc-ot1.vf) \
tex(MerriwthrSans-ExtraBoldItalic-tosf-sc-t1--base.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-tosf-sc-t1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-tosf-sc-t1.vf) \
tex(MerriwthrSans-ExtraBoldItalic-tosf-t1--base.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-tosf-t1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-tosf-t1.vf) \
tex(MerriwthrSans-ExtraBoldItalic-tosf-ts1--base.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-tosf-ts1.tfm) \
tex(MerriwthrSans-ExtraBoldItalic-tosf-ts1.vf) \
tex(MerriwthrSans-Italic-lf-ly1.tfm) \
tex(MerriwthrSans-Italic-lf-ot1.tfm) \
tex(MerriwthrSans-Italic-lf-sc-ly1--base.tfm) \
tex(MerriwthrSans-Italic-lf-sc-ly1.tfm) \
tex(MerriwthrSans-Italic-lf-sc-ly1.vf) \
tex(MerriwthrSans-Italic-lf-sc-ot1--base.tfm) \
tex(MerriwthrSans-Italic-lf-sc-ot1.tfm) \
tex(MerriwthrSans-Italic-lf-sc-ot1.vf) \
tex(MerriwthrSans-Italic-lf-sc-t1--base.tfm) \
tex(MerriwthrSans-Italic-lf-sc-t1.tfm) \
tex(MerriwthrSans-Italic-lf-sc-t1.vf) \
tex(MerriwthrSans-Italic-lf-t1--base.tfm) \
tex(MerriwthrSans-Italic-lf-t1.tfm) \
tex(MerriwthrSans-Italic-lf-t1.vf) \
tex(MerriwthrSans-Italic-lf-ts1--base.tfm) \
tex(MerriwthrSans-Italic-lf-ts1.tfm) \
tex(MerriwthrSans-Italic-lf-ts1.vf) \
tex(MerriwthrSans-Italic-osf-ly1.tfm) \
tex(MerriwthrSans-Italic-osf-ot1.tfm) \
tex(MerriwthrSans-Italic-osf-sc-ly1--base.tfm) \
tex(MerriwthrSans-Italic-osf-sc-ly1.tfm) \
tex(MerriwthrSans-Italic-osf-sc-ly1.vf) \
tex(MerriwthrSans-Italic-osf-sc-ot1--base.tfm) \
tex(MerriwthrSans-Italic-osf-sc-ot1.tfm) \
tex(MerriwthrSans-Italic-osf-sc-ot1.vf) \
tex(MerriwthrSans-Italic-osf-sc-t1--base.tfm) \
tex(MerriwthrSans-Italic-osf-sc-t1.tfm) \
tex(MerriwthrSans-Italic-osf-sc-t1.vf) \
tex(MerriwthrSans-Italic-osf-t1--base.tfm) \
tex(MerriwthrSans-Italic-osf-t1.tfm) \
tex(MerriwthrSans-Italic-osf-t1.vf) \
tex(MerriwthrSans-Italic-osf-ts1--base.tfm) \
tex(MerriwthrSans-Italic-osf-ts1.tfm) \
tex(MerriwthrSans-Italic-osf-ts1.vf) \
tex(MerriwthrSans-Italic-sup-ly1.tfm) \
tex(MerriwthrSans-Italic-sup-ot1.tfm) \
tex(MerriwthrSans-Italic-sup-t1--base.tfm) \
tex(MerriwthrSans-Italic-sup-t1.tfm) \
tex(MerriwthrSans-Italic-sup-t1.vf) \
tex(MerriwthrSans-Italic-tlf-ly1.tfm) \
tex(MerriwthrSans-Italic-tlf-ot1.tfm) \
tex(MerriwthrSans-Italic-tlf-sc-ly1--base.tfm) \
tex(MerriwthrSans-Italic-tlf-sc-ly1.tfm) \
tex(MerriwthrSans-Italic-tlf-sc-ly1.vf) \
tex(MerriwthrSans-Italic-tlf-sc-ot1--base.tfm) \
tex(MerriwthrSans-Italic-tlf-sc-ot1.tfm) \
tex(MerriwthrSans-Italic-tlf-sc-ot1.vf) \
tex(MerriwthrSans-Italic-tlf-sc-t1--base.tfm) \
tex(MerriwthrSans-Italic-tlf-sc-t1.tfm) \
tex(MerriwthrSans-Italic-tlf-sc-t1.vf) \
tex(MerriwthrSans-Italic-tlf-t1--base.tfm) \
tex(MerriwthrSans-Italic-tlf-t1.tfm) \
tex(MerriwthrSans-Italic-tlf-t1.vf) \
tex(MerriwthrSans-Italic-tlf-ts1--base.tfm) \
tex(MerriwthrSans-Italic-tlf-ts1.tfm) \
tex(MerriwthrSans-Italic-tlf-ts1.vf) \
tex(MerriwthrSans-Italic-tosf-ly1.tfm) \
tex(MerriwthrSans-Italic-tosf-ot1.tfm) \
tex(MerriwthrSans-Italic-tosf-sc-ly1--base.tfm) \
tex(MerriwthrSans-Italic-tosf-sc-ly1.tfm) \
tex(MerriwthrSans-Italic-tosf-sc-ly1.vf) \
tex(MerriwthrSans-Italic-tosf-sc-ot1--base.tfm) \
tex(MerriwthrSans-Italic-tosf-sc-ot1.tfm) \
tex(MerriwthrSans-Italic-tosf-sc-ot1.vf) \
tex(MerriwthrSans-Italic-tosf-sc-t1--base.tfm) \
tex(MerriwthrSans-Italic-tosf-sc-t1.tfm) \
tex(MerriwthrSans-Italic-tosf-sc-t1.vf) \
tex(MerriwthrSans-Italic-tosf-t1--base.tfm) \
tex(MerriwthrSans-Italic-tosf-t1.tfm) \
tex(MerriwthrSans-Italic-tosf-t1.vf) \
tex(MerriwthrSans-Italic-tosf-ts1--base.tfm) \
tex(MerriwthrSans-Italic-tosf-ts1.tfm) \
tex(MerriwthrSans-Italic-tosf-ts1.vf) \
tex(MerriwthrSans-Light-lf-ly1.tfm) \
tex(MerriwthrSans-Light-lf-ot1.tfm) \
tex(MerriwthrSans-Light-lf-sc-ly1--base.tfm) \
tex(MerriwthrSans-Light-lf-sc-ly1.tfm) \
tex(MerriwthrSans-Light-lf-sc-ly1.vf) \
tex(MerriwthrSans-Light-lf-sc-ot1--base.tfm) \
tex(MerriwthrSans-Light-lf-sc-ot1.tfm) \
tex(MerriwthrSans-Light-lf-sc-ot1.vf) \
tex(MerriwthrSans-Light-lf-sc-t1--base.tfm) \
tex(MerriwthrSans-Light-lf-sc-t1.tfm) \
tex(MerriwthrSans-Light-lf-sc-t1.vf) \
tex(MerriwthrSans-Light-lf-t1--base.tfm) \
tex(MerriwthrSans-Light-lf-t1.tfm) \
tex(MerriwthrSans-Light-lf-t1.vf) \
tex(MerriwthrSans-Light-lf-ts1--base.tfm) \
tex(MerriwthrSans-Light-lf-ts1.tfm) \
tex(MerriwthrSans-Light-lf-ts1.vf) \
tex(MerriwthrSans-Light-osf-ly1.tfm) \
tex(MerriwthrSans-Light-osf-ot1.tfm) \
tex(MerriwthrSans-Light-osf-sc-ly1--base.tfm) \
tex(MerriwthrSans-Light-osf-sc-ly1.tfm) \
tex(MerriwthrSans-Light-osf-sc-ly1.vf) \
tex(MerriwthrSans-Light-osf-sc-ot1--base.tfm) \
tex(MerriwthrSans-Light-osf-sc-ot1.tfm) \
tex(MerriwthrSans-Light-osf-sc-ot1.vf) \
tex(MerriwthrSans-Light-osf-sc-t1--base.tfm) \
tex(MerriwthrSans-Light-osf-sc-t1.tfm) \
tex(MerriwthrSans-Light-osf-sc-t1.vf) \
tex(MerriwthrSans-Light-osf-t1--base.tfm) \
tex(MerriwthrSans-Light-osf-t1.tfm) \
tex(MerriwthrSans-Light-osf-t1.vf) \
tex(MerriwthrSans-Light-osf-ts1--base.tfm) \
tex(MerriwthrSans-Light-osf-ts1.tfm) \
tex(MerriwthrSans-Light-osf-ts1.vf) \
tex(MerriwthrSans-Light-sup-ly1.tfm) \
tex(MerriwthrSans-Light-sup-ot1.tfm) \
tex(MerriwthrSans-Light-sup-t1--base.tfm) \
tex(MerriwthrSans-Light-sup-t1.tfm) \
tex(MerriwthrSans-Light-sup-t1.vf) \
tex(MerriwthrSans-Light-tlf-ly1.tfm) \
tex(MerriwthrSans-Light-tlf-ot1.tfm) \
tex(MerriwthrSans-Light-tlf-sc-ly1--base.tfm) \
tex(MerriwthrSans-Light-tlf-sc-ly1.tfm) \
tex(MerriwthrSans-Light-tlf-sc-ly1.vf) \
tex(MerriwthrSans-Light-tlf-sc-ot1--base.tfm) \
tex(MerriwthrSans-Light-tlf-sc-ot1.tfm) \
tex(MerriwthrSans-Light-tlf-sc-ot1.vf) \
tex(MerriwthrSans-Light-tlf-sc-t1--base.tfm) \
tex(MerriwthrSans-Light-tlf-sc-t1.tfm) \
tex(MerriwthrSans-Light-tlf-sc-t1.vf) \
tex(MerriwthrSans-Light-tlf-t1--base.tfm) \
tex(MerriwthrSans-Light-tlf-t1.tfm) \
tex(MerriwthrSans-Light-tlf-t1.vf) \
tex(MerriwthrSans-Light-tlf-ts1--base.tfm) \
tex(MerriwthrSans-Light-tlf-ts1.tfm) \
tex(MerriwthrSans-Light-tlf-ts1.vf) \
tex(MerriwthrSans-Light-tosf-ly1.tfm) \
tex(MerriwthrSans-Light-tosf-ot1.tfm) \
tex(MerriwthrSans-Light-tosf-sc-ly1--base.tfm) \
tex(MerriwthrSans-Light-tosf-sc-ly1.tfm) \
tex(MerriwthrSans-Light-tosf-sc-ly1.vf) \
tex(MerriwthrSans-Light-tosf-sc-ot1--base.tfm) \
tex(MerriwthrSans-Light-tosf-sc-ot1.tfm) \
tex(MerriwthrSans-Light-tosf-sc-ot1.vf) \
tex(MerriwthrSans-Light-tosf-sc-t1--base.tfm) \
tex(MerriwthrSans-Light-tosf-sc-t1.tfm) \
tex(MerriwthrSans-Light-tosf-sc-t1.vf) \
tex(MerriwthrSans-Light-tosf-t1--base.tfm) \
tex(MerriwthrSans-Light-tosf-t1.tfm) \
tex(MerriwthrSans-Light-tosf-t1.vf) \
tex(MerriwthrSans-Light-tosf-ts1--base.tfm) \
tex(MerriwthrSans-Light-tosf-ts1.tfm) \
tex(MerriwthrSans-Light-tosf-ts1.vf) \
tex(MerriwthrSans-LightItalic-lf-ly1.tfm) \
tex(MerriwthrSans-LightItalic-lf-ot1.tfm) \
tex(MerriwthrSans-LightItalic-lf-sc-ly1--base.tfm) \
tex(MerriwthrSans-LightItalic-lf-sc-ly1.tfm) \
tex(MerriwthrSans-LightItalic-lf-sc-ly1.vf) \
tex(MerriwthrSans-LightItalic-lf-sc-ot1--base.tfm) \
tex(MerriwthrSans-LightItalic-lf-sc-ot1.tfm) \
tex(MerriwthrSans-LightItalic-lf-sc-ot1.vf) \
tex(MerriwthrSans-LightItalic-lf-sc-t1--base.tfm) \
tex(MerriwthrSans-LightItalic-lf-sc-t1.tfm) \
tex(MerriwthrSans-LightItalic-lf-sc-t1.vf) \
tex(MerriwthrSans-LightItalic-lf-t1--base.tfm) \
tex(MerriwthrSans-LightItalic-lf-t1.tfm) \
tex(MerriwthrSans-LightItalic-lf-t1.vf) \
tex(MerriwthrSans-LightItalic-lf-ts1--base.tfm) \
tex(MerriwthrSans-LightItalic-lf-ts1.tfm) \
tex(MerriwthrSans-LightItalic-lf-ts1.vf) \
tex(MerriwthrSans-LightItalic-osf-ly1.tfm) \
tex(MerriwthrSans-LightItalic-osf-ot1.tfm) \
tex(MerriwthrSans-LightItalic-osf-sc-ly1--base.tfm) \
tex(MerriwthrSans-LightItalic-osf-sc-ly1.tfm) \
tex(MerriwthrSans-LightItalic-osf-sc-ly1.vf) \
tex(MerriwthrSans-LightItalic-osf-sc-ot1--base.tfm) \
tex(MerriwthrSans-LightItalic-osf-sc-ot1.tfm) \
tex(MerriwthrSans-LightItalic-osf-sc-ot1.vf) \
tex(MerriwthrSans-LightItalic-osf-sc-t1--base.tfm) \
tex(MerriwthrSans-LightItalic-osf-sc-t1.tfm) \
tex(MerriwthrSans-LightItalic-osf-sc-t1.vf) \
tex(MerriwthrSans-LightItalic-osf-t1--base.tfm) \
tex(MerriwthrSans-LightItalic-osf-t1.tfm) \
tex(MerriwthrSans-LightItalic-osf-t1.vf) \
tex(MerriwthrSans-LightItalic-osf-ts1--base.tfm) \
tex(MerriwthrSans-LightItalic-osf-ts1.tfm) \
tex(MerriwthrSans-LightItalic-osf-ts1.vf) \
tex(MerriwthrSans-LightItalic-sup-ly1.tfm) \
tex(MerriwthrSans-LightItalic-sup-ot1.tfm) \
tex(MerriwthrSans-LightItalic-sup-t1--base.tfm) \
tex(MerriwthrSans-LightItalic-sup-t1.tfm) \
tex(MerriwthrSans-LightItalic-sup-t1.vf) \
tex(MerriwthrSans-LightItalic-tlf-ly1.tfm) \
tex(MerriwthrSans-LightItalic-tlf-ot1.tfm) \
tex(MerriwthrSans-LightItalic-tlf-sc-ly1--base.tfm) \
tex(MerriwthrSans-LightItalic-tlf-sc-ly1.tfm) \
tex(MerriwthrSans-LightItalic-tlf-sc-ly1.vf) \
tex(MerriwthrSans-LightItalic-tlf-sc-ot1--base.tfm) \
tex(MerriwthrSans-LightItalic-tlf-sc-ot1.tfm) \
tex(MerriwthrSans-LightItalic-tlf-sc-ot1.vf) \
tex(MerriwthrSans-LightItalic-tlf-sc-t1--base.tfm) \
tex(MerriwthrSans-LightItalic-tlf-sc-t1.tfm) \
tex(MerriwthrSans-LightItalic-tlf-sc-t1.vf) \
tex(MerriwthrSans-LightItalic-tlf-t1--base.tfm) \
tex(MerriwthrSans-LightItalic-tlf-t1.tfm) \
tex(MerriwthrSans-LightItalic-tlf-t1.vf) \
tex(MerriwthrSans-LightItalic-tlf-ts1--base.tfm) \
tex(MerriwthrSans-LightItalic-tlf-ts1.tfm) \
tex(MerriwthrSans-LightItalic-tlf-ts1.vf) \
tex(MerriwthrSans-LightItalic-tosf-ly1.tfm) \
tex(MerriwthrSans-LightItalic-tosf-ot1.tfm) \
tex(MerriwthrSans-LightItalic-tosf-sc-ly1--base.tfm) \
tex(MerriwthrSans-LightItalic-tosf-sc-ly1.tfm) \
tex(MerriwthrSans-LightItalic-tosf-sc-ly1.vf) \
tex(MerriwthrSans-LightItalic-tosf-sc-ot1--base.tfm) \
tex(MerriwthrSans-LightItalic-tosf-sc-ot1.tfm) \
tex(MerriwthrSans-LightItalic-tosf-sc-ot1.vf) \
tex(MerriwthrSans-LightItalic-tosf-sc-t1--base.tfm) \
tex(MerriwthrSans-LightItalic-tosf-sc-t1.tfm) \
tex(MerriwthrSans-LightItalic-tosf-sc-t1.vf) \
tex(MerriwthrSans-LightItalic-tosf-t1--base.tfm) \
tex(MerriwthrSans-LightItalic-tosf-t1.tfm) \
tex(MerriwthrSans-LightItalic-tosf-t1.vf) \
tex(MerriwthrSans-LightItalic-tosf-ts1--base.tfm) \
tex(MerriwthrSans-LightItalic-tosf-ts1.tfm) \
tex(MerriwthrSans-LightItalic-tosf-ts1.vf) \
tex(MerriwthrSans-Regular-lf-ly1.tfm) \
tex(MerriwthrSans-Regular-lf-ot1.tfm) \
tex(MerriwthrSans-Regular-lf-sc-ly1--base.tfm) \
tex(MerriwthrSans-Regular-lf-sc-ly1.tfm) \
tex(MerriwthrSans-Regular-lf-sc-ly1.vf) \
tex(MerriwthrSans-Regular-lf-sc-ot1--base.tfm) \
tex(MerriwthrSans-Regular-lf-sc-ot1.tfm) \
tex(MerriwthrSans-Regular-lf-sc-ot1.vf) \
tex(MerriwthrSans-Regular-lf-sc-t1--base.tfm) \
tex(MerriwthrSans-Regular-lf-sc-t1.tfm) \
tex(MerriwthrSans-Regular-lf-sc-t1.vf) \
tex(MerriwthrSans-Regular-lf-t1--base.tfm) \
tex(MerriwthrSans-Regular-lf-t1.tfm) \
tex(MerriwthrSans-Regular-lf-t1.vf) \
tex(MerriwthrSans-Regular-lf-ts1--base.tfm) \
tex(MerriwthrSans-Regular-lf-ts1.tfm) \
tex(MerriwthrSans-Regular-lf-ts1.vf) \
tex(MerriwthrSans-Regular-osf-ly1.tfm) \
tex(MerriwthrSans-Regular-osf-ot1.tfm) \
tex(MerriwthrSans-Regular-osf-sc-ly1--base.tfm) \
tex(MerriwthrSans-Regular-osf-sc-ly1.tfm) \
tex(MerriwthrSans-Regular-osf-sc-ly1.vf) \
tex(MerriwthrSans-Regular-osf-sc-ot1--base.tfm) \
tex(MerriwthrSans-Regular-osf-sc-ot1.tfm) \
tex(MerriwthrSans-Regular-osf-sc-ot1.vf) \
tex(MerriwthrSans-Regular-osf-sc-t1--base.tfm) \
tex(MerriwthrSans-Regular-osf-sc-t1.tfm) \
tex(MerriwthrSans-Regular-osf-sc-t1.vf) \
tex(MerriwthrSans-Regular-osf-t1--base.tfm) \
tex(MerriwthrSans-Regular-osf-t1.tfm) \
tex(MerriwthrSans-Regular-osf-t1.vf) \
tex(MerriwthrSans-Regular-osf-ts1--base.tfm) \
tex(MerriwthrSans-Regular-osf-ts1.tfm) \
tex(MerriwthrSans-Regular-osf-ts1.vf) \
tex(MerriwthrSans-Regular-sup-ly1.tfm) \
tex(MerriwthrSans-Regular-sup-ot1.tfm) \
tex(MerriwthrSans-Regular-sup-t1--base.tfm) \
tex(MerriwthrSans-Regular-sup-t1.tfm) \
tex(MerriwthrSans-Regular-sup-t1.vf) \
tex(MerriwthrSans-Regular-tlf-ly1.tfm) \
tex(MerriwthrSans-Regular-tlf-ot1.tfm) \
tex(MerriwthrSans-Regular-tlf-sc-ly1--base.tfm) \
tex(MerriwthrSans-Regular-tlf-sc-ly1.tfm) \
tex(MerriwthrSans-Regular-tlf-sc-ly1.vf) \
tex(MerriwthrSans-Regular-tlf-sc-ot1--base.tfm) \
tex(MerriwthrSans-Regular-tlf-sc-ot1.tfm) \
tex(MerriwthrSans-Regular-tlf-sc-ot1.vf) \
tex(MerriwthrSans-Regular-tlf-sc-t1--base.tfm) \
tex(MerriwthrSans-Regular-tlf-sc-t1.tfm) \
tex(MerriwthrSans-Regular-tlf-sc-t1.vf) \
tex(MerriwthrSans-Regular-tlf-t1--base.tfm) \
tex(MerriwthrSans-Regular-tlf-t1.tfm) \
tex(MerriwthrSans-Regular-tlf-t1.vf) \
tex(MerriwthrSans-Regular-tlf-ts1--base.tfm) \
tex(MerriwthrSans-Regular-tlf-ts1.tfm) \
tex(MerriwthrSans-Regular-tlf-ts1.vf) \
tex(MerriwthrSans-Regular-tosf-ly1.tfm) \
tex(MerriwthrSans-Regular-tosf-ot1.tfm) \
tex(MerriwthrSans-Regular-tosf-sc-ly1--base.tfm) \
tex(MerriwthrSans-Regular-tosf-sc-ly1.tfm) \
tex(MerriwthrSans-Regular-tosf-sc-ly1.vf) \
tex(MerriwthrSans-Regular-tosf-sc-ot1--base.tfm) \
tex(MerriwthrSans-Regular-tosf-sc-ot1.tfm) \
tex(MerriwthrSans-Regular-tosf-sc-ot1.vf) \
tex(MerriwthrSans-Regular-tosf-sc-t1--base.tfm) \
tex(MerriwthrSans-Regular-tosf-sc-t1.tfm) \
tex(MerriwthrSans-Regular-tosf-sc-t1.vf) \
tex(MerriwthrSans-Regular-tosf-t1--base.tfm) \
tex(MerriwthrSans-Regular-tosf-t1.tfm) \
tex(MerriwthrSans-Regular-tosf-t1.vf) \
tex(MerriwthrSans-Regular-tosf-ts1--base.tfm) \
tex(MerriwthrSans-Regular-tosf-ts1.tfm) \
tex(MerriwthrSans-Regular-tosf-ts1.vf) \
tex(OT1Merriwthr-LF.fd) \
tex(OT1Merriwthr-OsF.fd) \
tex(OT1Merriwthr-Sup.fd) \
tex(OT1Merriwthr-TLF.fd) \
tex(OT1Merriwthr-TOsF.fd) \
tex(OT1MerriwthrSans-LF.fd) \
tex(OT1MerriwthrSans-OsF.fd) \
tex(OT1MerriwthrSans-Sup.fd) \
tex(OT1MerriwthrSans-TLF.fd) \
tex(OT1MerriwthrSans-TOsF.fd) \
tex(T1Merriwthr-LF.fd) \
tex(T1Merriwthr-OsF.fd) \
tex(T1Merriwthr-Sup.fd) \
tex(T1Merriwthr-TLF.fd) \
tex(T1Merriwthr-TOsF.fd) \
tex(T1MerriwthrSans-LF.fd) \
tex(T1MerriwthrSans-OsF.fd) \
tex(T1MerriwthrSans-Sup.fd) \
tex(T1MerriwthrSans-TLF.fd) \
tex(T1MerriwthrSans-TOsF.fd) \
tex(TS1Merriwthr-LF.fd) \
tex(TS1Merriwthr-OsF.fd) \
tex(TS1Merriwthr-TLF.fd) \
tex(TS1Merriwthr-TOsF.fd) \
tex(TS1MerriwthrSans-LF.fd) \
tex(TS1MerriwthrSans-OsF.fd) \
tex(TS1MerriwthrSans-TLF.fd) \
tex(TS1MerriwthrSans-TOsF.fd) \
tex(merriweather.map) \
tex(merriweather.sty) \
tex(merriwthr_27vehb.enc) \
tex(merriwthr_2hyv6t.enc) \
tex(merriwthr_2j7grf.enc) \
tex(merriwthr_2r7lb2.enc) \
tex(merriwthr_4ylisx.enc) \
tex(merriwthr_5lck5z.enc) \
tex(merriwthr_5xld5w.enc) \
tex(merriwthr_6qeh6o.enc) \
tex(merriwthr_7bivwm.enc) \
tex(merriwthr_7jdyhk.enc) \
tex(merriwthr_7npxgm.enc) \
tex(merriwthr_7t3tp2.enc) \
tex(merriwthr_7tayun.enc) \
tex(merriwthr_abao47.enc) \
tex(merriwthr_adz5lu.enc) \
tex(merriwthr_afua2j.enc) \
tex(merriwthr_ags7qn.enc) \
tex(merriwthr_ah5y5a.enc) \
tex(merriwthr_b6rchs.enc) \
tex(merriwthr_btdrxl.enc) \
tex(merriwthr_c4h6ot.enc) \
tex(merriwthr_cc6s4l.enc) \
tex(merriwthr_ckyw6q.enc) \
tex(merriwthr_cqy4t2.enc) \
tex(merriwthr_cvdnuw.enc) \
tex(merriwthr_cy3ufi.enc) \
tex(merriwthr_diijaa.enc) \
tex(merriwthr_dl4a4c.enc) \
tex(merriwthr_dx3n55.enc) \
tex(merriwthr_e2idhw.enc) \
tex(merriwthr_e5zf5y.enc) \
tex(merriwthr_f5n6m3.enc) \
tex(merriwthr_fs3efe.enc) \
tex(merriwthr_gbcczm.enc) \
tex(merriwthr_gdbfjs.enc) \
tex(merriwthr_gldhmf.enc) \
tex(merriwthr_gmchnq.enc) \
tex(merriwthr_h6z4fc.enc) \
tex(merriwthr_h7gtfv.enc) \
tex(merriwthr_hwcxwn.enc) \
tex(merriwthr_hz3jhh.enc) \
tex(merriwthr_ibepov.enc) \
tex(merriwthr_igdvgb.enc) \
tex(merriwthr_jjwbah.enc) \
tex(merriwthr_k4bbiq.enc) \
tex(merriwthr_lkhefy.enc) \
tex(merriwthr_lm56sz.enc) \
tex(merriwthr_mb4bqm.enc) \
tex(merriwthr_me3dx7.enc) \
tex(merriwthr_mgprdv.enc) \
tex(merriwthr_mr3nck.enc) \
tex(merriwthr_mx2b4h.enc) \
tex(merriwthr_nszfm3.enc) \
tex(merriwthr_o43b2q.enc) \
tex(merriwthr_ob5vn4.enc) \
tex(merriwthr_okb76x.enc) \
tex(merriwthr_owzwzj.enc) \
tex(merriwthr_p242jx.enc) \
tex(merriwthr_posqbl.enc) \
tex(merriwthr_qfmkcs.enc) \
tex(merriwthr_qndjqi.enc) \
tex(merriwthr_rzflsg.enc) \
tex(merriwthr_s56ilq.enc) \
tex(merriwthr_stxeas.enc) \
tex(merriwthr_ttjzpe.enc) \
tex(merriwthr_u2frii.enc) \
tex(merriwthr_uduhhn.enc) \
tex(merriwthr_urus45.enc) \
tex(merriwthr_vvhkhe.enc) \
tex(merriwthr_w4rwtq.enc) \
tex(merriwthr_wlsyn3.enc) \
tex(merriwthr_wppmfi.enc) \
tex(merriwthr_x754fd.enc) \
tex(merriwthr_xfdjpz.enc) \
tex(merriwthr_xys2i2.enc) \
tex(merriwthr_ynquvw.enc) \
texlive-merriweather"
RDEPENDS:${PN} += "/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex(fontaxes.sty) \
tex(fontenc.sty) \
tex(fontspec.sty) \
tex(ifluatex.sty) \
tex(ifxetex.sty) \
tex(textcomp.sty) \
tex(updmap.cfg) \
tex(xkeyval.sty) \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-merriweather-fonts \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
