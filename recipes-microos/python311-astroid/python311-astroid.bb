SUMMARY = "Representation of Python source as an AST for pylint"
DESCRIPTION = "This module provides a common base representation of Python source code for \
projects such as pychecker, pyreverse, pylint. The development of this library \
is governed by pylint's needs. \
 \
It provides a compatible representation which comes from the _ast \
module. It rebuilds the tree generated by the builtin _ast module by \
recursively walking down the AST and building an extended ast. The new \
node classes have additional methods and attributes for different \
usages. They include some support for static inference and local name \
scopes. Furthermore, astroid builds partial trees by inspecting living \
objects."
LICENSE = "LGPL-2.1-or-later"

PV = "2.15.4"

RPM_NAME = "python311-astroid-2.15.4-2.1.noarch.rpm"
RPM_HASH = "82dccf8e0ee3c4413b5d879c0283d61646ae5e7037d65f5800b3769b6f20e26d7fa34592c5c02f0c58eb16035bfb1e770d8f99f60c29b5721cd863079bc20cb2"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "python3.11dist(astroid) python311-astroid python3dist(astroid)"
RDEPENDS:${PN} += "python(abi) python311-lazy-object-proxy python311-wrapt"

inherit rpm
