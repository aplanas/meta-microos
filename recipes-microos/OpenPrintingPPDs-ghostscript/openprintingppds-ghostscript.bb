SUMMARY = "PPD files from OpenPrinting.org which use Ghostscript built-in drivers"
DESCRIPTION = "PPD files for non-PostScript printers \
which use a Ghostscript built-in driver \
and PPD files for PostScript level 1 printers \
which use the Ghostscript driver pswrite."
LICENSE = "GPL-2.0-or-later & MIT"

PV = "4.0.0.2"

RPM_NAME = "OpenPrintingPPDs-ghostscript-4.0.0.2-6.9.noarch.rpm"
RPM_HASH = "609564b030067af96a89a35637f26280759d407b31fd77fea86ebd13abff2b1f2bf0e5049a43991e34ae7ff1380a3c0e3f9b5de3df059876f371ec966d3fab3c"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "OpenPrintingPPDs-ghostscript \
postscriptdriver(apollo;apollo_p-2200;) \
postscriptdriver(brother;brother_hl-1450_series;) \
postscriptdriver(brother;brother_hl-1470n_series;) \
postscriptdriver(brother;brother_hl-2460_series;) \
postscriptdriver(brother;brother_hl-2600cn_series;) \
postscriptdriver(brother;brother_hl-3260n_series;) \
postscriptdriver(brother;brother_hl-3450cn_series;) \
postscriptdriver(brother;brother_hl-4050cdn;) \
postscriptdriver(brother;brother_hl-4070cdw;) \
postscriptdriver(brother;brother_hl-5050_series;) \
postscriptdriver(brother;brother_hl-5070n_series;) \
postscriptdriver(brother;brother_hl-5150d_series;) \
postscriptdriver(brother;brother_hl-5170dn_series;) \
postscriptdriver(brother;brother_hl-7050_series;) \
postscriptdriver(brother;brother_mfc-9840cdw;) \
postscriptdriver(brother;hl-1050_series;) \
postscriptdriver(brother;hl-1070_series;) \
postscriptdriver(brother;hl-1230_series;) \
postscriptdriver(brother;hl-1240_series;) \
postscriptdriver(brother;hl-1250_series;) \
postscriptdriver(brother;hl-1430_series;) \
postscriptdriver(brother;hl-1440_series;) \
postscriptdriver(brother;hl-2030_series;) \
postscriptdriver(brother;hl-2040_series;) \
postscriptdriver(brother;hl-2140_series;) \
postscriptdriver(brother;hl-5040_series;) \
postscriptdriver(brother;hl-5140_series;) \
postscriptdriver(canon;bjc-1000;) \
postscriptdriver(canon;bjc-2100;) \
postscriptdriver(canon;bjc-210;) \
postscriptdriver(canon;bjc-250;) \
postscriptdriver(canon;bjc-3000;) \
postscriptdriver(canon;bjc-4100;) \
postscriptdriver(canon;bjc-4300;) \
postscriptdriver(canon;bjc-4400;) \
postscriptdriver(canon;bjc-50;) \
postscriptdriver(canon;bjc-55;) \
postscriptdriver(canon;bjc-80;) \
postscriptdriver(canon;bjc-8200;) \
postscriptdriver(canon;bjc-85;) \
postscriptdriver(canon;i450;) \
postscriptdriver(canon;ir3225_(ufr_ii);) \
postscriptdriver(canon;lbp-1000;) \
postscriptdriver(canon;multipass_c3500;) \
postscriptdriver(canon;s100sp;) \
postscriptdriver(canon;s600;) \
postscriptdriver(dell;laser_printer_1110;) \
postscriptdriver(dell;laser_printer_3000cn;) \
postscriptdriver(dell;laser_printer_3100cn;) \
postscriptdriver(epson;al-c1900_ps3;) \
postscriptdriver(epson;al-c2000_ps3;) \
postscriptdriver(epson;al-c4000_ps3;) \
postscriptdriver(epson;al-c8600_ps3;) \
postscriptdriver(epson;epl-5700;) \
postscriptdriver(epson;epl-5900_ps3;) \
postscriptdriver(epson;epl-6100_ps3;) \
postscriptdriver(epson;epl-n1600;) \
postscriptdriver(epson;stylus_color_1520;) \
postscriptdriver(epson;stylus_color_440;) \
postscriptdriver(epson;stylus_color_600;) \
postscriptdriver(epson;stylus_color_670;) \
postscriptdriver(epson;stylus_color_740;) \
postscriptdriver(epson;stylus_color_800;) \
postscriptdriver(epson;stylus_photo_750;) \
postscriptdriver(gelsprinter;gx_3050n;) \
postscriptdriver(gelsprinter;gx_3050sfn;) \
postscriptdriver(gelsprinter;gx_5050n;) \
postscriptdriver(gelsprinter;gx_e3350n;) \
postscriptdriver(gelsprinter;gx_e5550n;) \
postscriptdriver(gestetner;10512;) \
postscriptdriver(gestetner;2212;) \
postscriptdriver(gestetner;2712;) \
postscriptdriver(gestetner;3212;) \
postscriptdriver(gestetner;3502;) \
postscriptdriver(gestetner;3532/4235g;) \
postscriptdriver(gestetner;4502;) \
postscriptdriver(gestetner;4532/4245g;) \
postscriptdriver(gestetner;6002;) \
postscriptdriver(gestetner;7502;) \
postscriptdriver(gestetner;9002;) \
postscriptdriver(gestetner;cs555;) \
postscriptdriver(gestetner;dsc1020;) \
postscriptdriver(gestetner;dsc1025;) \
postscriptdriver(gestetner;dsc1030;) \
postscriptdriver(gestetner;dsc1045;) \
postscriptdriver(gestetner;dsc1060;) \
postscriptdriver(gestetner;dsc424;) \
postscriptdriver(gestetner;dsc428;) \
postscriptdriver(gestetner;dsc432;) \
postscriptdriver(gestetner;dsc435;) \
postscriptdriver(gestetner;dsc445;) \
postscriptdriver(gestetner;dsc460;) \
postscriptdriver(gestetner;dsm1525;) \
postscriptdriver(gestetner;dsm1530;) \
postscriptdriver(gestetner;dsm1533;) \
postscriptdriver(gestetner;dsm415;) \
postscriptdriver(gestetner;dsm615;) \
postscriptdriver(gestetner;dsm616;) \
postscriptdriver(gestetner;dsm618;) \
postscriptdriver(gestetner;dsm618d;) \
postscriptdriver(gestetner;dsm620;) \
postscriptdriver(gestetner;dsm620d;) \
postscriptdriver(gestetner;dsm622;) \
postscriptdriver(gestetner;dsm627;) \
postscriptdriver(gestetner;dsm635/635g;) \
postscriptdriver(gestetner;dsm645/645g;) \
postscriptdriver(gestetner;dsm651;) \
postscriptdriver(gestetner;dsm660;) \
postscriptdriver(gestetner;dsm675;) \
postscriptdriver(gestetner;dsm725;) \
postscriptdriver(gestetner;dsm730;) \
postscriptdriver(gestetner;dsm735/735g;) \
postscriptdriver(gestetner;dsm745/745g;) \
postscriptdriver(gestetner;mp1100/dsm7110;) \
postscriptdriver(gestetner;mp1350/dsm7135;) \
postscriptdriver(gestetner;mp1600/dsm716;) \
postscriptdriver(gestetner;mp2000/dsm721d;) \
postscriptdriver(gestetner;mp2352/dsm923;) \
postscriptdriver(gestetner;mp2500/dsm625;) \
postscriptdriver(gestetner;mp2852/dsm928;) \
postscriptdriver(gestetner;mp3352/dsm933;) \
postscriptdriver(gestetner;mp3500/dsm735e;) \
postscriptdriver(gestetner;mp4500/dsm745e;) \
postscriptdriver(gestetner;mp5500/dsm755;) \
postscriptdriver(gestetner;mp6500/dsm765;) \
postscriptdriver(gestetner;mp7500/dsm775;) \
postscriptdriver(gestetner;mp9000/dsm790;) \
postscriptdriver(gestetner;mp_161/dsm416;) \
postscriptdriver(gestetner;mp_171;) \
postscriptdriver(gestetner;mp_2001;) \
postscriptdriver(gestetner;mp_2501;) \
postscriptdriver(gestetner;mp_2510/dsm725e;) \
postscriptdriver(gestetner;mp_2550;) \
postscriptdriver(gestetner;mp_2550b;) \
postscriptdriver(gestetner;mp_2553;) \
postscriptdriver(gestetner;mp_2851;) \
postscriptdriver(gestetner;mp_3010/dsm730e;) \
postscriptdriver(gestetner;mp_3053;) \
postscriptdriver(gestetner;mp_3350;) \
postscriptdriver(gestetner;mp_3350b;) \
postscriptdriver(gestetner;mp_3351;) \
postscriptdriver(gestetner;mp_3353;) \
postscriptdriver(gestetner;mp_4000;) \
postscriptdriver(gestetner;mp_4000b;) \
postscriptdriver(gestetner;mp_4001;) \
postscriptdriver(gestetner;mp_4002;) \
postscriptdriver(gestetner;mp_5000;) \
postscriptdriver(gestetner;mp_5000b;) \
postscriptdriver(gestetner;mp_5001;) \
postscriptdriver(gestetner;mp_5002;) \
postscriptdriver(gestetner;mp_6000;) \
postscriptdriver(gestetner;mp_6001;) \
postscriptdriver(gestetner;mp_6002;) \
postscriptdriver(gestetner;mp_7000;) \
postscriptdriver(gestetner;mp_7001;) \
postscriptdriver(gestetner;mp_7502;) \
postscriptdriver(gestetner;mp_8000;) \
postscriptdriver(gestetner;mp_8001;) \
postscriptdriver(gestetner;mp_9001;) \
postscriptdriver(gestetner;mp_9002;) \
postscriptdriver(gestetner;mp_c2003;) \
postscriptdriver(gestetner;mp_c2050;) \
postscriptdriver(gestetner;mp_c2051;) \
postscriptdriver(gestetner;mp_c2503;) \
postscriptdriver(gestetner;mp_c2550;) \
postscriptdriver(gestetner;mp_c2551;) \
postscriptdriver(gestetner;mp_c2800;) \
postscriptdriver(gestetner;mp_c3001;) \
postscriptdriver(gestetner;mp_c3002;) \
postscriptdriver(gestetner;mp_c3003;) \
postscriptdriver(gestetner;mp_c300;) \
postscriptdriver(gestetner;mp_c300sr;) \
postscriptdriver(gestetner;mp_c3300;) \
postscriptdriver(gestetner;mp_c3501;) \
postscriptdriver(gestetner;mp_c3502;) \
postscriptdriver(gestetner;mp_c3503;) \
postscriptdriver(gestetner;mp_c4000;) \
postscriptdriver(gestetner;mp_c400;) \
postscriptdriver(gestetner;mp_c400sr;) \
postscriptdriver(gestetner;mp_c4501;) \
postscriptdriver(gestetner;mp_c4501a;) \
postscriptdriver(gestetner;mp_c4502;) \
postscriptdriver(gestetner;mp_c4502a;) \
postscriptdriver(gestetner;mp_c4503;) \
postscriptdriver(gestetner;mp_c5000;) \
postscriptdriver(gestetner;mp_c5501;) \
postscriptdriver(gestetner;mp_c5501a;) \
postscriptdriver(gestetner;mp_c5502;) \
postscriptdriver(gestetner;mp_c5502a;) \
postscriptdriver(gestetner;mp_c5503;) \
postscriptdriver(gestetner;mp_c6000;) \
postscriptdriver(gestetner;mp_c6003;) \
postscriptdriver(gestetner;mp_c6501;) \
postscriptdriver(gestetner;mp_c6502;) \
postscriptdriver(gestetner;mp_c7500;) \
postscriptdriver(gestetner;mp_c7501;) \
postscriptdriver(gestetner;mp_c8002;) \
postscriptdriver(gestetner;mpc1500/gs106;) \
postscriptdriver(gestetner;mpc2500/dsc525;) \
postscriptdriver(gestetner;mpc3000/dsc530;) \
postscriptdriver(gestetner;mpc3500/dsc535;) \
postscriptdriver(gestetner;mpc4500/dsc545;) \
postscriptdriver(gestetner;pro_1106ex;) \
postscriptdriver(gestetner;pro_1107ex;) \
postscriptdriver(gestetner;pro_1356ex;) \
postscriptdriver(gestetner;pro_1357ex;) \
postscriptdriver(gestetner;pro_906ex;) \
postscriptdriver(gestetner;pro_907ex;) \
postscriptdriver(hewlett-packard;deskjet_1120c;) \
postscriptdriver(hewlett-packard;deskjet_1220c;) \
postscriptdriver(hewlett-packard;deskjet_350;) \
postscriptdriver(hewlett-packard;deskjet_540;) \
postscriptdriver(hewlett-packard;deskjet_600;) \
postscriptdriver(hewlett-packard;deskjet_610c;) \
postscriptdriver(hewlett-packard;deskjet_660c;) \
postscriptdriver(hewlett-packard;deskjet_670c;) \
postscriptdriver(hewlett-packard;deskjet_690c;) \
postscriptdriver(hewlett-packard;deskjet_810c;) \
postscriptdriver(hewlett-packard;deskjet_840c;) \
postscriptdriver(hewlett-packard;deskjet_845c;) \
postscriptdriver(hewlett-packard;deskjet_850c;) \
postscriptdriver(hewlett-packard;deskjet_870c;) \
postscriptdriver(hewlett-packard;deskjet_880c;) \
postscriptdriver(hewlett-packard;deskjet_890c;) \
postscriptdriver(hewlett-packard;deskjet_895c;) \
postscriptdriver(hewlett-packard;deskjet_930c;) \
postscriptdriver(hewlett-packard;deskjet_940c;) \
postscriptdriver(hewlett-packard;deskjet_950c;) \
postscriptdriver(hewlett-packard;deskjet_960c;) \
postscriptdriver(hewlett-packard;deskjet_970c;) \
postscriptdriver(hewlett-packard;deskjet_980c;) \
postscriptdriver(hewlett-packard;deskjet_990c;) \
postscriptdriver(hewlett-packard;hp_2000c;) \
postscriptdriver(hewlett-packard;hp_business_inkjet_2200;) \
postscriptdriver(hewlett-packard;hp_color_laserjet_2500;) \
postscriptdriver(hewlett-packard;hp_color_laserjet_4550;) \
postscriptdriver(hewlett-packard;hp_color_laserjet_4600;) \
postscriptdriver(hewlett-packard;hp_deskjet_340;) \
postscriptdriver(hewlett-packard;hp_deskjet_400;) \
postscriptdriver(hewlett-packard;hp_laserjet_1015;) \
postscriptdriver(hewlett-packard;hp_laserjet_1100;) \
postscriptdriver(hewlett-packard;hp_laserjet_1150;) \
postscriptdriver(hewlett-packard;hp_laserjet_1200;) \
postscriptdriver(hewlett-packard;hp_laserjet_1220;) \
postscriptdriver(hewlett-packard;hp_laserjet_1300;) \
postscriptdriver(hewlett-packard;hp_laserjet_1320_series;) \
postscriptdriver(hewlett-packard;hp_laserjet_2100_series;) \
postscriptdriver(hewlett-packard;hp_laserjet_2200;) \
postscriptdriver(hewlett-packard;hp_laserjet_2300_series;) \
postscriptdriver(hewlett-packard;hp_laserjet_3200;) \
postscriptdriver(hewlett-packard;hp_laserjet_3200m;) \
postscriptdriver(hewlett-packard;hp_laserjet_3300/3310/3320;) \
postscriptdriver(hewlett-packard;hp_laserjet_3330;) \
postscriptdriver(hewlett-packard;hp_laserjet_3390;) \
postscriptdriver(hewlett-packard;hp_laserjet_4000_series;) \
postscriptdriver(hewlett-packard;hp_laserjet_4050_series;) \
postscriptdriver(hewlett-packard;hp_laserjet_4100_series;) \
postscriptdriver(hewlett-packard;hp_laserjet_4200;) \
postscriptdriver(hewlett-packard;hp_laserjet_4300;) \
postscriptdriver(hewlett-packard;hp_laserjet_4350;) \
postscriptdriver(hewlett-packard;hp_laserjet_4_plus;) \
postscriptdriver(hewlett-packard;hp_laserjet_5100_series;) \
postscriptdriver(hewlett-packard;hp_laserjet_5l;) \
postscriptdriver(hewlett-packard;hp_laserjet_5p;) \
postscriptdriver(hewlett-packard;hp_laserjet_5si;) \
postscriptdriver(hewlett-packard;hp_laserjet_6l;) \
postscriptdriver(hewlett-packard;hp_laserjet_6p;) \
postscriptdriver(hewlett-packard;hp_laserjet_8150_series;) \
postscriptdriver(hewlett-packard;laserjet_4l;) \
postscriptdriver(hewlett-packard;laserjet_color_4500;) \
postscriptdriver(hewlett-packard;officejet;) \
postscriptdriver(hewlett-packard;officejet_g55;) \
postscriptdriver(hewlett-packard;officejet_g85;) \
postscriptdriver(hewlett-packard;officejet_g95;) \
postscriptdriver(hewlett-packard;officejet_pro_1150c;) \
postscriptdriver(hewlett-packard;officejet_pro_1170c_series;) \
postscriptdriver(hewlett-packard;officejet_r40;) \
postscriptdriver(hewlett-packard;officejet_series_300;) \
postscriptdriver(hewlett-packard;officejet_series_500;) \
postscriptdriver(hewlett-packard;officejet_series_600;) \
postscriptdriver(hewlett-packard;officejet_t_series;) \
postscriptdriver(hewlett-packard;photosmart_p1000;) \
postscriptdriver(hewlett-packard;photosmart_p1100;) \
postscriptdriver(hewlett-packard;psc_500;) \
postscriptdriver(hp;photosmart_100;) \
postscriptdriver(hp;photosmart_1115;) \
postscriptdriver(hp;photosmart_1218;) \
postscriptdriver(hp;photosmart_1315;) \
postscriptdriver(ibm;infoprint;) \
postscriptdriver(infoprint;pro_1107ex;) \
postscriptdriver(infoprint;pro_1357ex;) \
postscriptdriver(infoprint;pro_907ex;) \
postscriptdriver(infotec;4353_mf;) \
postscriptdriver(infotec;4452_mf;) \
postscriptdriver(infotec;is2022;) \
postscriptdriver(infotec;is2027;) \
postscriptdriver(infotec;is2032;) \
postscriptdriver(infotec;is2035;) \
postscriptdriver(infotec;is2045;) \
postscriptdriver(infotec;is2090;) \
postscriptdriver(infotec;is2105;) \
postscriptdriver(infotec;is_2015;) \
postscriptdriver(infotec;is_2018;) \
postscriptdriver(infotec;is_2018d;) \
postscriptdriver(infotec;is_2060;) \
postscriptdriver(infotec;is_2075;) \
postscriptdriver(infotec;is_2122;) \
postscriptdriver(infotec;is_2127;) \
postscriptdriver(infotec;is_2132;) \
postscriptdriver(infotec;is_2135;) \
postscriptdriver(infotec;is_2145;) \
postscriptdriver(infotec;is_2151;) \
postscriptdriver(infotec;is_2160;) \
postscriptdriver(infotec;is_2175;) \
postscriptdriver(infotec;is_2215;) \
postscriptdriver(infotec;is_2216;) \
postscriptdriver(infotec;is_2220;) \
postscriptdriver(infotec;is_2220d;) \
postscriptdriver(infotec;is_2225;) \
postscriptdriver(infotec;is_2230;) \
postscriptdriver(infotec;is_2235;) \
postscriptdriver(infotec;is_2245;) \
postscriptdriver(infotec;is_2255;) \
postscriptdriver(infotec;is_2265;) \
postscriptdriver(infotec;is_2275;) \
postscriptdriver(infotec;is_2316;) \
postscriptdriver(infotec;is_2320;) \
postscriptdriver(infotec;is_2325;) \
postscriptdriver(infotec;is_2416;) \
postscriptdriver(infotec;is_2425;) \
postscriptdriver(infotec;is_2430;) \
postscriptdriver(infotec;is_2435;) \
postscriptdriver(infotec;is_2445;) \
postscriptdriver(infotec;is_3090;) \
postscriptdriver(infotec;is_3110;) \
postscriptdriver(infotec;is_3135;) \
postscriptdriver(infotec;isc_1024c;) \
postscriptdriver(infotec;isc_1032c;) \
postscriptdriver(infotec;isc_2428;) \
postscriptdriver(infotec;isc_2525;) \
postscriptdriver(infotec;isc_2835;) \
postscriptdriver(infotec;isc_3030;) \
postscriptdriver(infotec;isc_3535;) \
postscriptdriver(infotec;isc_3545;) \
postscriptdriver(infotec;isc_4045;) \
postscriptdriver(infotec;isc_4560;) \
postscriptdriver(infotec;isc_5560;) \
postscriptdriver(infotec;isc_615g;) \
postscriptdriver(infotec;mp_171;) \
postscriptdriver(infotec;mp_2001;) \
postscriptdriver(infotec;mp_201;) \
postscriptdriver(infotec;mp_2352;) \
postscriptdriver(infotec;mp_2501;) \
postscriptdriver(infotec;mp_2550;) \
postscriptdriver(infotec;mp_2550b;) \
postscriptdriver(infotec;mp_2553;) \
postscriptdriver(infotec;mp_2851;) \
postscriptdriver(infotec;mp_2852;) \
postscriptdriver(infotec;mp_3053;) \
postscriptdriver(infotec;mp_3350;) \
postscriptdriver(infotec;mp_3350b;) \
postscriptdriver(infotec;mp_3351;) \
postscriptdriver(infotec;mp_3352;) \
postscriptdriver(infotec;mp_3353;) \
postscriptdriver(infotec;mp_4000;) \
postscriptdriver(infotec;mp_4000b;) \
postscriptdriver(infotec;mp_4001;) \
postscriptdriver(infotec;mp_4002;) \
postscriptdriver(infotec;mp_5000;) \
postscriptdriver(infotec;mp_5000b;) \
postscriptdriver(infotec;mp_5001;) \
postscriptdriver(infotec;mp_5002;) \
postscriptdriver(infotec;mp_6000;) \
postscriptdriver(infotec;mp_6001;) \
postscriptdriver(infotec;mp_6002;) \
postscriptdriver(infotec;mp_7000;) \
postscriptdriver(infotec;mp_7001;) \
postscriptdriver(infotec;mp_7502;) \
postscriptdriver(infotec;mp_8000;) \
postscriptdriver(infotec;mp_8001;) \
postscriptdriver(infotec;mp_9001;) \
postscriptdriver(infotec;mp_9002;) \
postscriptdriver(infotec;mp_c2003;) \
postscriptdriver(infotec;mp_c2003z;) \
postscriptdriver(infotec;mp_c2050;) \
postscriptdriver(infotec;mp_c2051;) \
postscriptdriver(infotec;mp_c2503;) \
postscriptdriver(infotec;mp_c2503z;) \
postscriptdriver(infotec;mp_c2550;) \
postscriptdriver(infotec;mp_c2551;) \
postscriptdriver(infotec;mp_c2800;) \
postscriptdriver(infotec;mp_c3001;) \
postscriptdriver(infotec;mp_c3002;) \
postscriptdriver(infotec;mp_c3003;) \
postscriptdriver(infotec;mp_c300;) \
postscriptdriver(infotec;mp_c300sr;) \
postscriptdriver(infotec;mp_c3300;) \
postscriptdriver(infotec;mp_c3501;) \
postscriptdriver(infotec;mp_c3502;) \
postscriptdriver(infotec;mp_c3503;) \
postscriptdriver(infotec;mp_c4000;) \
postscriptdriver(infotec;mp_c400;) \
postscriptdriver(infotec;mp_c400sr;) \
postscriptdriver(infotec;mp_c4501;) \
postscriptdriver(infotec;mp_c4501a;) \
postscriptdriver(infotec;mp_c4502;) \
postscriptdriver(infotec;mp_c4502a;) \
postscriptdriver(infotec;mp_c4503;) \
postscriptdriver(infotec;mp_c5000;) \
postscriptdriver(infotec;mp_c5501;) \
postscriptdriver(infotec;mp_c5501a;) \
postscriptdriver(infotec;mp_c5502;) \
postscriptdriver(infotec;mp_c5502a;) \
postscriptdriver(infotec;mp_c5503;) \
postscriptdriver(infotec;mp_c6000;) \
postscriptdriver(infotec;mp_c6003;) \
postscriptdriver(infotec;mp_c6501;) \
postscriptdriver(infotec;mp_c6502;) \
postscriptdriver(infotec;mp_c7500;) \
postscriptdriver(infotec;mp_c7501;) \
postscriptdriver(infotec;mp_c8002;) \
postscriptdriver(infotec;pro_1106ex;) \
postscriptdriver(infotec;pro_1107ex;) \
postscriptdriver(infotec;pro_1356ex;) \
postscriptdriver(infotec;pro_1357ex;) \
postscriptdriver(infotec;pro_8100s;) \
postscriptdriver(infotec;pro_8110s;) \
postscriptdriver(infotec;pro_8120s;) \
postscriptdriver(infotec;pro_906ex;) \
postscriptdriver(infotec;pro_907ex;) \
postscriptdriver(infotec;pro_c5100s;) \
postscriptdriver(infotec;pro_c5110s;) \
postscriptdriver(kyocera;f-1000;) \
postscriptdriver(kyocera;f-1010;) \
postscriptdriver(kyocera;f-1200;) \
postscriptdriver(kyocera;f-1200s;) \
postscriptdriver(kyocera;f-1800;) \
postscriptdriver(kyocera;f-2000;) \
postscriptdriver(kyocera;f-2010;) \
postscriptdriver(kyocera;f-2200;) \
postscriptdriver(kyocera;f-2200s;) \
postscriptdriver(kyocera;f-3000;) \
postscriptdriver(kyocera;f-3010;) \
postscriptdriver(kyocera;f-3300;) \
postscriptdriver(kyocera;f-5000;) \
postscriptdriver(kyocera;f-800;) \
postscriptdriver(kyocera;f-800t;) \
postscriptdriver(kyocera;f-820;) \
postscriptdriver(kyocera;fs-1020d;) \
postscriptdriver(kyocera;fs-1500;) \
postscriptdriver(kyocera;fs-1550+;) \
postscriptdriver(kyocera;fs-1550;) \
postscriptdriver(kyocera;fs-1600+;) \
postscriptdriver(kyocera;fs-1600;) \
postscriptdriver(kyocera;fs-3400+;) \
postscriptdriver(kyocera;fs-3400;) \
postscriptdriver(kyocera;fs-3500;) \
postscriptdriver(kyocera;fs-3600+;) \
postscriptdriver(kyocera;fs-3600;) \
postscriptdriver(kyocera;fs-400;) \
postscriptdriver(kyocera;fs-5500;) \
postscriptdriver(kyocera;fs-600;) \
postscriptdriver(kyocera;fs-6500;) \
postscriptdriver(kyocera;fs-850;) \
postscriptdriver(kyocera;kyocera_cs-c2525e;) \
postscriptdriver(kyocera;kyocera_cs-c3225e;) \
postscriptdriver(kyocera;kyocera_cs-c3232e;) \
postscriptdriver(kyocera;kyocera_cs-c4035e;) \
postscriptdriver(kyocera;kyocera_cs_250ci;) \
postscriptdriver(kyocera;kyocera_cs_300ci;) \
postscriptdriver(kyocera;kyocera_cs_3050ci;) \
postscriptdriver(kyocera;kyocera_cs_3550ci;) \
postscriptdriver(kyocera;kyocera_cs_400ci;) \
postscriptdriver(kyocera;kyocera_cs_500ci;) \
postscriptdriver(kyocera;kyocera_fs-1000;) \
postscriptdriver(kyocera;kyocera_fs-1030d;) \
postscriptdriver(kyocera;kyocera_fs-1118mfp;) \
postscriptdriver(kyocera;kyocera_fs-1200;) \
postscriptdriver(kyocera;kyocera_fs-1700+;) \
postscriptdriver(kyocera;kyocera_fs-1700;) \
postscriptdriver(kyocera;kyocera_fs-1714m;) \
postscriptdriver(kyocera;kyocera_fs-1750;) \
postscriptdriver(kyocera;kyocera_fs-2000d;) \
postscriptdriver(kyocera;kyocera_fs-2100d;) \
postscriptdriver(kyocera;kyocera_fs-2100dn;) \
postscriptdriver(kyocera;kyocera_fs-3700+;) \
postscriptdriver(kyocera;kyocera_fs-3700;) \
postscriptdriver(kyocera;kyocera_fs-3718m;) \
postscriptdriver(kyocera;kyocera_fs-3750;) \
postscriptdriver(kyocera;kyocera_fs-3900dn;) \
postscriptdriver(kyocera;kyocera_fs-4000dn;) \
postscriptdriver(kyocera;kyocera_fs-4100dn;) \
postscriptdriver(kyocera;kyocera_fs-4200dn;) \
postscriptdriver(kyocera;kyocera_fs-4300dn;) \
postscriptdriver(kyocera;kyocera_fs-5800c;) \
postscriptdriver(kyocera;kyocera_fs-5900c;) \
postscriptdriver(kyocera;kyocera_fs-600;) \
postscriptdriver(kyocera;kyocera_fs-6300;) \
postscriptdriver(kyocera;kyocera_fs-6500+;) \
postscriptdriver(kyocera;kyocera_fs-6700;) \
postscriptdriver(kyocera;kyocera_fs-680;) \
postscriptdriver(kyocera;kyocera_fs-6900;) \
postscriptdriver(kyocera;kyocera_fs-6950dn;) \
postscriptdriver(kyocera;kyocera_fs-7000+;) \
postscriptdriver(kyocera;kyocera_fs-7000;) \
postscriptdriver(kyocera;kyocera_fs-7028m;) \
postscriptdriver(kyocera;kyocera_fs-800;) \
postscriptdriver(kyocera;kyocera_fs-9000;) \
postscriptdriver(kyocera;kyocera_fs-9130dn;) \
postscriptdriver(kyocera;kyocera_fs-920;) \
postscriptdriver(kyocera;kyocera_fs-9530dn;) \
postscriptdriver(kyocera;kyocera_fs-c5015n;) \
postscriptdriver(kyocera;kyocera_fs-c5020n;) \
postscriptdriver(kyocera;kyocera_fs-c5025n;) \
postscriptdriver(kyocera;kyocera_fs-c5030n;) \
postscriptdriver(kyocera;kyocera_fs-c5100dn;) \
postscriptdriver(kyocera;kyocera_fs-c5200dn;) \
postscriptdriver(kyocera;kyocera_fs-c5300dn;) \
postscriptdriver(kyocera;kyocera_fs-c5350dn;) \
postscriptdriver(kyocera;kyocera_fs-c5400dn;) \
postscriptdriver(kyocera;kyocera_fs-c8100dn+;) \
postscriptdriver(kyocera;kyocera_fs-c8100dn;) \
postscriptdriver(kyocera;kyocera_km-1820;) \
postscriptdriver(kyocera;kyocera_km-3050;) \
postscriptdriver(kyocera;kyocera_km-4050;) \
postscriptdriver(kyocera;kyocera_km-5050;) \
postscriptdriver(kyocera;kyocera_km-6030;) \
postscriptdriver(kyocera;kyocera_km-8030;) \
postscriptdriver(kyocera;kyocera_km-c2520;) \
postscriptdriver(kyocera;kyocera_km-c2525e;) \
postscriptdriver(kyocera;kyocera_km-c3225;) \
postscriptdriver(kyocera;kyocera_km-c3225e;) \
postscriptdriver(kyocera;kyocera_km-c3232;) \
postscriptdriver(kyocera;kyocera_km-c3232e;) \
postscriptdriver(kyocera;kyocera_km-c4035e;) \
postscriptdriver(kyocera;kyocera_taskalfa_250ci;) \
postscriptdriver(kyocera;kyocera_taskalfa_300ci;) \
postscriptdriver(kyocera;kyocera_taskalfa_400ci;) \
postscriptdriver(kyocera;kyocera_taskalfa_500ci;) \
postscriptdriver(kyocera;p-2000;) \
postscriptdriver(kyocera;p-2002;) \
postscriptdriver(kyocera_mita;km-1510;) \
postscriptdriver(kyocera_mita;km-1530;) \
postscriptdriver(kyocera_mita;km-1810;) \
postscriptdriver(kyocera_mita;km-2030;) \
postscriptdriver(kyocera_mita;km-2530;) \
postscriptdriver(kyocera_mita;km-3530;) \
postscriptdriver(kyocera_mita;km-4230/5230;) \
postscriptdriver(kyocera_mita;km-4230;) \
postscriptdriver(kyocera_mita;km-4530;) \
postscriptdriver(kyocera_mita;km-5230;) \
postscriptdriver(kyocera_mita;km-5530;) \
postscriptdriver(kyocera_mita;km-6230;) \
postscriptdriver(kyocera_mita;km-c2630;) \
postscriptdriver(kyocera_mita;km-c830;) \
postscriptdriver(kyocera_mita;km-c850;) \
postscriptdriver(kyocera_mita;kyocera_mita_ci-1100;) \
postscriptdriver(kyocera_mita;kyocera_mita_cs-1815;) \
postscriptdriver(kyocera_mita;kyocera_mita_fs-1000+;) \
postscriptdriver(kyocera_mita;kyocera_mita_fs-1010;) \
postscriptdriver(kyocera_mita;kyocera_mita_fs-1018mfp;) \
postscriptdriver(kyocera_mita;kyocera_mita_fs-1050;) \
postscriptdriver(kyocera_mita;kyocera_mita_fs-1800+;) \
postscriptdriver(kyocera_mita;kyocera_mita_fs-1800;) \
postscriptdriver(kyocera_mita;kyocera_mita_fs-1900;) \
postscriptdriver(kyocera_mita;kyocera_mita_fs-1920;) \
postscriptdriver(kyocera_mita;kyocera_mita_fs-3800;) \
postscriptdriver(kyocera_mita;kyocera_mita_fs-3820n;) \
postscriptdriver(kyocera_mita;kyocera_mita_fs-3830n;) \
postscriptdriver(kyocera_mita;kyocera_mita_fs-6020;) \
postscriptdriver(kyocera_mita;kyocera_mita_fs-6026;) \
postscriptdriver(kyocera_mita;kyocera_mita_fs-6750;) \
postscriptdriver(kyocera_mita;kyocera_mita_fs-8000c;) \
postscriptdriver(kyocera_mita;kyocera_mita_fs-9100dn;) \
postscriptdriver(kyocera_mita;kyocera_mita_fs-9500dn;) \
postscriptdriver(kyocera_mita;kyocera_mita_fs-c5016n;) \
postscriptdriver(kyocera_mita;kyocera_mita_fs-c8008n;) \
postscriptdriver(kyocera_mita;kyocera_mita_km-1815;) \
postscriptdriver(lanier;5622;) \
postscriptdriver(lanier;5627;) \
postscriptdriver(lanier;5632;) \
postscriptdriver(lanier;5635;) \
postscriptdriver(lanier;5645;) \
postscriptdriver(lanier;lc155;) \
postscriptdriver(lanier;ld0105;) \
postscriptdriver(lanier;ld015;) \
postscriptdriver(lanier;ld035;) \
postscriptdriver(lanier;ld045;) \
postscriptdriver(lanier;ld060;) \
postscriptdriver(lanier;ld075;) \
postscriptdriver(lanier;ld090;) \
postscriptdriver(lanier;ld115;) \
postscriptdriver(lanier;ld116;) \
postscriptdriver(lanier;ld118;) \
postscriptdriver(lanier;ld118d;) \
postscriptdriver(lanier;ld120;) \
postscriptdriver(lanier;ld120d;) \
postscriptdriver(lanier;ld122;) \
postscriptdriver(lanier;ld124c;) \
postscriptdriver(lanier;ld127;) \
postscriptdriver(lanier;ld132;) \
postscriptdriver(lanier;ld132c;) \
postscriptdriver(lanier;ld135;) \
postscriptdriver(lanier;ld145;) \
postscriptdriver(lanier;ld151;) \
postscriptdriver(lanier;ld160;) \
postscriptdriver(lanier;ld160c;) \
postscriptdriver(lanier;ld175;) \
postscriptdriver(lanier;ld225;) \
postscriptdriver(lanier;ld230;) \
postscriptdriver(lanier;ld235;) \
postscriptdriver(lanier;ld245;) \
postscriptdriver(lanier;ld328c;) \
postscriptdriver(lanier;ld335c;) \
postscriptdriver(lanier;ld345c;) \
postscriptdriver(lanier;ld_130c;) \
postscriptdriver(lanier;ld_130csr;) \
postscriptdriver(lanier;ld_140c;) \
postscriptdriver(lanier;ld_140csr;) \
postscriptdriver(lanier;ld_620c;) \
postscriptdriver(lanier;ld_625c;) \
postscriptdriver(lanier;mp2500/ld125;) \
postscriptdriver(lanier;mp_1100/ld1100;) \
postscriptdriver(lanier;mp_1350/ld1135;) \
postscriptdriver(lanier;mp_1600/ld316;) \
postscriptdriver(lanier;mp_161/ld016;) \
postscriptdriver(lanier;mp_171/ld_117;) \
postscriptdriver(lanier;mp_2000/ld320d;) \
postscriptdriver(lanier;mp_2001;) \
postscriptdriver(lanier;mp_201/ld_220;) \
postscriptdriver(lanier;mp_2352;) \
postscriptdriver(lanier;mp_2501;) \
postscriptdriver(lanier;mp_2510/ld325;) \
postscriptdriver(lanier;mp_2550/ld425;) \
postscriptdriver(lanier;mp_2550b/ld425b;) \
postscriptdriver(lanier;mp_2553;) \
postscriptdriver(lanier;mp_2851/ld528;) \
postscriptdriver(lanier;mp_2852;) \
postscriptdriver(lanier;mp_3010/ld330;) \
postscriptdriver(lanier;mp_3053;) \
postscriptdriver(lanier;mp_3350/ld433;) \
postscriptdriver(lanier;mp_3350b/ld433b;) \
postscriptdriver(lanier;mp_3351/ld533;) \
postscriptdriver(lanier;mp_3352;) \
postscriptdriver(lanier;mp_3353;) \
postscriptdriver(lanier;mp_3500/ld335;) \
postscriptdriver(lanier;mp_4000/ld040;) \
postscriptdriver(lanier;mp_4000b/ld040b;) \
postscriptdriver(lanier;mp_4001/ld140;) \
postscriptdriver(lanier;mp_4002;) \
postscriptdriver(lanier;mp_4500/ld345;) \
postscriptdriver(lanier;mp_5000/ld050;) \
postscriptdriver(lanier;mp_5000b/ld050b;) \
postscriptdriver(lanier;mp_5001/ld150;) \
postscriptdriver(lanier;mp_5002;) \
postscriptdriver(lanier;mp_5500/ld255;) \
postscriptdriver(lanier;mp_6000/ld260;) \
postscriptdriver(lanier;mp_6001/ld360;) \
postscriptdriver(lanier;mp_6002;) \
postscriptdriver(lanier;mp_6500/ld265;) \
postscriptdriver(lanier;mp_7000/ld270;) \
postscriptdriver(lanier;mp_7001/ld370;) \
postscriptdriver(lanier;mp_7500/ld275;) \
postscriptdriver(lanier;mp_7502;) \
postscriptdriver(lanier;mp_8000/ld280;) \
postscriptdriver(lanier;mp_8001/ld380;) \
postscriptdriver(lanier;mp_9000/ld190;) \
postscriptdriver(lanier;mp_9001/ld390;) \
postscriptdriver(lanier;mp_9002;) \
postscriptdriver(lanier;mp_c2003;) \
postscriptdriver(lanier;mp_c2050/ld520c;) \
postscriptdriver(lanier;mp_c2500/ld425c;) \
postscriptdriver(lanier;mp_c2503;) \
postscriptdriver(lanier;mp_c2550/ld525c;) \
postscriptdriver(lanier;mp_c2800/ld528c;) \
postscriptdriver(lanier;mp_c3000/ld430c;) \
postscriptdriver(lanier;mp_c3001/ld630c;) \
postscriptdriver(lanier;mp_c3002;) \
postscriptdriver(lanier;mp_c3003;) \
postscriptdriver(lanier;mp_c300;) \
postscriptdriver(lanier;mp_c300sr;) \
postscriptdriver(lanier;mp_c3300/ld533c;) \
postscriptdriver(lanier;mp_c3500/ld435c;) \
postscriptdriver(lanier;mp_c3501/ld635c;) \
postscriptdriver(lanier;mp_c3502;) \
postscriptdriver(lanier;mp_c3503;) \
postscriptdriver(lanier;mp_c4000/ld540c;) \
postscriptdriver(lanier;mp_c400;) \
postscriptdriver(lanier;mp_c400sr;) \
postscriptdriver(lanier;mp_c4500/ld445c;) \
postscriptdriver(lanier;mp_c4501/ld645c;) \
postscriptdriver(lanier;mp_c4502;) \
postscriptdriver(lanier;mp_c4502a;) \
postscriptdriver(lanier;mp_c4503;) \
postscriptdriver(lanier;mp_c5000/ld550c;) \
postscriptdriver(lanier;mp_c5501/ld655c;) \
postscriptdriver(lanier;mp_c5502;) \
postscriptdriver(lanier;mp_c5502a;) \
postscriptdriver(lanier;mp_c5503;) \
postscriptdriver(lanier;mp_c6000/ld260c;) \
postscriptdriver(lanier;mp_c6003;) \
postscriptdriver(lanier;mp_c6501/ld365c;) \
postscriptdriver(lanier;mp_c6502;) \
postscriptdriver(lanier;mp_c7500/ld275c;) \
postscriptdriver(lanier;mp_c7501/ld375c;) \
postscriptdriver(lanier;mp_c8002;) \
postscriptdriver(lanier;mpc1500/ld215c;) \
postscriptdriver(lanier;mpc4501a/ld645ca;) \
postscriptdriver(lanier;mpc5501a/ld655ca;) \
postscriptdriver(lanier;pro_1106ex;) \
postscriptdriver(lanier;pro_1107ex;) \
postscriptdriver(lanier;pro_1356ex;) \
postscriptdriver(lanier;pro_1357ex;) \
postscriptdriver(lanier;pro_8100s;) \
postscriptdriver(lanier;pro_8110s;) \
postscriptdriver(lanier;pro_8120s;) \
postscriptdriver(lanier;pro_906ex;) \
postscriptdriver(lanier;pro_907ex;) \
postscriptdriver(lanier;pro_c5100s;) \
postscriptdriver(lanier;pro_c5110s;) \
postscriptdriver(lanier;sg3110dn;) \
postscriptdriver(lanier;sg3110dnw;) \
postscriptdriver(lanier;sg3110sfnw;) \
postscriptdriver(lexmark;e210;) \
postscriptdriver(lexmark;lexmark_3000_color_jetprinter;) \
postscriptdriver(lexmark;lexmark_3200;) \
postscriptdriver(lexmark;lexmark_5700;) \
postscriptdriver(lexmark;lexmark_z22-z32;) \
postscriptdriver(lexmark_international;ibm_3112_page_printer;) \
postscriptdriver(lexmark_international;lexmark_e120;) \
postscriptdriver(lexmark_international;lexmark_e120n;) \
postscriptdriver(lexmark_international;lexmark_e230;) \
postscriptdriver(lexmark_international;lexmark_e238;) \
postscriptdriver(lexmark_international;lexmark_e321;) \
postscriptdriver(lexmark_international;lexmark_e350d;) \
postscriptdriver(lexmark_international;lexmark_e352dn;) \
postscriptdriver(lexmark_international;lexmark_optra_e+_laserprinter;) \
postscriptdriver(minolta;pagepro_1100;) \
postscriptdriver(minolta;pagepro_6;) \
postscriptdriver(minolta;pagepro_8;) \
postscriptdriver(minolta;pagepro_8l;) \
postscriptdriver(minolta;pagepro___6e;) \
postscriptdriver(nec;superscript_1800;) \
postscriptdriver(nec;superscript_870;) \
postscriptdriver(nrg;10515/10518/10512;) \
postscriptdriver(nrg;2205/2238/2212;) \
postscriptdriver(nrg;2705/2738/2712;) \
postscriptdriver(nrg;3205/3238/3212;) \
postscriptdriver(nrg;3525/3508/3502;) \
postscriptdriver(nrg;3545/3518/3532;) \
postscriptdriver(nrg;4525/4508/4502;) \
postscriptdriver(nrg;4545/4518/4532;) \
postscriptdriver(nrg;6002/6005/6008;) \
postscriptdriver(nrg;7502/7505/7508;) \
postscriptdriver(nrg;9005/9008/9002;) \
postscriptdriver(nrg;cs555;) \
postscriptdriver(nrg;dsc424;) \
postscriptdriver(nrg;dsc428;) \
postscriptdriver(nrg;dsc432;) \
postscriptdriver(nrg;dsc435;) \
postscriptdriver(nrg;dsc445;) \
postscriptdriver(nrg;dsc460;) \
postscriptdriver(nrg;dsm415;) \
postscriptdriver(nrg;dsm615;) \
postscriptdriver(nrg;dsm616;) \
postscriptdriver(nrg;dsm618;) \
postscriptdriver(nrg;dsm618d;) \
postscriptdriver(nrg;dsm620;) \
postscriptdriver(nrg;dsm620d;) \
postscriptdriver(nrg;dsm622;) \
postscriptdriver(nrg;dsm627;) \
postscriptdriver(nrg;dsm632;) \
postscriptdriver(nrg;dsm635;) \
postscriptdriver(nrg;dsm645;) \
postscriptdriver(nrg;dsm651;) \
postscriptdriver(nrg;dsm660;) \
postscriptdriver(nrg;dsm675;) \
postscriptdriver(nrg;dsm725;) \
postscriptdriver(nrg;dsm730;) \
postscriptdriver(nrg;dsm735;) \
postscriptdriver(nrg;dsm745;) \
postscriptdriver(nrg;mp_1100;) \
postscriptdriver(nrg;mp_1350;) \
postscriptdriver(nrg;mp_1600;) \
postscriptdriver(nrg;mp_161;) \
postscriptdriver(nrg;mp_171;) \
postscriptdriver(nrg;mp_2000;) \
postscriptdriver(nrg;mp_2001;) \
postscriptdriver(nrg;mp_201;) \
postscriptdriver(nrg;mp_2352;) \
postscriptdriver(nrg;mp_2500;) \
postscriptdriver(nrg;mp_2501;) \
postscriptdriver(nrg;mp_2510;) \
postscriptdriver(nrg;mp_2550;) \
postscriptdriver(nrg;mp_2550b;) \
postscriptdriver(nrg;mp_2553;) \
postscriptdriver(nrg;mp_2851;) \
postscriptdriver(nrg;mp_2852;) \
postscriptdriver(nrg;mp_3010;) \
postscriptdriver(nrg;mp_3053;) \
postscriptdriver(nrg;mp_3350;) \
postscriptdriver(nrg;mp_3350b;) \
postscriptdriver(nrg;mp_3351;) \
postscriptdriver(nrg;mp_3352;) \
postscriptdriver(nrg;mp_3353;) \
postscriptdriver(nrg;mp_3500;) \
postscriptdriver(nrg;mp_4000;) \
postscriptdriver(nrg;mp_4000b;) \
postscriptdriver(nrg;mp_4001;) \
postscriptdriver(nrg;mp_4002;) \
postscriptdriver(nrg;mp_4500;) \
postscriptdriver(nrg;mp_5000;) \
postscriptdriver(nrg;mp_5000b;) \
postscriptdriver(nrg;mp_5001;) \
postscriptdriver(nrg;mp_5002;) \
postscriptdriver(nrg;mp_5500;) \
postscriptdriver(nrg;mp_6000;) \
postscriptdriver(nrg;mp_6001;) \
postscriptdriver(nrg;mp_6002;) \
postscriptdriver(nrg;mp_6500;) \
postscriptdriver(nrg;mp_7000;) \
postscriptdriver(nrg;mp_7001;) \
postscriptdriver(nrg;mp_7500;) \
postscriptdriver(nrg;mp_7502;) \
postscriptdriver(nrg;mp_8000;) \
postscriptdriver(nrg;mp_8001;) \
postscriptdriver(nrg;mp_9000;) \
postscriptdriver(nrg;mp_9001;) \
postscriptdriver(nrg;mp_9002;) \
postscriptdriver(nrg;mp_c1500sp;) \
postscriptdriver(nrg;mp_c2003;) \
postscriptdriver(nrg;mp_c2003z;) \
postscriptdriver(nrg;mp_c2050;) \
postscriptdriver(nrg;mp_c2051;) \
postscriptdriver(nrg;mp_c2500;) \
postscriptdriver(nrg;mp_c2503;) \
postscriptdriver(nrg;mp_c2503z;) \
postscriptdriver(nrg;mp_c2550;) \
postscriptdriver(nrg;mp_c2551;) \
postscriptdriver(nrg;mp_c2800;) \
postscriptdriver(nrg;mp_c3000;) \
postscriptdriver(nrg;mp_c3001;) \
postscriptdriver(nrg;mp_c3002;) \
postscriptdriver(nrg;mp_c3003;) \
postscriptdriver(nrg;mp_c300;) \
postscriptdriver(nrg;mp_c300sr;) \
postscriptdriver(nrg;mp_c3300;) \
postscriptdriver(nrg;mp_c3500;) \
postscriptdriver(nrg;mp_c3501;) \
postscriptdriver(nrg;mp_c3502;) \
postscriptdriver(nrg;mp_c3503;) \
postscriptdriver(nrg;mp_c4000;) \
postscriptdriver(nrg;mp_c400;) \
postscriptdriver(nrg;mp_c400sr;) \
postscriptdriver(nrg;mp_c4500;) \
postscriptdriver(nrg;mp_c4501;) \
postscriptdriver(nrg;mp_c4501a;) \
postscriptdriver(nrg;mp_c4502;) \
postscriptdriver(nrg;mp_c4502a;) \
postscriptdriver(nrg;mp_c4503;) \
postscriptdriver(nrg;mp_c5000;) \
postscriptdriver(nrg;mp_c5501;) \
postscriptdriver(nrg;mp_c5501a;) \
postscriptdriver(nrg;mp_c5502;) \
postscriptdriver(nrg;mp_c5502a;) \
postscriptdriver(nrg;mp_c5503;) \
postscriptdriver(nrg;mp_c6000;) \
postscriptdriver(nrg;mp_c6003;) \
postscriptdriver(nrg;mp_c6501;) \
postscriptdriver(nrg;mp_c6502;) \
postscriptdriver(nrg;mp_c7500;) \
postscriptdriver(nrg;mp_c7501;) \
postscriptdriver(nrg;mp_c8002;) \
postscriptdriver(nrg;pro_1106ex;) \
postscriptdriver(nrg;pro_1107ex;) \
postscriptdriver(nrg;pro_1356ex;) \
postscriptdriver(nrg;pro_1357ex;) \
postscriptdriver(nrg;pro_8100s;) \
postscriptdriver(nrg;pro_8110s;) \
postscriptdriver(nrg;pro_8120s;) \
postscriptdriver(nrg;pro_906ex;) \
postscriptdriver(nrg;pro_907ex;) \
postscriptdriver(nrg;pro_c5100s;) \
postscriptdriver(nrg;pro_c5110s;) \
postscriptdriver(nrg;sg3110dn;) \
postscriptdriver(nrg;sg3110dnw;) \
postscriptdriver(nrg;sg3110sfnw;) \
postscriptdriver(oce;oce_8445;) \
postscriptdriver(oce;oce_8465;) \
postscriptdriver(oce;oce_varioprint_2050;) \
postscriptdriver(oce;oce_varioprint_2060;) \
postscriptdriver(oce;oce_varioprint_2070;) \
postscriptdriver(oce;oce_varioprint_2090_ps3;) \
postscriptdriver(oce;oce_vp2105_ps3;) \
postscriptdriver(oki;b4300;) \
postscriptdriver(oki;c5300;) \
postscriptdriver(oki;c5400;) \
postscriptdriver(oki;c6100;) \
postscriptdriver(oki;c7300;) \
postscriptdriver(oki;c9200;) \
postscriptdriver(oki;c9400;) \
postscriptdriver(oki;oki;) \
postscriptdriver(oki_data_corp;b410;) \
postscriptdriver(oki_data_corp;ml320/1turbo;) \
postscriptdriver(oki_data_corp;oki_okipage_4w;) \
postscriptdriver(oki_data_corp;okidata_okipage_6e;) \
postscriptdriver(oki_data_corp;okidata_okipage_6ex;) \
postscriptdriver(oki_data_corp;okipage_10e;) \
postscriptdriver(oki_data_corp;okipage_10ex;) \
postscriptdriver(oki_data_corp;okipage_14ex;) \
postscriptdriver(oki_data_corp;okipage_8p;) \
postscriptdriver(panasonic;kx-p6500;) \
postscriptdriver(ricoh;aficio_1022;) \
postscriptdriver(ricoh;aficio_1027;) \
postscriptdriver(ricoh;aficio_1032;) \
postscriptdriver(ricoh;aficio_1035;) \
postscriptdriver(ricoh;aficio_1045;) \
postscriptdriver(ricoh;aficio_1060;) \
postscriptdriver(ricoh;aficio_1075;) \
postscriptdriver(ricoh;aficio_1515;) \
postscriptdriver(ricoh;aficio_2015;) \
postscriptdriver(ricoh;aficio_2016;) \
postscriptdriver(ricoh;aficio_2018;) \
postscriptdriver(ricoh;aficio_2018d;) \
postscriptdriver(ricoh;aficio_2020;) \
postscriptdriver(ricoh;aficio_2020d;) \
postscriptdriver(ricoh;aficio_2022;) \
postscriptdriver(ricoh;aficio_2027;) \
postscriptdriver(ricoh;aficio_2032;) \
postscriptdriver(ricoh;aficio_2035;) \
postscriptdriver(ricoh;aficio_2035e;) \
postscriptdriver(ricoh;aficio_2045;) \
postscriptdriver(ricoh;aficio_2045e;) \
postscriptdriver(ricoh;aficio_2051;) \
postscriptdriver(ricoh;aficio_2060;) \
postscriptdriver(ricoh;aficio_2075;) \
postscriptdriver(ricoh;aficio_2090;) \
postscriptdriver(ricoh;aficio_2105;) \
postscriptdriver(ricoh;aficio_3025;) \
postscriptdriver(ricoh;aficio_3030;) \
postscriptdriver(ricoh;aficio_3035;) \
postscriptdriver(ricoh;aficio_3045;) \
postscriptdriver(ricoh;aficio_3224c;) \
postscriptdriver(ricoh;aficio_3228c;) \
postscriptdriver(ricoh;aficio_3232c;) \
postscriptdriver(ricoh;aficio_3235c;) \
postscriptdriver(ricoh;aficio_3245c;) \
postscriptdriver(ricoh;aficio_3260c;) \
postscriptdriver(ricoh;aficio_color5560;) \
postscriptdriver(ricoh;aficio_mp_1100;) \
postscriptdriver(ricoh;aficio_mp_1350;) \
postscriptdriver(ricoh;aficio_mp_1600;) \
postscriptdriver(ricoh;aficio_mp_161;) \
postscriptdriver(ricoh;aficio_mp_171;) \
postscriptdriver(ricoh;aficio_mp_2000;) \
postscriptdriver(ricoh;aficio_mp_201;) \
postscriptdriver(ricoh;aficio_mp_2352;) \
postscriptdriver(ricoh;aficio_mp_2500;) \
postscriptdriver(ricoh;aficio_mp_2510;) \
postscriptdriver(ricoh;aficio_mp_2550;) \
postscriptdriver(ricoh;aficio_mp_2550b;) \
postscriptdriver(ricoh;aficio_mp_2851;) \
postscriptdriver(ricoh;aficio_mp_2852;) \
postscriptdriver(ricoh;aficio_mp_3010;) \
postscriptdriver(ricoh;aficio_mp_3350;) \
postscriptdriver(ricoh;aficio_mp_3350b;) \
postscriptdriver(ricoh;aficio_mp_3351;) \
postscriptdriver(ricoh;aficio_mp_3352;) \
postscriptdriver(ricoh;aficio_mp_3500;) \
postscriptdriver(ricoh;aficio_mp_4000;) \
postscriptdriver(ricoh;aficio_mp_4000b;) \
postscriptdriver(ricoh;aficio_mp_4001;) \
postscriptdriver(ricoh;aficio_mp_4002;) \
postscriptdriver(ricoh;aficio_mp_4500;) \
postscriptdriver(ricoh;aficio_mp_5000;) \
postscriptdriver(ricoh;aficio_mp_5000b;) \
postscriptdriver(ricoh;aficio_mp_5001;) \
postscriptdriver(ricoh;aficio_mp_5002;) \
postscriptdriver(ricoh;aficio_mp_5500;) \
postscriptdriver(ricoh;aficio_mp_6000;) \
postscriptdriver(ricoh;aficio_mp_6001;) \
postscriptdriver(ricoh;aficio_mp_6002;) \
postscriptdriver(ricoh;aficio_mp_6500;) \
postscriptdriver(ricoh;aficio_mp_7000;) \
postscriptdriver(ricoh;aficio_mp_7001;) \
postscriptdriver(ricoh;aficio_mp_7500;) \
postscriptdriver(ricoh;aficio_mp_7502;) \
postscriptdriver(ricoh;aficio_mp_8000;) \
postscriptdriver(ricoh;aficio_mp_8001;) \
postscriptdriver(ricoh;aficio_mp_9000;) \
postscriptdriver(ricoh;aficio_mp_9001;) \
postscriptdriver(ricoh;aficio_mp_9002;) \
postscriptdriver(ricoh;aficio_mp_c2050;) \
postscriptdriver(ricoh;aficio_mp_c2051;) \
postscriptdriver(ricoh;aficio_mp_c2500;) \
postscriptdriver(ricoh;aficio_mp_c2550;) \
postscriptdriver(ricoh;aficio_mp_c2551;) \
postscriptdriver(ricoh;aficio_mp_c2800;) \
postscriptdriver(ricoh;aficio_mp_c3000;) \
postscriptdriver(ricoh;aficio_mp_c3001;) \
postscriptdriver(ricoh;aficio_mp_c3002;) \
postscriptdriver(ricoh;aficio_mp_c300;) \
postscriptdriver(ricoh;aficio_mp_c300sr;) \
postscriptdriver(ricoh;aficio_mp_c3300;) \
postscriptdriver(ricoh;aficio_mp_c3500;) \
postscriptdriver(ricoh;aficio_mp_c3501;) \
postscriptdriver(ricoh;aficio_mp_c3502;) \
postscriptdriver(ricoh;aficio_mp_c4000;) \
postscriptdriver(ricoh;aficio_mp_c400;) \
postscriptdriver(ricoh;aficio_mp_c400sr;) \
postscriptdriver(ricoh;aficio_mp_c4500;) \
postscriptdriver(ricoh;aficio_mp_c4501;) \
postscriptdriver(ricoh;aficio_mp_c4501a;) \
postscriptdriver(ricoh;aficio_mp_c4502;) \
postscriptdriver(ricoh;aficio_mp_c4502a;) \
postscriptdriver(ricoh;aficio_mp_c5000;) \
postscriptdriver(ricoh;aficio_mp_c5501;) \
postscriptdriver(ricoh;aficio_mp_c5501a;) \
postscriptdriver(ricoh;aficio_mp_c5502;) \
postscriptdriver(ricoh;aficio_mp_c5502a;) \
postscriptdriver(ricoh;aficio_mp_c6000;) \
postscriptdriver(ricoh;aficio_mp_c6501;) \
postscriptdriver(ricoh;aficio_mp_c7500;) \
postscriptdriver(ricoh;aficio_mp_c7501;) \
postscriptdriver(ricoh;aficiosg3110dn;) \
postscriptdriver(ricoh;aficiosg3110dnw;) \
postscriptdriver(ricoh;aficiosg3110sfnw;) \
postscriptdriver(ricoh;mp_2001;) \
postscriptdriver(ricoh;mp_2501;) \
postscriptdriver(ricoh;mp_2553;) \
postscriptdriver(ricoh;mp_3053;) \
postscriptdriver(ricoh;mp_3353;) \
postscriptdriver(ricoh;mp_c1500/615c;) \
postscriptdriver(ricoh;mp_c2003;) \
postscriptdriver(ricoh;mp_c2003z;) \
postscriptdriver(ricoh;mp_c2503;) \
postscriptdriver(ricoh;mp_c2503z;) \
postscriptdriver(ricoh;mp_c3003;) \
postscriptdriver(ricoh;mp_c3503;) \
postscriptdriver(ricoh;mp_c4503;) \
postscriptdriver(ricoh;mp_c5503;) \
postscriptdriver(ricoh;mp_c6003;) \
postscriptdriver(ricoh;mp_c6502;) \
postscriptdriver(ricoh;mp_c8002;) \
postscriptdriver(ricoh;pro_1106ex;) \
postscriptdriver(ricoh;pro_1107ex;) \
postscriptdriver(ricoh;pro_1356ex;) \
postscriptdriver(ricoh;pro_1357ex;) \
postscriptdriver(ricoh;pro_8100s;) \
postscriptdriver(ricoh;pro_8110s;) \
postscriptdriver(ricoh;pro_8120s;) \
postscriptdriver(ricoh;pro_906ex;) \
postscriptdriver(ricoh;pro_907ex;) \
postscriptdriver(ricoh;pro_c5100s;) \
postscriptdriver(ricoh;pro_c5110s;) \
postscriptdriver(ricoh;sg3120bsfnw;) \
postscriptdriver(samsung;6050;) \
postscriptdriver(samsung;clp-350_series;) \
postscriptdriver(samsung;clp-550;) \
postscriptdriver(samsung;clp-610_series;) \
postscriptdriver(samsung;clp-620_series;) \
postscriptdriver(samsung;m262x_282x_series;) \
postscriptdriver(samsung;m267x_287x_series;) \
postscriptdriver(samsung;ml-1430;) \
postscriptdriver(samsung;ml-1440;) \
postscriptdriver(samsung;ml-1450;) \
postscriptdriver(samsung;ml-1510_700;) \
postscriptdriver(samsung;ml-1610;) \
postscriptdriver(samsung;ml-1650;) \
postscriptdriver(samsung;ml-1710;) \
postscriptdriver(samsung;ml-1740;) \
postscriptdriver(samsung;ml-2010;) \
postscriptdriver(samsung;ml-2150_series;) \
postscriptdriver(samsung;ml-2550_series;) \
postscriptdriver(samsung;ml-2580_series;) \
postscriptdriver(samsung;ml-2950_series;) \
postscriptdriver(samsung;ml-6060;) \
postscriptdriver(samsung;scx-470x_series;) \
postscriptdriver(samsung;scx-472x_series;) \
postscriptdriver(samsung;scx-4x24_series;) \
postscriptdriver(samsung;scx-4x25_series;) \
postscriptdriver(samsung;scx-4x26_series;) \
postscriptdriver(savin;2522;) \
postscriptdriver(savin;2527;) \
postscriptdriver(savin;2532;) \
postscriptdriver(savin;2535/2235;) \
postscriptdriver(savin;2545/2245;) \
postscriptdriver(savin;2560;) \
postscriptdriver(savin;2575;) \
postscriptdriver(savin;3515;) \
postscriptdriver(savin;40105;) \
postscriptdriver(savin;4015;) \
postscriptdriver(savin;4018;) \
postscriptdriver(savin;4018d;) \
postscriptdriver(savin;4022;) \
postscriptdriver(savin;4027;) \
postscriptdriver(savin;4035/4135g;) \
postscriptdriver(savin;4035e/4135eg;) \
postscriptdriver(savin;4045/4145g;) \
postscriptdriver(savin;4045e/4145eg;) \
postscriptdriver(savin;4051;) \
postscriptdriver(savin;4060;) \
postscriptdriver(savin;4075;) \
postscriptdriver(savin;4090;) \
postscriptdriver(savin;7025;) \
postscriptdriver(savin;8016;) \
postscriptdriver(savin;8020;) \
postscriptdriver(savin;8020d;) \
postscriptdriver(savin;8025;) \
postscriptdriver(savin;8025e;) \
postscriptdriver(savin;8030;) \
postscriptdriver(savin;8030e;) \
postscriptdriver(savin;8035/8035g;) \
postscriptdriver(savin;8035e;) \
postscriptdriver(savin;8045/8045g;) \
postscriptdriver(savin;8045e;) \
postscriptdriver(savin;8055;) \
postscriptdriver(savin;8060;) \
postscriptdriver(savin;8065;) \
postscriptdriver(savin;8070;) \
postscriptdriver(savin;8075;) \
postscriptdriver(savin;8080;) \
postscriptdriver(savin;8090;) \
postscriptdriver(savin;8110;) \
postscriptdriver(savin;8135;) \
postscriptdriver(savin;816;) \
postscriptdriver(savin;9016;) \
postscriptdriver(savin;9021d;) \
postscriptdriver(savin;9025;) \
postscriptdriver(savin;9025b;) \
postscriptdriver(savin;9033;) \
postscriptdriver(savin;9033b;) \
postscriptdriver(savin;9040;) \
postscriptdriver(savin;9040b;) \
postscriptdriver(savin;9050;) \
postscriptdriver(savin;9050b;) \
postscriptdriver(savin;9060;) \
postscriptdriver(savin;9070;) \
postscriptdriver(savin;9080;) \
postscriptdriver(savin;9090;) \
postscriptdriver(savin;917;) \
postscriptdriver(savin;920;) \
postscriptdriver(savin;9228;) \
postscriptdriver(savin;9233;) \
postscriptdriver(savin;9240;) \
postscriptdriver(savin;9250;) \
postscriptdriver(savin;c2410;) \
postscriptdriver(savin;c2525;) \
postscriptdriver(savin;c2824;) \
postscriptdriver(savin;c2828;) \
postscriptdriver(savin;c3030;) \
postscriptdriver(savin;c3210e;) \
postscriptdriver(savin;c3333;) \
postscriptdriver(savin;c3528;) \
postscriptdriver(savin;c3535;) \
postscriptdriver(savin;c4040;) \
postscriptdriver(savin;c4535;) \
postscriptdriver(savin;c4540;) \
postscriptdriver(savin;c5050;) \
postscriptdriver(savin;c6045;) \
postscriptdriver(savin;c6055;) \
postscriptdriver(savin;c7570;) \
postscriptdriver(savin;c9020;) \
postscriptdriver(savin;c9025;) \
postscriptdriver(savin;c9065;) \
postscriptdriver(savin;c9075;) \
postscriptdriver(savin;c9120;) \
postscriptdriver(savin;c9125;) \
postscriptdriver(savin;c9130;) \
postscriptdriver(savin;c9135;) \
postscriptdriver(savin;c9145;) \
postscriptdriver(savin;c9145a;) \
postscriptdriver(savin;c9155;) \
postscriptdriver(savin;c9155a;) \
postscriptdriver(savin;c_230;) \
postscriptdriver(savin;c_230sr;) \
postscriptdriver(savin;c_240;) \
postscriptdriver(savin;c_240sr;) \
postscriptdriver(savin;mp_2352;) \
postscriptdriver(savin;mp_2501;) \
postscriptdriver(savin;mp_2553;) \
postscriptdriver(savin;mp_2852;) \
postscriptdriver(savin;mp_3053;) \
postscriptdriver(savin;mp_3352;) \
postscriptdriver(savin;mp_3353;) \
postscriptdriver(savin;mp_4002;) \
postscriptdriver(savin;mp_5002;) \
postscriptdriver(savin;mp_6002;) \
postscriptdriver(savin;mp_7502;) \
postscriptdriver(savin;mp_9002;) \
postscriptdriver(savin;mp_c2003;) \
postscriptdriver(savin;mp_c2503;) \
postscriptdriver(savin;mp_c3002;) \
postscriptdriver(savin;mp_c3003;) \
postscriptdriver(savin;mp_c3502;) \
postscriptdriver(savin;mp_c3503;) \
postscriptdriver(savin;mp_c4502;) \
postscriptdriver(savin;mp_c4502a;) \
postscriptdriver(savin;mp_c4503;) \
postscriptdriver(savin;mp_c5502;) \
postscriptdriver(savin;mp_c5502a;) \
postscriptdriver(savin;mp_c5503;) \
postscriptdriver(savin;mp_c6003;) \
postscriptdriver(savin;mp_c6502;) \
postscriptdriver(savin;mp_c8002;) \
postscriptdriver(savin;pro_1106ex;) \
postscriptdriver(savin;pro_1107ex;) \
postscriptdriver(savin;pro_1356ex;) \
postscriptdriver(savin;pro_1357ex;) \
postscriptdriver(savin;pro_8100s;) \
postscriptdriver(savin;pro_8110s;) \
postscriptdriver(savin;pro_8120s;) \
postscriptdriver(savin;pro_906ex;) \
postscriptdriver(savin;pro_907ex;) \
postscriptdriver(savin;pro_c5100s;) \
postscriptdriver(savin;pro_c5110s;) \
postscriptdriver(savin;sdc555;) \
postscriptdriver(savin;sg3110dn;) \
postscriptdriver(savin;sg3110dnw;) \
postscriptdriver(savin;sg3110sfnw;) \
postscriptdriver(savin;sgc_1506;) \
postscriptdriver(sharp;ar-160/200_series;) \
postscriptdriver(sharp;sharp_ar-nb2;) \
postscriptdriver(sharp;sharp_ar-p19;) \
postscriptdriver(sharp;sharp_ar-p20;) \
postscriptdriver(sharp;sharp_ar-pk4;) \
postscriptdriver(tektronix;phaser_750dp;) \
postscriptdriver(tektronix;phaser_750dx;) \
postscriptdriver(tektronix;phaser_750n;) \
postscriptdriver(tektronix;phaser_750p;) \
postscriptdriver(xerox;document_homecentre;) \
postscriptdriver(xerox;docuprint;) \
postscriptdriver(xerox;docuprint_c11;) \
postscriptdriver(xerox;docuprint_c8;) \
postscriptdriver(xerox;docuprint_p12;) \
postscriptdriver(xerox;docuprint_p8e;) \
postscriptdriver(xerox;phaser_4400b;) \
postscriptdriver(xerox;phaser_4400dt;) \
postscriptdriver(xerox;phaser_4400dx;) \
postscriptdriver(xerox;phaser_4400n;) \
postscriptdriver(xerox;phaser_4500b;) \
postscriptdriver(xerox;phaser_4500dt;) \
postscriptdriver(xerox;phaser_4500dx;) \
postscriptdriver(xerox;phaser_4500n;) \
postscriptdriver(xerox;phaser_4510b;) \
postscriptdriver(xerox;phaser_4510dt;) \
postscriptdriver(xerox;phaser_4510dx;) \
postscriptdriver(xerox;phaser_4510n;) \
postscriptdriver(xerox;phaser_5500b;) \
postscriptdriver(xerox;phaser_5500dn;) \
postscriptdriver(xerox;phaser_5500dt;) \
postscriptdriver(xerox;phaser_5500dx;) \
postscriptdriver(xerox;phaser_5500n;) \
postscriptdriver(xerox;phaser_6130n;) \
postscriptdriver(xerox;phaser_6180dn;) \
postscriptdriver(xerox;phaser_6180mfp-d;) \
postscriptdriver(xerox;phaser_6200b;) \
postscriptdriver(xerox;phaser_6200dp;) \
postscriptdriver(xerox;phaser_6200dx;) \
postscriptdriver(xerox;phaser_6200n;) \
postscriptdriver(xerox;phaser_6250b;) \
postscriptdriver(xerox;phaser_6250dp;) \
postscriptdriver(xerox;phaser_6250dt;) \
postscriptdriver(xerox;phaser_6250dx;) \
postscriptdriver(xerox;phaser_6250n;) \
postscriptdriver(xerox;phaser_6300dn;) \
postscriptdriver(xerox;phaser_6300n;) \
postscriptdriver(xerox;phaser_6350dp;) \
postscriptdriver(xerox;phaser_6350dt;) \
postscriptdriver(xerox;phaser_6350dx;) \
postscriptdriver(xerox;phaser_6360dn;) \
postscriptdriver(xerox;phaser_6360dx;) \
postscriptdriver(xerox;phaser_7300b;) \
postscriptdriver(xerox;phaser_7300dn;) \
postscriptdriver(xerox;phaser_7300dt;) \
postscriptdriver(xerox;phaser_7300dx;) \
postscriptdriver(xerox;phaser_7300n;) \
postscriptdriver(xerox;phaser_7400dn;) \
postscriptdriver(xerox;phaser_7400dt;) \
postscriptdriver(xerox;phaser_7400dx;) \
postscriptdriver(xerox;phaser_7400dxf;) \
postscriptdriver(xerox;phaser_7400n;) \
postscriptdriver(xerox;phaser_7700dn;) \
postscriptdriver(xerox;phaser_7700dx;) \
postscriptdriver(xerox;phaser_7700gx;) \
postscriptdriver(xerox;phaser_7750b;) \
postscriptdriver(xerox;phaser_7750dn;) \
postscriptdriver(xerox;phaser_7750dxf;) \
postscriptdriver(xerox;phaser_7750gx;) \
postscriptdriver(xerox;phaser_7760dn;) \
postscriptdriver(xerox;phaser_7760dx;) \
postscriptdriver(xerox;phaser_7760gx;) \
postscriptdriver(xerox;phaser_8400b;) \
postscriptdriver(xerox;phaser_8400bd;) \
postscriptdriver(xerox;phaser_8400dp;) \
postscriptdriver(xerox;phaser_8400dx;) \
postscriptdriver(xerox;phaser_8400n;) \
postscriptdriver(xerox;phaser_8500dn;) \
postscriptdriver(xerox;phaser_8500n;) \
postscriptdriver(xerox;phaser_8550dp;) \
postscriptdriver(xerox;phaser_8550dt;) \
postscriptdriver(xerox;phaser_8550dx;) \
postscriptdriver(xerox;phaser_8560dn;) \
postscriptdriver(xerox;phaser_8860;) \
postscriptdriver(xerox;workcentre_c2424;) \
postscriptdriver(xerox;xerox_phaser_2135;) \
postscriptdriver(xerox;xerox_phaser_3500;) \
postscriptdriver(xerox;xerox_wc_pe120;)"
RDEPENDS:${PN} += "foomatic-filters \
ghostscript-library"

inherit rpm
